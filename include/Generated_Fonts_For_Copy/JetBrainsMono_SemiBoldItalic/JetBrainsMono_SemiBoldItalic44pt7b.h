#ifndef _JETBRAINSMONO_SEMIBOLDITALIC44PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x3E, 0x1F, 0x9F,
  0x0F, 0xCF, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x07, 0x8F, 0x83,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80, 0x07, 0x01,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xEE, 0xFE, 0x0F, 0xCE, 0x7E, 0x0F, 0x8E, 0x3E,
  0x1F, 0x0E, 0x3E, 0x1F, 0x0C, 0x00, 0x1F, 0x0C, 0x00, 0x1F, 0x9C, 0x00,
  0x1F, 0x9C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3B, 0xF8, 0x00, 0x39, 0xF8, 0x00, 0x30, 0xF8, 0x00, 0x70, 0xF8,
  0xF8, 0x70, 0xF8, 0xF8, 0x70, 0xF8, 0xF8, 0x71, 0xF8, 0xFC, 0x73, 0xF0,
  0xFE, 0x67, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0x01, 0xFF, 0x80, 0x3C, 0x03, 0xFF, 0x80, 0x78, 0x07, 0xC7, 0x80,
  0xF0, 0x07, 0x83, 0xC0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0x03, 0x83,
  0xC0, 0x07, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x8F, 0x00, 0x0F, 0x07, 0x9E,
  0x00, 0x0F, 0x8F, 0x3C, 0x00, 0x07, 0xFF, 0x3C, 0x00, 0x07, 0xFE, 0x78,
  0x00, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0F, 0x3F,
  0x80, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x3C, 0xFF, 0xE0, 0x00, 0x79, 0xE1,
  0xE0, 0x00, 0xF1, 0xE0, 0xE0, 0x01, 0xE1, 0xC1, 0xE0, 0x01, 0xC3, 0xC1,
  0xE0, 0x03, 0xC3, 0xC1, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0x0F, 0x03, 0xC1,
  0xE0, 0x1E, 0x03, 0xE3, 0xC0, 0x3C, 0x03, 0xFF, 0x80, 0x78, 0x01, 0xFF,
  0x80, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE,
  0x0F, 0xCF, 0x9F, 0x07, 0xCF, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xC3, 0xE0,
  0xFF, 0xE1, 0xF0, 0x7F, 0xE0, 0xF8, 0x1F, 0xE0, 0xF8, 0x0F, 0xE0, 0x7C,
  0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0xC1, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xE0, 0x7F, 0xF1, 0xF0, 0x1F, 0xF0, 0x7C,
  0x00, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x1E, 0x06,
  0x3C, 0x1C, 0x3E, 0x7F, 0x1C, 0xFE, 0x7F, 0x99, 0xFF, 0xFF, 0xDF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0xCF, 0x00, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x87, 0xC0,
  0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1C, 0x03, 0x80, 0x0C, 0x03, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFC, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0x8F, 0x8F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0xFC,
  0xF9, 0xF1, 0xF1, 0xF3, 0xE0, 0xC3, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x7C, 0x07, 0xF7, 0xE0,
  0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1C, 0x0F, 0x80, 0xC0, 0x7C, 0x04, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC,
  0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x0F,
  0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x10, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0x7C, 0x01,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0xFE, 0x01, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x3E, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xC3, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x0F,
  0x81, 0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x08,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFE, 0x0F, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xEF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0x7F, 0x9F, 0xF1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x07, 0xFB, 0xF0, 0x03, 0x8F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC,
  0x3F, 0x87, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFC, 0x00, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x0F,
  0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x21, 0xE1, 0xE0, 0x3F, 0xBC,
  0x3C, 0x0F, 0xF7, 0x87, 0x83, 0xFF, 0xF1, 0xF0, 0xF8, 0x3E, 0x3E, 0x1E,
  0x07, 0xC7, 0x83, 0xC0, 0xF8, 0xF0, 0x78, 0x1E, 0x1E, 0x1F, 0x03, 0xC3,
  0xC3, 0xE0, 0x78, 0xF8, 0x78, 0x0F, 0x1F, 0x0F, 0x03, 0xE3, 0xC1, 0xE0,
  0x7C, 0x78, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x7C, 0x3C,
  0x1F, 0xFF, 0x8F, 0x83, 0xFE, 0xF1, 0xF0, 0x3F, 0x9E, 0x3E, 0x00, 0xC0,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x78,
  0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x7C, 0x7E,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0x81, 0xFE, 0x0F, 0x80,
  0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3E, 0x0F,
  0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xE0,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xF0, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC7,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x07,
  0xE3, 0xF0, 0x1F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x1F,
  0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x7E, 0x1F,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x78,
  0x3D, 0xC3, 0xDE, 0x1F, 0x70, 0xEF, 0x87, 0xDC, 0x7B, 0xC1, 0xE7, 0x9C,
  0xF0, 0x79, 0xEF, 0x3C, 0x1E, 0x7B, 0x9F, 0x07, 0x9F, 0xE7, 0xC1, 0xE3,
  0xF9, 0xF0, 0xF8, 0xFC, 0x78, 0x3E, 0x3F, 0x1E, 0x0F, 0x8F, 0x8F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0x83, 0xF8, 0x07, 0xC1, 0xFC, 0x03, 0xE0, 0xFF, 0x01, 0xF0, 0x7F, 0x80,
  0xF0, 0x3F, 0xC0, 0x78, 0x3F, 0xE0, 0x7C, 0x1F, 0xF0, 0x3E, 0x0F, 0xF8,
  0x1F, 0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xC0, 0xF3,
  0xC3, 0xE0, 0xF9, 0xE1, 0xF0, 0x7C, 0xF8, 0xF8, 0x3E, 0x3C, 0x7C, 0x1F,
  0x1E, 0x3E, 0x0F, 0x0F, 0x1E, 0x07, 0x87, 0x8F, 0x07, 0xC3, 0xEF, 0x83,
  0xE0, 0xF7, 0xC1, 0xF0, 0x7B, 0xE0, 0xF8, 0x3D, 0xF0, 0x7C, 0x1E, 0xF0,
  0x3C, 0x0F, 0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0x01, 0xFE, 0x0F, 0x80, 0xFF,
  0x07, 0xC0, 0x7F, 0x83, 0xE0, 0x3F, 0x81, 0xE0, 0x1F, 0xC1, 0xF0, 0x07,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1,
  0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x07, 0xF0, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F,
  0x87, 0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0x81, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x0F,
  0x83, 0xE7, 0x81, 0xF0, 0x78, 0xF0, 0x7E, 0x0F, 0x1E, 0x0F, 0xC3, 0xE3,
  0xC1, 0xF0, 0x7C, 0x78, 0x76, 0x0F, 0x0F, 0x0E, 0xC1, 0xE1, 0xE1, 0xD8,
  0x7C, 0x7C, 0x3F, 0x0F, 0x0F, 0x8E, 0xE1, 0xE1, 0xF1, 0xDC, 0x3C, 0x3E,
  0x3B, 0x8F, 0x87, 0xC6, 0x71, 0xE0, 0xF1, 0xCE, 0x3C, 0x1E, 0x39, 0xC7,
  0x83, 0xC7, 0x39, 0xF0, 0x79, 0xC7, 0x3C, 0x0F, 0x38, 0xE7, 0x81, 0xE7,
  0x1C, 0xF0, 0x3C, 0xE3, 0xBC, 0x07, 0xB8, 0x77, 0x80, 0xF7, 0x0E, 0xF0,
  0x1E, 0xE1, 0xDE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xDE, 0x01, 0xDC, 0x1B, 0xC0, 0x7F, 0x03, 0x70, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x3F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x80, 0x0F, 0x9F, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1E, 0xF0, 0x03, 0xEF, 0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x7C,
  0x0F, 0x07, 0xC1, 0xF0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x3E, 0x7C, 0x03,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xF8, 0x3E, 0x1F, 0x87,
  0xC1, 0xF0, 0xFC, 0x3E, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x7C, 0x1F, 0xFD,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0,
  0x1F, 0x87, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFD,
  0xF0, 0x1F, 0xE3, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0xE0, 0x1F, 0x1F, 0xE0, 0x7C, 0xFF, 0xC1, 0xF7, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xC1, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xCF, 0xE0, 0x3F, 0x3F, 0xC3, 0xF8, 0xFF, 0xFF, 0xE3,
  0xEF, 0xFF, 0x0F, 0xBF, 0xF8, 0x3E, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07,
  0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xE7, 0xC0, 0x1F,
  0x1F, 0x80, 0xFC, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x30, 0x3E, 0x01, 0xFE, 0x3E, 0x07, 0xFF, 0x7E, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFB, 0xE0, 0x1F, 0xE3, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC,
  0x7E, 0x07, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xFC, 0x7C, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x3F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x07, 0xE1,
  0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x03, 0xFF, 0x7E, 0x03,
  0xFC, 0xF8, 0x01, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE1, 0xE0, 0x1F, 0x1F, 0xE0, 0x7D, 0xFF, 0xC1, 0xF7,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C,
  0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF8,
  0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7F, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x08, 0x0C, 0x07, 0xDF, 0x1F, 0x83, 0xDF, 0xDF, 0xE1, 0xFF,
  0xEF, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E,
  0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0x87, 0xC7, 0x83, 0x83, 0xC3,
  0xC1, 0xC1, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x7C,
  0x7C, 0x3C, 0x3E, 0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x1F, 0x0F, 0x07,
  0x8F, 0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xE0, 0xF0,
  0xF0, 0xF0, 0x70, 0x78, 0xF8, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x7C,
  0x7F, 0x81, 0xF7, 0xFF, 0x07, 0xDF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x07,
  0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x9F,
  0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xC7, 0xF8, 0x07, 0xCF, 0xFC, 0x07,
  0xDF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F,
  0x80, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0xFF, 0xF0, 0x3E,
  0xFF, 0xE0, 0x3E, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x7C, 0x1F,
  0xFD, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x1F, 0x87, 0xF0, 0xDF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x1F,
  0xFD, 0xF0, 0x1F, 0xE3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x3F, 0xE0, 0x3E, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xFC,
  0x03, 0xF3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF8, 0x7F,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x7E, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07,
  0xC0, 0xF0, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0F,
  0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x1E, 0xF0, 0xFC, 0x3C,
  0xF0, 0xFC, 0x3C, 0xF1, 0xDC, 0x3C, 0xF1, 0xDC, 0x7C, 0xF1, 0xDC, 0x78,
  0xF1, 0x9C, 0x78, 0xF3, 0x9C, 0x78, 0xF3, 0x9C, 0xF0, 0xF3, 0x1C, 0xF0,
  0xF7, 0x1C, 0xF0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFE, 0x1D, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7E,
  0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFE, 0x1F, 0xE1, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xBE,
  0x01, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xC0,
  0x3C, 0x7F, 0xC0, 0x79, 0xFF, 0xC1, 0xF7, 0xFF, 0xC3, 0xEF, 0x8F, 0x87,
  0x9E, 0x0F, 0xFF, 0x3C, 0x1F, 0xFE, 0xF8, 0x1F, 0xF9, 0xF0, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 32, 26, 8, -32 },
  { 45, 17, 13, 26, 7, -32 },
  { 73, 26, 32, 26, 1, -32 },
  { 177, 24, 44, 26, 2, -38 },
  { 309, 32, 32, 26, -2, -32 },
  { 437, 25, 33, 26, 1, -33 },
  { 541, 7, 13, 26, 12, -32 },
  { 553, 19, 43, 26, 6, -37 },
  { 656, 19, 43, 26, 2, -37 },
  { 759, 24, 23, 26, 2, -27 },
  { 828, 21, 21, 26, 3, -25 },
  { 884, 12, 14, 26, 4, -7 },
  { 905, 15, 5, 26, 6, -17 },
  { 915, 8, 8, 26, 8, -8 },
  { 923, 27, 42, 26, 0, -37 },
  { 1065, 23, 33, 26, 2, -33 },
  { 1160, 21, 32, 26, 2, -32 },
  { 1244, 23, 33, 26, 2, -33 },
  { 1339, 23, 32, 26, 2, -32 },
  { 1431, 22, 32, 26, 2, -32 },
  { 1519, 23, 32, 26, 2, -32 },
  { 1611, 22, 32, 26, 2, -32 },
  { 1699, 22, 32, 26, 5, -32 },
  { 1787, 23, 33, 26, 2, -33 },
  { 1882, 22, 33, 26, 4, -33 },
  { 1973, 11, 25, 26, 8, -25 },
  { 2008, 15, 32, 26, 4, -25 },
  { 2068, 22, 23, 26, 3, -26 },
  { 2132, 21, 15, 26, 3, -22 },
  { 2172, 22, 23, 26, 2, -26 },
  { 2236, 18, 32, 26, 6, -32 },
  { 2308, 27, 41, 26, 0, -33 },
  { 2447, 23, 32, 26, 0, -32 },
  { 2539, 24, 32, 26, 2, -32 },
  { 2635, 24, 33, 26, 2, -33 },
  { 2734, 23, 32, 26, 2, -32 },
  { 2826, 24, 32, 26, 2, -32 },
  { 2922, 25, 32, 26, 2, -32 },
  { 3022, 24, 33, 26, 2, -33 },
  { 3121, 24, 32, 26, 2, -32 },
  { 3217, 23, 32, 26, 2, -32 },
  { 3309, 25, 32, 26, 0, -32 },
  { 3409, 26, 32, 26, 2, -32 },
  { 3513, 19, 32, 26, 3, -32 },
  { 3589, 26, 32, 26, 1, -32 },
  { 3693, 25, 32, 26, 1, -32 },
  { 3793, 23, 33, 26, 2, -33 },
  { 3888, 25, 32, 26, 2, -32 },
  { 3988, 23, 41, 26, 2, -33 },
  { 4106, 24, 32, 26, 2, -32 },
  { 4202, 25, 33, 26, 1, -33 },
  { 4306, 22, 32, 26, 5, -32 },
  { 4394, 24, 32, 26, 2, -32 },
  { 4490, 23, 32, 26, 5, -32 },
  { 4582, 27, 32, 26, 2, -32 },
  { 4690, 29, 32, 26, -1, -32 },
  { 4806, 24, 32, 26, 4, -32 },
  { 4902, 24, 32, 26, 2, -32 },
  { 4998, 18, 42, 26, 6, -37 },
  { 5093, 14, 42, 26, 7, -37 },
  { 5167, 19, 42, 26, 3, -37 },
  { 5267, 20, 17, 26, 4, -32 },
  { 5310, 22, 5, 26, 0, 1 },
  { 5324, 9, 7, 26, 11, -35 },
  { 5332, 23, 25, 26, 2, -25 },
  { 5404, 22, 32, 26, 2, -32 },
  { 5492, 22, 25, 26, 2, -25 },
  { 5561, 24, 32, 26, 2, -32 },
  { 5657, 22, 25, 26, 2, -25 },
  { 5726, 30, 40, 26, -2, -32 },
  { 5876, 23, 33, 26, 2, -25 },
  { 5971, 22, 32, 26, 2, -32 },
  { 6059, 22, 35, 26, 1, -35 },
  { 6156, 24, 43, 26, 0, -35 },
  { 6285, 24, 32, 26, 2, -32 },
  { 6381, 19, 32, 26, 4, -32 },
  { 6457, 25, 25, 26, 0, -25 },
  { 6536, 22, 25, 26, 2, -25 },
  { 6605, 22, 25, 26, 2, -25 },
  { 6674, 24, 33, 26, 0, -25 },
  { 6773, 23, 33, 26, 2, -25 },
  { 6868, 23, 25, 26, 2, -25 },
  { 6940, 22, 25, 26, 2, -25 },
  { 7009, 22, 31, 26, 3, -31 },
  { 7095, 23, 24, 26, 2, -24 },
  { 7164, 22, 24, 26, 4, -24 },
  { 7230, 24, 24, 26, 3, -24 },
  { 7302, 26, 24, 26, 0, -24 },
  { 7380, 23, 32, 26, 2, -24 },
  { 7472, 22, 24, 26, 2, -24 },
  { 7538, 23, 42, 26, 4, -37 },
  { 7659, 12, 42, 26, 8, -37 },
  { 7722, 23, 42, 26, 1, -37 },
  { 7843, 23, 10, 26, 2, -21 },
};

const GFXfont JetBrainsMono_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC44PT7B_H_
