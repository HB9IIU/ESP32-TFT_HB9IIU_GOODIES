#ifndef _JETBRAINSMONO_SEMIBOLDITALIC18PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x18, 0xC4, 0x60, 0x01, 0xCE, 0x00, 0x6F, 0xDB,
  0x36, 0x6C, 0xC0, 0x06, 0x61, 0x88, 0x33, 0x1F, 0xF3, 0xFE, 0x33, 0x04,
  0x41, 0x88, 0xFF, 0xDF, 0xF1, 0x88, 0x33, 0x04, 0x40, 0x02, 0x01, 0x00,
  0x40, 0x7C, 0x3F, 0x99, 0x66, 0x41, 0xF0, 0x7C, 0x0F, 0xC0, 0xF0, 0x2E,
  0x0B, 0x36, 0xCF, 0xF1, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x1E, 0x19, 0x91,
  0x8C, 0x98, 0x45, 0x83, 0xF8, 0x0E, 0x80, 0x08, 0x00, 0xFC, 0x0F, 0x60,
  0xD9, 0x0C, 0xC8, 0x46, 0xCC, 0x3C, 0x00, 0x0F, 0x87, 0x61, 0x9C, 0x40,
  0x18, 0x06, 0x07, 0xC1, 0xB3, 0x67, 0x99, 0xCE, 0x31, 0xFE, 0x7D, 0xC0,
  0xFB, 0x6C, 0x06, 0x1C, 0x61, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06,
  0x0C, 0x1C, 0x1C, 0x3C, 0x18, 0x10, 0x3C, 0x0E, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0xF0, 0xC0, 0x0C, 0x03,
  0x08, 0xCB, 0xAE, 0x7F, 0xC7, 0x03, 0x61, 0x98, 0xE7, 0x00, 0x0C, 0x06,
  0x03, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x3B, 0x99, 0xCC, 0x60, 0x7F,
  0xF8, 0x6F, 0xE0, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x00, 0x1F, 0x1D, 0xD8, 0x6C, 0x36, 0x1B, 0x4D, 0x77, 0x93,
  0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x0E, 0x3E, 0x76, 0x46, 0x06, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF, 0x1F, 0x1F, 0xD8, 0x6C, 0x30,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x1F, 0xEF, 0xF0, 0x3F, 0x9F,
  0xC0, 0xC0, 0xC1, 0xC0, 0xF8, 0x1C, 0x06, 0x03, 0x61, 0xB0, 0xDF, 0xC7,
  0xC0, 0x03, 0x83, 0x83, 0x81, 0x81, 0x81, 0x8D, 0x8D, 0xC6, 0xFF, 0x7F,
  0x80, 0xC0, 0x60, 0x60, 0x3F, 0x9F, 0xCC, 0x0C, 0x06, 0x63, 0xF9, 0x8C,
  0x07, 0x03, 0x01, 0xB0, 0xDF, 0xC7, 0xC0, 0x07, 0x07, 0x03, 0x03, 0x03,
  0x03, 0xF9, 0xFD, 0xC7, 0xC1, 0xE1, 0xB0, 0xDF, 0xC7, 0xC0, 0xFF, 0xFF,
  0xF0, 0xD8, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0E,
  0x00, 0x1F, 0x1D, 0xD8, 0x6C, 0x37, 0x39, 0xF8, 0xF8, 0xEE, 0xC3, 0x61,
  0xB0, 0xDF, 0xE7, 0xC0, 0x1F, 0x0E, 0xE6, 0x19, 0x86, 0x61, 0x98, 0x67,
  0xF8, 0xEC, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x70, 0x00, 0x33, 0xCC, 0x00,
  0x00, 0x0C, 0xE7, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x00, 0x0E, 0x71, 0x86,
  0x30, 0xC0, 0x00, 0x81, 0xC3, 0xC7, 0x87, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0x80, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x40, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x18, 0x7C, 0xF0, 0xE0, 0x40, 0x00, 0x7C, 0x7E, 0x07,
  0x03, 0x07, 0x0E, 0x3C, 0x30, 0x60, 0x00, 0x00, 0x60, 0xE0, 0x0F, 0xC3,
  0x1C, 0xC1, 0xB0, 0x36, 0x36, 0xCF, 0xDB, 0x12, 0x62, 0x4C, 0xD9, 0x9B,
  0x33, 0x67, 0xEC, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x03, 0x83, 0xC1,
  0xA1, 0x98, 0xCC, 0x66, 0x63, 0x3F, 0xBF, 0xD8, 0x6C, 0x3C, 0x18, 0x3F,
  0x1F, 0xE6, 0x19, 0x86, 0x61, 0x9F, 0xC7, 0xF1, 0x8C, 0xC1, 0xB0, 0xEC,
  0x33, 0xFC, 0xFC, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x36, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x3F, 0x3F, 0xD8, 0x6C, 0x36,
  0x1B, 0x0D, 0x86, 0xC3, 0xC3, 0x61, 0xB1, 0xDF, 0xCF, 0xC0, 0x3F, 0xCF,
  0xE3, 0x01, 0x80, 0x60, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF6, 0x01, 0x80, 0x60, 0x18, 0x07, 0xF1,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x1F, 0xDC, 0x6C,
  0x36, 0x03, 0x01, 0xBF, 0xDF, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x31,
  0xDC, 0x66, 0x19, 0x86, 0x61, 0x9F, 0xE7, 0xF9, 0x8C, 0xC3, 0x30, 0xCC,
  0x33, 0x0C, 0xC7, 0x00, 0x3F, 0x9F, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x1F, 0xEF, 0xE0, 0x07, 0xC1, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0xB8, 0x6E, 0x39, 0xFC, 0x3E, 0x00,
  0x30, 0xDC, 0x66, 0x39, 0x8C, 0x66, 0x1F, 0x87, 0xC1, 0xB8, 0xC6, 0x31,
  0x8C, 0x73, 0x0C, 0xC3, 0x00, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xFF, 0xFF, 0x38, 0xE7, 0x1C, 0xE7, 0x9C, 0xA2,
  0xFC, 0xDD, 0x9B, 0xB3, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x30, 0xCC, 0x18,
  0x30, 0xDE, 0x27, 0x99, 0xE6, 0x79, 0x9A, 0x66, 0xDB, 0x34, 0xCF, 0x33,
  0xCC, 0x73, 0x1C, 0xC7, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x36, 0x1B, 0x0D,
  0x87, 0xC7, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x3F, 0x9F, 0xE6, 0x1D,
  0x83, 0x61, 0xD8, 0x67, 0xF1, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0x1F, 0x1F, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x87, 0x83, 0xC3, 0x61,
  0xB0, 0xDF, 0xC7, 0xC0, 0x60, 0x38, 0x0C, 0x3F, 0x1F, 0xE6, 0x1D, 0x86,
  0x61, 0x98, 0xE7, 0xF1, 0xF0, 0xC6, 0x31, 0x8C, 0x63, 0x1C, 0xC3, 0x00,
  0x1F, 0x0F, 0xE6, 0x19, 0x80, 0x60, 0x1E, 0x03, 0xF0, 0x1C, 0x03, 0x80,
  0xCC, 0x33, 0xFC, 0x7C, 0x00, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x30, 0xDC, 0x66, 0x19,
  0x86, 0x61, 0x98, 0x66, 0x1B, 0x8E, 0xC3, 0x30, 0xCC, 0x33, 0xF8, 0x7C,
  0x00, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x63, 0x31, 0x98, 0xD8, 0x6C, 0x3C,
  0x1E, 0x0F, 0x07, 0x00, 0x46, 0x69, 0xCB, 0x3B, 0x66, 0x6D, 0xCD, 0xA9,
  0x35, 0x66, 0xAC, 0xF5, 0x1C, 0xA3, 0x9C, 0x73, 0x8C, 0x60, 0x38, 0x63,
  0x18, 0x66, 0x0E, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1B, 0x07, 0x60,
  0xCC, 0x30, 0xCC, 0x18, 0xC1, 0xF0, 0xE6, 0x31, 0x98, 0x66, 0x1F, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3F, 0x9F, 0xC0,
  0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x38, 0x1F, 0xEF, 0xF0,
  0x1F, 0x1F, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x78, 0xF8, 0xC3, 0x0C, 0x38, 0x61, 0x86, 0x18, 0x30,
  0xC3, 0x0C, 0x38, 0x61, 0x86, 0x1C, 0x1F, 0x1F, 0x07, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x7C, 0xF8, 0x0E,
  0x05, 0x06, 0x86, 0x63, 0x33, 0x1B, 0x86, 0xFF, 0xFF, 0xC0, 0xCC, 0x3D,
  0xBF, 0xD8, 0xEC, 0x7E, 0x36, 0x1B, 0x0D, 0x86, 0xFF, 0x3D, 0x80, 0x30,
  0x38, 0x18, 0x0D, 0xE7, 0xFB, 0x1D, 0x86, 0xC7, 0xC3, 0x61, 0xB0, 0xDF,
  0xCD, 0xE0, 0x1F, 0x1F, 0x98, 0x6C, 0x0E, 0x06, 0x03, 0x01, 0x86, 0xFE,
  0x3E, 0x00, 0x01, 0xC0, 0x60, 0x18, 0xF6, 0x7F, 0x98, 0xE6, 0x3B, 0x8C,
  0xC3, 0x30, 0xCC, 0x33, 0xFC, 0x7B, 0x00, 0x1E, 0x1F, 0x98, 0x6C, 0x3F,
  0xFF, 0xFB, 0x01, 0x86, 0xFE, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0x00,
  0x70, 0x1F, 0xE3, 0xFE, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0xFC, 0x0F, 0x80, 0x3D, 0xBF, 0xD8, 0xEC, 0x3E,
  0x36, 0x1B, 0x0D, 0xCE, 0x7B, 0x01, 0x81, 0x8F, 0xCF, 0xC0, 0x30, 0x38,
  0x18, 0x0D, 0xE7, 0xFB, 0x1D, 0x86, 0xC6, 0xC3, 0x61, 0xB0, 0xD8, 0x6C,
  0x70, 0x06, 0x06, 0x00, 0x00, 0x3E, 0x7C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1F, 0x87, 0xE2, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x63, 0xF8, 0xFC,
  0x00, 0x30, 0x0C, 0x06, 0x01, 0x87, 0x63, 0x99, 0xC6, 0x61, 0xF0, 0xFC,
  0x33, 0x8C, 0x63, 0x1C, 0xC3, 0x00, 0xF8, 0xF8, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x7F, 0x3E, 0x3D, 0xCD, 0xB6, 0x6D, 0x93,
  0x64, 0xD9, 0x36, 0xCD, 0x32, 0xCD, 0xB2, 0x60, 0x6F, 0x3F, 0xD8, 0xEC,
  0x36, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x80, 0x1E, 0x1F, 0x98, 0xEC,
  0x3E, 0x3E, 0x1B, 0x0D, 0x86, 0xFE, 0x3E, 0x00, 0x37, 0x8F, 0xF3, 0x1C,
  0xC3, 0x31, 0xD8, 0x66, 0x19, 0x86, 0x7F, 0x1B, 0xC6, 0x03, 0x80, 0xC0,
  0x00, 0x3D, 0xBF, 0xD8, 0xEC, 0x7E, 0x36, 0x1B, 0x0D, 0x86, 0xFF, 0x3D,
  0x81, 0x80, 0xC0, 0x60, 0x7F, 0x3F, 0xDC, 0x6C, 0x36, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x00, 0x3F, 0x3F, 0xD8, 0x6C, 0x07, 0xE0, 0xF8, 0x0D,
  0x86, 0xFF, 0x3F, 0x00, 0x0C, 0x06, 0x07, 0x0F, 0xFF, 0xF8, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x07, 0xE1, 0xF0, 0x61, 0xB0, 0xD8, 0x6C, 0x3E,
  0x36, 0x1B, 0x0D, 0x86, 0xFE, 0x3E, 0x00, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC,
  0x67, 0x61, 0xB0, 0xF0, 0x78, 0x38, 0x00, 0xCC, 0xF3, 0x3C, 0xCB, 0x56,
  0xD5, 0xB5, 0x4E, 0x53, 0x9C, 0xE6, 0x31, 0x80, 0x30, 0xE7, 0x30, 0x6E,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x81, 0x98, 0x73, 0x1C, 0x30, 0x61, 0xB0,
  0xD8, 0x6C, 0x7E, 0x36, 0x1B, 0x0D, 0xFE, 0x7B, 0x01, 0x81, 0x8F, 0xCF,
  0xC0, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x7F,
  0x80, 0x03, 0x83, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0xF0, 0x1C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x7C, 0x1C, 0x00, 0x18, 0xC6, 0x63,
  0x18, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x9C, 0xC0, 0x1C, 0x07, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x38, 0x03, 0xC3, 0x80, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x81, 0xE0, 0xF0, 0x00, 0x79, 0xEE, 0xF3, 0xE0, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 7, 5, 11, 3, -13 },
  { 15, 11, 13, 11, 0, -13 },
  { 33, 10, 19, 11, 1, -16 },
  { 57, 13, 13, 11, -1, -13 },
  { 79, 10, 13, 11, 0, -13 },
  { 96, 3, 5, 11, 5, -13 },
  { 98, 7, 17, 11, 3, -15 },
  { 113, 8, 17, 11, 1, -15 },
  { 130, 10, 9, 11, 1, -11 },
  { 142, 9, 8, 11, 1, -10 },
  { 151, 5, 6, 11, 2, -3 },
  { 155, 7, 2, 11, 2, -7 },
  { 157, 4, 3, 11, 3, -3 },
  { 159, 11, 17, 11, 0, -15 },
  { 183, 9, 13, 11, 1, -13 },
  { 198, 8, 13, 11, 1, -13 },
  { 211, 9, 13, 11, 1, -13 },
  { 226, 9, 13, 11, 1, -13 },
  { 241, 9, 13, 11, 1, -13 },
  { 256, 9, 13, 11, 1, -13 },
  { 271, 9, 13, 11, 1, -13 },
  { 286, 9, 13, 11, 2, -13 },
  { 301, 9, 13, 11, 1, -13 },
  { 316, 10, 13, 11, 1, -13 },
  { 333, 5, 10, 11, 3, -10 },
  { 340, 6, 13, 11, 2, -10 },
  { 350, 9, 10, 11, 1, -11 },
  { 362, 9, 6, 11, 1, -9 },
  { 369, 9, 10, 11, 1, -11 },
  { 381, 8, 13, 11, 2, -13 },
  { 394, 11, 16, 11, 0, -13 },
  { 416, 9, 13, 11, 0, -13 },
  { 431, 10, 13, 11, 1, -13 },
  { 448, 9, 13, 11, 1, -13 },
  { 463, 9, 13, 11, 1, -13 },
  { 478, 10, 13, 11, 1, -13 },
  { 495, 10, 13, 11, 1, -13 },
  { 512, 9, 13, 11, 1, -13 },
  { 527, 10, 13, 11, 1, -13 },
  { 544, 9, 13, 11, 1, -13 },
  { 559, 10, 13, 11, 0, -13 },
  { 576, 10, 13, 11, 1, -13 },
  { 593, 8, 13, 11, 1, -13 },
  { 606, 11, 13, 11, 0, -13 },
  { 624, 10, 13, 11, 1, -13 },
  { 641, 9, 13, 11, 1, -13 },
  { 656, 10, 13, 11, 1, -13 },
  { 673, 9, 16, 11, 1, -13 },
  { 691, 10, 13, 11, 1, -13 },
  { 708, 10, 13, 11, 1, -13 },
  { 725, 9, 13, 11, 2, -13 },
  { 740, 10, 13, 11, 1, -13 },
  { 757, 9, 13, 11, 2, -13 },
  { 772, 11, 13, 11, 1, -13 },
  { 790, 11, 13, 11, 0, -13 },
  { 808, 10, 13, 11, 2, -13 },
  { 825, 9, 13, 11, 1, -13 },
  { 840, 8, 17, 11, 2, -15 },
  { 857, 6, 17, 11, 3, -15 },
  { 870, 8, 17, 11, 1, -15 },
  { 887, 9, 7, 11, 1, -13 },
  { 895, 9, 2, 11, 0, 0 },
  { 898, 3, 2, 11, 5, -14 },
  { 899, 9, 10, 11, 1, -10 },
  { 911, 9, 13, 11, 1, -13 },
  { 926, 9, 10, 11, 1, -10 },
  { 938, 10, 13, 11, 1, -13 },
  { 955, 9, 10, 11, 1, -10 },
  { 967, 12, 16, 11, -1, -13 },
  { 991, 9, 13, 11, 1, -10 },
  { 1006, 9, 13, 11, 1, -13 },
  { 1021, 8, 14, 11, 1, -14 },
  { 1035, 10, 17, 11, 0, -14 },
  { 1057, 10, 13, 11, 1, -13 },
  { 1074, 8, 13, 11, 2, -13 },
  { 1087, 10, 10, 11, 0, -10 },
  { 1100, 9, 10, 11, 1, -10 },
  { 1112, 9, 10, 11, 1, -10 },
  { 1124, 10, 13, 11, 0, -10 },
  { 1141, 9, 13, 11, 1, -10 },
  { 1156, 9, 10, 11, 1, -10 },
  { 1168, 9, 10, 11, 1, -10 },
  { 1180, 9, 13, 11, 1, -13 },
  { 1195, 9, 10, 11, 1, -10 },
  { 1207, 9, 10, 11, 2, -10 },
  { 1219, 10, 10, 11, 1, -10 },
  { 1232, 11, 10, 11, 0, -10 },
  { 1246, 9, 13, 11, 1, -10 },
  { 1261, 9, 10, 11, 1, -10 },
  { 1273, 9, 17, 11, 2, -15 },
  { 1293, 5, 17, 11, 3, -15 },
  { 1304, 10, 17, 11, 0, -15 },
  { 1326, 9, 4, 11, 1, -8 },
};

const GFXfont JetBrainsMono_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC18PT7B_H_
