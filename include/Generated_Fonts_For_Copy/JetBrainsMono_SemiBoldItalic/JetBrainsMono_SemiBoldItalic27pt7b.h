#ifndef _JETBRAINSMONO_SEMIBOLDITALIC27PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x00, 0x00, 0x01, 0xE3, 0xC7, 0x80, 0xF3, 0xFC, 0xEE, 0x3B, 0x8E,
  0xE3, 0xB8, 0xEE, 0x33, 0x1C, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61, 0x80,
  0x70, 0xC0, 0x30, 0xE0, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x06, 0x18,
  0x07, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x01, 0xC3, 0x23, 0xFF, 0xE3, 0xFF,
  0xF0, 0x70, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x1C, 0x30, 0x0C, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0x87,
  0x27, 0x1E, 0x4E, 0x39, 0x80, 0x73, 0x00, 0xF6, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x01, 0xBC, 0x03, 0x38, 0x06, 0x73, 0x8C, 0xE7,
  0x93, 0xC7, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x03, 0x80, 0x61, 0xF8, 0x18, 0x73, 0x86, 0x0C, 0x71,
  0x81, 0x8C, 0x70, 0x71, 0x9C, 0x0E, 0x37, 0x00, 0xFC, 0xC0, 0x1F, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xEF, 0x00, 0x3B, 0xF0, 0x0E, 0xE6,
  0x01, 0x98, 0xE0, 0x63, 0x18, 0x18, 0xE3, 0x06, 0x1C, 0xE1, 0xC1, 0xF8,
  0x70, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x0E, 0x1C, 0x0E,
  0x1C, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F,
  0x8F, 0x7B, 0xCE, 0x71, 0xDC, 0x71, 0xF8, 0x70, 0xF8, 0x70, 0x70, 0x70,
  0xF0, 0x7B, 0xF8, 0x7F, 0xF8, 0x3F, 0x1C, 0x7B, 0x9C, 0xE7, 0x39, 0x9C,
  0x00, 0x30, 0x0E, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xF0,
  0x1F, 0x00, 0x70, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x03,
  0x0C, 0x27, 0x99, 0xFF, 0xAF, 0xCF, 0xFE, 0x01, 0xC0, 0x07, 0xC0, 0x39,
  0x80, 0xF3, 0x83, 0xC7, 0x83, 0x06, 0x02, 0x08, 0x00, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x37, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x39, 0x1C, 0xE7, 0x39, 0xCE, 0x73,
  0x89, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xFB,
  0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF8, 0x3D, 0xC1,
  0xCE, 0x18, 0x70, 0x87, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x0F, 0x38, 0x1C, 0xE0,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xEF, 0xFF, 0x3F,
  0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE1, 0x03, 0xB8, 0x1E, 0xF0, 0x71, 0xF7, 0xC7, 0xFE, 0x0F, 0xE0,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xFF,
  0xE7, 0xFF, 0x3F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x78, 0x3F, 0xF0, 0xFF, 0xE3, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xBC, 0x1E, 0x70, 0x71, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x1D, 0xF0, 0xFF, 0xE7, 0xC7, 0x9E, 0x0E, 0x70, 0x3F, 0xC0, 0xEE, 0x03,
  0xB8, 0x0E, 0xF0, 0x79, 0xF7, 0xC7, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0xE1,
  0xFF, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xC7, 0x0E, 0x1E, 0xF0,
  0x3F, 0x80, 0xFE, 0x0F, 0x3C, 0x78, 0x79, 0xC0, 0xE7, 0x03, 0xBC, 0x0E,
  0xF0, 0x79, 0xF7, 0xC7, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF,
  0x8E, 0x0E, 0x70, 0x3D, 0xC0, 0x7F, 0x03, 0xFC, 0x0E, 0xF0, 0x39, 0xE3,
  0xE7, 0xFF, 0x0F, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x79, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x8F, 0x9F, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x00, 0x00, 0x08, 0x01, 0xC0,
  0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0x30, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x80,
  0x30, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0x80, 0x0E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0x00,
  0x00, 0x7C, 0x0F, 0xF1, 0xFF, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC7, 0xF0, 0xFC, 0x3E, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xE7, 0xC3,
  0xC0, 0xE1, 0xC0, 0x31, 0xC0, 0x18, 0xE0, 0x0C, 0x61, 0xF6, 0x31, 0xFB,
  0x38, 0xE3, 0x9C, 0x61, 0xCE, 0x70, 0xE7, 0x38, 0x63, 0x1C, 0x31, 0x8E,
  0x39, 0xC7, 0x1C, 0xE3, 0xFE, 0x71, 0xFF, 0x38, 0x20, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xB0, 0x0E, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xE3,
  0xFF, 0x8E, 0x07, 0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0x1F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C,
  0x1E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0xC3, 0x83, 0xC7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x79, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xFF, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE1, 0xE3, 0xC1, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0xF3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0xF0, 0xF1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE7, 0xF3, 0x8F, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x70, 0xFB, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x78, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x80,
  0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xE1, 0xFF, 0xC7,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x78,
  0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x38, 0x70, 0x38, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x71, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x07, 0x8F, 0x07, 0x86, 0xC3, 0xC3, 0x63,
  0x61, 0xB1, 0xF0, 0xD9, 0xB8, 0x6C, 0xDC, 0x76, 0xEC, 0x3B, 0x6E, 0x1C,
  0xF7, 0x0E, 0x73, 0x87, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0xE1, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x07, 0x00, 0x1E,
  0x0E, 0x3C, 0x1C, 0x78, 0x39, 0xF8, 0x73, 0xF1, 0xC7, 0xE3, 0x8E, 0xC7,
  0x1D, 0x8E, 0x3B, 0x1C, 0x67, 0x39, 0xCE, 0x63, 0x9D, 0xC7, 0x1B, 0x8E,
  0x37, 0x1C, 0x7E, 0x30, 0xFC, 0xE1, 0xF9, 0xC1, 0xE3, 0x83, 0xC7, 0x07,
  0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0xC1, 0xC7, 0x03,
  0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xFF, 0xE1, 0xFF,
  0x80, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xF3, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x7F, 0xF9, 0xFF, 0xE3,
  0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0,
  0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x39,
  0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70,
  0x70, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE1, 0xF3,
  0xC1, 0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFE, 0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xF1,
  0xE0, 0xE3, 0x81, 0xC7, 0x03, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xE0, 0xE3, 0xC1, 0xC7, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x70, 0x1C,
  0xF0, 0x78, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x39, 0xE0, 0xF3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x79, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x3C, 0x70, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xB8, 0x0E, 0xF0, 0x73, 0xC1, 0xC7, 0x0F, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x70, 0x1D,
  0xC0, 0x36, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0xC3, 0xB8, 0xE1,
  0x9C, 0x71, 0xCE, 0x28, 0xE7, 0x34, 0x73, 0x9E, 0x31, 0xCF, 0x38, 0xE5,
  0x9C, 0x76, 0xCC, 0x3B, 0x66, 0x19, 0xB7, 0x0D, 0x9B, 0x86, 0xCD, 0x83,
  0x66, 0xC1, 0xA3, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C,
  0x1E, 0x1C, 0x00, 0x1E, 0x07, 0x87, 0x03, 0x83, 0x83, 0x81, 0xE3, 0xC0,
  0x71, 0xC0, 0x39, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x79, 0xC0, 0x38,
  0xE0, 0x3C, 0x78, 0x3C, 0x1C, 0x1C, 0x0F, 0x1E, 0x03, 0x80, 0xE0, 0x1F,
  0x80, 0xFF, 0x03, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x83, 0x9E, 0x0E, 0x70,
  0x3B, 0x80, 0xEE, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x0F,
  0xF0, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x07, 0xF0, 0xFF,
  0x00, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0x03, 0x80, 0x0F, 0xE1, 0xFC, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x3F, 0xC7, 0xF8, 0xFF, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0D, 0x80,
  0xEE, 0x0E, 0x70, 0x71, 0x87, 0x0E, 0x38, 0x73, 0x83, 0xB8, 0x0E, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF3, 0x8E, 0x70, 0x07, 0x9C, 0x7F, 0x73, 0xFF, 0xCF,
  0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x07, 0x9C, 0x1C, 0x7D, 0xF1, 0xFD, 0xC3, 0xE7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE7, 0xC3, 0xBF, 0x8F, 0xFE, 0x3C,
  0x3C, 0xE0, 0xF7, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C,
  0x1E, 0x70, 0x73, 0xB7, 0xCE, 0xFE, 0x39, 0xF0, 0x07, 0xE0, 0x3F, 0xE1,
  0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x03, 0x9C, 0x1C, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0xF3, 0x87, 0xF7,
  0x1F, 0xFE, 0x3C, 0x3C, 0x70, 0x79, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xFB, 0xE1, 0xFD, 0xC1, 0xF3,
  0x80, 0x07, 0xE0, 0x3F, 0xE1, 0xE7, 0x8E, 0x0E, 0x38, 0x3D, 0xC0, 0xE7,
  0xFF, 0x9F, 0xFE, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x1E, 0x79, 0xF0,
  0xFF, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xB9, 0xFD, 0xDF, 0xFE, 0xF0, 0xF7, 0x07, 0xF8, 0x3B, 0x81,
  0xDC, 0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x3D, 0xFF, 0xC7, 0xFE, 0x1E, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC3, 0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE7, 0xC3, 0xBF, 0x8F, 0xFE,
  0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x1E, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0x00, 0xE0, 0x0F,
  0x80, 0x78, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x3F, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x83, 0xCE, 0x07, 0x1C, 0x1C,
  0x38, 0x78, 0x71, 0xE0, 0xE7, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1C,
  0x70, 0x38, 0xF0, 0x70, 0xE1, 0xE1, 0xE3, 0x81, 0xC7, 0x03, 0xC0, 0x7F,
  0x87, 0xF0, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x1B, 0x9E, 0x3F, 0xFE, 0x3D, 0xEE, 0x38,
  0xC6, 0x39, 0xCE, 0x39, 0xCE, 0x31, 0x8E, 0x71, 0x8E, 0x71, 0x8E, 0x71,
  0x8C, 0x73, 0x9C, 0x73, 0x9C, 0x73, 0x1C, 0x63, 0x1C, 0xE3, 0x1C, 0x39,
  0xF0, 0xEF, 0xE3, 0xFF, 0x8F, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0xF0, 0x73, 0x81, 0xCE,
  0x07, 0x00, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0E, 0x38, 0x3D, 0xE0,
  0xF7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x7F,
  0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x1C, 0xF8, 0x3B, 0xF8, 0x7F, 0xF0, 0xF0,
  0xF1, 0xC1, 0xE7, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0xF1, 0xC1, 0xC7, 0x6F, 0x8E, 0xFE, 0x1C, 0xF8, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x9C, 0x7F, 0x73, 0xFF,
  0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0,
  0xE7, 0x07, 0x9C, 0x1C, 0x7D, 0xF1, 0xFD, 0xC3, 0xE7, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1D, 0xF0, 0x3F, 0xF8, 0xEF, 0xF1,
  0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xF0, 0x7F, 0xE3, 0xE7, 0xCE, 0x0F, 0x38, 0x00, 0xE0, 0x03, 0xF8, 0x07,
  0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0xBC, 0x1E, 0xF8, 0xF1, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x38, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0x3D, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00,
  0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x70, 0x71, 0xC3, 0xC7, 0x0E,
  0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0xC3, 0x8F, 0x87, 0x1B, 0x1E, 0x76, 0x3C, 0xEC, 0x59,
  0x99, 0xB3, 0x33, 0x6E, 0x64, 0xD8, 0xD9, 0xB1, 0xB3, 0xE3, 0x45, 0x87,
  0x8B, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x00, 0x1C, 0x0F, 0x1E, 0x1E,
  0x0E, 0x3C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x38,
  0xF0, 0x3C, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x39, 0xE0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x8F, 0x9F, 0xFC, 0x3F,
  0x70, 0x79, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE1, 0xFF, 0x87, 0xFC, 0x1F,
  0xC0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x1F,
  0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xC0,
  0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE0, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x04, 0x00, 0xFC, 0x37, 0xF1, 0xDC,
  0xE7, 0x63, 0xFF, 0x87, 0xE0, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 20, 16, 5, -20 },
  { 19, 10, 8, 16, 5, -20 },
  { 29, 17, 20, 16, 0, -20 },
  { 72, 15, 27, 16, 1, -23 },
  { 123, 19, 20, 16, -1, -20 },
  { 171, 16, 20, 16, 0, -20 },
  { 211, 5, 8, 16, 7, -20 },
  { 216, 12, 26, 16, 4, -23 },
  { 255, 12, 26, 16, 1, -23 },
  { 294, 15, 14, 16, 1, -16 },
  { 321, 13, 12, 16, 2, -15 },
  { 341, 8, 8, 16, 2, -4 },
  { 349, 9, 3, 16, 4, -10 },
  { 353, 5, 5, 16, 5, -5 },
  { 357, 17, 25, 16, 0, -22 },
  { 411, 15, 20, 16, 1, -20 },
  { 449, 13, 20, 16, 1, -20 },
  { 482, 14, 20, 16, 1, -20 },
  { 517, 14, 20, 16, 1, -20 },
  { 552, 14, 20, 16, 1, -20 },
  { 587, 14, 20, 16, 1, -20 },
  { 622, 14, 20, 16, 1, -20 },
  { 657, 14, 20, 16, 3, -20 },
  { 692, 14, 20, 16, 1, -20 },
  { 727, 14, 20, 16, 2, -20 },
  { 762, 7, 15, 16, 5, -15 },
  { 776, 10, 19, 16, 2, -15 },
  { 800, 13, 14, 16, 2, -16 },
  { 823, 13, 10, 16, 2, -14 },
  { 840, 14, 14, 16, 1, -16 },
  { 865, 11, 20, 16, 4, -20 },
  { 893, 17, 25, 16, 0, -20 },
  { 947, 14, 20, 16, 0, -20 },
  { 982, 15, 20, 16, 1, -20 },
  { 1020, 15, 20, 16, 1, -20 },
  { 1058, 15, 20, 16, 1, -20 },
  { 1096, 15, 20, 16, 1, -20 },
  { 1134, 15, 20, 16, 1, -20 },
  { 1172, 15, 20, 16, 1, -20 },
  { 1210, 15, 20, 16, 1, -20 },
  { 1248, 15, 20, 16, 1, -20 },
  { 1286, 16, 20, 16, 0, -20 },
  { 1326, 16, 20, 16, 1, -20 },
  { 1366, 12, 20, 16, 2, -20 },
  { 1396, 17, 20, 16, 0, -20 },
  { 1439, 15, 20, 16, 1, -20 },
  { 1477, 15, 20, 16, 1, -20 },
  { 1515, 15, 20, 16, 1, -20 },
  { 1553, 15, 25, 16, 1, -20 },
  { 1600, 15, 20, 16, 1, -20 },
  { 1638, 15, 20, 16, 1, -20 },
  { 1676, 14, 20, 16, 3, -20 },
  { 1711, 15, 20, 16, 1, -20 },
  { 1749, 14, 20, 16, 3, -20 },
  { 1784, 17, 20, 16, 1, -20 },
  { 1827, 17, 20, 16, 0, -20 },
  { 1870, 14, 20, 16, 3, -20 },
  { 1905, 15, 20, 16, 1, -20 },
  { 1943, 12, 25, 16, 3, -22 },
  { 1981, 9, 25, 16, 4, -22 },
  { 2010, 11, 25, 16, 2, -22 },
  { 2045, 13, 11, 16, 2, -20 },
  { 2063, 13, 2, 16, 0, 1 },
  { 2067, 5, 4, 16, 7, -21 },
  { 2070, 14, 15, 16, 1, -15 },
  { 2097, 14, 20, 16, 1, -20 },
  { 2132, 14, 15, 16, 1, -15 },
  { 2159, 15, 20, 16, 1, -20 },
  { 2197, 14, 15, 16, 1, -15 },
  { 2224, 18, 25, 16, -1, -20 },
  { 2281, 13, 20, 16, 2, -15 },
  { 2314, 14, 20, 16, 1, -20 },
  { 2349, 13, 21, 16, 1, -21 },
  { 2384, 15, 26, 16, 0, -21 },
  { 2433, 15, 20, 16, 1, -20 },
  { 2471, 12, 20, 16, 2, -20 },
  { 2501, 16, 15, 16, 0, -15 },
  { 2531, 14, 15, 16, 1, -15 },
  { 2558, 14, 15, 16, 1, -15 },
  { 2585, 15, 20, 16, 0, -15 },
  { 2623, 14, 20, 16, 1, -15 },
  { 2658, 15, 15, 16, 1, -15 },
  { 2687, 14, 15, 16, 1, -15 },
  { 2714, 13, 19, 16, 2, -19 },
  { 2745, 14, 15, 16, 1, -15 },
  { 2772, 14, 15, 16, 2, -15 },
  { 2799, 15, 15, 16, 2, -15 },
  { 2828, 16, 15, 16, 0, -15 },
  { 2858, 14, 20, 16, 1, -15 },
  { 2893, 14, 15, 16, 1, -15 },
  { 2920, 14, 25, 16, 2, -22 },
  { 2964, 7, 25, 16, 5, -22 },
  { 2986, 14, 25, 16, 1, -22 },
  { 3030, 14, 7, 16, 1, -13 },
};

const GFXfont JetBrainsMono_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC27PT7B_H_
