#ifndef _JETBRAINSMONO_SEMIBOLDITALIC47PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xBF,
  0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xC1, 0xFB, 0xE0, 0xF9, 0xF0, 0x7D,
  0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0x81, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x1E,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x3C, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFE, 0xEF, 0xF0, 0x7E, 0x71, 0xF8, 0x7E, 0x38, 0xFC, 0x3E, 0x1C,
  0x7E, 0x1F, 0x0E, 0x3F, 0x1F, 0x86, 0x00, 0x0F, 0xC7, 0x00, 0x07, 0xF3,
  0x80, 0x01, 0xF9, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xBF, 0xC0, 0x01, 0xCF, 0xE0, 0x01, 0xC3, 0xF0,
  0x00, 0xE1, 0xF8, 0x00, 0x70, 0xFC, 0xFC, 0x38, 0x7E, 0x7E, 0x1C, 0x3E,
  0x3F, 0x0E, 0x3F, 0x1F, 0xCE, 0x3F, 0x07, 0xFF, 0x7F, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x1F, 0xE0, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0xF0, 0x0F, 0xFF, 0x00,
  0x78, 0x03, 0xC3, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x78, 0x1E,
  0x0F, 0x80, 0x1E, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0xF0, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0x3E, 0x1F, 0x3C, 0x00, 0x07,
  0xCF, 0x9E, 0x00, 0x01, 0xFF, 0xEF, 0x80, 0x00, 0x3F, 0xE3, 0xC0, 0x00,
  0x07, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x00, 0x0F, 0x9F,
  0xE0, 0x00, 0x03, 0xCF, 0xFC, 0x00, 0x01, 0xE7, 0xFF, 0x80, 0x00, 0xF3,
  0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x1E, 0x00, 0x1E,
  0x1E, 0x07, 0x80, 0x0F, 0x87, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x78, 0x01,
  0xE0, 0x78, 0x3C, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x07, 0xCF, 0xC0,
  0x3C, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x7C, 0xFC, 0xF8, 0x3E, 0x7E, 0x3F, 0x1F, 0x9F, 0x87, 0xC7,
  0xC7, 0xC1, 0xFB, 0xE1, 0xF0, 0x3F, 0xF8, 0x7C, 0x0F, 0xFC, 0x1F, 0x01,
  0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x01, 0xFE, 0x0F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x7C,
  0x0F, 0xFF, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0x7E, 0xFD, 0xFB, 0xF7, 0xCF,
  0xBF, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78,
  0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x78, 0x0E,
  0x3E, 0x1E, 0x1F, 0x9F, 0xE3, 0x9F, 0xE7, 0xFC, 0xCF, 0xFB, 0xFF, 0xBF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1F,
  0x00, 0x38, 0x07, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x7E, 0x3C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x1F, 0x9F,
  0x8F, 0x8F, 0xCF, 0x87, 0xC7, 0xC7, 0xC3, 0xE1, 0xC3, 0xE3, 0xF0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xDF, 0x80, 0xFE,
  0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x07, 0xE0, 0x30, 0x1F, 0x00, 0x80, 0x7C,
  0x04, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7,
  0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F,
  0x83, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x3E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x20,
  0x00, 0xF9, 0xFF, 0x00, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7C, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFE, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC,
  0x7E, 0x01, 0xFC, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x87, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x0F, 0x81, 0xFE,
  0x78, 0x78, 0x1F, 0xFB, 0xC3, 0xC0, 0xFD, 0xFE, 0x1E, 0x0F, 0x83, 0xF1,
  0xF0, 0x78, 0x0F, 0x0F, 0x87, 0xC0, 0x78, 0x7C, 0x3E, 0x07, 0xC3, 0xE1,
  0xF0, 0x3E, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x78, 0x0F, 0x8F, 0x83, 0xC0,
  0x78, 0x7C, 0x3E, 0x03, 0xC3, 0xE1, 0xF0, 0x1E, 0x1F, 0x0F, 0x81, 0xF0,
  0xF0, 0x7C, 0x0F, 0x87, 0x83, 0xF0, 0xFC, 0x3C, 0x0F, 0xFD, 0xE3, 0xE0,
  0x7F, 0xDE, 0x1F, 0x01, 0xFC, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF0,
  0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x3E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x3E,
  0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xC1, 0xFF, 0x07, 0xC0, 0x1F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFF, 0x9F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x3E, 0x00, 0xFE, 0x1F, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x7F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xFE, 0x7E,
  0x1F, 0xFE, 0x7C, 0x1F, 0xFC, 0x7C, 0x1F, 0xFC, 0x7C, 0x3F, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFF,
  0x9F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x9F, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x77, 0x01, 0xFE, 0x0F, 0x70, 0x1F, 0xE0, 0xF7, 0x83,
  0xDE, 0x0F, 0x78, 0x3F, 0xE0, 0xF7, 0x87, 0xBC, 0x0F, 0x78, 0x7B, 0xC0,
  0xF7, 0x8F, 0x3C, 0x0F, 0x38, 0xF7, 0xC1, 0xF3, 0x8E, 0x7C, 0x1F, 0x3D,
  0xE7, 0xC1, 0xF3, 0xDE, 0x7C, 0x1F, 0x3F, 0xC7, 0x81, 0xF3, 0xFC, 0xF8,
  0x1F, 0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00,
  0xFC, 0x3F, 0xC0, 0x3E, 0x0F, 0xF8, 0x0F, 0x83, 0xFE, 0x03, 0xE0, 0xF7,
  0x80, 0xF8, 0x3D, 0xE0, 0x3E, 0x0F, 0x78, 0x0F, 0x87, 0xDF, 0x07, 0xC1,
  0xF7, 0xC1, 0xF0, 0x7C, 0xF0, 0x7C, 0x1F, 0x3C, 0x1F, 0x07, 0xCF, 0x07,
  0xC1, 0xF3, 0xE1, 0xF0, 0xF8, 0xF8, 0xF8, 0x3E, 0x3E, 0x3E, 0x0F, 0x87,
  0x8F, 0x83, 0xE1, 0xE3, 0xE0, 0xF8, 0x78, 0xF8, 0x3E, 0x1F, 0x3E, 0x0F,
  0x87, 0xCF, 0x87, 0xC0, 0xF7, 0xC1, 0xF0, 0x3D, 0xF0, 0x7C, 0x0F, 0x7C,
  0x1F, 0x03, 0xFF, 0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x1F, 0xF0, 0xF8, 0x07,
  0xF8, 0x3E, 0x01, 0xFE, 0x0F, 0x80, 0x7F, 0x83, 0xE0, 0x1F, 0xE0, 0xF8,
  0x03, 0xF8, 0x3E, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0,
  0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xE1, 0xF0, 0x03, 0xF8, 0x7C, 0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7C, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC1, 0xFF, 0x3F,
  0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0xC1,
  0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0xF3, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E,
  0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0x8F, 0x83, 0xF0, 0x7C, 0x7C, 0x1F, 0x83,
  0xE3, 0xE0, 0xFC, 0x1E, 0x1F, 0x0E, 0xE0, 0xF0, 0xF0, 0x77, 0x0F, 0x87,
  0x83, 0xB8, 0x7C, 0x3C, 0x1D, 0xC3, 0xC1, 0xE1, 0xDE, 0x1E, 0x0F, 0x0E,
  0xE1, 0xF0, 0x78, 0x77, 0x0F, 0x83, 0xC7, 0xB8, 0x78, 0x3E, 0x39, 0xC3,
  0xC1, 0xF1, 0xCE, 0x3E, 0x0F, 0x8E, 0x71, 0xE0, 0x7C, 0xE3, 0x8F, 0x03,
  0xE7, 0x1C, 0x78, 0x1F, 0x38, 0xE7, 0xC0, 0xF9, 0xC7, 0x3C, 0x07, 0xDC,
  0x39, 0xE0, 0x3C, 0xE1, 0xCF, 0x01, 0xE7, 0x0E, 0xF8, 0x0F, 0x78, 0x77,
  0x80, 0x7B, 0x83, 0xBC, 0x03, 0xDC, 0x1D, 0xE0, 0x1E, 0xE0, 0xFF, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x81,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8,
  0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFB, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xE0, 0x3E, 0x1F,
  0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8,
  0x03, 0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x00, 0xFF,
  0x1F, 0x01, 0xFF, 0x9F, 0x07, 0xFF, 0xDF, 0x07, 0xFF, 0xDF, 0x0F, 0xFB,
  0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xFD,
  0xF8, 0x0F, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xF0, 0x0F, 0x9F, 0xF8, 0x1F, 0xBF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0x7B, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xF9, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0xF3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0x1F, 0x00, 0x7F, 0xE7, 0xC0, 0x7F, 0xFD,
  0xF0, 0x1F, 0xFF, 0x7C, 0x0F, 0xFB, 0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83,
  0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F,
  0xE3, 0xFE, 0x07, 0xFF, 0xEF, 0x80, 0xFF, 0xF7, 0xE0, 0x1F, 0xFD, 0xF8,
  0x03, 0xFC, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0xC0, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x3E, 0x07, 0xFE,
  0x7C, 0x3F, 0xFE, 0xF8, 0x7F, 0xFD, 0xF1, 0xFF, 0x7F, 0xE7, 0xF0, 0x3F,
  0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x3F,
  0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF8,
  0x0F, 0xE7, 0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xBE, 0x0F, 0xFE,
  0x7C, 0x0F, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xF0,
  0x0F, 0x9F, 0xF8, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFB, 0xFE,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x0F,
  0xC0, 0x1F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0x3E, 0x1F, 0x07, 0xDF, 0xCF,
  0xE1, 0xFF, 0xF7, 0xFC, 0x7F, 0xFD, 0xFF, 0x1F, 0x0F, 0x87, 0xC7, 0xC3,
  0xC1, 0xF1, 0xF0, 0xF0, 0x7C, 0xF8, 0x3C, 0x1F, 0x3E, 0x0F, 0x0F, 0x8F,
  0x83, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x78, 0x3E, 0x3E, 0x1E, 0x0F,
  0x9F, 0x07, 0x83, 0xE7, 0xC1, 0xE1, 0xF1, 0xF0, 0x78, 0x7C, 0x7C, 0x1E,
  0x1F, 0x1F, 0x0F, 0x07, 0xC7, 0xC3, 0xC1, 0xF1, 0xE0, 0xF0, 0x7C, 0xF8,
  0x3C, 0x1E, 0x3E, 0x0F, 0x0F, 0x8F, 0x83, 0xC3, 0xE3, 0xE1, 0xE0, 0xF8,
  0xF8, 0x78, 0x3E, 0x3E, 0x1E, 0x0F, 0x80, 0x0F, 0x8F, 0xF0, 0x0F, 0x9F,
  0xF8, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0x7B, 0xFE, 0x1F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0x7F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7F, 0x1F, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0xF9, 0xFF, 0x80, 0x7E,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xDE, 0xFF, 0x81, 0xFC, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0xFC, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F,
  0xF0, 0x0F, 0x8F, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0x01, 0xFF,
  0x9F, 0x07, 0xFF, 0xDF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0x1F, 0xC0,
  0xFF, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x8E,
  0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xFD, 0xF8, 0x0F, 0xF1,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x8F, 0xF0, 0x1F, 0x9F, 0xF8, 0x1F, 0x3F, 0xFC, 0x1F, 0x7F,
  0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0x80,
  0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x03,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0,
  0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F,
  0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x7F,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x1E, 0x03, 0xFE,
  0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7B, 0xE0, 0xF8, 0x1E, 0xF8, 0x7E, 0x0F,
  0xBE, 0x1F, 0x83, 0xCF, 0x87, 0xE0, 0xF3, 0xC3, 0xB8, 0x7C, 0xF0, 0xEE,
  0x1E, 0x3C, 0x3B, 0x87, 0x8F, 0x0E, 0xE1, 0xE3, 0xC7, 0x38, 0xF8, 0xF1,
  0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x38, 0xE7, 0xC3, 0xCE, 0x39, 0xE0,
  0xF3, 0x8E, 0x78, 0x3D, 0xC3, 0xBE, 0x0F, 0x70, 0xEF, 0x03, 0xDC, 0x3B,
  0xC0, 0xFE, 0x0E, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F,
  0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xFF,
  0xFF, 0x87, 0xFF, 0xDF, 0x0F, 0xFF, 0x3E, 0x0F, 0xFC, 0xFC, 0x07, 0xF1,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xC7, 0xFF, 0x03, 0xE7, 0xFF, 0x81,
  0xF7, 0xFF, 0xE0, 0xF3, 0xE1, 0xF8, 0xF9, 0xF0, 0xFF, 0xFC, 0xF0, 0x3F,
  0xFC, 0x78, 0x0F, 0xFC, 0x7C, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 34, 28, 8, -34 },
  { 57, 17, 14, 28, 8, -34 },
  { 87, 28, 34, 28, 1, -34 },
  { 206, 25, 48, 28, 2, -41 },
  { 356, 34, 35, 28, -2, -35 },
  { 505, 26, 35, 28, 1, -35 },
  { 619, 7, 14, 28, 13, -34 },
  { 632, 20, 46, 28, 7, -40 },
  { 747, 20, 46, 28, 2, -40 },
  { 862, 26, 25, 28, 2, -29 },
  { 944, 23, 23, 28, 3, -27 },
  { 1011, 13, 15, 28, 4, -7 },
  { 1036, 17, 5, 28, 6, -18 },
  { 1047, 9, 8, 28, 8, -8 },
  { 1056, 29, 44, 28, 0, -39 },
  { 1216, 25, 35, 28, 2, -35 },
  { 1326, 22, 34, 28, 2, -34 },
  { 1420, 25, 35, 28, 2, -35 },
  { 1530, 25, 34, 28, 2, -34 },
  { 1637, 24, 34, 28, 2, -34 },
  { 1739, 25, 34, 28, 2, -34 },
  { 1846, 24, 34, 28, 2, -34 },
  { 1948, 24, 34, 28, 5, -34 },
  { 2050, 25, 35, 28, 2, -35 },
  { 2160, 24, 35, 28, 4, -35 },
  { 2265, 12, 26, 28, 8, -26 },
  { 2304, 16, 34, 28, 4, -26 },
  { 2372, 23, 25, 28, 4, -28 },
  { 2444, 23, 17, 28, 3, -24 },
  { 2493, 23, 25, 28, 2, -28 },
  { 2565, 20, 34, 28, 6, -34 },
  { 2650, 29, 43, 28, 0, -35 },
  { 2806, 24, 34, 28, 0, -34 },
  { 2908, 25, 34, 28, 2, -34 },
  { 3015, 24, 35, 28, 3, -35 },
  { 3120, 25, 34, 28, 2, -34 },
  { 3227, 26, 34, 28, 2, -34 },
  { 3338, 26, 34, 28, 2, -34 },
  { 3449, 24, 35, 28, 3, -35 },
  { 3554, 26, 34, 28, 2, -34 },
  { 3665, 25, 34, 28, 2, -34 },
  { 3772, 27, 34, 28, 0, -34 },
  { 3887, 28, 34, 28, 2, -34 },
  { 4006, 21, 34, 28, 3, -34 },
  { 4096, 28, 34, 28, 1, -34 },
  { 4215, 26, 34, 28, 2, -34 },
  { 4326, 24, 35, 28, 3, -35 },
  { 4431, 26, 34, 28, 2, -34 },
  { 4542, 25, 43, 28, 2, -35 },
  { 4677, 26, 34, 28, 2, -34 },
  { 4788, 25, 35, 28, 2, -35 },
  { 4898, 24, 34, 28, 5, -34 },
  { 5000, 26, 34, 28, 2, -34 },
  { 5111, 25, 34, 28, 5, -34 },
  { 5218, 29, 34, 28, 2, -34 },
  { 5342, 31, 34, 28, -1, -34 },
  { 5474, 25, 34, 28, 5, -34 },
  { 5581, 25, 34, 28, 2, -34 },
  { 5688, 20, 44, 28, 6, -39 },
  { 5798, 15, 44, 28, 7, -39 },
  { 5881, 19, 44, 28, 4, -39 },
  { 5986, 21, 18, 28, 4, -34 },
  { 6034, 23, 5, 28, 0, 1 },
  { 6049, 10, 7, 28, 12, -37 },
  { 6058, 24, 26, 28, 2, -26 },
  { 6136, 24, 34, 28, 2, -34 },
  { 6238, 23, 26, 28, 3, -26 },
  { 6313, 26, 34, 28, 2, -34 },
  { 6424, 23, 26, 28, 3, -26 },
  { 6499, 32, 42, 28, -2, -34 },
  { 6667, 23, 34, 28, 3, -26 },
  { 6765, 24, 34, 28, 2, -34 },
  { 6867, 24, 37, 28, 1, -37 },
  { 6978, 26, 45, 28, 0, -37 },
  { 7125, 26, 34, 28, 2, -34 },
  { 7236, 21, 34, 28, 4, -34 },
  { 7326, 26, 26, 28, 1, -26 },
  { 7411, 24, 26, 28, 2, -26 },
  { 7489, 23, 26, 28, 3, -26 },
  { 7564, 26, 34, 28, 0, -26 },
  { 7675, 24, 34, 28, 2, -26 },
  { 7777, 24, 26, 28, 3, -26 },
  { 7855, 24, 26, 28, 2, -26 },
  { 7933, 24, 33, 28, 3, -33 },
  { 8032, 25, 26, 28, 2, -26 },
  { 8114, 24, 26, 28, 4, -26 },
  { 8192, 26, 26, 28, 3, -26 },
  { 8277, 28, 26, 28, 0, -26 },
  { 8368, 23, 34, 28, 3, -26 },
  { 8466, 24, 26, 28, 2, -26 },
  { 8544, 24, 44, 28, 4, -39 },
  { 8676, 13, 44, 28, 8, -39 },
  { 8748, 24, 44, 28, 1, -39 },
  { 8880, 25, 11, 28, 2, -22 },
};

const GFXfont JetBrainsMono_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC47PT7B_H_
