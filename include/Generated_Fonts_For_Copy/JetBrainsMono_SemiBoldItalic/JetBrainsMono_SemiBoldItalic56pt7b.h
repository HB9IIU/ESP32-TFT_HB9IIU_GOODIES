#ifndef _JETBRAINSMONO_SEMIBOLDITALIC56PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x00, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF0, 0x3F, 0x9F, 0x81, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07,
  0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x3C, 0xFF, 0x01, 0xF8,
  0x70, 0xFE, 0x07, 0xF0, 0xE1, 0xFC, 0x0F, 0xC1, 0xC3, 0xF8, 0x1F, 0x87,
  0x87, 0xF0, 0x7F, 0x0F, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x01, 0xFC, 0x3C,
  0x00, 0x01, 0xFC, 0x70, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x3F, 0xC0,
  0x00, 0x1C, 0x3F, 0xC0, 0x00, 0x38, 0x3F, 0x80, 0x00, 0x70, 0x7F, 0x00,
  0x01, 0xE0, 0xFE, 0x1F, 0x83, 0xC1, 0xF8, 0x3F, 0x07, 0x83, 0xF0, 0xFE,
  0x0F, 0x0F, 0xE0, 0xFE, 0x1C, 0x3F, 0x81, 0xFE, 0x38, 0xFF, 0x03, 0xFF,
  0x77, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x7F,
  0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x1F, 0x00, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x00, 0x07, 0xC1,
  0xF1, 0xF0, 0x00, 0x07, 0xFF, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xE7, 0xC0,
  0x00, 0x03, 0xFF, 0xC7, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0x80, 0x00, 0x00,
  0x18, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xE7, 0xFF, 0x80, 0x00, 0x07,
  0xCF, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x00, 0x1F, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3C,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xCF, 0xE3, 0xF0, 0x3F, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xE7, 0xE1, 0xFC,
  0x0F, 0xFF, 0xC3, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0x1F, 0xFC, 0x0F, 0xC0,
  0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xFE, 0x03, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xF1,
  0xF8, 0x0F, 0xFF, 0xC3, 0xF8, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x01, 0xF0, 0x02, 0x3C, 0x07, 0xC0,
  0x79, 0xFC, 0x1E, 0x0F, 0xE7, 0xFC, 0x78, 0xFF, 0xBF, 0xF9, 0xE7, 0xFE,
  0xFF, 0xF7, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x80, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x06, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0x8F, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x7C, 0x1F, 0x8F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F,
  0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xDF, 0x80, 0x1F, 0xE7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFC, 0x1F,
  0xC0, 0x1F, 0x03, 0xF0, 0x03, 0x80, 0x7E, 0x00, 0x60, 0x0F, 0xC0, 0x10,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF9, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xBF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x7F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xEF, 0xE0, 0x07, 0xF9,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x07, 0xF0, 0x02, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0xF8, 0x03, 0xFC, 0xFC, 0x3E, 0x01, 0xFF, 0xBE, 0x1F,
  0x80, 0xFF, 0xEF, 0x87, 0xE0, 0x7F, 0xFF, 0xE1, 0xF8, 0x1F, 0x83, 0xF8,
  0x7C, 0x0F, 0xC0, 0x7E, 0x1F, 0x03, 0xE0, 0x1F, 0x87, 0xC0, 0xF8, 0x07,
  0xC3, 0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x1F, 0x80, 0x7C, 0x3F, 0x07, 0xE0,
  0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xE0, 0x7C, 0x03, 0xF0, 0xF8, 0x1F,
  0x00, 0xFC, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0x83, 0xF0, 0x0F, 0x87, 0xE0,
  0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x0F, 0xC0, 0xFE, 0x1F,
  0x03, 0xF8, 0x7F, 0x87, 0xC0, 0x7F, 0xFB, 0xC3, 0xF0, 0x1F, 0xFD, 0xF0,
  0xFC, 0x03, 0xFE, 0x7C, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x7E,
  0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xFF,
  0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC,
  0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x10, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xFC, 0x3F, 0x83, 0xFF,
  0xF0, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8,
  0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x07,
  0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1E, 0xF0, 0x0F, 0x78, 0x1F, 0x78, 0x0F,
  0xFC, 0x0F, 0xBC, 0x07, 0xBE, 0x07, 0xDE, 0x07, 0xDF, 0x03, 0xEF, 0x83,
  0xCF, 0x81, 0xF7, 0xC3, 0xEF, 0xC0, 0xFB, 0xE1, 0xF7, 0xC0, 0xFC, 0xF0,
  0xF3, 0xE0, 0x7E, 0x78, 0xF9, 0xF0, 0x3F, 0x3C, 0x79, 0xF8, 0x1F, 0x9E,
  0x7C, 0xFC, 0x0F, 0xCF, 0xBC, 0x7E, 0x07, 0xC7, 0xFE, 0x3E, 0x03, 0xE3,
  0xFE, 0x3F, 0x03, 0xF0, 0xFF, 0x1F, 0x81, 0xF8, 0x7F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0xC3, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x7E, 0x07, 0xFC, 0x00, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x1F, 0xF0,
  0x03, 0xF0, 0x3F, 0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0x1F, 0x81, 0xFF, 0xC0,
  0x3F, 0x03, 0xFF, 0x80, 0x7E, 0x07, 0xDF, 0x00, 0xFC, 0x0F, 0xBE, 0x01,
  0xF8, 0x1F, 0x7C, 0x03, 0xF0, 0x3E, 0xFC, 0x07, 0xE0, 0xFD, 0xF8, 0x1F,
  0x81, 0xF9, 0xF0, 0x3F, 0x03, 0xF3, 0xE0, 0x7E, 0x07, 0xE7, 0xC0, 0xFC,
  0x0F, 0xCF, 0x81, 0xF8, 0x1F, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x0F, 0xC0,
  0xFC, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0xFC, 0x0F, 0xC1, 0xF1, 0xF8, 0x3F, 0x03, 0xE3, 0xE0, 0x7E,
  0x07, 0xCF, 0xC0, 0xFC, 0x0F, 0x9F, 0x81, 0xF8, 0x1F, 0xBF, 0x03, 0xF0,
  0x3F, 0x7E, 0x07, 0xE0, 0x3E, 0xFC, 0x1F, 0xC0, 0x7D, 0xF8, 0x3F, 0x00,
  0xFB, 0xE0, 0x7E, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x81, 0xF8, 0x03,
  0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xE0, 0x0F, 0xFC, 0x1F, 0x80, 0x1F,
  0xF0, 0x3F, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF0,
  0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x0F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0x9F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFC,
  0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x03, 0xE3, 0xE0, 0x3F,
  0x81, 0xF8, 0xF8, 0x0F, 0xE0, 0x7E, 0x3E, 0x03, 0xF8, 0x1F, 0x0F, 0x81,
  0xFE, 0x07, 0xC3, 0xE0, 0x7F, 0x83, 0xF0, 0xF8, 0x1D, 0xC0, 0xFC, 0x3E,
  0x07, 0x70, 0x3E, 0x0F, 0x83, 0xDC, 0x0F, 0x87, 0xE0, 0xF7, 0x07, 0xE1,
  0xF8, 0x39, 0xC1, 0xF8, 0x7E, 0x1E, 0x70, 0x7C, 0x1F, 0x87, 0x9C, 0x1F,
  0x07, 0xE1, 0xE7, 0x0F, 0xC1, 0xF8, 0x73, 0xC3, 0xE0, 0x7E, 0x3C, 0xF0,
  0xF8, 0x1F, 0x0F, 0x3C, 0x3E, 0x07, 0xC3, 0x8F, 0x1F, 0x81, 0xF0, 0xE3,
  0xC7, 0xC0, 0x7C, 0x78, 0xF1, 0xF0, 0x1F, 0x1E, 0x3C, 0x7C, 0x07, 0xC7,
  0x0F, 0x3F, 0x01, 0xF3, 0xC3, 0xCF, 0x80, 0x7C, 0xF0, 0xF3, 0xE0, 0x1F,
  0x3C, 0x3C, 0xF8, 0x07, 0xCE, 0x0F, 0x7E, 0x01, 0xF7, 0x83, 0xDF, 0x00,
  0x7D, 0xE0, 0xE7, 0xC0, 0x3F, 0x70, 0x39, 0xF0, 0x0F, 0xFC, 0x0E, 0xF8,
  0x03, 0xEF, 0x03, 0xBE, 0x00, 0xFB, 0xC0, 0xEF, 0x80, 0x3E, 0xE0, 0x3B,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xF9, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F,
  0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xFF, 0x1F,
  0x80, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFE, 0x7F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7E, 0x03, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0xF1, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x0F, 0xC7, 0xFF, 0x00, 0x7E, 0x7F, 0xFC,
  0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFB, 0xC7, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07,
  0xEF, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0x03, 0xFB, 0xFF, 0xF0, 0x1F, 0xCF,
  0xFF, 0x00, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x3F, 0xF8, 0xFC, 0x03,
  0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0x3F, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0xFC,
  0x03, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC, 0x7F, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE3,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC3, 0xF8, 0x07, 0xFF, 0x1F, 0x80, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF,
  0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xF8, 0x7F, 0x80, 0x7F,
  0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xCF,
  0xC0, 0x1F, 0xFC, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x0F, 0xC7, 0xFF, 0x00,
  0x7E, 0x7F, 0xFC, 0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC7, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x01, 0xFE, 0x07,
  0xE0, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0xBF, 0xCF, 0xF8,
  0x3F, 0xFF, 0x9F, 0xF0, 0x7D, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xCF, 0xE1,
  0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x1F,
  0x83, 0xE0, 0x7E, 0x3F, 0x07, 0xC0, 0xFC, 0x7E, 0x0F, 0x83, 0xF0, 0xFC,
  0x1F, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F, 0x8F, 0xC0,
  0xF0, 0x3F, 0x1F, 0x83, 0xE0, 0x7E, 0x3F, 0x07, 0xC0, 0xF8, 0x7E, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x07, 0xE3, 0xF0, 0x3E, 0x0F, 0xC7, 0xE0, 0x78,
  0x1F, 0x8F, 0xC1, 0xF0, 0x3F, 0x1F, 0x83, 0xE0, 0x7C, 0x3F, 0x07, 0xC1,
  0xF8, 0x7C, 0x0F, 0x83, 0xF1, 0xF8, 0x1F, 0x07, 0xE3, 0xF0, 0x3C, 0x0F,
  0xC7, 0xE0, 0xF8, 0x1F, 0x8F, 0xC1, 0xF0, 0x3E, 0x1F, 0x83, 0xE0, 0x7C,
  0x3F, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x3F, 0x1F, 0xFC,
  0x01, 0xF9, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07,
  0xEF, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x05,
  0x00, 0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x03, 0xF1, 0xFF, 0xC0, 0x07, 0xE7,
  0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0xF1,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7E, 0xFF, 0xFF, 0x00, 0xFD,
  0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xC0, 0x0F, 0xE3,
  0xFF, 0x00, 0x1F, 0x80, 0x40, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xFF, 0x1F,
  0x80, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFE, 0x7F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0x7E, 0x03, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0xF1, 0xFC, 0x00, 0x18, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE1,
  0xFF, 0x00, 0x3F, 0x3F, 0xFE, 0x01, 0xFB, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF,
  0xC0, 0xFD, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07,
  0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07,
  0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F,
  0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x01,
  0xF7, 0xC0, 0xFE, 0x07, 0xEF, 0x81, 0xFC, 0x0F, 0x9F, 0x03, 0xF8, 0x1F,
  0x3E, 0x0F, 0xF0, 0x7E, 0x7C, 0x1F, 0xE0, 0xF8, 0xF8, 0x3B, 0xC1, 0xF1,
  0xF0, 0x77, 0x83, 0xE3, 0xE1, 0xEF, 0x0F, 0x87, 0xC3, 0x9E, 0x1F, 0x0F,
  0x87, 0x3C, 0x3E, 0x1F, 0x1E, 0x78, 0xF8, 0x3E, 0x3C, 0xF1, 0xF0, 0x7C,
  0x71, 0xE3, 0xE0, 0xF9, 0xE3, 0xCF, 0xC1, 0xF3, 0xC7, 0x9F, 0x03, 0xE7,
  0x0F, 0x3E, 0x07, 0xDE, 0x1E, 0x7C, 0x0F, 0xBC, 0x3D, 0xF0, 0x1F, 0x70,
  0x7B, 0xE0, 0x3E, 0xE0, 0xF7, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x01, 0xEE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xBF, 0x83, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x3F, 0x00, 0xFF, 0xC3, 0xF0,
  0x01, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xC7, 0xFF, 0x80, 0x7E, 0x7F, 0xFE,
  0x03, 0xF7, 0xFF, 0xF8, 0x1F, 0xBF, 0x1F, 0xC0, 0xF9, 0xF0, 0x7F, 0x0F,
  0xDF, 0x81, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0x3F,
  0x00, 0xFF, 0xE1, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 14, 41, 34, 10, -41 },
  { 73, 21, 17, 34, 9, -41 },
  { 118, 33, 41, 34, 1, -41 },
  { 288, 31, 57, 34, 2, -49 },
  { 509, 40, 41, 34, -2, -41 },
  { 714, 31, 42, 34, 1, -41 },
  { 877, 9, 17, 34, 15, -41 },
  { 897, 24, 54, 34, 8, -47 },
  { 1059, 23, 54, 34, 3, -47 },
  { 1215, 30, 29, 34, 3, -34 },
  { 1324, 28, 27, 34, 3, -32 },
  { 1419, 16, 17, 34, 5, -8 },
  { 1453, 20, 5, 34, 7, -21 },
  { 1466, 11, 11, 34, 10, -10 },
  { 1482, 35, 52, 34, 0, -46 },
  { 1710, 29, 42, 34, 3, -41 },
  { 1863, 27, 41, 34, 2, -41 },
  { 2002, 30, 41, 34, 2, -41 },
  { 2156, 30, 42, 34, 2, -41 },
  { 2314, 28, 41, 34, 3, -41 },
  { 2458, 29, 42, 34, 3, -41 },
  { 2611, 29, 42, 34, 2, -41 },
  { 2764, 28, 41, 34, 6, -41 },
  { 2908, 30, 43, 34, 2, -42 },
  { 3070, 28, 41, 34, 5, -41 },
  { 3214, 14, 32, 34, 10, -31 },
  { 3270, 19, 40, 34, 5, -31 },
  { 3365, 28, 31, 34, 4, -34 },
  { 3474, 27, 19, 34, 4, -28 },
  { 3539, 28, 31, 34, 2, -34 },
  { 3648, 24, 41, 34, 7, -41 },
  { 3771, 34, 51, 34, 0, -41 },
  { 3988, 29, 41, 34, 0, -41 },
  { 4137, 31, 41, 34, 2, -41 },
  { 4296, 30, 42, 34, 3, -41 },
  { 4454, 30, 41, 34, 2, -41 },
  { 4608, 30, 41, 34, 3, -41 },
  { 4762, 32, 41, 34, 2, -41 },
  { 4926, 30, 42, 34, 3, -41 },
  { 5084, 31, 41, 34, 2, -41 },
  { 5243, 29, 41, 34, 3, -41 },
  { 5392, 32, 42, 34, 0, -41 },
  { 5560, 33, 41, 34, 2, -41 },
  { 5730, 26, 41, 34, 3, -41 },
  { 5864, 33, 41, 34, 1, -41 },
  { 6034, 31, 41, 34, 2, -41 },
  { 6193, 29, 42, 34, 3, -41 },
  { 6346, 32, 41, 34, 2, -41 },
  { 6510, 29, 51, 34, 3, -41 },
  { 6695, 31, 41, 34, 2, -41 },
  { 6854, 31, 43, 34, 2, -42 },
  { 7021, 29, 41, 34, 6, -41 },
  { 7170, 30, 42, 34, 3, -41 },
  { 7328, 29, 41, 34, 6, -41 },
  { 7477, 34, 41, 34, 3, -41 },
  { 7652, 36, 41, 34, -1, -41 },
  { 7837, 31, 41, 34, 5, -41 },
  { 7996, 31, 41, 34, 2, -41 },
  { 8155, 24, 52, 34, 7, -46 },
  { 8311, 19, 52, 34, 8, -46 },
  { 8435, 24, 52, 34, 4, -46 },
  { 8591, 25, 22, 34, 5, -41 },
  { 8660, 28, 6, 34, 0, 1 },
  { 8681, 12, 8, 34, 14, -44 },
  { 8693, 29, 32, 34, 3, -31 },
  { 8809, 29, 42, 34, 2, -41 },
  { 8962, 28, 32, 34, 3, -31 },
  { 9074, 30, 42, 34, 3, -41 },
  { 9232, 28, 32, 34, 3, -31 },
  { 9344, 38, 51, 34, -3, -41 },
  { 9587, 29, 41, 34, 3, -31 },
  { 9736, 29, 41, 34, 2, -41 },
  { 9885, 28, 44, 34, 2, -44 },
  { 10039, 29, 54, 34, 1, -44 },
  { 10235, 32, 41, 34, 2, -41 },
  { 10399, 25, 41, 34, 5, -41 },
  { 10528, 31, 31, 34, 1, -31 },
  { 10649, 29, 31, 34, 2, -31 },
  { 10762, 28, 32, 34, 3, -31 },
  { 10874, 31, 41, 34, 0, -31 },
  { 11033, 29, 41, 34, 3, -31 },
  { 11182, 29, 31, 34, 3, -31 },
  { 11295, 29, 32, 34, 2, -31 },
  { 11411, 28, 39, 34, 4, -39 },
  { 11548, 29, 32, 34, 3, -31 },
  { 11664, 28, 31, 34, 5, -31 },
  { 11773, 31, 31, 34, 4, -31 },
  { 11894, 33, 31, 34, 0, -31 },
  { 12022, 28, 41, 34, 3, -31 },
  { 12166, 29, 31, 34, 2, -31 },
  { 12279, 29, 52, 34, 5, -46 },
  { 12468, 15, 52, 34, 10, -46 },
  { 12566, 29, 52, 34, 1, -46 },
  { 12755, 29, 13, 34, 3, -26 },
};

const GFXfont JetBrainsMono_SemiBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC56PT7B_H_
