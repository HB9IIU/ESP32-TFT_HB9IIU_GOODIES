#ifndef _JETBRAINSMONO_SEMIBOLDITALIC14PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0xB0, 0xD8, 0x6D, 0x2C, 0xB6, 0x09, 0x0C, 0x9F, 0xEF,
  0xE3, 0x21, 0x23, 0xFC, 0xC8, 0x48, 0x64, 0x00, 0x04, 0x04, 0x1F, 0x3B,
  0x28, 0x38, 0x3C, 0x0E, 0x0A, 0x52, 0x76, 0x7C, 0x10, 0x10, 0x3C, 0x49,
  0x22, 0x50, 0xE8, 0x04, 0x02, 0xC1, 0xE8, 0x52, 0x24, 0xB1, 0xC0, 0x1E,
  0x32, 0x20, 0x30, 0x30, 0x5B, 0x4E, 0xCC, 0xCE, 0x7E, 0xFE, 0x04, 0x73,
  0x08, 0x61, 0x04, 0x10, 0xC3, 0x0C, 0x18, 0x30, 0x40, 0x20, 0xC1, 0x82,
  0x08, 0x20, 0x86, 0x18, 0x63, 0x1C, 0xC2, 0x00, 0x18, 0x32, 0x4F, 0xF1,
  0x0F, 0x33, 0x24, 0x18, 0x20, 0x47, 0xF3, 0x06, 0x0C, 0x00, 0x36, 0x6C,
  0xF8, 0x7C, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x3C, 0xCD, 0x1E, 0x3F, 0x7A, 0xA1,
  0x42, 0xCC, 0xF0, 0x3D, 0xA5, 0x86, 0x18, 0x61, 0x04, 0x13, 0xF0, 0x3C,
  0xCF, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xF8, 0x7E, 0x08, 0x61, 0x83,
  0xC0, 0x81, 0x46, 0xCD, 0xF0, 0x0E, 0x30, 0x41, 0x86, 0x58, 0xBF, 0x7E,
  0x0C, 0x18, 0x7E, 0xC1, 0x02, 0xC7, 0xD0, 0x81, 0x02, 0xCC, 0xF0, 0x0C,
  0x30, 0xC3, 0x07, 0xD8, 0xA1, 0xC2, 0xCC, 0xF0, 0x7F, 0x42, 0xC6, 0x0C,
  0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0x3C, 0xCD, 0x1B, 0x23, 0x8D, 0xB1,
  0x42, 0xCD, 0xF0, 0x3C, 0xCF, 0x0E, 0x3C, 0x6F, 0x82, 0x0C, 0x30, 0xC0,
  0x37, 0x00, 0x00, 0x6E, 0x19, 0xC0, 0x00, 0x00, 0xCC, 0x66, 0x00, 0x06,
  0x3B, 0xC6, 0x07, 0x03, 0x83, 0x00, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x60,
  0xF0, 0x78, 0x23, 0xDC, 0x20, 0x00, 0x7A, 0x60, 0xC2, 0x79, 0x84, 0x00,
  0xC3, 0x00, 0x1F, 0x10, 0x98, 0x49, 0xE4, 0x92, 0xCB, 0x65, 0xA6, 0x9F,
  0x40, 0x30, 0x0F, 0x01, 0x80, 0x0C, 0x38, 0x78, 0xB3, 0x64, 0xDF, 0xB3,
  0x43, 0x84, 0x7C, 0x8D, 0x1A, 0x3F, 0x99, 0xB1, 0x62, 0x8D, 0xF0, 0x3E,
  0xCD, 0x1E, 0x0C, 0x18, 0x30, 0x42, 0xCC, 0xF0, 0x3E, 0x23, 0x23, 0x23,
  0x63, 0x63, 0x62, 0x66, 0x7E, 0xF8, 0x7E, 0xC1, 0x02, 0x07, 0xD8, 0x30,
  0x60, 0x81, 0xF8, 0x7E, 0xC1, 0x02, 0x0F, 0xDF, 0xB0, 0x60, 0x81, 0x00,
  0x3E, 0xCD, 0x1E, 0x0C, 0x1B, 0xF1, 0x42, 0xCC, 0xF0, 0x62, 0xCD, 0x1A,
  0x3F, 0xF8, 0xB1, 0x66, 0x8D, 0x18, 0x7E, 0x30, 0x60, 0x81, 0x06, 0x0C,
  0x18, 0x31, 0xF8, 0x0F, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0xC6, 0xCC,
  0x78, 0x31, 0x91, 0x89, 0x84, 0x87, 0xC3, 0x61, 0xB0, 0xCC, 0x46, 0x63,
  0x00, 0x61, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xFF, 0xF0, 0x33, 0x99, 0x9D,
  0x4E, 0xA7, 0xF2, 0x59, 0x08, 0x84, 0xC2, 0x63, 0x00, 0x31, 0x31, 0x3B,
  0x3B, 0x6B, 0x6A, 0x6A, 0x4E, 0x4E, 0xC6, 0x3C, 0xCD, 0x1E, 0x3C, 0x78,
  0xB1, 0x46, 0xCC, 0xF0, 0x3F, 0x23, 0x21, 0x23, 0x67, 0x7E, 0x60, 0x60,
  0x40, 0xC0, 0x3C, 0xCD, 0x1E, 0x3C, 0x78, 0xB1, 0x42, 0xCC, 0xF0, 0x60,
  0xC0, 0x80, 0x3F, 0x23, 0x23, 0x23, 0x7E, 0x7C, 0x6C, 0x64, 0x46, 0xC6,
  0x1F, 0x33, 0x20, 0x30, 0x3C, 0x0E, 0x02, 0x42, 0x66, 0x7C, 0x7F, 0x98,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x62, 0x8D, 0x1E, 0x3C,
  0x78, 0xB1, 0x66, 0xCC, 0xF0, 0x87, 0x0A, 0x34, 0x4D, 0x9A, 0x34, 0x78,
  0xE1, 0xC0, 0xD9, 0xDB, 0x9A, 0xAA, 0xAA, 0xAE, 0xAC, 0xCC, 0xCC, 0xCC,
  0x33, 0x99, 0x85, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x48, 0x66, 0x63, 0x00,
  0xC3, 0x66, 0x64, 0x2C, 0x28, 0x30, 0x30, 0x30, 0x30, 0x20, 0x7E, 0x0C,
  0x30, 0xC1, 0x86, 0x18, 0x60, 0xFD, 0xF8, 0x3C, 0xF2, 0x18, 0x61, 0x86,
  0x10, 0x43, 0x0C, 0x30, 0xF3, 0xC0, 0xC6, 0x10, 0x86, 0x31, 0x84, 0x31,
  0x8C, 0x21, 0x0C, 0x3C, 0xF0, 0xC2, 0x08, 0x21, 0x86, 0x18, 0x61, 0x04,
  0xF3, 0xC0, 0x18, 0x70, 0xB3, 0x2C, 0x60, 0xFF, 0xFC, 0xD0, 0x36, 0xFF,
  0x1E, 0x2C, 0x51, 0xB3, 0x7E, 0x30, 0x20, 0x2E, 0x3E, 0x63, 0x62, 0x62,
  0x66, 0x66, 0xDC, 0x38, 0xFB, 0x1E, 0x0C, 0x10, 0xB3, 0x3C, 0x02, 0x0C,
  0xDB, 0xFC, 0x78, 0xB1, 0x46, 0xCD, 0xF8, 0x38, 0xDB, 0x1F, 0xEF, 0xD0,
  0x33, 0x3C, 0x07, 0xC1, 0x00, 0xC0, 0xFE, 0x3F, 0x83, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x83, 0xC0, 0xC0, 0x00, 0x36, 0xFF, 0x1E, 0x2C, 0x59,
  0xBF, 0x16, 0x0D, 0xF3, 0x80, 0x30, 0x20, 0x2E, 0x3E, 0x63, 0x62, 0x62,
  0x66, 0x46, 0xC6, 0x06, 0x18, 0x01, 0xE3, 0xC1, 0x82, 0x04, 0x08, 0x33,
  0xF8, 0x03, 0x06, 0x00, 0x3E, 0x3E, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0xF8, 0xE0, 0x60, 0xC1, 0x1A, 0x2C, 0xDF, 0x3E, 0x6C, 0x8D, 0x18,
  0xF0, 0x43, 0x0C, 0x30, 0xC2, 0x08, 0x30, 0xF0, 0x7B, 0x6F, 0x4B, 0x4B,
  0x4B, 0x5A, 0xD2, 0xD2, 0x2E, 0x3E, 0x63, 0x62, 0x62, 0x66, 0x46, 0xC6,
  0x38, 0xFB, 0x1E, 0x2C, 0x51, 0xB3, 0x3C, 0x2E, 0x3E, 0x63, 0x62, 0x62,
  0x66, 0x66, 0x5C, 0xC0, 0xC0, 0xC0, 0x36, 0xFF, 0x1E, 0x2C, 0x51, 0xB3,
  0x7E, 0x0C, 0x10, 0x20, 0x7C, 0xFD, 0x1E, 0x3C, 0x18, 0x30, 0x40, 0x3C,
  0xFF, 0x03, 0x83, 0xC0, 0xB3, 0x7C, 0x10, 0x63, 0xFF, 0xF3, 0x04, 0x08,
  0x10, 0x70, 0x78, 0x47, 0x8F, 0x1E, 0x2C, 0x59, 0xB3, 0x3C, 0xC3, 0x8D,
  0x12, 0x66, 0x8F, 0x1C, 0x38, 0x93, 0x92, 0xAA, 0xAE, 0xB4, 0xD4, 0xCC,
  0xC8, 0x63, 0x36, 0x14, 0x1C, 0x18, 0x3C, 0x64, 0xC6, 0x47, 0x8F, 0x1E,
  0x2C, 0x59, 0xBF, 0x06, 0x0D, 0xF3, 0x80, 0x7E, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0x7E, 0x02, 0x1C, 0x20, 0x40, 0x83, 0x3C, 0x78, 0x18, 0x20, 0xC1,
  0x83, 0xC1, 0x00, 0x2D, 0xB6, 0x96, 0xDB, 0x49, 0x00, 0x30, 0x38, 0x08,
  0x08, 0x18, 0x18, 0x0F, 0x1E, 0x10, 0x10, 0x10, 0x30, 0xF0, 0xC0, 0x21,
  0xEE, 0x78, 0x60,
};

const GFXglyph JetBrainsMono_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 6, 4, 8, 2, -10 },
  { 8, 9, 10, 8, 0, -10 },
  { 20, 8, 14, 8, 0, -12 },
  { 34, 10, 10, 8, -1, -10 },
  { 47, 8, 10, 8, 0, -10 },
  { 57, 2, 4, 8, 4, -10 },
  { 58, 6, 14, 8, 2, -12 },
  { 69, 6, 14, 8, 1, -12 },
  { 80, 7, 8, 8, 1, -9 },
  { 87, 7, 7, 8, 1, -8 },
  { 94, 4, 4, 8, 1, -2 },
  { 96, 5, 1, 8, 2, -5 },
  { 97, 3, 2, 8, 2, -2 },
  { 98, 9, 14, 8, 0, -12 },
  { 114, 7, 10, 8, 1, -10 },
  { 123, 6, 10, 8, 1, -10 },
  { 131, 7, 10, 8, 1, -10 },
  { 140, 7, 10, 8, 1, -10 },
  { 149, 7, 10, 8, 1, -10 },
  { 158, 7, 10, 8, 1, -10 },
  { 167, 7, 10, 8, 1, -10 },
  { 176, 8, 10, 8, 1, -10 },
  { 186, 7, 10, 8, 1, -10 },
  { 195, 7, 10, 8, 1, -10 },
  { 204, 4, 8, 8, 2, -8 },
  { 208, 5, 10, 8, 1, -8 },
  { 215, 7, 7, 8, 1, -8 },
  { 222, 7, 5, 8, 1, -7 },
  { 227, 7, 7, 8, 1, -8 },
  { 234, 6, 10, 8, 2, -10 },
  { 242, 9, 13, 8, 0, -10 },
  { 257, 7, 10, 8, 0, -10 },
  { 266, 7, 10, 8, 1, -10 },
  { 275, 7, 10, 8, 1, -10 },
  { 284, 8, 10, 8, 0, -10 },
  { 294, 7, 10, 8, 1, -10 },
  { 303, 7, 10, 8, 1, -10 },
  { 312, 7, 10, 8, 1, -10 },
  { 321, 7, 10, 8, 1, -10 },
  { 330, 7, 10, 8, 1, -10 },
  { 339, 8, 10, 8, 0, -10 },
  { 349, 9, 10, 8, 0, -10 },
  { 361, 6, 10, 8, 1, -10 },
  { 369, 9, 10, 8, 0, -10 },
  { 381, 8, 10, 8, 0, -10 },
  { 391, 7, 10, 8, 1, -10 },
  { 400, 8, 10, 8, 0, -10 },
  { 410, 7, 13, 8, 1, -10 },
  { 422, 8, 10, 8, 0, -10 },
  { 432, 8, 10, 8, 0, -10 },
  { 442, 8, 10, 8, 1, -10 },
  { 452, 7, 10, 8, 1, -10 },
  { 461, 7, 10, 8, 2, -10 },
  { 470, 8, 10, 8, 1, -10 },
  { 480, 9, 10, 8, 0, -10 },
  { 492, 8, 10, 8, 1, -10 },
  { 502, 7, 10, 8, 1, -10 },
  { 511, 6, 14, 8, 2, -12 },
  { 522, 5, 14, 8, 2, -12 },
  { 531, 6, 14, 8, 1, -12 },
  { 542, 7, 5, 8, 1, -10 },
  { 547, 7, 2, 8, 0, 0 },
  { 549, 2, 2, 8, 4, -11 },
  { 550, 7, 8, 8, 1, -8 },
  { 557, 8, 10, 8, 0, -10 },
  { 567, 7, 8, 8, 1, -8 },
  { 574, 7, 10, 8, 1, -10 },
  { 583, 7, 8, 8, 1, -8 },
  { 590, 10, 13, 8, -1, -10 },
  { 607, 7, 11, 8, 1, -8 },
  { 617, 8, 10, 8, 0, -10 },
  { 627, 7, 11, 8, 0, -11 },
  { 637, 8, 14, 8, 0, -11 },
  { 651, 7, 10, 8, 1, -10 },
  { 660, 6, 10, 8, 1, -10 },
  { 668, 8, 8, 8, 0, -8 },
  { 676, 8, 8, 8, 0, -8 },
  { 684, 7, 8, 8, 1, -8 },
  { 691, 8, 11, 8, 0, -8 },
  { 702, 7, 11, 8, 1, -8 },
  { 712, 7, 8, 8, 1, -8 },
  { 719, 7, 8, 8, 1, -8 },
  { 726, 7, 10, 8, 1, -10 },
  { 735, 7, 8, 8, 1, -8 },
  { 742, 7, 8, 8, 1, -8 },
  { 749, 8, 8, 8, 1, -8 },
  { 757, 8, 8, 8, 0, -8 },
  { 765, 7, 11, 8, 1, -8 },
  { 775, 7, 8, 8, 1, -8 },
  { 782, 7, 14, 8, 1, -12 },
  { 795, 3, 14, 8, 3, -12 },
  { 801, 8, 14, 8, 0, -12 },
  { 815, 7, 4, 8, 1, -7 },
};

const GFXfont JetBrainsMono_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC14PT7B_H_
