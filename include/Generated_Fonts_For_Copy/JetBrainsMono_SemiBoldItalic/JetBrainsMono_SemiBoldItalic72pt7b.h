#ifndef _JETBRAINSMONO_SEMIBOLDITALIC72PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F,
  0xF1, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF1, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xEF, 0x7F, 0xF8, 0x07, 0xFE, 0x3E, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7C, 0x3F, 0xE0, 0x3F, 0xE0, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xE0, 0x7F,
  0x80, 0xFF, 0x03, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0x81, 0xFE, 0x07, 0xFC,
  0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x7C, 0x00,
  0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x00, 0xFF,
  0xE3, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x00, 0x07, 0xC3, 0xFF, 0x00,
  0x00, 0x0F, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0x07, 0xFC, 0x00, 0x00, 0x3C,
  0x0F, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xE1,
  0xFF, 0x03, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x0F,
  0x81, 0xFE, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x1F, 0xF0,
  0x1F, 0xF8, 0x78, 0x7F, 0xE0, 0x3F, 0xF9, 0xF3, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0x9F, 0xE0, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF1, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0xFC,
  0x01, 0xF8, 0x07, 0xE1, 0xFE, 0x03, 0xE0, 0x3F, 0xC7, 0xFF, 0x07, 0xC1,
  0xFF, 0x8F, 0xFF, 0x0F, 0x0F, 0xFF, 0xBF, 0xFF, 0x9E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xB9, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xE3, 0xFF,
  0xCF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x0F, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0xC1, 0xFE, 0x0F, 0x80, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF7,
  0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xE0, 0x00,
  0xF8, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x03, 0x00, 0x0F, 0xF0,
  0x00, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x5F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0x9F,
  0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x7F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0xF0, 0x07,
  0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF,
  0xF7, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xF7, 0xFC, 0x00, 0x3F, 0xFC, 0xFF,
  0x80, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xFC, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xE7, 0xE0, 0xFE, 0x00, 0xFF, 0xFE,
  0x7E, 0x0F, 0xE0, 0x0F, 0xFF, 0xE7, 0xE0, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0x7E, 0x07, 0xF0, 0x07, 0xFF, 0xE7,
  0xE0, 0x7F, 0x00, 0x7F, 0xFC, 0x7E, 0x0F, 0xE0, 0x03, 0xFF, 0x8F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x01, 0xFB, 0xF8,
  0x07, 0xF3, 0xE0, 0x3F, 0x7F, 0x00, 0xFE, 0x7E, 0x0F, 0xCF, 0xE0, 0x1F,
  0xCF, 0xC1, 0xF9, 0xFC, 0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x00, 0x7F, 0x3F,
  0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE3, 0xF1, 0xFC, 0x01, 0xFC, 0x7C, 0x7E,
  0x3F, 0x80, 0x7F, 0x8F, 0x8F, 0x87, 0xF0, 0x0F, 0xF1, 0xFB, 0xF1, 0xFE,
  0x01, 0xFC, 0x3F, 0x7E, 0x3F, 0x80, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0x07,
  0xF0, 0xFF, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF7, 0xF0, 0x07, 0xF8, 0x07, 0xFB, 0xF8, 0x03, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0xFF,
  0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x83, 0xFC,
  0x01, 0xFC, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0x00, 0xFF,
  0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xC7, 0xF8, 0x07, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xFC,
  0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x9F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xF0,
  0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x7F,
  0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7B, 0xC0, 0x3F, 0x87, 0xF0,
  0x0F, 0x78, 0x07, 0xF0, 0xFE, 0x03, 0xEF, 0x01, 0xFC, 0x1F, 0xC0, 0x7D,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0x7C, 0x07, 0xF0, 0x7F, 0x03, 0xEF, 0x80,
  0xFE, 0x0F, 0xE0, 0x7D, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xBE, 0x07, 0xF0,
  0x3F, 0x81, 0xE7, 0xC0, 0xFE, 0x07, 0xF0, 0x7C, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0x9F, 0x07, 0xF0, 0x3F, 0x81, 0xE3, 0xE0, 0xFE, 0x07, 0xF0, 0x7C,
  0x7C, 0x1F, 0xC0, 0xFE, 0x0F, 0x8F, 0x83, 0xF0, 0x1F, 0xC1, 0xF1, 0xF0,
  0xFE, 0x03, 0xF8, 0x3C, 0x3C, 0x1F, 0xC0, 0x7F, 0x0F, 0x87, 0x83, 0xF8,
  0x0F, 0xE1, 0xF0, 0xF0, 0x7E, 0x01, 0xFC, 0x3E, 0x1E, 0x1F, 0xC0, 0x3F,
  0x8F, 0x83, 0xC3, 0xF8, 0x07, 0xF1, 0xF0, 0x78, 0x7F, 0x00, 0xFE, 0x3E,
  0x0F, 0x0F, 0xC0, 0x1F, 0xC7, 0x81, 0xE3, 0xF8, 0x03, 0xF9, 0xF0, 0x7C,
  0x7F, 0x00, 0x7F, 0x3E, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8,
  0x01, 0xF8, 0xF0, 0x3E, 0x7F, 0x00, 0x3F, 0x3E, 0x07, 0xCF, 0xE0, 0x07,
  0xE7, 0xC0, 0xF9, 0xF8, 0x01, 0xFC, 0xF8, 0x1F, 0x3F, 0x00, 0x3F, 0xBE,
  0x03, 0xEF, 0xE0, 0x07, 0xF7, 0xC0, 0x7D, 0xFC, 0x00, 0xFE, 0xF8, 0x0F,
  0xBF, 0x00, 0x1F, 0xDE, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFB, 0xC0, 0x1E, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xDF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xF3, 0xF0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x7F,
  0x80, 0x1F, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0xFF, 0xBF,
  0xC0, 0x1F, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0xE7, 0xFC, 0x00, 0x7F,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFC, 0x00, 0x7F,
  0x8F, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0xFE,
  0x01, 0xFE, 0xFF, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xFC, 0x07,
  0xF9, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0xFC, 0x01, 0xFE, 0x1F, 0xFF,
  0x80, 0x0F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x07, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xF8, 0x00, 0xFF,
  0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0xFF, 0x00, 0x3F, 0xFF,
  0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xFF, 0xCF, 0xF8,
  0x00, 0x7F, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0x80, 0x1F,
  0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFB, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xFF,
  0xEF, 0xF0, 0x03, 0xFF, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xFC, 0x00,
  0x3F, 0xFC, 0x1F, 0xE0, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0x8F, 0xFF, 0xF0, 0x07, 0xFC, 0xFF,
  0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF7, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0xFF, 0x87, 0xFE,
  0x00, 0xFE, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F,
  0x7F, 0xFB, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0xC1, 0xFE,
  0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x1F, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0xC1,
  0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0xF8,
  0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0x9F,
  0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFF,
  0x80, 0x00, 0x7F, 0x87, 0xFF, 0xE0, 0x00, 0x7F, 0x8F, 0xFF, 0xF0, 0x00,
  0xFF, 0x9F, 0xFF, 0xF8, 0x00, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xFF,
  0x00, 0x1F, 0xE3, 0xFF, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x7F, 0x80,
  0x1F, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0xC0,
  0x1F, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0xE7, 0xFC, 0x00, 0x7F, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xC7, 0xFF, 0xFC, 0x00,
  0xFF, 0x3F, 0xFF, 0xF0, 0x07, 0xF9, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xDE, 0x01, 0xF8, 0xFE, 0x03, 0xDE,
  0x03, 0xF8, 0xFC, 0x07, 0xDE, 0x03, 0xF8, 0xFC, 0x07, 0x9E, 0x03, 0xF0,
  0xFC, 0x07, 0x9E, 0x07, 0xF0, 0xFC, 0x0F, 0x9E, 0x07, 0xF0, 0xFC, 0x0F,
  0x9E, 0x07, 0xE0, 0xFC, 0x0F, 0x1E, 0x07, 0xE0, 0xFC, 0x1F, 0x1E, 0x0F,
  0xE0, 0xFC, 0x1F, 0x1E, 0x0F, 0xC0, 0xFC, 0x1E, 0x3E, 0x0F, 0xC0, 0xFC,
  0x3E, 0x3E, 0x1F, 0xC0, 0xFC, 0x3E, 0x3E, 0x1F, 0xC0, 0xFC, 0x3C, 0x3E,
  0x1F, 0x80, 0xFC, 0x3C, 0x3E, 0x3F, 0x80, 0xFC, 0x7C, 0x3E, 0x3F, 0x80,
  0xFC, 0x7C, 0x3E, 0x3F, 0x00, 0xFC, 0x78, 0x3E, 0x7F, 0x00, 0xFC, 0xF8,
  0x3E, 0x7F, 0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0xFC, 0xF0, 0x3E, 0x7E,
  0x00, 0xFD, 0xF0, 0x3E, 0xFE, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0xFD,
  0xE0, 0x3E, 0xFC, 0x00, 0xFD, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xEF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFE, 0x01,
  0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0xFC, 0x1F,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xF1, 0xFF, 0xFF,
  0x00, 0x3F, 0x9F, 0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF,
  0xF8, 0xFF, 0x80, 0xFE, 0x7F, 0x03, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xF8,
  0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xCF, 0xE0,
  0x07, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0xFF, 0xC3, 0xF8, 0x00, 0xFF, 0xFC,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 18, 53, 43, 13, -53 },
  { 121, 27, 22, 43, 12, -53 },
  { 196, 43, 53, 43, 1, -53 },
  { 481, 39, 73, 43, 3, -63 },
  { 837, 51, 53, 43, -3, -53 },
  { 1175, 41, 54, 43, 1, -53 },
  { 1452, 11, 22, 43, 20, -53 },
  { 1483, 30, 70, 43, 11, -61 },
  { 1746, 30, 70, 43, 4, -61 },
  { 2009, 39, 38, 43, 3, -44 },
  { 2195, 36, 34, 43, 4, -41 },
  { 2348, 20, 23, 43, 6, -11 },
  { 2406, 25, 8, 43, 10, -28 },
  { 2431, 14, 13, 43, 12, -12 },
  { 2454, 45, 68, 43, 0, -60 },
  { 2837, 38, 54, 43, 4, -53 },
  { 3094, 35, 53, 43, 3, -53 },
  { 3326, 38, 53, 43, 3, -53 },
  { 3578, 38, 54, 43, 3, -53 },
  { 3835, 37, 53, 43, 3, -53 },
  { 4081, 37, 54, 43, 4, -53 },
  { 4331, 36, 54, 43, 3, -53 },
  { 4574, 37, 53, 43, 7, -53 },
  { 4820, 38, 54, 43, 3, -53 },
  { 5077, 36, 53, 43, 6, -53 },
  { 5316, 19, 41, 43, 12, -40 },
  { 5414, 25, 52, 43, 6, -40 },
  { 5577, 35, 39, 43, 6, -43 },
  { 5748, 35, 25, 43, 5, -36 },
  { 5858, 36, 39, 43, 3, -43 },
  { 6034, 31, 53, 43, 9, -53 },
  { 6240, 44, 66, 43, 0, -53 },
  { 6603, 37, 53, 43, 0, -53 },
  { 6849, 39, 53, 43, 3, -53 },
  { 7108, 38, 54, 43, 4, -53 },
  { 7365, 39, 53, 43, 3, -53 },
  { 7624, 40, 53, 43, 3, -53 },
  { 7889, 40, 53, 43, 3, -53 },
  { 8154, 38, 54, 43, 4, -53 },
  { 8411, 40, 53, 43, 3, -53 },
  { 8676, 38, 53, 43, 4, -53 },
  { 8928, 42, 54, 43, 0, -53 },
  { 9212, 42, 53, 43, 3, -53 },
  { 9491, 33, 53, 43, 4, -53 },
  { 9710, 43, 53, 43, 1, -53 },
  { 9995, 41, 53, 43, 2, -53 },
  { 10267, 37, 54, 43, 4, -53 },
  { 10517, 41, 53, 43, 3, -53 },
  { 10789, 38, 66, 43, 4, -53 },
  { 11103, 40, 53, 43, 3, -53 },
  { 11368, 40, 54, 43, 2, -53 },
  { 11638, 38, 53, 43, 7, -53 },
  { 11890, 39, 54, 43, 4, -53 },
  { 12154, 38, 53, 43, 8, -53 },
  { 12406, 43, 53, 43, 4, -53 },
  { 12691, 46, 53, 43, -1, -53 },
  { 12996, 40, 53, 43, 7, -53 },
  { 13261, 39, 53, 43, 3, -53 },
  { 13520, 30, 68, 43, 9, -60 },
  { 13775, 23, 68, 43, 11, -60 },
  { 13971, 30, 68, 43, 6, -60 },
  { 14226, 33, 29, 43, 6, -53 },
  { 14346, 35, 7, 43, 0, 2 },
  { 14377, 15, 11, 43, 18, -57 },
  { 14398, 38, 41, 43, 3, -40 },
  { 14593, 37, 54, 43, 3, -53 },
  { 14843, 36, 41, 43, 4, -40 },
  { 15028, 39, 54, 43, 4, -53 },
  { 15292, 35, 41, 43, 4, -40 },
  { 15472, 49, 66, 43, -4, -53 },
  { 15877, 37, 53, 43, 4, -40 },
  { 16123, 37, 53, 43, 3, -53 },
  { 16369, 36, 56, 43, 2, -56 },
  { 16621, 38, 69, 43, 1, -56 },
  { 16949, 40, 53, 43, 3, -53 },
  { 17214, 32, 53, 43, 6, -53 },
  { 17426, 41, 40, 43, 1, -40 },
  { 17631, 37, 40, 43, 3, -40 },
  { 17816, 35, 41, 43, 4, -40 },
  { 17996, 40, 53, 43, 0, -40 },
  { 18261, 38, 53, 43, 3, -40 },
  { 18513, 38, 40, 43, 4, -40 },
  { 18703, 37, 41, 43, 3, -40 },
  { 18893, 36, 50, 43, 5, -50 },
  { 19118, 37, 41, 43, 4, -40 },
  { 19308, 37, 40, 43, 6, -40 },
  { 19493, 40, 40, 43, 5, -40 },
  { 19693, 42, 40, 43, 0, -40 },
  { 19903, 36, 53, 43, 4, -40 },
  { 20142, 37, 40, 43, 3, -40 },
  { 20327, 38, 68, 43, 6, -60 },
  { 20650, 19, 68, 43, 13, -60 },
  { 20812, 38, 68, 43, 1, -60 },
  { 21135, 37, 17, 43, 4, -34 },
};

const GFXfont JetBrainsMono_SemiBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC72PT7B_H_
