#ifndef _JETBRAINSMONO_SEMIBOLDITALIC15PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x64, 0x44, 0x0C, 0xC0, 0xDE, 0xE7, 0x29, 0x00, 0x09,
  0x84, 0x86, 0x4F, 0xF1, 0x21, 0x90, 0x99, 0xFE, 0x64, 0x26, 0x32, 0x00,
  0x08, 0x08, 0x3E, 0x7E, 0x6B, 0x68, 0x70, 0x3C, 0x1E, 0x16, 0x96, 0xDC,
  0x78, 0x20, 0x20, 0x1C, 0x64, 0x98, 0x92, 0x12, 0x83, 0xA0, 0x08, 0x03,
  0xE0, 0xF6, 0x36, 0xC4, 0x93, 0x1E, 0x00, 0x1E, 0x19, 0x8C, 0xC6, 0x01,
  0x03, 0xC5, 0x2C, 0x9C, 0xC6, 0x67, 0x1E, 0xC0, 0x7F, 0xC0, 0x02, 0x18,
  0x61, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x03, 0x06, 0x07, 0x04, 0x00,
  0x20, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x33, 0x88, 0x00,
  0x18, 0x18, 0xD3, 0xFE, 0x18, 0x68, 0xCC, 0x48, 0x18, 0x30, 0x67, 0xFF,
  0xE2, 0x0C, 0x18, 0x3B, 0x19, 0x80, 0xFF, 0xC0, 0x7C, 0x01, 0x81, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x00, 0x3E, 0x76, 0x63, 0x42, 0xC2, 0xDE, 0xC6, 0xC6, 0xC6, 0xCC, 0x78,
  0x1C, 0x79, 0xB4, 0x40, 0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x3E, 0x76,
  0x42, 0x82, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0xFC, 0x7F, 0x7E, 0x0C,
  0x18, 0x1C, 0x3E, 0x06, 0x06, 0xC6, 0xCC, 0x78, 0x06, 0x18, 0x61, 0x83,
  0x0C, 0xF1, 0xFF, 0xFC, 0x18, 0x30, 0x7F, 0x7E, 0x60, 0x60, 0x5C, 0xE6,
  0x06, 0x06, 0xC6, 0xCC, 0x78, 0x0C, 0x30, 0x61, 0x87, 0xDF, 0xF1, 0xC3,
  0x87, 0x99, 0xE0, 0xFF, 0xFE, 0x10, 0x60, 0x83, 0x0C, 0x18, 0x60, 0xC3,
  0x00, 0x3E, 0x76, 0x62, 0x66, 0x6C, 0x38, 0x6E, 0xC6, 0xC6, 0xCC, 0x78,
  0x3E, 0x76, 0x43, 0xC3, 0xC2, 0x7E, 0x3C, 0x0C, 0x18, 0x30, 0x60, 0x6C,
  0x00, 0x36, 0x18, 0xC0, 0x00, 0x04, 0xC6, 0x66, 0x00, 0x03, 0x0E, 0x38,
  0xE0, 0xE0, 0x78, 0x1E, 0x04, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x40,
  0xE0, 0xF0, 0x70, 0xE7, 0xB8, 0x40, 0x79, 0xF0, 0xC3, 0x0D, 0xE6, 0x10,
  0x03, 0x0C, 0x00, 0x1F, 0x18, 0xD8, 0x2C, 0x14, 0xEA, 0x4D, 0x27, 0xB2,
  0xD9, 0x67, 0xB0, 0x18, 0x07, 0x81, 0xC0, 0x0E, 0x0E, 0x1E, 0x1E, 0x12,
  0x32, 0x32, 0x7E, 0x63, 0x43, 0xC3, 0x7E, 0x7E, 0x63, 0x42, 0x46, 0xFC,
  0xC6, 0xC6, 0xC6, 0x9C, 0xF8, 0x3E, 0x76, 0x63, 0x40, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC6, 0xCC, 0x78, 0x7C, 0x7E, 0x63, 0x42, 0x42, 0xC6, 0xC6, 0xC6,
  0xC6, 0xFC, 0xF8, 0x7F, 0x7F, 0x60, 0x60, 0x40, 0x7E, 0xC0, 0xC0, 0xC0,
  0xFC, 0xFC, 0x7F, 0x7F, 0x60, 0x60, 0x40, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x3E, 0x76, 0x63, 0x40, 0xC0, 0xDE, 0xDE, 0xC6, 0xC6, 0xCC, 0x78,
  0x63, 0x63, 0x62, 0x42, 0x46, 0xFE, 0xC6, 0xC6, 0xC6, 0xC4, 0x8C, 0x7F,
  0x7E, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0xFC, 0xFC, 0x0F, 0x87,
  0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0xC6, 0x77, 0x1F, 0x00, 0x63,
  0x63, 0x66, 0x4C, 0x4C, 0xF8, 0xC8, 0xCC, 0xCC, 0xCC, 0x86, 0x20, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0xFF, 0xF0, 0x31, 0x99, 0xCC, 0xEF,
  0xF6, 0xD3, 0x69, 0x84, 0x86, 0x43, 0x61, 0xB0, 0xC0, 0x31, 0x9C, 0xCE,
  0x65, 0x22, 0x93, 0x59, 0xBC, 0xDE, 0x47, 0x23, 0x31, 0x80, 0x3E, 0x76,
  0x63, 0x42, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0x78, 0x7E, 0x7F, 0x63,
  0x43, 0x43, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0x80, 0x3E, 0x76, 0x63, 0x42,
  0xC2, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0x78, 0x18, 0x08, 0x0C, 0x7E, 0x7F,
  0x63, 0x43, 0x46, 0xFE, 0xF8, 0xCC, 0xCC, 0xCC, 0x86, 0x1F, 0x1D, 0x8C,
  0x66, 0x03, 0x80, 0xF0, 0x1C, 0x06, 0x43, 0x33, 0x0F, 0x00, 0xFF, 0xFC,
  0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x80, 0x63, 0x63, 0x63, 0x42,
  0x46, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0x78, 0x83, 0xC6, 0xC4, 0xCC, 0xCC,
  0xC8, 0xD8, 0xD0, 0xF0, 0x70, 0x60, 0xC9, 0xEC, 0xB6, 0x5B, 0x6D, 0xB5,
  0x52, 0xA9, 0x5C, 0xCE, 0x66, 0x33, 0x00, 0x31, 0x99, 0x84, 0xC3, 0xC1,
  0xC0, 0x60, 0x70, 0x6C, 0x26, 0x33, 0x30, 0xC0, 0xC1, 0xB1, 0x99, 0x84,
  0xC3, 0xC1, 0xC0, 0xE0, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x7F, 0x7E, 0x06,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xFC, 0xFC, 0x3C, 0xC2, 0x08, 0x61,
  0x86, 0x18, 0x41, 0x0C, 0x30, 0xF3, 0xC0, 0xC2, 0x18, 0xC6, 0x10, 0xC6,
  0x31, 0x84, 0x31, 0x8C, 0x3C, 0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61,
  0x86, 0xF3, 0xC0, 0x1C, 0x38, 0xD1, 0x26, 0x78, 0xC0, 0xFF, 0xFC, 0xCC,
  0x7A, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0x7E, 0x60, 0xC1, 0x82, 0xF6, 0x78,
  0xF1, 0xE3, 0xC7, 0x9A, 0xE0, 0x3E, 0xCF, 0x1E, 0x0C, 0x18, 0xF3, 0x3C,
  0x03, 0x03, 0x02, 0x7A, 0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x3E,
  0xCF, 0x1F, 0xFC, 0x18, 0x73, 0x3C, 0x03, 0xC1, 0xF0, 0x60, 0x11, 0x3F,
  0x83, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0xF8, 0x38, 0x00,
  0x7A, 0xCF, 0x1E, 0x3C, 0x79, 0xFD, 0x16, 0x0D, 0xFB, 0xC0, 0x60, 0xC1,
  0x82, 0xF6, 0x78, 0xF1, 0xE3, 0xC7, 0x8A, 0x30, 0x06, 0x06, 0x00, 0x00,
  0x3C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x7F, 0xFF, 0x03, 0x03, 0x00, 0x00,
  0x3E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0xF8, 0xF0, 0x60,
  0x60, 0x60, 0x67, 0x46, 0xCC, 0xF8, 0xF8, 0xCC, 0xCC, 0x86, 0x79, 0xF0,
  0x40, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0xF8, 0x7B, 0x36, 0xDA, 0x49,
  0x24, 0x92, 0x5B, 0x6D, 0xB6, 0x7E, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0x46,
  0x3E, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0x3C, 0x3F, 0x33, 0x63, 0x63, 0x63,
  0x63, 0x66, 0x5C, 0xC0, 0xC0, 0xC0, 0x7A, 0xCF, 0x1E, 0x3C, 0x78, 0xF3,
  0x7E, 0x0C, 0x18, 0x30, 0x7E, 0x66, 0x42, 0x40, 0xC0, 0xC0, 0xC0, 0xC0,
  0x7E, 0x8D, 0x03, 0xE0, 0xE0, 0xF3, 0x7E, 0x18, 0x18, 0x11, 0xFE, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x3C, 0x3C, 0x62, 0x8F, 0x1E, 0x3C, 0x78, 0xF3,
  0x3C, 0xC3, 0x46, 0x46, 0x6C, 0x6C, 0x68, 0x78, 0x30, 0x99, 0x9B, 0x9A,
  0xAA, 0xAE, 0xAC, 0xCC, 0xCC, 0x73, 0x9B, 0x07, 0x83, 0x81, 0xC1, 0xA1,
  0x99, 0x86, 0x62, 0x8F, 0x1E, 0x3C, 0x79, 0xFD, 0x06, 0x0D, 0xFB, 0xC0,
  0x7E, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0x7E, 0x07, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0xF0, 0x18, 0x18, 0x18, 0x10, 0x10, 0x1C, 0x0C, 0x32, 0x66, 0x66,
  0x64, 0x4C, 0xCC, 0xC8, 0x3C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x0F, 0x18,
  0x18, 0x18, 0x10, 0x30, 0xF0, 0xC0, 0x73, 0xD2, 0x9E,
};

const GFXglyph JetBrainsMono_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 5, 5, 9, 3, -11 },
  { 11, 9, 11, 9, 0, -11 },
  { 24, 8, 15, 9, 1, -13 },
  { 39, 11, 11, 9, -1, -11 },
  { 55, 9, 11, 9, 0, -11 },
  { 68, 2, 5, 9, 4, -11 },
  { 70, 7, 15, 9, 2, -13 },
  { 84, 6, 15, 9, 1, -13 },
  { 96, 8, 8, 9, 1, -9 },
  { 104, 7, 8, 9, 1, -9 },
  { 111, 5, 4, 9, 1, -2 },
  { 114, 5, 2, 9, 2, -6 },
  { 116, 2, 3, 9, 3, -3 },
  { 117, 9, 14, 9, 0, -12 },
  { 133, 8, 11, 9, 1, -11 },
  { 144, 7, 11, 9, 1, -11 },
  { 154, 8, 11, 9, 1, -11 },
  { 165, 8, 11, 9, 1, -11 },
  { 176, 7, 11, 9, 1, -11 },
  { 186, 8, 11, 9, 1, -11 },
  { 197, 7, 11, 9, 1, -11 },
  { 207, 7, 11, 9, 2, -11 },
  { 217, 8, 11, 9, 1, -11 },
  { 228, 8, 11, 9, 1, -11 },
  { 239, 3, 8, 9, 3, -8 },
  { 242, 5, 10, 9, 1, -8 },
  { 249, 8, 8, 9, 1, -9 },
  { 257, 7, 6, 9, 1, -8 },
  { 263, 7, 8, 9, 1, -9 },
  { 270, 6, 11, 9, 2, -11 },
  { 279, 9, 14, 9, 0, -11 },
  { 295, 8, 11, 9, 0, -11 },
  { 306, 8, 11, 9, 1, -11 },
  { 317, 8, 11, 9, 1, -11 },
  { 328, 8, 11, 9, 1, -11 },
  { 339, 8, 11, 9, 1, -11 },
  { 350, 8, 11, 9, 1, -11 },
  { 361, 8, 11, 9, 1, -11 },
  { 372, 8, 11, 9, 1, -11 },
  { 383, 8, 11, 9, 1, -11 },
  { 394, 9, 11, 9, 0, -11 },
  { 407, 8, 11, 9, 1, -11 },
  { 418, 7, 11, 9, 1, -11 },
  { 428, 9, 11, 9, 0, -11 },
  { 441, 9, 11, 9, 0, -11 },
  { 454, 8, 11, 9, 1, -11 },
  { 465, 8, 11, 9, 1, -11 },
  { 476, 8, 14, 9, 1, -11 },
  { 490, 8, 11, 9, 1, -11 },
  { 501, 9, 11, 9, 0, -11 },
  { 514, 7, 11, 9, 2, -11 },
  { 524, 8, 11, 9, 1, -11 },
  { 535, 8, 11, 9, 2, -11 },
  { 546, 9, 11, 9, 1, -11 },
  { 559, 9, 11, 9, 0, -11 },
  { 572, 9, 11, 9, 1, -11 },
  { 585, 8, 11, 9, 1, -11 },
  { 596, 6, 14, 9, 2, -12 },
  { 607, 5, 14, 9, 2, -12 },
  { 616, 6, 14, 9, 1, -12 },
  { 627, 7, 6, 9, 1, -11 },
  { 633, 7, 2, 9, 0, 0 },
  { 635, 3, 2, 9, 4, -12 },
  { 636, 7, 8, 9, 1, -8 },
  { 643, 7, 11, 9, 1, -11 },
  { 653, 7, 8, 9, 1, -8 },
  { 660, 8, 11, 9, 1, -11 },
  { 671, 7, 8, 9, 1, -8 },
  { 678, 10, 14, 9, -1, -11 },
  { 696, 7, 11, 9, 1, -8 },
  { 706, 7, 11, 9, 1, -11 },
  { 716, 8, 12, 9, 0, -12 },
  { 728, 8, 15, 9, 0, -12 },
  { 743, 8, 11, 9, 1, -11 },
  { 754, 7, 11, 9, 1, -11 },
  { 764, 9, 8, 9, 0, -8 },
  { 773, 7, 8, 9, 1, -8 },
  { 780, 7, 8, 9, 1, -8 },
  { 787, 8, 11, 9, 0, -8 },
  { 798, 7, 11, 9, 1, -8 },
  { 808, 8, 8, 9, 1, -8 },
  { 816, 7, 8, 9, 1, -8 },
  { 823, 8, 11, 9, 1, -11 },
  { 834, 7, 8, 9, 1, -8 },
  { 841, 8, 8, 9, 1, -8 },
  { 849, 8, 8, 9, 1, -8 },
  { 857, 9, 8, 9, 0, -8 },
  { 866, 7, 11, 9, 1, -8 },
  { 876, 7, 8, 9, 1, -8 },
  { 883, 8, 14, 9, 1, -12 },
  { 897, 4, 14, 9, 3, -12 },
  { 904, 8, 14, 9, 0, -12 },
  { 918, 8, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC15PT7B_H_
