#ifndef _JETBRAINSMONO_SEMIBOLDITALIC9PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x5E, 0x88, 0xB7, 0x00, 0x28, 0xA7, 0xD4, 0xF9, 0x4A, 0x00, 0x11,
  0x96, 0xA7, 0x1E, 0xAE, 0x20, 0x66, 0xAB, 0x14, 0x39, 0xA9, 0x80, 0x32,
  0x50, 0xCA, 0xCB, 0xE0, 0x58, 0x13, 0x44, 0x44, 0xC4, 0x60, 0x43, 0x11,
  0x11, 0x12, 0xC0, 0x16, 0xCC, 0xA0, 0x64, 0xF4, 0x60, 0xE0, 0xC0, 0x0C,
  0x61, 0x0C, 0x21, 0x04, 0x20, 0x32, 0x52, 0xD4, 0xA5, 0xC0, 0x13, 0x94,
  0x23, 0x13, 0xE0, 0x32, 0x42, 0x33, 0x23, 0xE0, 0x78, 0x44, 0x60, 0xED,
  0xC0, 0x08, 0x88, 0x94, 0xF8, 0x40, 0x7A, 0x10, 0xF0, 0xAD, 0xC0, 0x10,
  0x88, 0xF4, 0xC5, 0xC0, 0xFC, 0x84, 0x42, 0x22, 0x00, 0x32, 0x52, 0x65,
  0xE5, 0xC0, 0x69, 0x9B, 0x64, 0xC0, 0xC0, 0x80, 0x60, 0x05, 0x00, 0x3C,
  0xC7, 0xF0, 0x0F, 0x60, 0xC7, 0xC0, 0x63, 0x16, 0x40, 0xC0, 0x31, 0x25,
  0xAA, 0xAA, 0xAB, 0x20, 0x60, 0x11, 0x8C, 0xA7, 0x26, 0x20, 0x72, 0x52,
  0xE4, 0xA7, 0xC0, 0x32, 0x50, 0x84, 0x25, 0xC0, 0x72, 0x52, 0x94, 0xAF,
  0xC0, 0x7A, 0x10, 0xF4, 0x23, 0xC0, 0x7A, 0x10, 0xF4, 0x22, 0x00, 0x32,
  0x50, 0x85, 0xA5, 0xC0, 0x4A, 0x52, 0xF4, 0xAE, 0x40, 0x78, 0x8C, 0x42,
  0x13, 0xC0, 0x19, 0x42, 0x11, 0xC9, 0xC0, 0x4D, 0x25, 0x1C, 0x51, 0x49,
  0x80, 0x48, 0x88, 0x88, 0xF0, 0x4D, 0xA7, 0x9E, 0x4A, 0x29, 0x80, 0x6B,
  0x5A, 0xD6, 0xAE, 0x40, 0x32, 0x52, 0x94, 0xAD, 0xC0, 0x72, 0x52, 0xF4,
  0x22, 0x00, 0x32, 0x52, 0x94, 0xA5, 0xC2, 0x10, 0x72, 0x52, 0xF5, 0x2A,
  0x60, 0x32, 0x50, 0xE1, 0xC5, 0xC0, 0xF9, 0x18, 0x84, 0x21, 0x00, 0x4A,
  0x52, 0x94, 0xAD, 0xC0, 0x8C, 0xA5, 0x4A, 0x51, 0x00, 0x55, 0x57, 0x9E,
  0x59, 0x6D, 0x00, 0x4D, 0xA3, 0x0C, 0x31, 0x49, 0x80, 0x8C, 0x9C, 0xC4,
  0x21, 0x00, 0x78, 0x44, 0x62, 0x23, 0xC0, 0x74, 0x44, 0x44, 0x8E, 0xC9,
  0x26, 0x49, 0x64, 0x92, 0xD6, 0x26, 0x69, 0xF0, 0xC0, 0x7A, 0x52, 0xB7,
  0x00, 0x42, 0x1E, 0x94, 0xAE, 0xC0, 0x3A, 0x50, 0x97, 0x00, 0x08, 0x5E,
  0x94, 0xAD, 0xC0, 0x32, 0x5E, 0x97, 0x00, 0x0C, 0xC2, 0x1E, 0x20, 0x82,
  0x10, 0x80, 0x7A, 0x52, 0xB7, 0x09, 0x80, 0x42, 0x1E, 0x94, 0xAE, 0x40,
  0x10, 0x1C, 0x22, 0x13, 0xE0, 0x18, 0x1C, 0x21, 0x08, 0x44, 0xC0, 0x42,
  0x12, 0xA6, 0x2A, 0x60, 0xE4, 0x44, 0x44, 0x70, 0x7B, 0x6B, 0x5A, 0x80,
  0x7A, 0x52, 0xB9, 0x00, 0x3A, 0x52, 0xB7, 0x00, 0x7A, 0x52, 0xBB, 0x42,
  0x00, 0x7A, 0x52, 0xB7, 0x08, 0x40, 0x7A, 0x50, 0x8C, 0x00, 0x7A, 0x1D,
  0x17, 0x00, 0x4F, 0x44, 0x46, 0x4A, 0x52, 0xB7, 0x00, 0x99, 0xAA, 0x40,
  0xEF, 0xAD, 0x4A, 0x00, 0x49, 0x88, 0xAD, 0x80, 0x4A, 0x52, 0xA7, 0x09,
  0x80, 0x78, 0x88, 0x8F, 0x00, 0x32, 0x2C, 0x64, 0x46, 0x5E, 0xAA, 0x71,
  0x08, 0x72, 0x10, 0x98, 0x6C, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 6, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 7, 5, 0, -7 },
  { 23, 5, 7, 5, 0, -7 },
  { 28, 2, 3, 5, 2, -7 },
  { 29, 4, 9, 5, 1, -8 },
  { 34, 4, 9, 5, 0, -8 },
  { 39, 5, 4, 5, 0, -5 },
  { 42, 4, 4, 5, 1, -5 },
  { 44, 2, 2, 5, 1, -1 },
  { 45, 3, 1, 5, 1, -3 },
  { 46, 1, 2, 5, 2, -2 },
  { 47, 6, 8, 5, 0, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 5, 7, 5, 0, -7 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 5, 7, 5, 0, -7 },
  { 83, 5, 7, 5, 0, -7 },
  { 88, 5, 7, 5, 1, -7 },
  { 93, 5, 7, 5, 0, -7 },
  { 98, 4, 7, 5, 1, -7 },
  { 102, 2, 5, 5, 2, -5 },
  { 104, 3, 6, 5, 1, -5 },
  { 107, 4, 4, 5, 1, -5 },
  { 109, 4, 4, 5, 1, -5 },
  { 111, 5, 4, 5, 0, -5 },
  { 114, 4, 7, 5, 1, -7 },
  { 118, 6, 9, 5, 0, -7 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 5, 7, 5, 0, -7 },
  { 135, 5, 7, 5, 0, -7 },
  { 140, 5, 7, 5, 0, -7 },
  { 145, 5, 7, 5, 0, -7 },
  { 150, 5, 7, 5, 0, -7 },
  { 155, 5, 7, 5, 0, -7 },
  { 160, 5, 7, 5, 0, -7 },
  { 165, 5, 7, 5, 0, -7 },
  { 170, 5, 7, 5, 0, -7 },
  { 175, 6, 7, 5, 0, -7 },
  { 181, 4, 7, 5, 1, -7 },
  { 185, 6, 7, 5, 0, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 5, 9, 5, 0, -7 },
  { 212, 5, 7, 5, 0, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 5, 7, 5, 1, -7 },
  { 227, 5, 7, 5, 0, -7 },
  { 232, 5, 7, 5, 1, -7 },
  { 237, 6, 7, 5, 0, -7 },
  { 243, 6, 7, 5, 0, -7 },
  { 249, 5, 7, 5, 1, -7 },
  { 254, 5, 7, 5, 0, -7 },
  { 259, 4, 8, 5, 1, -7 },
  { 263, 3, 8, 5, 1, -7 },
  { 266, 3, 8, 5, 1, -7 },
  { 269, 4, 4, 5, 1, -7 },
  { 271, 4, 1, 5, 0, 0 },
  { 272, 2, 1, 5, 2, -7 },
  { 273, 5, 5, 5, 0, -5 },
  { 277, 5, 7, 5, 0, -7 },
  { 282, 5, 5, 5, 0, -5 },
  { 286, 5, 7, 5, 0, -7 },
  { 291, 5, 5, 5, 0, -5 },
  { 295, 6, 9, 5, 0, -7 },
  { 302, 5, 7, 5, 0, -5 },
  { 307, 5, 7, 5, 0, -7 },
  { 312, 5, 7, 5, 0, -7 },
  { 317, 5, 9, 5, 0, -7 },
  { 323, 5, 7, 5, 0, -7 },
  { 328, 4, 7, 5, 1, -7 },
  { 332, 5, 5, 5, 0, -5 },
  { 336, 5, 5, 5, 0, -5 },
  { 340, 5, 5, 5, 0, -5 },
  { 344, 5, 7, 5, 0, -5 },
  { 349, 5, 7, 5, 0, -5 },
  { 354, 5, 5, 5, 0, -5 },
  { 358, 5, 5, 5, 0, -5 },
  { 362, 4, 6, 5, 1, -6 },
  { 365, 5, 5, 5, 0, -5 },
  { 369, 4, 5, 5, 1, -5 },
  { 372, 5, 5, 5, 1, -5 },
  { 376, 5, 5, 5, 0, -5 },
  { 380, 5, 7, 5, 0, -5 },
  { 385, 5, 5, 5, 0, -5 },
  { 389, 4, 8, 5, 1, -7 },
  { 393, 2, 8, 5, 2, -7 },
  { 395, 5, 8, 5, 0, -7 },
  { 400, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC9PT7B_H_
