#ifndef _JETBRAINSMONO_SEMIBOLDITALIC53PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x7F, 0x07,
  0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x07,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFC, 0xE3, 0xF8,
  0x1F, 0xC7, 0x0F, 0xC0, 0xFC, 0x38, 0x7E, 0x0F, 0xE1, 0xC3, 0xF0, 0x7E,
  0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0xC7, 0x00, 0x00, 0xFE, 0x38,
  0x00, 0x07, 0xF9, 0xC0, 0x00, 0x1F, 0xEE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3D,
  0xFF, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x0E, 0x1F, 0xC0, 0x00, 0x70, 0x7E,
  0x00, 0x03, 0x83, 0xF0, 0x00, 0x1C, 0x1F, 0x8F, 0xE1, 0xE0, 0xFC, 0x7F,
  0x0F, 0x0F, 0xC3, 0xF8, 0x70, 0x7E, 0x0F, 0xE3, 0x87, 0xF0, 0x7F, 0x9C,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC0, 0x0F, 0x03,
  0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x3E, 0x07, 0x80,
  0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x0F,
  0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x7C, 0x00, 0x07, 0x81, 0xF3, 0xE0, 0x00,
  0x1F, 0x0F, 0x8F, 0x00, 0x00, 0x7F, 0xFE, 0x78, 0x00, 0x00, 0xFF, 0xF3,
  0xE0, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x00,
  0x01, 0xF3, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xFF, 0x00, 0x00, 0x7C, 0xFF,
  0xFC, 0x00, 0x03, 0xE3, 0xE0, 0xF0, 0x00, 0x0F, 0x1F, 0x03, 0xE0, 0x00,
  0x78, 0x7C, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0x80,
  0xF0, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x80, 0x1F, 0xFF,
  0x80, 0x3E, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x7F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x81, 0xFC, 0xFE,
  0x7E, 0x07, 0xE3, 0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x07,
  0xE7, 0xE1, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF,
  0xC0, 0x7E, 0x01, 0xFF, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x9F, 0xC0, 0xFF,
  0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8,
  0xF8, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0x00, 0xF8, 0x0E, 0x7E, 0x0F, 0x03, 0xE7, 0xF8, 0xF0, 0xFE, 0xFF,
  0xCF, 0x3F, 0xFF, 0xFE, 0x6F, 0xFF, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7C, 0x3F, 0x0E, 0x0F, 0xC3, 0xF1, 0xF0, 0xFC, 0x3F, 0x3F,
  0x8F, 0xC3, 0xE3, 0xF8, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xF8,
  0x7E, 0x0E, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xCF, 0xC0, 0x1F, 0xE7, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x70, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x08, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x17, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0xFE, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0xFC, 0xFF, 0xF0,
  0x1F, 0xBF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xCF, 0xC0, 0x07, 0xF7, 0xFE, 0x01, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0x8F,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC1, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF0,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xF0, 0x07,
  0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x07, 0xF1, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0xFC, 0x03, 0xFF, 0xBF, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0xF8, 0x7E,
  0x03, 0xFE, 0x7C, 0x3E, 0x03, 0xFF, 0xBE, 0x1F, 0x03, 0xFF, 0xDE, 0x0F,
  0x81, 0xF8, 0x7F, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0xF8, 0x0F, 0xC3,
  0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x01, 0xF0,
  0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0xF8, 0x0F,
  0x83, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x1F, 0x87,
  0xF0, 0x7C, 0x0F, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0x7C, 0x3F, 0x01, 0xFF,
  0x3E, 0x1F, 0x00, 0x7F, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x3F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x83,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xFC, 0x3F, 0x07, 0xFF, 0xC7,
  0xF0, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0x87, 0xE0, 0xFF, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x01, 0xEF, 0x03, 0xFE, 0x07, 0xDE, 0x07, 0xBE, 0x0F, 0x7C,
  0x0F, 0x3C, 0x1E, 0xF8, 0x3E, 0x78, 0x79, 0xF0, 0x7C, 0xF0, 0xF3, 0xE0,
  0xF9, 0xE3, 0xEF, 0x81, 0xF3, 0xC7, 0x9F, 0x03, 0xE7, 0x9F, 0x3E, 0x07,
  0xCF, 0xBC, 0x7C, 0x1F, 0x8F, 0x79, 0xF8, 0x3F, 0x1F, 0xE3, 0xF0, 0x7E,
  0x3F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0x81, 0xF8, 0xFE, 0x3F, 0x03, 0xE1,
  0xFC, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0xFC, 0x0F, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x81, 0xFF, 0x00, 0x7E,
  0x07, 0xFC, 0x01, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0x81,
  0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF,
  0xE0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0x7C,
  0x0F, 0x80, 0xF9, 0xF0, 0x3E, 0x07, 0xE7, 0xC1, 0xF8, 0x1F, 0x8F, 0x87,
  0xE0, 0x7E, 0x3E, 0x1F, 0x81, 0xF8, 0xF8, 0x7E, 0x07, 0xC3, 0xE1, 0xF0,
  0x1F, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x1F, 0x03, 0xF0, 0x7C, 0xFC, 0x0F,
  0xC1, 0xF3, 0xF0, 0x3F, 0x07, 0xCF, 0xC0, 0xFC, 0x1F, 0x3F, 0x03, 0xE0,
  0x7C, 0xF8, 0x0F, 0x80, 0xFB, 0xE0, 0x7E, 0x03, 0xEF, 0x81, 0xF8, 0x0F,
  0xBE, 0x07, 0xE0, 0x3E, 0xF8, 0x1F, 0x80, 0xFB, 0xE0, 0x7C, 0x01, 0xFF,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xC0,
  0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0xC0,
  0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E,
  0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x3F,
  0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x7E,
  0x3E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0x7C, 0x7E, 0x0F, 0xE0, 0x7C,
  0x7E, 0x0E, 0xE0, 0xFC, 0x7E, 0x0E, 0xE0, 0xF8, 0x7C, 0x1E, 0xE0, 0xF8,
  0x7C, 0x1E, 0xE0, 0xF8, 0x7C, 0x1C, 0xE1, 0xF8, 0x7C, 0x1C, 0xE1, 0xF0,
  0x7C, 0x3D, 0xE1, 0xF0, 0x7C, 0x39, 0xE1, 0xF0, 0x7C, 0x39, 0xE3, 0xF0,
  0x7C, 0x79, 0xE3, 0xE0, 0x7C, 0x79, 0xE3, 0xE0, 0x7C, 0x71, 0xE3, 0xE0,
  0x7C, 0x71, 0xE7, 0xC0, 0x7C, 0xF1, 0xE7, 0xC0, 0x7C, 0xF1, 0xE7, 0xC0,
  0x7C, 0xE1, 0xC7, 0xC0, 0x7D, 0xE1, 0xCF, 0x80, 0xF9, 0xE1, 0xCF, 0x80,
  0xF9, 0xC1, 0xCF, 0x80, 0xF9, 0xC1, 0xCF, 0x80, 0xFB, 0xC1, 0xCF, 0x00,
  0xFB, 0xC1, 0xDF, 0x00, 0xFB, 0x81, 0xDF, 0x00, 0xFB, 0x81, 0xDF, 0x00,
  0xFF, 0x81, 0xDE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3F, 0x00,
  0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF8, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF0, 0xFC, 0x0F, 0xFF, 0xBF,
  0x83, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xF8,
  0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFF,
  0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0x3F,
  0x03, 0xFF, 0xCF, 0xC0, 0x1F, 0xF1, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x3F, 0x8F, 0xF8,
  0x07, 0xE7, 0xFF, 0x80, 0xFD, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F,
  0x80, 0x7F, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x0F, 0xCF, 0xFF, 0x81, 0xF9, 0xFF, 0xE0, 0x3F, 0x1F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x03,
  0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xE0, 0x7E, 0x00, 0xFF, 0x87, 0xE0, 0x3F, 0xFE,
  0xFE, 0x07, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xF7,
  0xE0, 0x3F, 0xFE, 0x7E, 0x01, 0xFF, 0xCF, 0xC0, 0x0F, 0xF8, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0xFC,
  0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF8, 0xFC, 0x07, 0xFF, 0xBF, 0x83,
  0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x1F,
  0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0x7E, 0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xF1, 0xF8, 0x03, 0xFC, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x8F, 0xF8, 0x07, 0xE7, 0xFF, 0x80, 0xFD, 0xFF, 0xF8,
  0x1F, 0xBF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFE,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x02, 0x01, 0xC0, 0x3E,
  0x7E, 0x1F, 0xC0, 0xFB, 0xFC, 0xFF, 0x03, 0xEF, 0xF7, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF0,
  0x3E, 0x1F, 0x83, 0xC1, 0xF8, 0x7C, 0x0F, 0x07, 0xE1, 0xF0, 0x7C, 0x1F,
  0x8F, 0xC1, 0xF0, 0x7E, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1E, 0x07, 0xC3,
  0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xF0, 0xF8,
  0x3E, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F,
  0x03, 0xE1, 0xF0, 0x3C, 0x1F, 0x87, 0xC1, 0xF0, 0x7E, 0x1F, 0x07, 0xC1,
  0xF8, 0xFC, 0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xE0, 0x7C,
  0x3E, 0x07, 0x83, 0xF0, 0xF8, 0x1E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xFC, 0x7F, 0xC0, 0x3F, 0x3F, 0xFC, 0x07, 0xEF,
  0xFF, 0xC0, 0xFD, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xCF,
  0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0xFC, 0xFF, 0xF0, 0x07, 0xEF,
  0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1,
  0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xFC,
  0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7E, 0x7F, 0xFC, 0x03, 0xF3, 0xFF, 0xC0, 0x1F, 0x87, 0xF8, 0x00,
  0xFC, 0x04, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF0, 0xFC, 0x0F, 0xFF, 0xBF, 0x83, 0xFF,
  0xF7, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xF0,
  0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0x3F, 0x03, 0xFF,
  0xCF, 0xC0, 0x1F, 0xF1, 0xF8, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x7F, 0xE0, 0x0F, 0xCF,
  0xFF, 0x80, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC3, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x7D, 0xF0, 0x3F,
  0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x07, 0xF0, 0x3E, 0x7C, 0x1F, 0xC1,
  0xF3, 0xE0, 0x7F, 0x07, 0xCF, 0x83, 0xFC, 0x1F, 0x3E, 0x0E, 0xF0, 0xF8,
  0xF8, 0x3B, 0xC3, 0xE3, 0xE0, 0xEF, 0x0F, 0x8F, 0x87, 0xBC, 0x3C, 0x3E,
  0x1C, 0xF1, 0xF0, 0xF8, 0x73, 0xC7, 0xC3, 0xE3, 0xCF, 0x1F, 0x0F, 0x8E,
  0x3C, 0xF8, 0x3E, 0x38, 0xF3, 0xE0, 0xF9, 0xE3, 0xCF, 0x83, 0xE7, 0x0F,
  0x7C, 0x0F, 0x9C, 0x3D, 0xF0, 0x3E, 0xF0, 0xF7, 0xC0, 0xFB, 0xC3, 0xDE,
  0x03, 0xEE, 0x0F, 0xF8, 0x0F, 0xB8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1,
  0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0xFF,
  0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xF0, 0x3F, 0xFE, 0x7E,
  0x01, 0xFF, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0x9F, 0xFF, 0x01, 0xF7, 0xFF, 0xF0,
  0x3E, 0xFC, 0xFE, 0x0F, 0xFF, 0x0F, 0xE1, 0xF7, 0xE0, 0xFF, 0xFE, 0xF8,
  0x0F, 0xFF, 0xDF, 0x01, 0xFF, 0xF3, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0xFE,
  0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -39 },
  { 65, 20, 16, 32, 9, -39 },
  { 105, 32, 39, 32, 1, -39 },
  { 261, 29, 53, 32, 2, -46 },
  { 454, 38, 39, 32, -2, -39 },
  { 640, 30, 40, 32, 1, -39 },
  { 790, 8, 16, 32, 15, -39 },
  { 806, 22, 52, 32, 8, -45 },
  { 949, 22, 52, 32, 3, -45 },
  { 1092, 28, 27, 32, 3, -32 },
  { 1187, 26, 25, 32, 3, -30 },
  { 1269, 15, 16, 32, 4, -8 },
  { 1299, 19, 5, 32, 7, -20 },
  { 1311, 10, 10, 32, 9, -9 },
  { 1324, 33, 50, 32, 0, -44 },
  { 1531, 28, 40, 32, 3, -39 },
  { 1671, 26, 39, 32, 2, -39 },
  { 1798, 28, 39, 32, 2, -39 },
  { 1935, 28, 40, 32, 2, -39 },
  { 2075, 26, 39, 32, 3, -39 },
  { 2202, 27, 40, 32, 3, -39 },
  { 2337, 27, 40, 32, 2, -39 },
  { 2472, 28, 39, 32, 5, -39 },
  { 2609, 28, 40, 32, 2, -39 },
  { 2749, 27, 39, 32, 4, -39 },
  { 2881, 14, 31, 32, 9, -30 },
  { 2936, 18, 38, 32, 5, -30 },
  { 3022, 26, 29, 32, 4, -32 },
  { 3117, 26, 19, 32, 3, -27 },
  { 3179, 27, 29, 32, 2, -32 },
  { 3277, 22, 39, 32, 7, -39 },
  { 3385, 33, 49, 32, 0, -39 },
  { 3588, 27, 39, 32, 0, -39 },
  { 3720, 29, 39, 32, 2, -39 },
  { 3862, 28, 40, 32, 3, -39 },
  { 4002, 29, 39, 32, 2, -39 },
  { 4144, 30, 39, 32, 2, -39 },
  { 4291, 30, 39, 32, 2, -39 },
  { 4438, 28, 40, 32, 3, -39 },
  { 4578, 29, 39, 32, 2, -39 },
  { 4720, 28, 39, 32, 3, -39 },
  { 4857, 31, 40, 32, 0, -39 },
  { 5012, 31, 39, 32, 2, -39 },
  { 5164, 24, 39, 32, 3, -39 },
  { 5281, 31, 39, 32, 1, -39 },
  { 5433, 30, 39, 32, 2, -39 },
  { 5580, 27, 40, 32, 3, -39 },
  { 5715, 30, 39, 32, 2, -39 },
  { 5862, 28, 49, 32, 3, -39 },
  { 6034, 29, 39, 32, 2, -39 },
  { 6176, 29, 40, 32, 2, -39 },
  { 6321, 28, 39, 32, 5, -39 },
  { 6458, 29, 40, 32, 3, -39 },
  { 6603, 28, 39, 32, 6, -39 },
  { 6740, 32, 39, 32, 3, -39 },
  { 6896, 34, 39, 32, -1, -39 },
  { 7062, 29, 39, 32, 5, -39 },
  { 7204, 29, 39, 32, 2, -39 },
  { 7346, 22, 50, 32, 7, -44 },
  { 7484, 17, 50, 32, 8, -44 },
  { 7591, 22, 50, 32, 4, -44 },
  { 7729, 25, 21, 32, 4, -39 },
  { 7795, 26, 6, 32, 0, 1 },
  { 7815, 11, 8, 32, 13, -42 },
  { 7826, 27, 31, 32, 3, -30 },
  { 7931, 27, 40, 32, 2, -39 },
  { 8066, 26, 31, 32, 3, -30 },
  { 8167, 28, 40, 32, 3, -39 },
  { 8307, 26, 31, 32, 3, -30 },
  { 8408, 36, 49, 32, -3, -39 },
  { 8629, 27, 40, 32, 3, -30 },
  { 8764, 27, 39, 32, 2, -39 },
  { 8896, 26, 42, 32, 2, -42 },
  { 9033, 28, 52, 32, 1, -42 },
  { 9215, 30, 39, 32, 2, -39 },
  { 9362, 23, 39, 32, 5, -39 },
  { 9475, 30, 30, 32, 1, -30 },
  { 9588, 27, 30, 32, 2, -30 },
  { 9690, 26, 31, 32, 3, -30 },
  { 9791, 29, 40, 32, 0, -30 },
  { 9936, 27, 40, 32, 3, -30 },
  { 10071, 28, 30, 32, 3, -30 },
  { 10176, 27, 31, 32, 2, -30 },
  { 10281, 26, 37, 32, 4, -37 },
  { 10402, 27, 30, 32, 3, -29 },
  { 10504, 27, 29, 32, 5, -29 },
  { 10602, 30, 29, 32, 3, -29 },
  { 10711, 31, 29, 32, 0, -29 },
  { 10824, 27, 39, 32, 3, -29 },
  { 10956, 27, 29, 32, 2, -29 },
  { 11054, 28, 50, 32, 4, -44 },
  { 11229, 14, 50, 32, 10, -44 },
  { 11317, 28, 50, 32, 1, -44 },
  { 11492, 27, 12, 32, 3, -25 },
};

const GFXfont JetBrainsMono_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC53PT7B_H_
