#ifndef _JETBRAINSMONO_SEMIBOLDITALIC30PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x20, 0x00, 0x00, 0x38, 0x78, 0xF8, 0x78, 0x78,
  0xEF, 0x3D, 0xC7, 0xB8, 0xFF, 0x1D, 0xE3, 0xBC, 0x77, 0x0E, 0xE1, 0xC0,
  0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00,
  0x61, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x60,
  0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x06, 0x07, 0xFF, 0xF1, 0xFF, 0xFC,
  0x98, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xC1, 0x80, 0x70, 0xE0, 0x1C,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x01, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x6F, 0x1C, 0x47, 0x1C, 0xC7, 0x3C, 0xC0,
  0x3C, 0xC0, 0x1E, 0xC0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x01, 0xBE, 0x01, 0x9E, 0x01, 0x9E, 0xF1, 0x9E, 0xF3, 0x1C, 0xFB, 0x3C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0xC0, 0x38, 0x7F, 0x03, 0x87, 0xBC, 0x38, 0x38, 0xE1,
  0x81, 0x86, 0x18, 0x0C, 0x31, 0xC0, 0x61, 0x9C, 0x03, 0xBD, 0xC0, 0x1F,
  0xDC, 0x00, 0x7D, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0xE0, 0x0E, 0xF7, 0x00, 0xE6, 0x18, 0x0E, 0x30, 0xC0, 0x63,
  0x8E, 0x06, 0x1C, 0x70, 0x70, 0xE7, 0x07, 0x03, 0xF8, 0x70, 0x1F, 0x80,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xF8, 0x73, 0x9E, 0x7B, 0xC7, 0x79, 0xE3, 0xF8, 0xE0, 0xF8, 0x70, 0x7C,
  0x38, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0x87, 0xFD, 0xE1, 0xFC, 0x78, 0x7B,
  0xDE, 0xE7, 0x7B, 0xDC, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x03, 0x0C, 0x73,
  0xE6, 0xFB, 0xFA, 0xFE, 0x3F, 0xF8, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xBC,
  0x03, 0xCE, 0x03, 0xC7, 0x83, 0xC3, 0xC0, 0x40, 0xC0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x1C, 0x07, 0x3C,
  0x07, 0x3C, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x39, 0xCF, 0x3B, 0xCE, 0x79,
  0xCE, 0x79, 0xCE, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70,
  0x1C, 0x78, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0xE0, 0x7B, 0x81, 0xE7, 0x03, 0x0E, 0x04, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x1C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x10, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0x78,
  0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x0E, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF9, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3B, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3,
  0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x39, 0xC0,
  0xF3, 0xC1, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x20, 0x3F, 0xF0, 0xFF, 0xF1, 0xF1, 0xF7, 0x81, 0xEF, 0x01, 0xDC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x39, 0xE0, 0xF3, 0xFF, 0xC3, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0x80, 0xFF, 0x01,
  0xDE, 0x07, 0xBC, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C,
  0x0E, 0x1E, 0x3C, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3C,
  0x3C, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0x78, 0x3C, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C,
  0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78,
  0x1E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x04, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0E, 0x1F, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x7C, 0xFC, 0xFC, 0x78, 0x03, 0x81, 0xF0, 0xFC, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x3C,
  0x00, 0x70, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x0C, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x10,
  0x00, 0x38, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0x1C, 0x00, 0x60, 0x00, 0x3F, 0x81, 0xFF, 0x1F, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0x0F, 0xF0, 0x7F,
  0x03, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7C, 0x78,
  0x3C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x67, 0x38,
  0x7D, 0xCE, 0x3F, 0xF3, 0x8E, 0x3D, 0xC7, 0x0E, 0x71, 0xC3, 0x9C, 0x70,
  0xE7, 0x1C, 0x39, 0xC7, 0x0E, 0x73, 0x83, 0xB8, 0x71, 0xCE, 0x1F, 0xB3,
  0x87, 0xDC, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xDC, 0x01, 0xDC, 0x03, 0xDC, 0x03, 0x9C, 0x07, 0x9C,
  0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFE, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0F, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x1C, 0x1F, 0x1C, 0x0F,
  0x1C, 0x07, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFC, 0x38, 0x3E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E,
  0x70, 0x1C, 0x70, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF3, 0xC1, 0xE7, 0x01, 0xDE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x3D, 0xC0, 0xF3, 0xC1, 0xE7, 0xFF, 0x87,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x3F,
  0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x1C, 0x70, 0x3C, 0x70, 0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xC1, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF3, 0xC1, 0xE7, 0x01, 0xDE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC7, 0xF3, 0x8F, 0xEF, 0x1F, 0xDE, 0x3F,
  0xBC, 0x0F, 0x78, 0x1E, 0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xE7, 0xFF, 0x87,
  0xFE, 0x07, 0xF0, 0x00, 0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC0,
  0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70,
  0xF0, 0x38, 0x78, 0x1C, 0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x10, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x70, 0x1E, 0x38,
  0x0E, 0x1E, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1E, 0x03,
  0xC7, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x07, 0x07, 0x01,
  0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x01, 0xE1, 0xE0, 0x70, 0x78,
  0x1C, 0x0E, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE7, 0xE3, 0xF3, 0xF1, 0xB9, 0xD8,
  0xD8, 0xEC, 0xFC, 0x76, 0x6E, 0x3B, 0x77, 0x3D, 0xB3, 0x9C, 0xF9, 0xCE,
  0x79, 0xE7, 0x1C, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x1E,
  0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE0, 0x1F,
  0x03, 0x8F, 0x83, 0xC7, 0xC1, 0xC3, 0xE0, 0xE1, 0xF8, 0x70, 0xFC, 0x38,
  0xEE, 0x1C, 0x77, 0x1E, 0x39, 0x8F, 0x1C, 0xE7, 0x0E, 0x73, 0x87, 0x39,
  0xC7, 0x9C, 0xE3, 0xCE, 0x71, 0xC3, 0xF8, 0xE1, 0xF8, 0x70, 0xFC, 0x38,
  0x7E, 0x1C, 0x3F, 0x1E, 0x0F, 0x8E, 0x07, 0xC7, 0x03, 0xC0, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0xC3, 0xE7, 0xFF, 0x87,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC1,
  0xF1, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E,
  0x07, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x1C,
  0x0F, 0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70,
  0x1C, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xE1, 0xC0, 0x70, 0xE0, 0x3C, 0x70, 0x1C,
  0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C,
  0x1E, 0x1E, 0x07, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x3E, 0x0F,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0x80, 0xE1,
  0xC0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07,
  0x0E, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0,
  0x78, 0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B, 0x80,
  0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x71, 0xE3,
  0xDC, 0x78, 0xE7, 0x1E, 0x39, 0x87, 0x8E, 0xE3, 0x67, 0x38, 0xD9, 0xCE,
  0x34, 0x73, 0x8F, 0x1C, 0xE6, 0xCE, 0x39, 0xB3, 0x8E, 0x6C, 0xE3, 0xB3,
  0x38, 0xEC, 0xDC, 0x3B, 0x37, 0x0E, 0xCD, 0xC3, 0xE3, 0x60, 0xF8, 0xF8,
  0x36, 0x3E, 0x0D, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x00,
  0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0x83, 0xC0, 0x78, 0xF0,
  0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x79, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x70, 0x3C, 0x0F, 0x07,
  0x81, 0xE1, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1E, 0x78,
  0x1C, 0x78, 0x3C, 0x38, 0x78, 0x38, 0x70, 0x3C, 0xF0, 0x1C, 0xE0, 0x1D,
  0xE0, 0x1D, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0F,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xF0,
  0x3C, 0x07, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xDC, 0x07, 0x70, 0x39, 0xC0, 0xE3,
  0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xF7, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE3, 0xC7, 0x0E, 0x3C, 0x03, 0xCF, 0x0F, 0xEF, 0x1F,
  0xFF, 0x1E, 0x3E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x78, 0x7C, 0x7F,
  0xFC, 0x3F, 0xBC, 0x1F, 0x38, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x70, 0x1D, 0xFC, 0x3F, 0xFE, 0x3F, 0x3E, 0x3C,
  0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xF7,
  0xE0, 0x03, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE3, 0xE7, 0x81, 0xCE, 0x03,
  0x9C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x01, 0xCF,
  0x03, 0x9E, 0x0F, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x1E, 0x78, 0x3F, 0xBC,
  0x3F, 0xFE, 0x1E, 0x3E, 0x1E, 0x0F, 0x0E, 0x07, 0x87, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1E,
  0x1F, 0x0F, 0xFF, 0x83, 0xFB, 0xC0, 0xF9, 0xC0, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0x8F, 0x0F, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC1, 0xEF, 0xFF, 0x1F, 0xF8,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0x9E, 0x3F, 0xBC, 0xFF, 0xF9, 0xE3, 0xE7, 0x83, 0xCE, 0x07,
  0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCF,
  0x8F, 0x9F, 0xFF, 0x1F, 0xDE, 0x1F, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x70, 0x1D, 0xFC, 0x3F, 0xFE, 0x3E,
  0x3E, 0x3C, 0x1E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x38, 0x00, 0x20, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x70,
  0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x1E, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xF1, 0xC0, 0x78, 0xF0, 0x38, 0x38,
  0x1C, 0x1E, 0x0E, 0x0F, 0x0F, 0x03, 0xC7, 0x81, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xF1, 0xFF, 0x87, 0xF8, 0x1D, 0xC7, 0x0F,
  0xF7, 0xC7, 0xFF, 0xE7, 0x9C, 0x73, 0x8E, 0x39, 0xC7, 0x1C, 0xE3, 0x8E,
  0x71, 0x8F, 0x38, 0xC7, 0x3C, 0x63, 0x9E, 0x71, 0xCE, 0x38, 0xE7, 0x1C,
  0x73, 0x8E, 0x79, 0xC6, 0x38, 0xE3, 0x1C, 0xF3, 0x8E, 0x00, 0x1C, 0x70,
  0x1D, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x3C, 0x1E, 0x3C, 0x0E, 0x38, 0x1E,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0x8F, 0x1F, 0x78, 0x3D, 0xC0, 0x77, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0xC3, 0xEF, 0xFF, 0x1F, 0xF8,
  0x3F, 0x80, 0x0E, 0x3C, 0x07, 0x7F, 0x07, 0xFF, 0xC3, 0xF3, 0xE1, 0xE0,
  0xF0, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0x87, 0x81, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7B, 0xF0, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x1E, 0x3E, 0x3C, 0x1E, 0x38,
  0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x3F, 0xBC, 0x3F, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3C, 0xF0, 0x77,
  0xF8, 0xEF, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E,
  0x1E, 0x3C, 0x0E, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0xF0, 0x3C, 0x7F, 0xFC, 0x7F,
  0xF8, 0x3F, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x07, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x38, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1E, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC0, 0xE7, 0x01, 0xCF, 0x07, 0x9E, 0x1E, 0x3F, 0xFC, 0x3F,
  0xF0, 0x3F, 0x80, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x81, 0xEF, 0x07,
  0x9E, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xF3, 0xC1, 0xE7, 0x01,
  0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xE1,
  0xC3, 0xF1, 0xE3, 0xB8, 0xF1, 0xDC, 0x78, 0xEE, 0x2C, 0x67, 0x36, 0x73,
  0x9B, 0x39, 0xCD, 0x98, 0xEC, 0xDC, 0x76, 0x6E, 0x3B, 0x36, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x00,
  0x1E, 0x03, 0xC7, 0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x00,
  0xEF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0x78,
  0xF0, 0x1E, 0x00, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC0, 0xE7,
  0x83, 0xCF, 0x8F, 0x9F, 0xFF, 0x1F, 0xDE, 0x0E, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78,
  0x78, 0x70, 0x70, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x3F,
  0x87, 0x7F, 0xC7, 0x71, 0xCF, 0x71, 0xFE, 0x70, 0xFC, 0x80, 0x78,
};

const GFXglyph JetBrainsMono_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 22, 18, 5, -22 },
  { 23, 11, 9, 18, 5, -22 },
  { 36, 18, 22, 18, 0, -22 },
  { 86, 16, 30, 18, 1, -26 },
  { 146, 21, 22, 18, -1, -22 },
  { 204, 17, 22, 18, 0, -22 },
  { 251, 5, 9, 18, 8, -22 },
  { 257, 13, 29, 18, 4, -25 },
  { 305, 12, 29, 18, 2, -25 },
  { 349, 17, 15, 18, 1, -18 },
  { 381, 15, 14, 18, 2, -17 },
  { 408, 8, 10, 18, 3, -5 },
  { 418, 10, 3, 18, 4, -11 },
  { 422, 6, 5, 18, 5, -5 },
  { 426, 19, 28, 18, 0, -25 },
  { 493, 16, 22, 18, 1, -22 },
  { 537, 15, 22, 18, 1, -22 },
  { 579, 16, 22, 18, 1, -22 },
  { 623, 16, 22, 18, 1, -22 },
  { 667, 16, 22, 18, 1, -22 },
  { 711, 15, 22, 18, 2, -22 },
  { 753, 15, 22, 18, 1, -22 },
  { 795, 15, 22, 18, 3, -22 },
  { 837, 16, 22, 18, 1, -22 },
  { 881, 16, 22, 18, 2, -22 },
  { 925, 8, 17, 18, 5, -17 },
  { 942, 10, 22, 18, 3, -17 },
  { 970, 15, 16, 18, 2, -18 },
  { 1000, 15, 10, 18, 2, -15 },
  { 1019, 15, 16, 18, 1, -18 },
  { 1049, 13, 22, 18, 4, -22 },
  { 1085, 18, 27, 18, 0, -22 },
  { 1146, 16, 22, 18, 0, -22 },
  { 1190, 16, 22, 18, 1, -22 },
  { 1234, 15, 22, 18, 2, -22 },
  { 1276, 16, 22, 18, 1, -22 },
  { 1320, 17, 22, 18, 1, -22 },
  { 1367, 17, 22, 18, 1, -22 },
  { 1414, 15, 22, 18, 2, -22 },
  { 1456, 17, 22, 18, 1, -22 },
  { 1503, 16, 22, 18, 1, -22 },
  { 1547, 17, 22, 18, 0, -22 },
  { 1594, 18, 22, 18, 1, -22 },
  { 1644, 13, 22, 18, 2, -22 },
  { 1680, 17, 22, 18, 1, -22 },
  { 1727, 17, 22, 18, 1, -22 },
  { 1774, 15, 22, 18, 2, -22 },
  { 1816, 17, 22, 18, 1, -22 },
  { 1863, 16, 27, 18, 1, -22 },
  { 1917, 17, 22, 18, 1, -22 },
  { 1964, 17, 22, 18, 1, -22 },
  { 2011, 16, 22, 18, 3, -22 },
  { 2055, 17, 22, 18, 1, -22 },
  { 2102, 16, 22, 18, 3, -22 },
  { 2146, 18, 22, 18, 2, -22 },
  { 2196, 19, 22, 18, 0, -22 },
  { 2249, 16, 22, 18, 3, -22 },
  { 2293, 16, 22, 18, 1, -22 },
  { 2337, 12, 28, 18, 4, -25 },
  { 2379, 10, 28, 18, 4, -25 },
  { 2414, 13, 28, 18, 2, -25 },
  { 2460, 14, 12, 18, 2, -22 },
  { 2481, 15, 3, 18, 0, 1 },
  { 2487, 6, 5, 18, 8, -24 },
  { 2491, 16, 17, 18, 1, -17 },
  { 2525, 16, 22, 18, 1, -22 },
  { 2569, 15, 17, 18, 2, -17 },
  { 2601, 17, 22, 18, 1, -22 },
  { 2648, 14, 17, 18, 2, -17 },
  { 2678, 21, 27, 18, -2, -22 },
  { 2749, 15, 22, 18, 2, -17 },
  { 2791, 16, 22, 18, 1, -22 },
  { 2835, 15, 24, 18, 1, -24 },
  { 2880, 16, 29, 18, 0, -24 },
  { 2938, 17, 22, 18, 1, -22 },
  { 2985, 13, 22, 18, 3, -22 },
  { 3021, 17, 17, 18, 0, -17 },
  { 3058, 16, 17, 18, 1, -17 },
  { 3092, 14, 17, 18, 2, -17 },
  { 3122, 17, 22, 18, 0, -17 },
  { 3169, 16, 22, 18, 1, -17 },
  { 3213, 15, 17, 18, 2, -17 },
  { 3245, 16, 17, 18, 1, -17 },
  { 3279, 15, 21, 18, 2, -21 },
  { 3319, 15, 17, 18, 2, -17 },
  { 3351, 15, 17, 18, 3, -17 },
  { 3383, 17, 17, 18, 2, -17 },
  { 3420, 18, 17, 18, 0, -17 },
  { 3459, 15, 22, 18, 2, -17 },
  { 3501, 16, 17, 18, 1, -17 },
  { 3535, 15, 28, 18, 3, -25 },
  { 3588, 8, 28, 18, 5, -25 },
  { 3616, 15, 28, 18, 1, -25 },
  { 3669, 16, 7, 18, 1, -14 },
};

const GFXfont JetBrainsMono_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC30PT7B_H_
