#ifndef _JETBRAINSMONO_SEMIBOLDITALIC46PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFC, 0xE7, 0xE0, 0xFC, 0x71, 0xF0, 0x7C, 0x30,
  0xF8, 0x3E, 0x38, 0x7C, 0x3F, 0x1C, 0x00, 0x1F, 0x8E, 0x00, 0x0F, 0xC7,
  0x00, 0x07, 0xF3, 0x80, 0x01, 0xFD, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x06, 0xFF, 0x00, 0x07, 0x1F, 0x80, 0x03, 0x8F, 0xC0,
  0x01, 0xC3, 0xE0, 0x00, 0xE1, 0xF1, 0xF8, 0x70, 0xF8, 0xFC, 0x30, 0xFC,
  0x7E, 0x38, 0x7C, 0x3F, 0x9C, 0x7E, 0x0F, 0xFE, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x7F, 0xC0,
  0x07, 0x80, 0x7F, 0xF0, 0x07, 0x80, 0x7F, 0xF8, 0x07, 0x80, 0x7C, 0x3C,
  0x07, 0x80, 0x3C, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x03, 0xC0, 0x0F, 0x07,
  0x83, 0xC0, 0x07, 0x83, 0xC3, 0xC0, 0x07, 0x81, 0xE3, 0xC0, 0x03, 0xC1,
  0xE3, 0xC0, 0x01, 0xF0, 0xF3, 0xC0, 0x00, 0x7F, 0xFB, 0xE0, 0x00, 0x3F,
  0xF9, 0xE0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF3, 0xF8, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0xF3, 0xFF, 0x80,
  0x00, 0xF3, 0xE7, 0xC0, 0x00, 0xF1, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x70,
  0x00, 0xF0, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x0F, 0x80, 0x78, 0x07, 0xCF,
  0x80, 0x78, 0x03, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x03,
  0xF3, 0xF7, 0xE0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x3F, 0x1F, 0x07,
  0xCF, 0x87, 0xC1, 0xFF, 0xC1, 0xF0, 0x3F, 0xE0, 0x7C, 0x07, 0xF8, 0x3F,
  0x01, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF0,
  0x3F, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xF0, 0x3F, 0xFC,
  0x7C, 0x07, 0xFC, 0x0F, 0x80, 0x7E, 0xFD, 0xF3, 0xE7, 0xDF, 0xBF, 0x7E,
  0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x78, 0x0C, 0x78, 0x3C, 0x1E, 0x7F,
  0x1E, 0x3F, 0x3F, 0xEE, 0x7F, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xE7, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1E, 0x1F, 0x9F, 0xDF, 0xFF, 0xF7, 0xFB, 0xFC, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x70, 0xF8, 0x7C, 0x7C,
  0x7C, 0x3E, 0x7E, 0x3E, 0x1F, 0x3F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0xC7,
  0x8F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFE, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x07, 0xC0, 0x38,
  0x1F, 0x00, 0x80, 0xFC, 0x04, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0x7C, 0x3F, 0x00, 0xF8,
  0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x8F,
  0xC0, 0x1F, 0xBF, 0xF0, 0x1F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE7,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xF0, 0x03, 0xF7, 0xFC, 0x0F,
  0xDF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF8, 0xFE, 0x03, 0xF3, 0xF8,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xC7, 0xE0, 0x1F, 0x8F, 0xF1, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x07,
  0xE1, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFE, 0x01, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x3F, 0x00,
  0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0xFC,
  0x7F, 0x07, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFE, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x0F, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3E,
  0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x02, 0x1F, 0x1F, 0x01, 0xFD,
  0xF1, 0xE0, 0x7F, 0xDE, 0x1E, 0x07, 0xFF, 0xE1, 0xE0, 0xF8, 0x7E, 0x3E,
  0x0F, 0x03, 0xE3, 0xE1, 0xF0, 0x3E, 0x3E, 0x1F, 0x03, 0xE3, 0xC1, 0xE0,
  0x3C, 0x3C, 0x1E, 0x03, 0xC3, 0xC1, 0xE0, 0x3C, 0x7C, 0x3E, 0x07, 0xC7,
  0xC3, 0xE0, 0x7C, 0x7C, 0x3E, 0x07, 0xC7, 0x83, 0xE0, 0x78, 0x78, 0x3E,
  0x0F, 0x87, 0x83, 0xE1, 0xF8, 0x78, 0x3F, 0xF7, 0x8F, 0x81, 0xFF, 0x78,
  0xF8, 0x0F, 0xE7, 0x8F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3C, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7C, 0x03, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0,
  0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xC0, 0x3F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x3F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7C, 0x0F, 0xF8, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0x7E, 0x0F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1,
  0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x0F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xFE, 0x1F, 0x07, 0xFF, 0x0F, 0x87, 0xFF, 0x87, 0xC3,
  0xFF, 0xC3, 0xE1, 0xFF, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x8F,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xDC, 0x1E, 0xE0, 0x7F, 0x83, 0xDC, 0x0E, 0xF0, 0x7B,
  0xC3, 0xDE, 0x0F, 0x78, 0x7B, 0xC1, 0xEF, 0x1E, 0xF8, 0x3D, 0xE3, 0xDF,
  0x0F, 0xBC, 0xF3, 0xC1, 0xF3, 0x9E, 0x78, 0x3E, 0x73, 0x9F, 0x07, 0xCE,
  0xF3, 0xE0, 0xF9, 0xFC, 0x7C, 0x1E, 0x3F, 0x8F, 0x87, 0xC7, 0xF3, 0xE0,
  0xF8, 0xFC, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0x83, 0xF8, 0x07,
  0xC1, 0xFC, 0x03, 0xE1, 0xFE, 0x01, 0xF0, 0xFF, 0x00, 0xF8, 0x7F, 0x80,
  0x7C, 0x3F, 0xE0, 0x7C, 0x1F, 0xF0, 0x3E, 0x0F, 0x78, 0x1F, 0x0F, 0xBC,
  0x0F, 0x87, 0xDE, 0x07, 0xC3, 0xEF, 0x83, 0xE1, 0xF7, 0xC1, 0xE0, 0xF9,
  0xE1, 0xF0, 0x78, 0xF0, 0xF8, 0x7C, 0x78, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F,
  0x1F, 0x1F, 0x0F, 0x87, 0x8F, 0x87, 0xC3, 0xCF, 0x83, 0xE1, 0xE7, 0xC3,
  0xE0, 0xF3, 0xE1, 0xF0, 0x7D, 0xF0, 0xF8, 0x3E, 0xF8, 0x7C, 0x0F, 0x7C,
  0x3E, 0x07, 0xBC, 0x1F, 0x03, 0xDE, 0x0F, 0x01, 0xFF, 0x0F, 0x80, 0xFF,
  0x87, 0xC0, 0x3F, 0xC3, 0xE0, 0x1F, 0xE1, 0xF0, 0x0F, 0xE0, 0xF8, 0x07,
  0xF0, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0x7C, 0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xFC, 0x7F, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x3E, 0x00, 0xFE,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x01,
  0xF8, 0x3E, 0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x1F, 0x87, 0xFC, 0x7F, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0,
  0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x07, 0xC1, 0xF3, 0xE0, 0xFC, 0x1F, 0x3E, 0x0F, 0x81, 0xF3, 0xE0, 0xF8,
  0x1E, 0x3C, 0x0D, 0x83, 0xE3, 0xC1, 0xF8, 0x3E, 0x3C, 0x1F, 0x83, 0xC3,
  0xC1, 0xF8, 0x3C, 0x3C, 0x3B, 0x87, 0xC3, 0xC3, 0xB8, 0x7C, 0x3C, 0x3B,
  0x87, 0x83, 0xC3, 0xB8, 0x78, 0x7C, 0x73, 0x8F, 0x87, 0xC7, 0x38, 0xF8,
  0x7C, 0x73, 0x8F, 0x07, 0xC7, 0x38, 0xF0, 0x7C, 0xE3, 0x9F, 0x07, 0xCE,
  0x39, 0xE0, 0x7C, 0xE3, 0x9E, 0x07, 0x9C, 0x39, 0xE0, 0x79, 0xC3, 0xBE,
  0x07, 0x9C, 0x3B, 0xC0, 0x79, 0xC3, 0xBC, 0x07, 0xB8, 0x73, 0xC0, 0x7B,
  0x87, 0x7C, 0x07, 0xB8, 0x77, 0x80, 0x7F, 0x87, 0x78, 0x07, 0xF0, 0x77,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x40, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xF7,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0,
  0xFC, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xBF, 0x07, 0xFF,
  0xBE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD,
  0xF0, 0x1F, 0xF9, 0xF0, 0x0F, 0xF1, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x1F, 0x3F, 0xE0,
  0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xF7, 0xFF, 0xC3, 0xFC, 0x1F, 0xC7,
  0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0xF0, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7D, 0xFF, 0xF0, 0xF9, 0xFF, 0x81, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0xFF, 0x9F, 0x80, 0xFF,
  0xEF, 0xC0, 0xFF, 0xF7, 0xC0, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xF0, 0x7E,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x7F,
  0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xE0, 0x1F, 0xF9, 0xF0, 0x07, 0xF8,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80,
  0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC7,
  0xE0, 0x1F, 0x8F, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xFC, 0xFC, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF8, 0x7F, 0x87, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x0F, 0xF1, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xC0, 0x1F, 0x3F, 0xE0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xF7, 0xFF, 0xC3, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x43,
  0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0E,
  0x0E, 0x01, 0xF7, 0xE3, 0xF0, 0x3F, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFC, 0xFC, 0x7C, 0x1F, 0x0F, 0x0F, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x3C,
  0x3E, 0x1F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x1E, 0x1F, 0x0F, 0x83, 0xC3,
  0xE1, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF8,
  0x78, 0x7C, 0x1E, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3E,
  0x1F, 0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0xF0, 0x7C, 0x3C, 0x1E, 0x1F, 0x07,
  0x87, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x3F, 0xE0, 0x7E, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE1, 0xF7, 0xFF, 0xC3, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x01,
  0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F,
  0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xF3, 0xFE, 0x01, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7D, 0xFF, 0xF0,
  0x3F, 0xC1, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC1, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7D, 0xFF, 0xF0, 0x3E,
  0x7F, 0xE0, 0x1F, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0x3F, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xBE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1,
  0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x8F,
  0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x1F, 0xF9, 0xF0, 0x0F, 0xF1,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x43, 0xE0, 0x07, 0xC7, 0xFC, 0x03, 0xE7, 0xFF, 0x01, 0xF7,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F,
  0xC0, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x0F,
  0x83, 0xFE, 0x0F, 0xC1, 0xEF, 0x07, 0xE0, 0xF7, 0x83, 0xF0, 0xFB, 0xC3,
  0xB8, 0x79, 0xE1, 0xDC, 0x3C, 0xF0, 0xEE, 0x3E, 0x78, 0xE7, 0x1E, 0x3C,
  0x73, 0x8F, 0x1E, 0x39, 0xC7, 0x8F, 0x38, 0xE7, 0x87, 0x9C, 0x73, 0xC3,
  0xCE, 0x39, 0xE1, 0xE7, 0x1D, 0xE0, 0xF7, 0x0E, 0xF0, 0x7B, 0x87, 0x78,
  0x3D, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x03,
  0xF1, 0xFC, 0x0F, 0xE3, 0xFE, 0xF7, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xBF,
  0x07, 0xFE, 0x7C, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x0F, 0x1F, 0xF8, 0x0F, 0x3F, 0xFC, 0x1F, 0x3F, 0xFC, 0x1F, 0x7C, 0x7E,
  0x1F, 0x7C, 0x3F, 0x3E, 0x78, 0x1F, 0xFE, 0x78, 0x1F, 0xFC, 0xF8, 0x0F,
  0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 34, 28, 8, -34 },
  { 52, 17, 14, 28, 8, -34 },
  { 82, 27, 34, 28, 1, -34 },
  { 197, 25, 46, 28, 2, -40 },
  { 341, 33, 34, 28, -2, -34 },
  { 482, 26, 34, 28, 1, -34 },
  { 593, 7, 14, 28, 13, -34 },
  { 606, 19, 45, 28, 7, -39 },
  { 713, 20, 45, 28, 2, -39 },
  { 826, 25, 24, 28, 2, -28 },
  { 901, 23, 22, 28, 3, -26 },
  { 965, 13, 14, 28, 4, -7 },
  { 988, 16, 5, 28, 6, -18 },
  { 998, 9, 8, 28, 8, -8 },
  { 1007, 29, 43, 28, 0, -38 },
  { 1163, 25, 34, 28, 2, -34 },
  { 1270, 22, 34, 28, 2, -34 },
  { 1364, 24, 34, 28, 2, -34 },
  { 1466, 24, 34, 28, 2, -34 },
  { 1568, 23, 34, 28, 2, -34 },
  { 1666, 24, 34, 28, 2, -34 },
  { 1768, 23, 34, 28, 2, -34 },
  { 1866, 23, 34, 28, 5, -34 },
  { 1964, 24, 34, 28, 2, -34 },
  { 2066, 23, 34, 28, 4, -34 },
  { 2164, 12, 26, 28, 8, -26 },
  { 2203, 16, 33, 28, 4, -26 },
  { 2269, 22, 25, 28, 4, -28 },
  { 2338, 22, 16, 28, 3, -23 },
  { 2382, 23, 25, 28, 2, -28 },
  { 2454, 19, 34, 28, 6, -34 },
  { 2535, 28, 42, 28, 0, -34 },
  { 2682, 24, 34, 28, 0, -34 },
  { 2784, 25, 34, 28, 2, -34 },
  { 2891, 25, 34, 28, 2, -34 },
  { 2998, 25, 34, 28, 2, -34 },
  { 3105, 25, 34, 28, 2, -34 },
  { 3212, 26, 34, 28, 2, -34 },
  { 3323, 25, 34, 28, 2, -34 },
  { 3430, 25, 34, 28, 2, -34 },
  { 3537, 25, 34, 28, 2, -34 },
  { 3644, 27, 34, 28, 0, -34 },
  { 3759, 27, 34, 28, 2, -34 },
  { 3874, 20, 34, 28, 3, -34 },
  { 3959, 27, 34, 28, 1, -34 },
  { 4074, 25, 34, 28, 2, -34 },
  { 4181, 24, 34, 28, 2, -34 },
  { 4283, 26, 34, 28, 2, -34 },
  { 4394, 25, 42, 28, 2, -34 },
  { 4526, 25, 34, 28, 2, -34 },
  { 4633, 25, 34, 28, 2, -34 },
  { 4740, 24, 34, 28, 5, -34 },
  { 4842, 25, 34, 28, 2, -34 },
  { 4949, 24, 34, 28, 5, -34 },
  { 5051, 28, 34, 28, 2, -34 },
  { 5170, 30, 34, 28, -1, -34 },
  { 5298, 25, 34, 28, 5, -34 },
  { 5405, 25, 34, 28, 2, -34 },
  { 5512, 19, 43, 28, 6, -38 },
  { 5615, 15, 43, 28, 7, -38 },
  { 5696, 19, 43, 28, 4, -38 },
  { 5799, 21, 18, 28, 4, -34 },
  { 5847, 23, 5, 28, 0, 1 },
  { 5862, 9, 6, 28, 12, -36 },
  { 5869, 24, 26, 28, 2, -26 },
  { 5947, 23, 34, 28, 2, -34 },
  { 6045, 24, 26, 28, 2, -26 },
  { 6123, 25, 34, 28, 2, -34 },
  { 6230, 23, 26, 28, 2, -26 },
  { 6305, 31, 42, 28, -2, -34 },
  { 6468, 23, 34, 28, 3, -26 },
  { 6566, 23, 34, 28, 2, -34 },
  { 6664, 23, 36, 28, 1, -36 },
  { 6768, 25, 44, 28, 0, -36 },
  { 6906, 26, 34, 28, 2, -34 },
  { 7017, 20, 34, 28, 4, -34 },
  { 7102, 27, 26, 28, 0, -26 },
  { 7190, 23, 26, 28, 2, -26 },
  { 7265, 23, 26, 28, 2, -26 },
  { 7340, 25, 34, 28, 0, -26 },
  { 7447, 24, 34, 28, 2, -26 },
  { 7549, 25, 26, 28, 2, -26 },
  { 7631, 23, 26, 28, 2, -26 },
  { 7706, 23, 32, 28, 3, -32 },
  { 7798, 24, 25, 28, 2, -25 },
  { 7873, 24, 25, 28, 4, -25 },
  { 7948, 25, 25, 28, 3, -25 },
  { 8027, 27, 25, 28, 0, -25 },
  { 8112, 23, 33, 28, 3, -25 },
  { 8207, 23, 25, 28, 2, -25 },
  { 8279, 24, 43, 28, 4, -38 },
  { 8408, 12, 43, 28, 8, -38 },
  { 8473, 24, 43, 28, 1, -38 },
  { 8602, 24, 10, 28, 2, -21 },
};

const GFXfont JetBrainsMono_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC46PT7B_H_
