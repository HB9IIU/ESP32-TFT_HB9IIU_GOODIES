#ifndef _JETBRAINSMONO_SEMIBOLDITALIC55PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x78, 0x01, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFB, 0x9F, 0xE0, 0x3F, 0x8E, 0x3F, 0x81, 0xFC,
  0x38, 0x7E, 0x07, 0xE1, 0xE1, 0xFC, 0x1F, 0x87, 0x87, 0xE0, 0xFE, 0x1E,
  0x00, 0x03, 0xF8, 0x70, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x3F, 0x87, 0x00,
  0x00, 0xFF, 0x3C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0x1F, 0xE0, 0x00, 0x1C, 0x3F, 0x80, 0x00, 0x70,
  0xFE, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x0F, 0x07, 0xE1, 0xF8, 0x3C, 0x3F,
  0x8F, 0xE0, 0xE0, 0xFE, 0x3F, 0x83, 0x83, 0xF0, 0x7F, 0x0E, 0x1F, 0xC1,
  0xFC, 0x78, 0xFF, 0x07, 0xFD, 0xEF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7E, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x0F, 0x00,
  0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x00,
  0xFC, 0x7E, 0x7C, 0x00, 0x01, 0xFF, 0xF9, 0xF0, 0x00, 0x01, 0xFF, 0xE3,
  0xE0, 0x00, 0x01, 0xFF, 0x8F, 0x80, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0x00,
  0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0xFF, 0x80, 0x00, 0x1F,
  0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x7C, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0xF8, 0x00, 0x3E,
  0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x1F,
  0xC7, 0xF7, 0xF0, 0x3F, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8,
  0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x1F, 0xDF, 0x83, 0xF0, 0x1F, 0xFF, 0x07,
  0xE0, 0x1F, 0xFC, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFD, 0xF8, 0x0F, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0x83, 0xF0, 0x0F, 0xFC,
  0x07, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x07, 0xC0, 0x31, 0xF0, 0x3C, 0x0F,
  0x9F, 0xE1, 0xE1, 0xFF, 0xFF, 0x8E, 0x3F, 0xFF, 0xFF, 0x77, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x40, 0x02, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0xC7, 0xF9, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF3, 0xFE, 0x3F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xF1, 0xF8, 0x38, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3,
  0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC1,
  0xF1, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xC7, 0xE0, 0x07,
  0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1E, 0x07, 0xF0, 0x03, 0x00, 0xFE,
  0x00, 0x40, 0x1F, 0xC0, 0x10, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xFC, 0x01, 0xFD, 0xFF,
  0xE0, 0x1F, 0xBF, 0xFF, 0x01, 0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x8F,
  0x80, 0x07, 0xF3, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xDF, 0x80, 0xFF, 0xF7, 0xF0, 0x0F, 0xFD, 0xFC, 0x00, 0x18,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xE0, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x20, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x3E, 0x01, 0xFF, 0x3E, 0x1F, 0x80, 0xFF, 0xEF, 0x87, 0xE0,
  0x7F, 0xFB, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F,
  0x03, 0xE0, 0x3F, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x7E, 0x03, 0xF0,
  0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x0F, 0xC0,
  0x7E, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x3E,
  0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xF8, 0x7F, 0x07, 0xC0,
  0xFF, 0xF7, 0xC3, 0xF0, 0x1F, 0xFD, 0xF0, 0xFC, 0x03, 0xFE, 0x7C, 0x3F,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x08,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8,
  0x01, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0xFF,
  0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x81, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0xFE, 0x1F, 0x83, 0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0x8F, 0xE0, 0xFF, 0xFC,
  0x7F, 0x07, 0xFF, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0x78, 0x0F, 0x7C, 0x0F, 0xBC, 0x0F,
  0xFC, 0x07, 0xDE, 0x07, 0xBE, 0x03, 0xEF, 0x07, 0xDF, 0x01, 0xF7, 0x83,
  0xCF, 0x81, 0xFB, 0xE3, 0xEF, 0xC0, 0xFD, 0xF1, 0xE7, 0xE0, 0x7E, 0x79,
  0xF3, 0xE0, 0x3E, 0x3C, 0xF9, 0xF0, 0x1F, 0x1E, 0x78, 0xF8, 0x0F, 0x8F,
  0x7C, 0xFC, 0x0F, 0xC7, 0xBC, 0x7E, 0x07, 0xE3, 0xFE, 0x3F, 0x03, 0xF1,
  0xFE, 0x1F, 0x01, 0xF8, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xF8, 0x03,
  0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xFF, 0xC0, 0x1F,
  0x81, 0xFF, 0x80, 0x3F, 0x03, 0xFF, 0x80, 0x7E, 0x07, 0xDF, 0x01, 0xF8,
  0x0F, 0xBE, 0x03, 0xF0, 0x3F, 0x7C, 0x07, 0xE0, 0x7E, 0xF8, 0x0F, 0xC0,
  0xFD, 0xF0, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0x03, 0xF3, 0xE0, 0x7C, 0x07,
  0xC7, 0xC1, 0xF8, 0x0F, 0x8F, 0x83, 0xF0, 0x3F, 0x1F, 0x07, 0xE0, 0x7E,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x3E, 0x03, 0xF0,
  0xF8, 0xFC, 0x07, 0xC1, 0xF1, 0xF8, 0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x03,
  0xE7, 0xE0, 0x7E, 0x07, 0xCF, 0xC0, 0xFC, 0x0F, 0x9F, 0x01, 0xF8, 0x1F,
  0x3E, 0x03, 0xF0, 0x3F, 0x7C, 0x0F, 0xC0, 0x7E, 0xF8, 0x1F, 0x80, 0x7F,
  0xF0, 0x3F, 0x00, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xFF,
  0x01, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xC0, 0x0F, 0xF8,
  0x1F, 0x80, 0x1F, 0xF0, 0x3F, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x7F, 0x01, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC,
  0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E,
  0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x68, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x03, 0xF0,
  0x1F, 0x9F, 0x01, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0x7E,
  0x03, 0xE3, 0xE0, 0x7F, 0x03, 0xF1, 0xF0, 0x3B, 0x81, 0xF0, 0xF8, 0x1D,
  0xC0, 0xF8, 0x7C, 0x1E, 0xE0, 0x7C, 0x7E, 0x0F, 0xF0, 0x7E, 0x3F, 0x07,
  0x78, 0x3E, 0x1F, 0x83, 0xBC, 0x1F, 0x0F, 0xC3, 0xDE, 0x0F, 0x87, 0xE1,
  0xEF, 0x0F, 0xC3, 0xF0, 0xE7, 0x87, 0xC1, 0xF0, 0x73, 0xC3, 0xE0, 0xF8,
  0x79, 0xE1, 0xF0, 0x7C, 0x3C, 0xF1, 0xF0, 0x3E, 0x1C, 0x78, 0xF8, 0x1F,
  0x1E, 0x38, 0x7C, 0x0F, 0x8F, 0x1C, 0x3E, 0x07, 0xC7, 0x0E, 0x3E, 0x03,
  0xE3, 0x87, 0x1F, 0x01, 0xF3, 0xC3, 0x8F, 0x80, 0xF9, 0xE1, 0xC7, 0xC0,
  0x7C, 0xE0, 0xE7, 0xC0, 0x3E, 0xF0, 0x73, 0xE0, 0x1F, 0x78, 0x39, 0xF0,
  0x1F, 0xBC, 0x3C, 0xF8, 0x0F, 0xDC, 0x1E, 0xF8, 0x07, 0xDE, 0x0F, 0x7C,
  0x03, 0xEF, 0x07, 0xBE, 0x01, 0xF7, 0x03, 0xDE, 0x00, 0xFB, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0xFC, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0x01, 0xFF, 0xE7, 0xF0,
  0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0,
  0x3F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xBF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xE7, 0xE0, 0x0F, 0xF8,
  0x7E, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE3, 0xFF, 0x00, 0xFE, 0x7F, 0xF8, 0x0F,
  0xEF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xE0, 0xFF, 0x81,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7E,
  0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x0F, 0xC3, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x0F,
  0xFC, 0x7F, 0x00, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF,
  0xDF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xEF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xE7, 0xE0, 0x03,
  0xFE, 0x1F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xF8, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x7F,
  0x01, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0xF7, 0xE0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x87, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xFB, 0xF0,
  0x1F, 0xFF, 0x3F, 0x00, 0xFF, 0xE7, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE3, 0xFF, 0x00, 0xFE, 0x7F, 0xF8, 0x0F,
  0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xE0, 0xFF, 0x81,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x3F,
  0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0xFF, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80,
  0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0x00, 0xE0, 0x1F, 0xBF, 0x87, 0xF0, 0x3E,
  0x7F, 0x9F, 0xF0, 0x7D, 0xFF, 0x7F, 0xE0, 0xFF, 0xFE, 0xFF, 0xC1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x3E, 0x1F, 0x83,
  0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x07, 0xE1, 0xF0, 0x3C, 0x0F, 0xC7, 0xE0, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0,
  0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7C, 0x0F, 0x83,
  0xF0, 0xF8, 0x1E, 0x07, 0xE3, 0xF0, 0x3C, 0x0F, 0x87, 0xE0, 0xF8, 0x1F,
  0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x7C, 0x0F, 0x03, 0xF1, 0xF8, 0x1E, 0x07, 0xC3, 0xF0, 0x7C, 0x0F, 0x87,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3E,
  0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x3F, 0xF0, 0x0F,
  0xE7, 0xFF, 0x80, 0xFE, 0xFF, 0xFC, 0x0F, 0xDF, 0xFF, 0xE0, 0xFD, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00,
  0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE3, 0xFF,
  0x00, 0x3F, 0x9F, 0xFE, 0x00, 0xFE, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xF8,
  0x0F, 0xDF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xEF,
  0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0x00, 0xFE, 0x7F, 0xF8, 0x03, 0xF0, 0xFF,
  0x80, 0x0F, 0xC0, 0x20, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0x01, 0xFF,
  0xE7, 0xF0, 0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF,
  0xBF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xE7, 0xE0,
  0x0F, 0xF8, 0x7E, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x1F, 0xFC, 0x03, 0xF9,
  0xFF, 0xF0, 0x1F, 0x9F, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7,
  0xF0, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x81, 0xF8, 0x0F, 0xBE, 0x07, 0xE0,
  0x3E, 0xF8, 0x1F, 0x81, 0xFB, 0xE0, 0xFE, 0x07, 0xCF, 0x83, 0xB8, 0x1F,
  0x3E, 0x0E, 0xE0, 0x7C, 0xF8, 0x7B, 0x83, 0xE3, 0xE1, 0xEE, 0x0F, 0x8F,
  0x87, 0x38, 0x3E, 0x3E, 0x3C, 0xE1, 0xF0, 0xF8, 0xF3, 0x87, 0xC3, 0xE3,
  0x8E, 0x1F, 0x0F, 0x8E, 0x38, 0xF8, 0x3E, 0x78, 0xE3, 0xE0, 0xF9, 0xC3,
  0x8F, 0x83, 0xE7, 0x0E, 0x7C, 0x0F, 0xBC, 0x39, 0xF0, 0x3E, 0xE0, 0xE7,
  0xC0, 0xF3, 0x83, 0x9E, 0x03, 0xDE, 0x0E, 0xF8, 0x0F, 0x78, 0x3B, 0xE0,
  0x3D, 0xC0, 0xEF, 0x80, 0xF7, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0x3F, 0x01, 0xFF, 0xF7, 0xF0, 0x0F, 0xFC,
  0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xC7, 0xFF, 0x80,
  0x7C, 0x7F, 0xFE, 0x03, 0xE3, 0xFF, 0xF0, 0x3F, 0x3F, 0xBF, 0xC1, 0xF9,
  0xF0, 0x7F, 0x0F, 0xDF, 0x83, 0xFC, 0xFC, 0xFC, 0x0F, 0xFF, 0xE7, 0xE0,
  0x3F, 0xFE, 0x3F, 0x01, 0xFF, 0xE1, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 40, 33, 10, -40 },
  { 71, 21, 16, 33, 9, -40 },
  { 113, 33, 40, 33, 1, -40 },
  { 278, 30, 56, 33, 2, -48 },
  { 488, 39, 40, 33, -2, -40 },
  { 683, 31, 42, 33, 1, -41 },
  { 846, 9, 16, 33, 15, -40 },
  { 864, 24, 53, 33, 8, -46 },
  { 1023, 23, 53, 33, 3, -46 },
  { 1176, 29, 29, 33, 3, -34 },
  { 1282, 28, 26, 33, 3, -31 },
  { 1373, 15, 17, 33, 5, -8 },
  { 1405, 20, 6, 33, 7, -21 },
  { 1420, 11, 10, 33, 9, -9 },
  { 1434, 34, 52, 33, 0, -46 },
  { 1655, 29, 42, 33, 3, -41 },
  { 1808, 27, 40, 33, 2, -40 },
  { 1943, 30, 41, 33, 2, -41 },
  { 2097, 29, 41, 33, 2, -40 },
  { 2246, 27, 40, 33, 3, -40 },
  { 2381, 28, 41, 33, 3, -40 },
  { 2525, 28, 41, 33, 2, -40 },
  { 2669, 28, 40, 33, 6, -40 },
  { 2809, 29, 42, 33, 2, -41 },
  { 2962, 27, 41, 33, 5, -41 },
  { 3101, 15, 32, 33, 9, -31 },
  { 3161, 19, 40, 33, 5, -31 },
  { 3256, 28, 30, 33, 4, -33 },
  { 3361, 27, 19, 33, 3, -28 },
  { 3426, 28, 30, 33, 2, -33 },
  { 3531, 23, 40, 33, 7, -40 },
  { 3646, 34, 51, 33, 0, -41 },
  { 3863, 28, 40, 33, 0, -40 },
  { 4003, 30, 40, 33, 2, -40 },
  { 4153, 29, 42, 33, 3, -41 },
  { 4306, 30, 40, 33, 2, -40 },
  { 4456, 30, 40, 33, 3, -40 },
  { 4606, 31, 40, 33, 2, -40 },
  { 4761, 29, 42, 33, 3, -41 },
  { 4914, 31, 40, 33, 2, -40 },
  { 5069, 29, 40, 33, 3, -40 },
  { 5214, 32, 41, 33, 0, -40 },
  { 5378, 33, 40, 33, 2, -40 },
  { 5543, 25, 40, 33, 3, -40 },
  { 5668, 33, 40, 33, 1, -40 },
  { 5833, 31, 40, 33, 2, -40 },
  { 5988, 29, 42, 33, 3, -41 },
  { 6141, 31, 40, 33, 2, -40 },
  { 6296, 29, 51, 33, 3, -41 },
  { 6481, 31, 40, 33, 2, -40 },
  { 6636, 30, 42, 33, 2, -41 },
  { 6794, 28, 40, 33, 6, -40 },
  { 6934, 30, 41, 33, 3, -40 },
  { 7088, 29, 40, 33, 6, -40 },
  { 7233, 33, 40, 33, 3, -40 },
  { 7398, 36, 40, 33, -1, -40 },
  { 7578, 31, 40, 33, 5, -40 },
  { 7733, 30, 40, 33, 2, -40 },
  { 7883, 23, 52, 33, 7, -46 },
  { 8033, 18, 52, 33, 8, -46 },
  { 8150, 23, 52, 33, 4, -46 },
  { 8300, 26, 21, 33, 4, -40 },
  { 8369, 27, 6, 33, 0, 1 },
  { 8390, 11, 8, 33, 14, -43 },
  { 8401, 28, 32, 33, 3, -31 },
  { 8513, 28, 41, 33, 2, -40 },
  { 8657, 28, 32, 33, 3, -31 },
  { 8769, 30, 41, 33, 3, -40 },
  { 8923, 27, 32, 33, 3, -31 },
  { 9031, 38, 50, 33, -3, -40 },
  { 9269, 28, 41, 33, 3, -31 },
  { 9413, 28, 40, 33, 2, -40 },
  { 9553, 27, 43, 33, 2, -43 },
  { 9699, 29, 53, 33, 1, -43 },
  { 9892, 31, 40, 33, 2, -40 },
  { 10047, 24, 40, 33, 5, -40 },
  { 10167, 31, 31, 33, 1, -31 },
  { 10288, 28, 31, 33, 2, -31 },
  { 10397, 27, 32, 33, 3, -31 },
  { 10505, 30, 41, 33, 0, -31 },
  { 10659, 28, 41, 33, 3, -31 },
  { 10803, 29, 31, 33, 3, -31 },
  { 10916, 28, 32, 33, 2, -31 },
  { 11028, 27, 39, 33, 4, -39 },
  { 11160, 28, 31, 33, 3, -30 },
  { 11269, 28, 30, 33, 5, -30 },
  { 11374, 30, 30, 33, 4, -30 },
  { 11487, 32, 30, 33, 0, -30 },
  { 11607, 28, 40, 33, 3, -30 },
  { 11747, 28, 30, 33, 2, -30 },
  { 11852, 28, 52, 33, 5, -46 },
  { 12034, 14, 52, 33, 10, -46 },
  { 12125, 29, 52, 33, 1, -46 },
  { 12314, 29, 13, 33, 3, -26 },
};

const GFXfont JetBrainsMono_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC55PT7B_H_
