#ifndef _JETBRAINSMONO_SEMIBOLDITALIC49PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xF9, 0xF8,
  0x7E, 0x7C, 0x1F, 0x9F, 0x07, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3C,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x88, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3C,
  0x00, 0x1E, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xC0, 0x01, 0xE0,
  0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x39, 0xFC,
  0x0F, 0xC7, 0x1F, 0x83, 0xF0, 0xE3, 0xF0, 0x7E, 0x3C, 0x7E, 0x0F, 0xC7,
  0x00, 0x01, 0xF0, 0xE0, 0x00, 0x3F, 0x1C, 0x00, 0x07, 0xE3, 0x80, 0x00,
  0xFE, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xDF, 0xF0, 0x00, 0x38, 0xFE, 0x00, 0x07, 0x0F,
  0xC0, 0x00, 0xE1, 0xF8, 0x00, 0x1C, 0x3F, 0x1F, 0x83, 0x87, 0xE3, 0xF0,
  0xE0, 0xFC, 0x7E, 0x1C, 0x3F, 0x0F, 0xE3, 0x87, 0xE1, 0xFE, 0x73, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xF8,
  0x00, 0xF8, 0x07, 0xFF, 0x80, 0x1E, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x3C,
  0x1E, 0x01, 0xE0, 0x0F, 0x83, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x1F, 0x00,
  0x3C, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xE1, 0xF0, 0x00, 0xF0, 0x3C, 0x3C,
  0x00, 0x1E, 0x0F, 0x8F, 0x00, 0x03, 0xC1, 0xE3, 0xC0, 0x00, 0x7C, 0x7C,
  0xF0, 0x00, 0x0F, 0xFF, 0x3E, 0x00, 0x00, 0xFF, 0xCF, 0x80, 0x00, 0x0F,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0x07, 0xCF, 0xFF, 0x00, 0x00, 0xF3,
  0xFF, 0xE0, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0x0F, 0x1E, 0x07, 0x80, 0x03,
  0xC3, 0xC0, 0xF0, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x1E, 0x00, 0x78, 0x0F, 0x83,
  0xC0, 0x1E, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0x1F, 0xFE, 0x01, 0xF0, 0x01,
  0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0x9F,
  0x9F, 0x83, 0xF3, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x1F, 0x83, 0xE7,
  0xE3, 0xF0, 0x7F, 0xF8, 0x7C, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0x81, 0xF0,
  0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0,
  0x3F, 0x01, 0xFF, 0x07, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE7, 0xC0, 0xFF, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xC0, 0x3F, 0x3F, 0x3F,
  0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x78, 0x0E, 0x3F,
  0x0F, 0x0F, 0xCF, 0xF1, 0xC7, 0xF9, 0xFF, 0xB9, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xF8, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0x80, 0x10, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1F,
  0x8F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7, 0xF8, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x78, 0x3E,
  0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF1, 0xF8, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F,
  0xC1, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x03, 0xE0, 0x0C,
  0x07, 0xE0, 0x08, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x80, 0x03, 0xE3,
  0xFE, 0x00, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFC, 0x7F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFE, 0xFF,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xFC,
  0x07, 0xF0, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x1F, 0xC1, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xDF, 0x80, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0xF8, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x7C, 0x78, 0x7C, 0x07, 0xF9, 0xE1, 0xF0, 0x3F, 0xF7, 0x87, 0xC1,
  0xFF, 0xFE, 0x1E, 0x07, 0xC1, 0xF8, 0x78, 0x3E, 0x07, 0xE3, 0xE0, 0xF8,
  0x0F, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x7C, 0x07,
  0xC3, 0xE1, 0xF0, 0x1F, 0x0F, 0x07, 0xC0, 0x7C, 0x7C, 0x1F, 0x01, 0xF1,
  0xF0, 0x7C, 0x07, 0x87, 0xC1, 0xF0, 0x3E, 0x1F, 0x07, 0xC0, 0xF8, 0x7C,
  0x1F, 0x07, 0xE1, 0xE0, 0x7E, 0x3F, 0x8F, 0x81, 0xFF, 0xFE, 0x3E, 0x03,
  0xFE, 0xF0, 0xF8, 0x07, 0xF3, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0x80, 0x7F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xF8, 0x01,
  0xFC, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0xFC,
  0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x00, 0x7F, 0x07, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x07, 0xFF, 0x9F, 0x83, 0xFF, 0xCF, 0xC3, 0xFF, 0xE7, 0xE1,
  0xFF, 0xE3, 0xF0, 0xFF, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x03,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7B, 0xC1, 0xFF, 0x03,
  0xFE, 0x0F, 0xBC, 0x3D, 0xF0, 0x7D, 0xE1, 0xEF, 0x03, 0xEF, 0x1E, 0x78,
  0x1E, 0x78, 0xF7, 0xC0, 0xF3, 0xCF, 0x3E, 0x0F, 0x9E, 0x79, 0xF0, 0x7C,
  0x77, 0x8F, 0x83, 0xE3, 0xBC, 0xFC, 0x1F, 0x1F, 0xE7, 0xC0, 0xF8, 0xFE,
  0x3E, 0x07, 0xC7, 0xF1, 0xF0, 0x7E, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0xFC,
  0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0xFF,
  0x00, 0x7C, 0x1F, 0xE0, 0x0F, 0x83, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x7C,
  0x1F, 0xF0, 0x0F, 0x83, 0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x3E, 0x0F, 0xFC,
  0x07, 0xC1, 0xFF, 0x81, 0xF8, 0x3E, 0xF0, 0x3F, 0x0F, 0xDE, 0x07, 0xC1,
  0xF3, 0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07, 0xCF, 0x83, 0xE0, 0xF8, 0xF0,
  0xFC, 0x1F, 0x1E, 0x1F, 0x83, 0xE3, 0xE3, 0xE0, 0xFC, 0x7C, 0x7C, 0x1F,
  0x0F, 0x8F, 0x83, 0xE0, 0xF1, 0xF0, 0x7C, 0x1E, 0x3E, 0x0F, 0x83, 0xEF,
  0xC1, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC1, 0xF7, 0xC1, 0xF0,
  0x1E, 0xF8, 0x3E, 0x03, 0xFF, 0x07, 0xC0, 0x7F, 0xE0, 0xF8, 0x0F, 0xFC,
  0x3F, 0x01, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0xF8, 0x03, 0xFC, 0x1F, 0x00,
  0x7F, 0x83, 0xE0, 0x0F, 0xF0, 0x7C, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0,
  0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80,
  0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFC, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0xFF, 0x83, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x7F, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xF9,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0x7E, 0x07, 0x8F, 0x81,
  0xF8, 0x3E, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x3B, 0x83, 0xE3, 0xE0, 0xFE,
  0x0F, 0x0F, 0x83, 0xF0, 0x7C, 0x3E, 0x1F, 0xC1, 0xF0, 0xF8, 0x77, 0x07,
  0xC3, 0xE1, 0xDC, 0x1E, 0x0F, 0x87, 0x70, 0xF8, 0x3C, 0x39, 0xC3, 0xE0,
  0xF0, 0xE7, 0x0F, 0x03, 0xC3, 0x9C, 0x3C, 0x0F, 0x1E, 0x71, 0xF0, 0x3C,
  0x71, 0xC7, 0xC1, 0xF1, 0xC7, 0x1E, 0x07, 0xC7, 0x1C, 0x78, 0x1F, 0x3C,
  0x73, 0xE0, 0x7C, 0xE1, 0xCF, 0x81, 0xF3, 0x87, 0x3C, 0x07, 0xDE, 0x1C,
  0xF0, 0x1F, 0x70, 0x77, 0xC0, 0x7D, 0xC3, 0xDF, 0x01, 0xF7, 0x0F, 0x78,
  0x07, 0xFC, 0x3D, 0xE0, 0x1E, 0xE0, 0xFF, 0x80, 0x7B, 0x83, 0xBC, 0x01,
  0xEE, 0x0E, 0xF0, 0x07, 0xF8, 0x3B, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xE0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01,
  0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0,
  0x3E, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x00, 0x7F, 0x8F,
  0xC0, 0x7F, 0xF3, 0xE0, 0x3F, 0xFE, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC, 0x07, 0xFF, 0x3F, 0x00, 0xFF, 0x8F,
  0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xFC, 0x03, 0xE7, 0xFF, 0x01,
  0xF7, 0xFF, 0xC1, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFC,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xFC,
  0x07, 0xF1, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0xFF, 0xF8, 0x3F,
  0x7F, 0xF8, 0x1F, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0, 0x7E,
  0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF1,
  0xF8, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xF3,
  0xF0, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x04, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x1F, 0x81, 0xFF, 0xCF, 0x81, 0xFF, 0xF7, 0xC1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC,
  0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x7F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xC0, 0xFF,
  0xF7, 0xE0, 0x7F, 0xF3, 0xF0, 0x0F, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE3, 0xFC, 0x03, 0xF7, 0xFF, 0x01, 0xF7, 0xFF, 0xC1, 0xFB, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7C, 0x1F,
  0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xC1, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x0F, 0xBF, 0x1F, 0x81, 0xEF, 0xF7, 0xF8, 0x7D, 0xFE, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x0F, 0x07, 0xC7, 0xC1,
  0xE0, 0xF8, 0xF8, 0x3C, 0x1F, 0x3F, 0x0F, 0x87, 0xE7, 0xC1, 0xE0, 0xF8,
  0xF8, 0x3C, 0x1F, 0x1F, 0x07, 0x83, 0xE3, 0xE0, 0xF0, 0x7C, 0x7C, 0x1E,
  0x0F, 0x9F, 0x87, 0xC3, 0xF3, 0xE0, 0xF0, 0x7C, 0x7C, 0x1E, 0x0F, 0x8F,
  0x83, 0xC1, 0xF1, 0xF0, 0x78, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC3, 0xE0,
  0xF9, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x07, 0xC7, 0xC1, 0xE0, 0xF8, 0xF8,
  0x3C, 0x1F, 0x1F, 0x07, 0x83, 0xE3, 0xE1, 0xF0, 0xFC, 0x00, 0x0F, 0xC7,
  0xF8, 0x07, 0xCF, 0xFE, 0x03, 0xEF, 0xFF, 0x83, 0xF7, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF1, 0xFE, 0x00,
  0x7C, 0xFF, 0xE0, 0x0F, 0xBF, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xFE,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0x7F, 0xFC, 0x07, 0xEF, 0xFF, 0x00,
  0xFC, 0x7F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x8F, 0xC0, 0x7F, 0xF3, 0xE0, 0x3F, 0xFC, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC, 0x07, 0xFF, 0x3F, 0x00, 0xFF,
  0x8F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x87, 0xF8, 0x07, 0xCF,
  0xFF, 0x03, 0xEF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F, 0xF0, 0xFF,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0,
  0x7E, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xF0, 0x07, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xDF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x00,
  0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xFF,
  0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x1F, 0x81, 0xEF, 0x83, 0xF0,
  0x7D, 0xF0, 0x7E, 0x0F, 0xBE, 0x1D, 0xC1, 0xE7, 0xC3, 0xB8, 0x7C, 0xF8,
  0x77, 0x0F, 0x9F, 0x1E, 0xE1, 0xE3, 0xE3, 0x9C, 0x3C, 0x7C, 0x73, 0x8F,
  0x8F, 0x9E, 0x71, 0xE1, 0xF3, 0x8E, 0x3C, 0x3E, 0x71, 0xCF, 0x87, 0xCE,
  0x39, 0xE0, 0xFB, 0x87, 0x3C, 0x1F, 0x70, 0xEF, 0x83, 0xEE, 0x1D, 0xF0,
  0x7F, 0x83, 0xBC, 0x0F, 0xF0, 0x77, 0x81, 0xEE, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x03, 0xF8,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0xFE, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFD, 0xF8, 0x1F, 0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x40, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFE, 0x01, 0xF1, 0xFF, 0xC0, 0x7C, 0xFF, 0xF8, 0x1F, 0x3F,
  0xFF, 0x07, 0xDF, 0x8F, 0xC3, 0xE7, 0xC1, 0xF9, 0xF9, 0xF0, 0x7F, 0xFE,
  0x7C, 0x0F, 0xFF, 0x1F, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 36, 29, 9, -36 },
  { 55, 18, 15, 29, 8, -36 },
  { 89, 29, 36, 29, 1, -36 },
  { 220, 27, 50, 29, 2, -43 },
  { 389, 35, 36, 29, -2, -36 },
  { 547, 27, 36, 29, 1, -36 },
  { 669, 8, 15, 29, 13, -36 },
  { 684, 21, 47, 29, 7, -41 },
  { 808, 21, 47, 29, 2, -41 },
  { 932, 27, 26, 29, 2, -30 },
  { 1020, 24, 23, 29, 3, -28 },
  { 1089, 14, 15, 29, 4, -7 },
  { 1116, 17, 5, 29, 7, -19 },
  { 1127, 10, 8, 29, 8, -8 },
  { 1137, 31, 46, 29, 0, -41 },
  { 1316, 26, 36, 29, 2, -36 },
  { 1433, 24, 36, 29, 2, -36 },
  { 1541, 26, 36, 29, 2, -36 },
  { 1658, 26, 36, 29, 2, -36 },
  { 1775, 25, 36, 29, 2, -36 },
  { 1888, 26, 36, 29, 2, -36 },
  { 2005, 25, 36, 29, 2, -36 },
  { 2118, 25, 36, 29, 5, -36 },
  { 2231, 26, 36, 29, 2, -36 },
  { 2348, 25, 36, 29, 4, -36 },
  { 2461, 13, 27, 29, 8, -27 },
  { 2505, 17, 35, 29, 4, -27 },
  { 2580, 24, 26, 29, 4, -29 },
  { 2658, 24, 17, 29, 3, -25 },
  { 2709, 24, 26, 29, 2, -29 },
  { 2787, 21, 36, 29, 6, -36 },
  { 2882, 30, 45, 29, 0, -36 },
  { 3051, 25, 36, 29, 0, -36 },
  { 3164, 27, 36, 29, 2, -36 },
  { 3286, 25, 36, 29, 3, -36 },
  { 3399, 26, 36, 29, 2, -36 },
  { 3516, 27, 36, 29, 2, -36 },
  { 3638, 28, 36, 29, 2, -36 },
  { 3764, 25, 36, 29, 3, -36 },
  { 3877, 27, 36, 29, 2, -36 },
  { 3999, 26, 36, 29, 2, -36 },
  { 4116, 28, 36, 29, 0, -36 },
  { 4242, 29, 36, 29, 2, -36 },
  { 4373, 22, 36, 29, 3, -36 },
  { 4472, 29, 36, 29, 1, -36 },
  { 4603, 27, 36, 29, 2, -36 },
  { 4725, 25, 36, 29, 3, -36 },
  { 4838, 28, 36, 29, 2, -36 },
  { 4964, 26, 45, 29, 2, -36 },
  { 5111, 27, 36, 29, 2, -36 },
  { 5233, 27, 36, 29, 2, -36 },
  { 5355, 26, 36, 29, 5, -36 },
  { 5472, 27, 36, 29, 2, -36 },
  { 5594, 26, 36, 29, 5, -36 },
  { 5711, 30, 36, 29, 2, -36 },
  { 5846, 32, 36, 29, -1, -36 },
  { 5990, 27, 36, 29, 5, -36 },
  { 6112, 26, 36, 29, 2, -36 },
  { 6229, 21, 46, 29, 6, -41 },
  { 6350, 16, 46, 29, 7, -41 },
  { 6442, 20, 46, 29, 4, -41 },
  { 6557, 22, 19, 29, 4, -36 },
  { 6610, 24, 5, 29, 0, 1 },
  { 6625, 10, 6, 29, 12, -38 },
  { 6633, 26, 27, 29, 2, -27 },
  { 6721, 25, 36, 29, 2, -36 },
  { 6834, 24, 27, 29, 3, -27 },
  { 6915, 27, 36, 29, 2, -36 },
  { 7037, 24, 27, 29, 3, -27 },
  { 7118, 34, 45, 29, -3, -36 },
  { 7310, 25, 36, 29, 3, -27 },
  { 7423, 25, 36, 29, 2, -36 },
  { 7536, 24, 38, 29, 2, -38 },
  { 7650, 27, 47, 29, 0, -38 },
  { 7809, 27, 36, 29, 2, -36 },
  { 7931, 22, 36, 29, 4, -36 },
  { 8030, 27, 27, 29, 1, -27 },
  { 8122, 25, 27, 29, 2, -27 },
  { 8207, 24, 27, 29, 3, -27 },
  { 8288, 27, 36, 29, 0, -27 },
  { 8410, 26, 36, 29, 2, -27 },
  { 8527, 25, 27, 29, 3, -27 },
  { 8612, 25, 27, 29, 2, -27 },
  { 8697, 24, 34, 29, 4, -34 },
  { 8799, 26, 27, 29, 2, -27 },
  { 8887, 25, 27, 29, 4, -27 },
  { 8972, 27, 27, 29, 3, -27 },
  { 9064, 29, 27, 29, 0, -27 },
  { 9162, 24, 36, 29, 3, -27 },
  { 9270, 25, 27, 29, 2, -27 },
  { 9355, 26, 46, 29, 4, -41 },
  { 9505, 13, 46, 29, 9, -41 },
  { 9580, 26, 46, 29, 1, -41 },
  { 9730, 26, 11, 29, 2, -23 },
};

const GFXfont JetBrainsMono_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC49PT7B_H_
