#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x3F, 0x7F, 0xFF, 0xFF, 0xF3, 0xE1, 0x00, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0x87, 0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF0, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7F, 0xFF, 0x9F, 0xB8, 0x6F, 0xCE, 0x03, 0xE3, 0x80, 0xF8, 0xE0,
  0x3E, 0x38, 0x0F, 0xCE, 0x01, 0xFB, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xEF, 0xC0, 0x39, 0xF0, 0x0E, 0x7C, 0x03, 0x9F, 0x80, 0xE7,
  0xF0, 0x39, 0xFF, 0x8E, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83,
  0xFF, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x1F, 0xE0, 0x07, 0xC0,
  0x1F, 0xF8, 0x03, 0xC0, 0x0F, 0xFE, 0x03, 0xE0, 0x07, 0x9F, 0x01, 0xE0,
  0x07, 0xC7, 0x80, 0xF0, 0x03, 0xC3, 0xE0, 0xF8, 0x01, 0xE1, 0xF0, 0x78,
  0x00, 0xF0, 0xF8, 0x3C, 0x00, 0x78, 0x7C, 0x3E, 0x00, 0x3C, 0x3E, 0x1E,
  0x00, 0x1E, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0xC7,
  0x80, 0x03, 0xC3, 0xE7, 0xC3, 0xC1, 0xF1, 0xF3, 0xC7, 0xF8, 0xF8, 0xF1,
  0xE3, 0xFE, 0x3C, 0xF9, 0xF3, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0xC7, 0xFC,
  0x79, 0xF1, 0xE3, 0xFC, 0x7C, 0xF0, 0xF0, 0x7C, 0x3C, 0x78, 0x7C, 0x00,
  0x3E, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x0F, 0x80,
  0x0F, 0x87, 0x87, 0xC0, 0x07, 0x83, 0xC3, 0xE0, 0x03, 0xC1, 0xE1, 0xF0,
  0x03, 0xE0, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x7C, 0x01, 0xF0, 0x3E, 0x3C,
  0x00, 0xF0, 0x0F, 0x1E, 0x00, 0x78, 0x07, 0xFF, 0x00, 0x7C, 0x03, 0xFF,
  0x00, 0x3C, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F,
  0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF9,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xC7, 0xFF, 0x87, 0xE3,
  0xF7, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0xF8, 0x3F, 0xFC,
  0xFC, 0x1F, 0xFE, 0x7E, 0x07, 0xFE, 0x3F, 0x01, 0xFF, 0x1F, 0x80, 0xFF,
  0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xCF, 0xC0, 0xFF,
  0x87, 0xF0, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xF8, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0xE1, 0xE3, 0x9F, 0xBF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x7C,
  0x07, 0xE7, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0x00, 0xC1, 0xC0, 0x08, 0x10,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xFB,
  0xF7, 0xFF, 0xDF, 0x9F, 0x08, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7E, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF,
  0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xFC,
  0x1F, 0x1F, 0x87, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0,
  0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7E, 0xFF, 0xF3, 0xF7,
  0x8F, 0xCC, 0x3F, 0x20, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xF0, 0x07,
  0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9E, 0x0F, 0xE3, 0x01,
  0xF8, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9E, 0x07, 0xE2, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xC1, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07,
  0x9F, 0x00, 0x3C, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x10,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xFE, 0x03, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0xF8, 0x3E, 0x7F, 0x87, 0xDF, 0xF8, 0xFB, 0xFF, 0x9F, 0xFF, 0xF3,
  0xF8, 0x7F, 0x7F, 0x07, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xE7,
  0xC0, 0x7C, 0xFC, 0x1F, 0x9F, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7E,
  0x03, 0xE7, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1,
  0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x9F, 0xC3, 0xF0, 0xFC, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0,
  0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0,
  0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFB, 0xE1, 0xFF, 0xBE, 0x07, 0xE3, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x83, 0x9F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x7D, 0xFB, 0xFF,
  0xFF, 0xDF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x9F, 0xBF, 0x7F, 0xFF, 0xF9, 0xF0, 0x80, 0x3E, 0x7E,
  0x7F, 0x7F, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xF8, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8,
  0x7C, 0x01, 0x80, 0xF0, 0xF0, 0x3F, 0xF1, 0xF1, 0xE0, 0xFF, 0xE1, 0xE7,
  0xC3, 0xFF, 0xC3, 0xCF, 0x07, 0xC7, 0x87, 0x9E, 0x1F, 0x0F, 0x0F, 0x3C,
  0x3C, 0x1E, 0x1F, 0xF8, 0x78, 0x3C, 0x3F, 0xF1, 0xF0, 0x78, 0x7F, 0xC3,
  0xE0, 0xF0, 0xFF, 0x87, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xC3, 0xFE, 0x1F,
  0x0F, 0x87, 0xBC, 0x3E, 0x1F, 0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF8, 0x78,
  0x7C, 0x3D, 0xF0, 0xF1, 0xF8, 0xF9, 0xE1, 0xF7, 0xFB, 0xE3, 0xC1, 0xFE,
  0x7F, 0xC7, 0x83, 0xFC, 0xFF, 0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x04, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F,
  0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0x80, 0x03, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFE, 0x0E, 0x1F, 0x80, 0x23, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x61, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF1, 0xFF,
  0x8F, 0xC0, 0xFF, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00,
  0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xEF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0x87, 0xF0, 0x02, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xEF, 0xC0, 0xFF, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFE, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x87, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0xCF, 0x80, 0xFC, 0x7C, 0x0F,
  0xE3, 0xE0, 0x7E, 0x1F, 0x07, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E,
  0x3F, 0x81, 0xF1, 0xF8, 0x0F, 0x9F, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xE0,
  0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0x81,
  0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xFC, 0xF8, 0x07, 0xE7,
  0xC0, 0x3F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7D, 0xFF, 0xFC, 0x01,
  0xF7, 0xFE, 0xF8, 0x07, 0xDF, 0xFB, 0xE0, 0x1E, 0x7F, 0xEF, 0x80, 0xF9,
  0xFF, 0xBE, 0x03, 0xE7, 0xFE, 0x7C, 0x0F, 0xBF, 0xF9, 0xF0, 0x3C, 0xFF,
  0xE7, 0xC1, 0xF3, 0xFF, 0x8F, 0x07, 0xCF, 0xFE, 0x3E, 0x1E, 0x3F, 0xF8,
  0xF8, 0xF8, 0xFF, 0xE3, 0xE3, 0xE3, 0xFF, 0x87, 0x8F, 0x8F, 0xFE, 0x1F,
  0x3C, 0x3F, 0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xF7, 0xC3, 0xFF, 0x83, 0xFF,
  0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x83,
  0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF,
  0xE0, 0x3F, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0x03, 0xFF, 0xBF, 0x07,
  0xFF, 0x3E, 0x0F, 0xFE, 0x7C, 0x1F, 0xFC, 0xFC, 0x3F, 0xF8, 0xF8, 0x7F,
  0xF1, 0xF8, 0xFF, 0xE1, 0xF1, 0xFF, 0xC3, 0xF3, 0xFF, 0x87, 0xE7, 0xFF,
  0x07, 0xCF, 0xFE, 0x0F, 0xCF, 0xFC, 0x0F, 0x9F, 0xF8, 0x1F, 0xBF, 0xF0,
  0x1F, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7,
  0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xF8, 0xFF, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x87, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F, 0x9F, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x3F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x03,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF3,
  0xF8, 0xFB, 0xF8, 0x0D, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xFC, 0x0F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x7E,
  0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0x3F, 0x3E,
  0x00, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x80,
  0x7E, 0x7E, 0x03, 0xFE, 0x03, 0xE1, 0xF0, 0x1E, 0xF0, 0x1F, 0x0F, 0x80,
  0xF7, 0x81, 0xF8, 0x7E, 0x07, 0xBC, 0x0F, 0xC3, 0xF0, 0x7D, 0xE0, 0x7E,
  0x1F, 0x83, 0xEF, 0x83, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F, 0x03, 0xE0, 0xF3,
  0xE1, 0xF8, 0x1F, 0x07, 0x9F, 0x0F, 0xC0, 0xFC, 0x7C, 0x78, 0x7E, 0x07,
  0xE3, 0xE3, 0xE3, 0xE0, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0xF9,
  0xF8, 0x07, 0xC7, 0x87, 0xCF, 0xC0, 0x3F, 0x7C, 0x1E, 0x7E, 0x01, 0xFB,
  0xE0, 0xF3, 0xE0, 0x07, 0xDF, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x3E, 0xF8,
  0x01, 0xF7, 0x81, 0xFF, 0xC0, 0x0F, 0xBC, 0x07, 0xFE, 0x00, 0x7D, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E,
  0x01, 0xFD, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x03,
  0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0,
  0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF3, 0xF0, 0x07,
  0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xEF, 0x80,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF0, 0xE1,
  0xFC, 0x40, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0xFE, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xBF, 0xF3, 0xDF, 0xF9, 0xE7, 0xF0, 0xF0,
  0x40, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0xC0, 0x7E, 0x7F, 0x0F, 0x9F, 0xF1, 0xF7, 0xFF, 0x3F,
  0xFF, 0xF7, 0xF8, 0xFE, 0xFE, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0xF3, 0xFB, 0xFF,
  0xFE, 0x7D, 0xFF, 0xCF, 0x9F, 0xF1, 0xF1, 0xFC, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x8E, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x02, 0x7F, 0x9E, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x40, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x06, 0x0F, 0x87,
  0xF1, 0xF1, 0xFF, 0x3E, 0x7F, 0xF7, 0xCF, 0xFF, 0xFB, 0xF8, 0xFF, 0x7E,
  0x0F, 0xEF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF0,
  0x3F, 0x7E, 0x0F, 0xEF, 0xE3, 0xFC, 0xFF, 0xFF, 0x9F, 0xFD, 0xF1, 0xFF,
  0xBE, 0x1F, 0xC3, 0xC0, 0x40, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x1F,
  0x7C, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x08, 0xFE, 0x0E,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x60, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x01, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F,
  0xFD, 0xF3, 0xFF, 0xFE, 0xFE, 0x3F, 0xDF, 0x83, 0xFB, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xFC,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F, 0xCF, 0x87, 0xF1, 0xF0, 0x10,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE8, 0x01,
  0xF9, 0xC0, 0x7F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC3, 0x83, 0xE3, 0xF8, 0xF9, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFE, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xF0, 0x33, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x03,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x7C, 0x0F, 0xE7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x03, 0x83, 0xE3, 0xF8, 0x3F,
  0x8F, 0xBF, 0xF1, 0xFF, 0x3E, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFC, 0xFF, 0xEF, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0x03, 0xF8, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x03,
  0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x01,
  0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F,
  0xF0, 0x3F, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xFC,
  0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x03,
  0xF0, 0x1F, 0x00, 0x38, 0x3E, 0x3F, 0x8F, 0x9F, 0xF3, 0xEF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xEF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF1, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x0F, 0xC3, 0xF9, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x38, 0x1F, 0x1F, 0xC3, 0xE7,
  0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xFD, 0xFE, 0x3F, 0xBF, 0x83, 0xF7, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xF7, 0xFC, 0xFE, 0xFB, 0xFF, 0x9F, 0x7F, 0xF3, 0xE7, 0xFC, 0x7E, 0x7F,
  0x0F, 0xC1, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x7C, 0x7F, 0xEF,
  0x9F, 0xFD, 0xF3, 0xFF, 0xFE, 0xFE, 0x3F, 0xDF, 0x83, 0xFB, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB,
  0xFD, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F, 0xCF, 0x87, 0xF1, 0xF0,
  0x10, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x37, 0x87, 0xFE, 0x7F, 0xF7, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x1C, 0x7C, 0x04, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7E,
  0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0x03, 0x00,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF9, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x04, 0x00, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xF7, 0xCF, 0xFC, 0xF1, 0xFC, 0x3C, 0x08, 0x00, 0xFC,
  0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0x3F, 0x7C, 0x07, 0xF0, 0x3F, 0x7E, 0x0F,
  0xF0, 0x3E, 0x7E, 0x0F, 0xF0, 0x3E, 0x3E, 0x0F, 0xF0, 0x3E, 0x3E, 0x0F,
  0x78, 0x7E, 0x3E, 0x0F, 0x78, 0x7E, 0x3F, 0x0F, 0x78, 0x7C, 0x3F, 0x1E,
  0x78, 0x7C, 0x1F, 0x1E, 0x78, 0x7C, 0x1F, 0x1E, 0x3C, 0xFC, 0x1F, 0x1E,
  0x3C, 0xF8, 0x1F, 0x9E, 0x3C, 0xF8, 0x0F, 0xBE, 0x3C, 0xF8, 0x0F, 0xBC,
  0x3C, 0xF8, 0x0F, 0xBC, 0x3D, 0xF8, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC,
  0x1F, 0xF0, 0x07, 0xBC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xF7, 0xE0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9,
  0xF8, 0x0F, 0x9F, 0x80, 0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xF9, 0xF0,
  0x1F, 0x9F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x80, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0x81, 0xFF, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0xC0,
  0x17, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x07,
  0xFE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 37, 12, 3, -36 },
  { 34, 15, 13, 21, 3, -36 },
  { 59, 23, 36, 24, 1, -36 },
  { 163, 18, 41, 23, 2, -38 },
  { 256, 33, 36, 37, 2, -36 },
  { 405, 25, 37, 26, 1, -36 },
  { 521, 6, 13, 11, 3, -36 },
  { 531, 12, 44, 15, 2, -36 },
  { 597, 12, 44, 15, 1, -36 },
  { 663, 19, 19, 21, 1, -38 },
  { 709, 20, 24, 23, 1, -30 },
  { 769, 8, 13, 12, 2, -6 },
  { 782, 12, 5, 15, 1, -16 },
  { 790, 7, 8, 12, 3, -7 },
  { 797, 18, 36, 20, 1, -36 },
  { 878, 19, 37, 22, 2, -36 },
  { 966, 14, 36, 22, 3, -36 },
  { 1029, 18, 36, 22, 2, -36 },
  { 1110, 18, 37, 22, 2, -36 },
  { 1194, 21, 36, 22, 1, -36 },
  { 1289, 18, 37, 22, 2, -36 },
  { 1373, 19, 37, 22, 2, -36 },
  { 1461, 20, 36, 22, 1, -36 },
  { 1551, 20, 37, 22, 1, -36 },
  { 1644, 20, 37, 22, 1, -36 },
  { 1737, 7, 28, 12, 3, -27 },
  { 1762, 8, 34, 12, 2, -27 },
  { 1796, 20, 23, 23, 1, -29 },
  { 1854, 20, 15, 23, 1, -25 },
  { 1892, 20, 23, 23, 1, -29 },
  { 1950, 17, 37, 18, 0, -36 },
  { 2029, 31, 40, 35, 2, -36 },
  { 2184, 25, 36, 25, 0, -36 },
  { 2297, 20, 36, 25, 3, -36 },
  { 2387, 20, 37, 23, 2, -36 },
  { 2480, 22, 36, 27, 3, -36 },
  { 2579, 15, 36, 21, 4, -36 },
  { 2647, 15, 36, 21, 4, -36 },
  { 2715, 23, 37, 28, 2, -36 },
  { 2822, 21, 36, 28, 4, -36 },
  { 2917, 13, 36, 15, 1, -36 },
  { 2976, 12, 46, 13, -3, -36 },
  { 3045, 21, 36, 24, 4, -36 },
  { 3140, 16, 36, 20, 3, -36 },
  { 3212, 30, 36, 38, 4, -36 },
  { 3347, 23, 36, 30, 4, -36 },
  { 3451, 25, 37, 29, 2, -36 },
  { 3567, 19, 36, 24, 3, -36 },
  { 3653, 25, 45, 29, 2, -36 },
  { 3794, 21, 36, 25, 3, -36 },
  { 3889, 17, 37, 21, 2, -36 },
  { 3968, 19, 36, 21, 1, -36 },
  { 4054, 21, 37, 28, 3, -36 },
  { 4152, 24, 36, 24, 0, -36 },
  { 4260, 37, 36, 37, 0, -36 },
  { 4427, 22, 36, 22, 0, -36 },
  { 4526, 22, 36, 22, 0, -36 },
  { 4625, 18, 36, 20, 1, -36 },
  { 4706, 11, 44, 16, 3, -36 },
  { 4767, 18, 36, 20, 1, -36 },
  { 4848, 11, 44, 16, 1, -36 },
  { 4909, 23, 21, 25, 1, -36 },
  { 4970, 21, 4, 21, 0, 4 },
  { 4981, 11, 8, 15, 2, -38 },
  { 4992, 17, 29, 22, 2, -28 },
  { 5054, 19, 39, 24, 3, -38 },
  { 5147, 16, 29, 19, 2, -28 },
  { 5205, 19, 39, 24, 2, -38 },
  { 5298, 18, 29, 22, 2, -28 },
  { 5364, 16, 38, 14, 0, -38 },
  { 5440, 19, 40, 24, 2, -28 },
  { 5535, 18, 38, 24, 3, -38 },
  { 5621, 6, 38, 12, 3, -38 },
  { 5650, 10, 50, 12, -1, -38 },
  { 5713, 20, 38, 23, 3, -38 },
  { 5808, 6, 38, 12, 3, -38 },
  { 5837, 30, 28, 36, 3, -28 },
  { 5942, 18, 28, 24, 3, -28 },
  { 6005, 20, 29, 24, 2, -28 },
  { 6078, 19, 40, 24, 3, -28 },
  { 6173, 19, 40, 24, 2, -28 },
  { 6268, 13, 28, 17, 3, -28 },
  { 6314, 16, 29, 18, 1, -28 },
  { 6372, 13, 34, 15, 1, -33 },
  { 6428, 18, 28, 24, 3, -27 },
  { 6491, 21, 27, 21, 0, -27 },
  { 6562, 32, 27, 33, 0, -27 },
  { 6670, 20, 27, 20, 0, -27 },
  { 6738, 21, 39, 21, 0, -27 },
  { 6841, 15, 27, 17, 1, -27 },
  { 6892, 15, 44, 18, 1, -36 },
  { 6975, 5, 50, 21, 8, -38 },
  { 7007, 15, 44, 18, 2, -36 },
  { 7090, 20, 7, 23, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD50PT7B_H_
