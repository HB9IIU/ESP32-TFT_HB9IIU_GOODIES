#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0xC0, 0xBB, 0xB0, 0x28, 0xA7, 0xCA, 0x2B, 0xF5, 0x14,
  0x50, 0x47, 0xDC, 0xC7, 0x5D, 0xF4, 0x40, 0x72, 0x2A, 0x35, 0x0B, 0xA7,
  0xA8, 0x54, 0x4A, 0x25, 0x33, 0x80, 0x78, 0xB1, 0x63, 0x87, 0x7A, 0xB3,
  0x66, 0x76, 0xE0, 0x7A, 0x49, 0x24, 0x89, 0x80, 0xCC, 0x92, 0x49, 0x6B,
  0x00, 0x25, 0x7E, 0xE5, 0x80, 0x31, 0x8D, 0xF3, 0x18, 0x69, 0x60, 0xE0,
  0xC0, 0x18, 0x84, 0x62, 0x31, 0x08, 0xC0, 0x7A, 0x53, 0x9C, 0xA5, 0x2B,
  0x70, 0x7E, 0x92, 0x49, 0x20, 0xFA, 0x42, 0x31, 0x19, 0x88, 0xF8, 0xFA,
  0x42, 0x37, 0x04, 0x33, 0xF0, 0x18, 0xE3, 0x96, 0x5B, 0x6F, 0xC6, 0x18,
  0xF8, 0x8E, 0xB1, 0x1B, 0xE0, 0x3B, 0x10, 0xFC, 0xE5, 0x29, 0x78, 0xF8,
  0x46, 0x31, 0x18, 0xC4, 0x60, 0x7A, 0x52, 0xF7, 0x27, 0x39, 0x78, 0x7A,
  0x73, 0x97, 0x94, 0x23, 0x70, 0xE0, 0x2C, 0x68, 0x00, 0xD2, 0xC0, 0x04,
  0x77, 0x30, 0x30, 0x30, 0xF8, 0x3E, 0x83, 0x83, 0x83, 0x33, 0x00, 0xF1,
  0x13, 0x26, 0x06, 0x60, 0x7C, 0xC2, 0x9A, 0xAA, 0xAB, 0xAA, 0xAA, 0x94,
  0xC0, 0x7C, 0x30, 0xE3, 0x9A, 0x69, 0xF7, 0xF1, 0xC4, 0xF4, 0xE7, 0x2F,
  0x4E, 0x33, 0xF0, 0x7E, 0x21, 0x08, 0x42, 0x19, 0x78, 0xF4, 0xE3, 0x18,
  0xC6, 0x33, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88,
  0x80, 0x7E, 0x21, 0x09, 0xC6, 0x39, 0x78, 0x8C, 0x63, 0xFF, 0xC6, 0x31,
  0x88, 0xF6, 0x66, 0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0x27, 0xE0, 0x9C,
  0xAD, 0x4E, 0x7A, 0x53, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC3, 0xC7,
  0xE7, 0xA7, 0xAF, 0xBB, 0x9B, 0x9B, 0x9B, 0xC7, 0x1E, 0x69, 0xB6, 0x59,
  0xE3, 0x8C, 0x7B, 0x28, 0xE3, 0x8E, 0x38, 0xF2, 0x78, 0xF4, 0xE7, 0x3F,
  0x72, 0x10, 0x80, 0x7B, 0x28, 0xE3, 0x8E, 0x38, 0xF2, 0x78, 0x60, 0xC0,
  0xF4, 0xE7, 0x3F, 0x5A, 0x53, 0x98, 0x7A, 0x30, 0xC3, 0x0C, 0x33, 0xF0,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0x78,
  0xC7, 0x34, 0xD2, 0x69, 0xE3, 0x8C, 0x30, 0xCC, 0xF3, 0x2C, 0xC9, 0x76,
  0x55, 0x95, 0xC7, 0x31, 0xCC, 0x33, 0x00, 0xCD, 0x67, 0x0C, 0x30, 0xC7,
  0x92, 0xCC, 0xCD, 0x25, 0x9C, 0x30, 0xC3, 0x0C, 0x30, 0xF8, 0xC4, 0x62,
  0x31, 0x18, 0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x18, 0x42, 0x18,
  0x42, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x30, 0xC2, 0x92, 0xC4, 0xF8,
  0x90, 0x78, 0xC2, 0xFC, 0xED, 0xA0, 0x84, 0x21, 0xED, 0xCE, 0x73, 0xDF,
  0x80, 0x7A, 0x11, 0x84, 0x25, 0xE0, 0x0C, 0x30, 0xDF, 0x4D, 0x3C, 0xD3,
  0x4D, 0xF0, 0x7A, 0x53, 0xF4, 0x25, 0xE0, 0x76, 0x4F, 0x44, 0x44, 0x44,
  0x7D, 0x34, 0xF3, 0x4D, 0x37, 0xC3, 0x89, 0xE0, 0x84, 0x21, 0xED, 0x4E,
  0x73, 0x9C, 0xC0, 0xDF, 0xC0, 0x51, 0x55, 0x55, 0xC0, 0x84, 0x21, 0x3B,
  0x53, 0x96, 0x94, 0xC0, 0xFF, 0xC0, 0xF6, 0xDB, 0x93, 0x93, 0x93, 0x93,
  0x93, 0xF6, 0xA7, 0x39, 0xCE, 0x60, 0x79, 0x24, 0xF3, 0x4D, 0x27, 0x80,
  0xF6, 0xE7, 0x39, 0xEE, 0xD0, 0x84, 0x00, 0x7D, 0x34, 0xF3, 0x4D, 0x37,
  0xC3, 0x0C, 0x30, 0xBA, 0x49, 0x20, 0x7C, 0xC7, 0x19, 0xF0, 0x44, 0xF4,
  0x44, 0x44, 0x70, 0x9C, 0xE7, 0x39, 0xCF, 0xE0, 0xCE, 0x56, 0xA7, 0x18,
  0xC0, 0xD9, 0xD9, 0x5F, 0x57, 0x56, 0x76, 0x26, 0xDA, 0x9C, 0x67, 0x2B,
  0x60, 0xCE, 0x56, 0xA7, 0x18, 0xC4, 0x67, 0x00, 0xF3, 0x26, 0x44, 0xF0,
  0x32, 0x22, 0x6C, 0x22, 0x22, 0x30, 0xFF, 0xF8, 0xE2, 0x22, 0x23, 0x22,
  0x26, 0xE0, 0x47, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 5, 1, -9 },
  { 6, 6, 9, 6, 0, -9 },
  { 13, 4, 11, 6, 1, -10 },
  { 19, 9, 9, 10, 0, -9 },
  { 30, 7, 9, 7, 0, -9 },
  { 38, 1, 3, 3, 1, -9 },
  { 39, 3, 11, 4, 1, -9 },
  { 44, 3, 11, 4, 0, -9 },
  { 49, 5, 5, 6, 0, -10 },
  { 53, 5, 6, 6, 0, -8 },
  { 57, 3, 4, 3, 0, -2 },
  { 59, 3, 1, 4, 0, -4 },
  { 60, 1, 2, 3, 1, -2 },
  { 61, 5, 9, 5, 0, -9 },
  { 67, 5, 9, 6, 0, -9 },
  { 73, 3, 9, 6, 1, -9 },
  { 77, 5, 9, 6, 0, -9 },
  { 83, 5, 9, 6, 0, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 4, 9, 6, 1, -9 },
  { 101, 5, 9, 6, 0, -9 },
  { 107, 5, 9, 6, 0, -9 },
  { 113, 5, 9, 6, 0, -9 },
  { 119, 5, 9, 6, 0, -9 },
  { 125, 2, 7, 3, 1, -7 },
  { 127, 3, 9, 3, 0, -7 },
  { 131, 6, 6, 6, 0, -8 },
  { 136, 5, 3, 6, 0, -6 },
  { 138, 6, 6, 6, 0, -8 },
  { 143, 4, 9, 5, 0, -9 },
  { 148, 8, 10, 9, 1, -9 },
  { 158, 6, 9, 6, 0, -9 },
  { 165, 5, 9, 7, 1, -9 },
  { 171, 5, 9, 6, 1, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 4, 9, 6, 1, -9 },
  { 188, 4, 9, 5, 1, -9 },
  { 193, 5, 9, 7, 1, -9 },
  { 199, 5, 9, 7, 1, -9 },
  { 205, 4, 9, 4, 0, -9 },
  { 210, 3, 12, 3, -1, -9 },
  { 215, 5, 9, 6, 1, -9 },
  { 221, 4, 9, 5, 1, -9 },
  { 226, 8, 9, 10, 1, -9 },
  { 235, 6, 9, 8, 1, -9 },
  { 242, 6, 9, 8, 1, -9 },
  { 249, 5, 9, 6, 1, -9 },
  { 255, 6, 11, 8, 1, -9 },
  { 264, 5, 9, 6, 1, -9 },
  { 270, 5, 9, 5, 0, -9 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 5, 9, 7, 1, -9 },
  { 288, 6, 9, 6, 0, -9 },
  { 295, 10, 9, 10, 0, -9 },
  { 307, 6, 9, 6, 0, -9 },
  { 314, 6, 9, 6, 0, -9 },
  { 321, 5, 9, 5, 0, -9 },
  { 327, 3, 11, 4, 1, -9 },
  { 332, 5, 9, 5, 0, -9 },
  { 338, 3, 11, 4, 0, -9 },
  { 343, 6, 5, 6, 0, -9 },
  { 347, 5, 1, 5, 0, 1 },
  { 348, 2, 2, 4, 1, -10 },
  { 349, 5, 7, 6, 0, -7 },
  { 354, 5, 10, 6, 1, -10 },
  { 361, 5, 7, 5, 0, -7 },
  { 366, 6, 10, 6, 0, -10 },
  { 374, 5, 7, 6, 0, -7 },
  { 379, 4, 10, 4, 0, -10 },
  { 384, 6, 10, 6, 0, -7 },
  { 392, 5, 10, 6, 1, -10 },
  { 399, 1, 10, 3, 1, -10 },
  { 401, 2, 13, 3, 0, -10 },
  { 405, 5, 10, 6, 1, -10 },
  { 412, 1, 10, 3, 1, -10 },
  { 414, 8, 7, 9, 1, -7 },
  { 421, 5, 7, 6, 1, -7 },
  { 426, 6, 7, 6, 0, -7 },
  { 432, 5, 10, 6, 1, -7 },
  { 439, 6, 10, 6, 0, -7 },
  { 447, 3, 7, 4, 1, -7 },
  { 450, 4, 7, 5, 0, -7 },
  { 454, 4, 9, 4, 0, -9 },
  { 459, 5, 7, 6, 1, -7 },
  { 464, 5, 7, 5, 0, -7 },
  { 469, 8, 7, 8, 0, -7 },
  { 476, 5, 7, 5, 0, -7 },
  { 481, 5, 10, 5, 0, -7 },
  { 488, 4, 7, 4, 0, -7 },
  { 492, 4, 11, 5, 0, -9 },
  { 498, 1, 13, 6, 2, -10 },
  { 500, 4, 11, 5, 0, -9 },
  { 506, 6, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD13PT7B_H_
