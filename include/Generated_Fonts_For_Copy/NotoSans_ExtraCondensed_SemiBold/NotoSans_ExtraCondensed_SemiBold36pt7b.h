#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x3B, 0xFF, 0xFB, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x38, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0xB1,
  0x9C, 0xC0, 0x73, 0x01, 0xCC, 0x07, 0xB0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x03, 0x78, 0x0C, 0xF0, 0x33, 0xC0, 0xCF, 0x83,
  0x3F, 0x8D, 0xEF, 0xFF, 0xBF, 0xFC, 0x3F, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1E, 0x01, 0xC0, 0x3F, 0x01, 0xC0, 0x7F, 0x81, 0xC0,
  0x73, 0x83, 0x80, 0x73, 0x83, 0x80, 0xF3, 0xC7, 0x80, 0xE3, 0xC7, 0x00,
  0xE1, 0xC7, 0x00, 0xE1, 0xCE, 0x00, 0xE3, 0xCE, 0x00, 0xF3, 0xCE, 0x38,
  0x73, 0x9C, 0xFC, 0x73, 0x9C, 0xFE, 0x7F, 0xBD, 0xEE, 0x3F, 0x39, 0xC7,
  0x1E, 0x39, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0x71, 0xC7,
  0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x01, 0xE1, 0xC7, 0x01, 0xC1, 0xCF,
  0x01, 0xC1, 0xFE, 0x03, 0x80, 0xFE, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE1, 0xE7, 0xFC, 0x79, 0xEF, 0x9E, 0xF9, 0xEF, 0x3C,
  0x3F, 0xCF, 0x0F, 0xF3, 0xC1, 0xF8, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F, 0xCF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xEF, 0x87, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x0E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0xE0, 0x70, 0x78,
  0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x8E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x1F, 0x3C, 0x71,
  0xE1, 0x84, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3D, 0xF7, 0x9E,
  0x79, 0xE7, 0x3C, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x7C, 0xF9, 0xE1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0x7F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x87, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xE3, 0xCF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xC1, 0xF0,
  0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBF, 0xCF, 0x63, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x3F,
  0xFC, 0x70, 0xF8, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x20,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x07,
  0xF8, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xEE, 0x1F, 0xBF, 0xFC, 0xFF, 0xE1,
  0xFF, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0x78, 0x0E, 0xF0, 0x39, 0xE0, 0x73, 0xC0, 0xE7,
  0x83, 0x8F, 0x07, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xE0, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xFF, 0xCF, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0xCF, 0xFE,
  0x33, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x40, 0xFB, 0x8F, 0xDF, 0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC2, 0x0F, 0x3E, 0x3D, 0xFC, 0xFF, 0xFB, 0xF1, 0xEF, 0x87,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE1,
  0xE3, 0xCF, 0x8F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F,
  0x3E, 0x78, 0x79, 0xE1, 0xE7, 0x83, 0x9E, 0x1E, 0x78, 0x78, 0xF3, 0xE3,
  0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x7B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x78,
  0xFB, 0xE1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE,
  0x1F, 0x78, 0x7D, 0xFF, 0xF7, 0xFB, 0xCF, 0xEF, 0x0F, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC4, 0x3F, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFC, 0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0xFF, 0xFE, 0xE0, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x1C, 0xF0, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x00,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x03,
  0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x1F, 0x87, 0xFC, 0xFF, 0xE7, 0xFF,
  0x61, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xE0, 0xE0,
  0x01, 0xC7, 0x80, 0x07, 0x1C, 0x1F, 0x8E, 0x71, 0xFE, 0x3B, 0x87, 0xB8,
  0xEE, 0x3C, 0xE3, 0xB8, 0xE3, 0x8F, 0xE3, 0x8E, 0x1F, 0x9E, 0x38, 0xFE,
  0x78, 0xE3, 0xB9, 0xE3, 0x8E, 0xE7, 0x8E, 0x3B, 0x8E, 0x38, 0xEE, 0x39,
  0xE3, 0xB8, 0xFF, 0xFC, 0xE1, 0xF3, 0xF3, 0xC3, 0x87, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x04, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3C, 0xE0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xF0, 0x3C, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF8,
  0x07, 0xFE, 0x01, 0xF0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x3D, 0xF0, 0x7B, 0xE1,
  0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0x3E, 0x3F, 0x7C, 0x1E, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xBF, 0xFF, 0x7F,
  0xFC, 0xFF, 0xF1, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE,
  0x7E, 0x09, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x13, 0xF3, 0x8F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF8,
  0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE,
  0x3E, 0x02, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F,
  0x3F, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xE7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF9, 0xFE,
  0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF5,
  0xFB, 0xFD, 0xFC, 0xFC, 0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xE7, 0x87,
  0xCF, 0x0F, 0x1E, 0x3E, 0x3C, 0x78, 0x79, 0xF0, 0xF7, 0xC1, 0xEF, 0x83,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3,
  0xE1, 0xE7, 0xC3, 0xC7, 0x87, 0x8F, 0x8F, 0x0F, 0x1E, 0x1F, 0x3C, 0x1E,
  0x78, 0x3E, 0xF0, 0x3D, 0xE0, 0x7C, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3B, 0xFB, 0x80, 0xEF, 0xEF, 0x07, 0xBF, 0xBC, 0x1E,
  0xFE, 0x70, 0x73, 0xF9, 0xC1, 0xCF, 0xE7, 0x8F, 0x3F, 0x9E, 0x3C, 0xFE,
  0x38, 0xE3, 0xF8, 0xE3, 0x8F, 0xE3, 0xDE, 0x3F, 0x8F, 0x70, 0xFE, 0x1D,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0x83,
  0xF8, 0x3E, 0x0F, 0xE0, 0xF0, 0x3F, 0x81, 0xC0, 0xF0, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xEF,
  0x0F, 0xEF, 0x0F, 0xEF, 0x0F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE3, 0xCF, 0xE3,
  0xCF, 0xE1, 0xEF, 0xE1, 0xEF, 0xE1, 0xE7, 0xE0, 0xF7, 0xE0, 0xF7, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3,
  0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF8,
  0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF8, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF8, 0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF8,
  0xFC, 0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9,
  0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x78, 0xF8,
  0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0xF8, 0x1F, 0x0F, 0xC0, 0xFF, 0xCF, 0xFE,
  0xFF, 0xE7, 0xC3, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xE0, 0x7B, 0xFF, 0xDF, 0xFE, 0xFF, 0xE3,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0xF3, 0xC0, 0x78, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1E,
  0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x1C, 0x78, 0x0F, 0x38, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xEF, 0x00, 0x77,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7B, 0xC0, 0x7C, 0x0F, 0x7C, 0x0F,
  0x81, 0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x7E, 0x07, 0x9E, 0x0F, 0xC1, 0xE3,
  0xC1, 0xFC, 0x3C, 0x78, 0x3B, 0x87, 0x87, 0x87, 0x70, 0xF0, 0xF1, 0xEE,
  0x1E, 0x1E, 0x3D, 0xC7, 0x83, 0xC7, 0x38, 0xF0, 0x78, 0xE7, 0x9E, 0x07,
  0x9C, 0x73, 0xC0, 0xF7, 0x8E, 0x78, 0x1E, 0xF1, 0xDE, 0x03, 0xDC, 0x3B,
  0xC0, 0x7B, 0x87, 0xF8, 0x07, 0x70, 0x7F, 0x00, 0xEE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0x70, 0x1E, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0x70,
  0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x3C, 0x1E, 0x0E,
  0x07, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7B, 0xE2, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x0F, 0xF9, 0xFF, 0xDF, 0xFE, 0xF0, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xF8, 0xFB, 0xFF, 0xDF, 0xCE, 0x7C, 0x70, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x70,
  0xF7, 0xF3, 0xFF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF8, 0x7F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x87, 0xFF, 0x3E, 0xFF, 0xFB, 0xDF, 0xCF, 0x3E, 0x00, 0x07, 0xC1,
  0xFF, 0x3F, 0xE3, 0xFE, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x33,
  0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xCF, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDF,
  0x1F, 0x78, 0x3D, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDF, 0x1F, 0x3F, 0xFC,
  0xFF, 0x71, 0xF9, 0xC0, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x0F, 0x3E, 0x78,
  0x79, 0xE0, 0xE7, 0x83, 0x9C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x18, 0xFF, 0xE1,
  0xFF, 0x83, 0xFC, 0x01, 0x81, 0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3F, 0xCF, 0xFB, 0xFF, 0x7F, 0xE1, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x0F, 0x1C, 0x7E, 0x73, 0xFD, 0xDF,
  0xFF, 0x7C, 0x7D, 0xE0, 0xF7, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x7C, 0x7C,
  0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x60, 0x7D, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x07, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0xF7, 0xF7,
  0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xFF, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0xC0,
  0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF,
  0xFB, 0xF3, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F, 0x3C, 0x78,
  0xF1, 0xE3, 0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x3E, 0x78, 0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1,
  0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xC1, 0xE3, 0xDF, 0xCF, 0xEF, 0xFF,
  0x7F, 0xBF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xE1, 0xF0, 0xFF, 0x07, 0x83,
  0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xE3, 0xC7, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x3C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xE3,
  0xC3, 0xDF, 0xCF, 0xFF, 0x3F, 0xFE, 0xF8, 0x7B, 0xE1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x83, 0xFE, 0x1F, 0xFC, 0xFB, 0xFF, 0xEF, 0x7F, 0x3C, 0xF8, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x0F, 0x1C, 0x7E, 0x73, 0xFD, 0xCF, 0xFF, 0x7C, 0x7D, 0xE0,
  0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x7C, 0x7C, 0xFF, 0xF3, 0xFF, 0xC7,
  0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xE3, 0xF9, 0xEF, 0x7B, 0xFE, 0xFE, 0xBE,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0x87, 0xFD, 0xFF, 0x7C, 0xEF,
  0x05, 0xE0, 0x3C, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0xE3, 0xFF, 0xFB, 0xFF, 0x3F, 0xC0, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E,
  0x47, 0xF1, 0xFC, 0x3F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x1F, 0xF9, 0xFB, 0xFD, 0xDF, 0xEE, 0x7E,
  0x70, 0xF0, 0x1F, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x38, 0xE0, 0x73, 0xC0, 0xF7, 0x81,
  0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3D, 0xE1, 0xF0, 0x7B,
  0xC3, 0xF0, 0xF7, 0x87, 0xE3, 0xCF, 0x0D, 0xC7, 0x8E, 0x3B, 0x8F, 0x1E,
  0x77, 0x1E, 0x3C, 0xE6, 0x38, 0x79, 0xCE, 0xF0, 0xF3, 0x9D, 0xE0, 0xEE,
  0x3B, 0xC1, 0xFC, 0x77, 0x83, 0xF8, 0xEE, 0x07, 0xF1, 0xDC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3D, 0xE1, 0xF7, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0x7B, 0xC1,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0,
  0x7F, 0x81, 0xEF, 0x0F, 0x3C, 0x3C, 0x79, 0xE1, 0xE7, 0x87, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC7, 0x87, 0x8F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x38, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xEF,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x8F, 0xE3, 0xE0, 0xF8, 0x3F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0xC3, 0xF0, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xF8, 0x3F,
  0x07, 0xE1, 0xFC, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0x00, 0x7E, 0x07,
  0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 11, 10, 15, 2, -26 },
  { 32, 16, 26, 18, 1, -26 },
  { 84, 14, 29, 16, 1, -27 },
  { 135, 24, 26, 26, 1, -26 },
  { 213, 18, 26, 19, 1, -26 },
  { 272, 4, 10, 8, 2, -26 },
  { 277, 8, 32, 11, 2, -26 },
  { 309, 8, 32, 11, 1, -26 },
  { 341, 13, 13, 15, 1, -27 },
  { 363, 14, 17, 16, 1, -21 },
  { 393, 6, 9, 9, 1, -4 },
  { 400, 9, 4, 11, 1, -12 },
  { 405, 5, 5, 9, 2, -5 },
  { 409, 14, 26, 14, 0, -26 },
  { 455, 14, 26, 16, 1, -26 },
  { 501, 10, 26, 16, 2, -26 },
  { 534, 14, 26, 16, 1, -26 },
  { 580, 14, 26, 16, 1, -26 },
  { 626, 15, 26, 16, 1, -26 },
  { 675, 13, 26, 16, 2, -26 },
  { 718, 14, 26, 16, 1, -26 },
  { 764, 14, 26, 16, 1, -26 },
  { 810, 14, 26, 16, 1, -26 },
  { 856, 14, 26, 16, 1, -26 },
  { 902, 5, 20, 9, 2, -20 },
  { 915, 6, 25, 9, 1, -20 },
  { 934, 14, 17, 16, 1, -21 },
  { 964, 14, 11, 16, 1, -18 },
  { 984, 14, 17, 16, 1, -21 },
  { 1014, 12, 26, 13, 0, -26 },
  { 1053, 22, 29, 25, 2, -26 },
  { 1133, 18, 26, 18, 0, -26 },
  { 1192, 15, 26, 18, 2, -26 },
  { 1241, 14, 26, 17, 2, -26 },
  { 1287, 16, 26, 20, 2, -26 },
  { 1339, 11, 26, 15, 3, -26 },
  { 1375, 10, 26, 15, 3, -26 },
  { 1408, 16, 26, 20, 2, -26 },
  { 1460, 15, 26, 20, 3, -26 },
  { 1509, 9, 26, 11, 1, -26 },
  { 1539, 9, 33, 9, -2, -26 },
  { 1577, 15, 26, 18, 3, -26 },
  { 1626, 12, 26, 14, 2, -26 },
  { 1665, 22, 26, 27, 3, -26 },
  { 1737, 16, 26, 22, 3, -26 },
  { 1789, 17, 26, 21, 2, -26 },
  { 1845, 14, 26, 17, 2, -26 },
  { 1891, 17, 32, 21, 2, -26 },
  { 1959, 16, 26, 18, 2, -26 },
  { 2011, 13, 26, 15, 1, -26 },
  { 2054, 14, 26, 15, 0, -26 },
  { 2100, 16, 26, 20, 2, -26 },
  { 2152, 17, 26, 17, 0, -26 },
  { 2208, 27, 26, 26, 0, -26 },
  { 2296, 16, 26, 16, 0, -26 },
  { 2348, 16, 26, 16, 0, -26 },
  { 2400, 13, 26, 14, 1, -26 },
  { 2443, 8, 32, 11, 2, -26 },
  { 2475, 14, 26, 14, 0, -26 },
  { 2521, 8, 32, 11, 1, -26 },
  { 2553, 16, 15, 18, 1, -26 },
  { 2583, 15, 2, 15, 0, 3 },
  { 2587, 8, 6, 11, 1, -28 },
  { 2593, 13, 20, 16, 1, -20 },
  { 2626, 14, 27, 18, 2, -27 },
  { 2674, 12, 20, 14, 1, -20 },
  { 2704, 14, 27, 18, 1, -27 },
  { 2752, 14, 20, 16, 1, -20 },
  { 2787, 11, 28, 10, 0, -28 },
  { 2826, 14, 29, 18, 1, -20 },
  { 2877, 13, 27, 17, 2, -27 },
  { 2921, 4, 27, 8, 2, -27 },
  { 2935, 7, 36, 8, -1, -27 },
  { 2967, 14, 27, 16, 2, -27 },
  { 3015, 4, 27, 8, 2, -27 },
  { 3029, 22, 20, 26, 2, -20 },
  { 3084, 13, 20, 17, 2, -20 },
  { 3117, 15, 20, 17, 1, -20 },
  { 3155, 14, 29, 18, 2, -20 },
  { 3206, 14, 29, 18, 1, -20 },
  { 3257, 10, 20, 12, 2, -20 },
  { 3282, 11, 20, 13, 1, -20 },
  { 3310, 10, 24, 11, 0, -24 },
  { 3340, 13, 20, 17, 2, -20 },
  { 3373, 15, 20, 15, 0, -20 },
  { 3411, 23, 20, 23, 0, -20 },
  { 3469, 14, 20, 15, 0, -20 },
  { 3504, 15, 29, 15, 0, -20 },
  { 3559, 10, 20, 12, 1, -20 },
  { 3584, 10, 32, 13, 1, -26 },
  { 3624, 3, 36, 15, 6, -28 },
  { 3638, 11, 32, 13, 1, -26 },
  { 3682, 14, 5, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD36PT7B_H_
