#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDB, 0x6D, 0x81, 0xFF, 0xEF, 0xDF, 0x9F, 0x3E, 0x78,
  0xC0, 0x0D, 0x82, 0x61, 0x98, 0x66, 0x19, 0x9F, 0xF1, 0xB0, 0x6C, 0x13,
  0x04, 0xCF, 0xFC, 0xCC, 0x32, 0x0C, 0x83, 0x60, 0xD8, 0x18, 0x18, 0x3E,
  0x7F, 0xFA, 0xD8, 0xD8, 0xF8, 0x78, 0x1E, 0x1F, 0x1B, 0x1B, 0x9F, 0xFE,
  0x7C, 0x18, 0x18, 0x70, 0x63, 0xE1, 0x0D, 0x8C, 0x32, 0x30, 0xCD, 0x83,
  0x36, 0x0C, 0x99, 0x36, 0xDE, 0xFB, 0x6D, 0xC9, 0xB0, 0x64, 0xC1, 0x93,
  0x0C, 0x6C, 0x31, 0xB0, 0xC7, 0xC6, 0x0E, 0x3C, 0x0F, 0xC1, 0x98, 0x33,
  0x06, 0x60, 0xDC, 0x1F, 0x01, 0xC0, 0x78, 0xDF, 0xBB, 0x3F, 0x63, 0xCC,
  0x79, 0xCF, 0x3F, 0xF3, 0xEF, 0xFF, 0xFF, 0x80, 0x19, 0xCC, 0xE6, 0x33,
  0x9C, 0xC6, 0x31, 0x8E, 0x71, 0x8C, 0x71, 0x86, 0xE1, 0x83, 0x0C, 0x18,
  0x61, 0x87, 0x1C, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x30, 0xCE, 0x00, 0x18,
  0x18, 0x99, 0xFF, 0xFF, 0x3C, 0x6C, 0xE6, 0x24, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x6F, 0xFD, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x60, 0x60, 0xE0, 0x3C, 0x7E, 0x6E, 0xE7, 0xE7, 0xC7, 0xC7,
  0xC3, 0xC3, 0xC3, 0xC7, 0xC7, 0xE7, 0xE6, 0x7E, 0x3C, 0x0C, 0x73, 0xDF,
  0xED, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3C, 0xFE, 0xCE,
  0x87, 0x07, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xE0, 0xFF,
  0xFF, 0x7C, 0xFE, 0xCE, 0x07, 0x07, 0x06, 0x0E, 0x7C, 0x7E, 0x06, 0x07,
  0x07, 0x07, 0x87, 0xFE, 0xFC, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x06,
  0xC3, 0x30, 0xCC, 0x63, 0x18, 0xC4, 0x33, 0xFF, 0xFF, 0xC0, 0xC0, 0x30,
  0x0C, 0x7E, 0x7E, 0x7E, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0x4F, 0x07, 0x07,
  0x07, 0x07, 0x8E, 0xFE, 0xFC, 0x1E, 0x3E, 0x70, 0x60, 0xE0, 0xC0, 0xDE,
  0xFE, 0xE7, 0xC7, 0xC3, 0xC3, 0xE7, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0xFF,
  0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x3C, 0x7E, 0xE7, 0xC7, 0xC7, 0xE7, 0x7E, 0x3C, 0x7C, 0xEE, 0xC7,
  0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0x38, 0x7E, 0xEE, 0xC7, 0xC7, 0xC7, 0xC7,
  0xE7, 0xFF, 0x7B, 0x07, 0x07, 0x06, 0x0E, 0xFC, 0xF8, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x0D, 0xFF, 0xB0, 0x01, 0x07, 0x1F, 0x7C,
  0xF0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x3D, 0xFD,
  0x38, 0x30, 0x60, 0xC3, 0x8E, 0x18, 0x60, 0xC0, 0x00, 0x07, 0x0E, 0x1C,
  0x07, 0x80, 0xFF, 0x0C, 0x1C, 0xC0, 0x66, 0x39, 0xA3, 0xEF, 0x33, 0x79,
  0x99, 0xC8, 0xCE, 0x4C, 0xF2, 0x67, 0x9B, 0xBC, 0xF7, 0x31, 0x11, 0x80,
  0x06, 0x04, 0x1F, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x7C, 0x0D, 0x81,
  0xB0, 0x36, 0x0E, 0xE1, 0xDC, 0x31, 0x86, 0x31, 0xFF, 0x3F, 0xE7, 0x1C,
  0xC1, 0xB8, 0x3F, 0x07, 0xFC, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8D,
  0xFC, 0xFF, 0x71, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0xFD, 0xFC, 0x1F, 0x1F,
  0xDE, 0x4E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x84, 0xFC, 0x3E, 0xFC, 0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xB9, 0xEF, 0xF3, 0xF0,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x0C, 0x30, 0xC3, 0x0F, 0xFF,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0x0F, 0x8F, 0xF7, 0x89, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x9F, 0xE7, 0xF9,
  0xFE, 0x1F, 0x87, 0x61, 0xDC, 0x73, 0xFC, 0x7F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xFF,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x39, 0xFF,
  0xE0, 0xC3, 0xE3, 0xB1, 0xD9, 0xCC, 0xC6, 0xE3, 0x61, 0xF0, 0xF8, 0x7E,
  0x33, 0x19, 0xCC, 0x66, 0x3B, 0x1D, 0x87, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x7F, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0D, 0xF8, 0x6F, 0x63, 0x7B, 0x3B, 0xD9, 0x9E,
  0xEC, 0xF3, 0x67, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x1C, 0x78, 0xC3, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC7, 0xF1, 0xFE, 0x7D, 0x9F, 0x77, 0xCD, 0xF3, 0xFC,
  0xFF, 0x1B, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0x1E, 0x07, 0xF1, 0xCF, 0x30,
  0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x66,
  0x1C, 0xE3, 0x8F, 0xE0, 0xF8, 0xFC, 0x7F, 0xBF, 0xDC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xCE, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1E,
  0x07, 0xF1, 0xCF, 0x30, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x66, 0x1C, 0xE3, 0x8F, 0xE0, 0xF8, 0x03, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0xFC, 0x3F, 0xCF, 0xF3, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B,
  0x9C, 0xFE, 0x3F, 0x8E, 0x63, 0x9C, 0xE7, 0x38, 0xEE, 0x3B, 0x87, 0x3C,
  0xFF, 0xDF, 0x0C, 0x1C, 0x3C, 0x3C, 0x3C, 0x1C, 0x18, 0x30, 0x71, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x61, 0xDC,
  0xE7, 0xF8, 0xFC, 0xE0, 0xFC, 0x19, 0x83, 0x30, 0xE6, 0x1C, 0xE3, 0x0C,
  0x61, 0x9C, 0x33, 0x87, 0x60, 0xEC, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0x70, 0xC1, 0x83, 0xE1, 0x83, 0xE1, 0xC7, 0x63, 0xC7, 0x63, 0xC6, 0x63,
  0xC6, 0x73, 0xC6, 0x73, 0x6E, 0x36, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x36,
  0x6C, 0x3E, 0x2C, 0x1C, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0xE1, 0x98, 0xE7,
  0x38, 0xCC, 0x3F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xDC,
  0x33, 0x1C, 0xE6, 0x3B, 0x87, 0xE1, 0xF8, 0x66, 0x39, 0xCE, 0x33, 0x0D,
  0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xF0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30,
  0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03, 0xFF, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x04, 0x03, 0x80, 0xE0,
  0x7C, 0x1B, 0x0E, 0xE3, 0x19, 0xC7, 0xE0, 0xC0, 0xFF, 0x80, 0xE3, 0x0C,
  0x30, 0x7C, 0x7E, 0x46, 0x07, 0x07, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xFF,
  0x73, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xC6, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8D, 0xFE, 0xDE, 0x00, 0x3E, 0xFF, 0x8F,
  0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC5, 0xF9, 0xF0, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x7B, 0x7F, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F,
  0x7B, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0, 0xE0, 0xE1, 0x7E,
  0x3E, 0x1E, 0x7C, 0xC9, 0x83, 0x0F, 0xBF, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x3B, 0x7F, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0xE7, 0x7F, 0x7B, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0x5F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x11, 0xCE, 0x00,
  0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x78, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0x9D, 0xCC, 0xEE, 0x7E, 0x3F, 0x1F,
  0x8E, 0xE7, 0x33, 0x9D, 0xC6, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xDE, 0x7B, 0x7F, 0xEE, 0x79, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C,
  0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xDE,
  0xDF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3C,
  0x3F, 0x39, 0xDC, 0x6C, 0x36, 0x1F, 0x0F, 0x86, 0xE3, 0x73, 0x9F, 0x87,
  0xC0, 0xCE, 0x7F, 0xB8, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xBF, 0xDD, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x3B, 0x7F, 0xE7,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F, 0x7B, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xCF, 0x7F, 0x78, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x7F,
  0xFC, 0x70, 0xE3, 0xE3, 0xC7, 0x0E, 0x3F, 0xFE, 0x30, 0xC3, 0x1F, 0xFD,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xF3, 0xC0, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x7B, 0xE3, 0xF1, 0xD8, 0xCC,
  0x67, 0x31, 0xB8, 0xD8, 0x6C, 0x36, 0x0F, 0x07, 0x03, 0x80, 0xE3, 0x8F,
  0x8E, 0x76, 0x79, 0xD9, 0xE6, 0x66, 0x99, 0xDB, 0x63, 0x4F, 0x8F, 0x3E,
  0x3C, 0xF0, 0xF3, 0xC3, 0xC7, 0x07, 0x1C, 0xE3, 0xBB, 0x9D, 0xC6, 0xC3,
  0xE0, 0xE0, 0x70, 0x7C, 0x36, 0x3B, 0x99, 0xDC, 0x70, 0xE3, 0xF1, 0xD8,
  0xCC, 0x67, 0x31, 0xB8, 0xD8, 0x6C, 0x3E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0xF0, 0x70, 0x00, 0x7E, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18,
  0x70, 0xC3, 0xFF, 0xF0, 0x06, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x39,
  0xE3, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x78, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x73,
  0xCC, 0x30, 0xC3, 0x0C, 0x33, 0xCE, 0x20, 0xF9, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 16, 5, 1, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 10, 16, 11, 0, -16 },
  { 33, 8, 18, 10, 1, -17 },
  { 51, 14, 16, 16, 1, -16 },
  { 79, 11, 16, 12, 1, -16 },
  { 101, 3, 6, 5, 1, -16 },
  { 104, 5, 19, 7, 1, -16 },
  { 116, 6, 19, 7, 0, -16 },
  { 131, 8, 9, 9, 1, -17 },
  { 140, 8, 10, 10, 1, -13 },
  { 150, 3, 6, 5, 1, -3 },
  { 153, 5, 2, 6, 1, -7 },
  { 155, 3, 3, 5, 1, -3 },
  { 157, 8, 16, 9, 0, -16 },
  { 173, 8, 16, 10, 1, -16 },
  { 189, 6, 16, 10, 1, -16 },
  { 201, 8, 16, 10, 1, -16 },
  { 217, 8, 16, 10, 1, -16 },
  { 233, 10, 16, 10, 0, -16 },
  { 253, 8, 16, 10, 1, -16 },
  { 269, 8, 16, 10, 1, -16 },
  { 285, 8, 16, 10, 1, -16 },
  { 301, 8, 16, 10, 1, -16 },
  { 317, 8, 16, 10, 1, -16 },
  { 333, 3, 12, 5, 1, -12 },
  { 338, 3, 15, 5, 1, -12 },
  { 344, 8, 10, 10, 1, -13 },
  { 354, 8, 6, 10, 1, -11 },
  { 360, 8, 10, 10, 1, -13 },
  { 370, 7, 16, 8, 0, -16 },
  { 384, 13, 18, 15, 1, -16 },
  { 414, 11, 16, 11, 0, -16 },
  { 436, 9, 16, 11, 1, -16 },
  { 454, 9, 16, 10, 1, -16 },
  { 472, 10, 16, 12, 1, -16 },
  { 492, 6, 16, 9, 2, -16 },
  { 504, 6, 16, 9, 2, -16 },
  { 516, 10, 16, 12, 1, -16 },
  { 536, 9, 16, 12, 2, -16 },
  { 554, 5, 16, 7, 1, -16 },
  { 564, 5, 20, 6, -1, -16 },
  { 577, 9, 16, 11, 2, -16 },
  { 595, 7, 16, 9, 1, -16 },
  { 609, 13, 16, 17, 2, -16 },
  { 635, 10, 16, 13, 2, -16 },
  { 655, 11, 16, 13, 1, -16 },
  { 677, 9, 16, 10, 1, -16 },
  { 695, 11, 20, 13, 1, -16 },
  { 723, 10, 16, 11, 1, -16 },
  { 743, 7, 16, 9, 1, -16 },
  { 757, 9, 16, 9, 0, -16 },
  { 775, 10, 16, 12, 1, -16 },
  { 795, 11, 16, 11, 0, -16 },
  { 817, 16, 16, 16, 0, -16 },
  { 849, 10, 16, 10, 0, -16 },
  { 869, 10, 16, 10, 0, -16 },
  { 889, 8, 16, 9, 0, -16 },
  { 905, 5, 20, 7, 1, -16 },
  { 918, 8, 16, 9, 0, -16 },
  { 934, 4, 20, 7, 1, -16 },
  { 944, 10, 9, 11, 0, -16 },
  { 956, 9, 1, 9, 0, 2 },
  { 958, 5, 4, 6, 1, -17 },
  { 961, 8, 12, 10, 1, -12 },
  { 973, 9, 17, 11, 1, -17 },
  { 993, 7, 12, 8, 1, -12 },
  { 1004, 8, 17, 11, 1, -17 },
  { 1021, 8, 12, 10, 1, -12 },
  { 1033, 7, 17, 6, 0, -17 },
  { 1048, 8, 17, 11, 1, -12 },
  { 1065, 8, 17, 11, 1, -17 },
  { 1082, 3, 17, 5, 1, -17 },
  { 1089, 5, 22, 5, -1, -17 },
  { 1103, 9, 17, 10, 1, -17 },
  { 1123, 3, 17, 5, 1, -17 },
  { 1130, 14, 12, 16, 1, -12 },
  { 1151, 8, 12, 11, 1, -12 },
  { 1163, 9, 12, 10, 1, -12 },
  { 1177, 9, 17, 11, 1, -12 },
  { 1197, 8, 17, 11, 1, -12 },
  { 1214, 6, 12, 7, 1, -12 },
  { 1223, 6, 12, 8, 1, -12 },
  { 1232, 6, 15, 7, 0, -15 },
  { 1244, 8, 12, 11, 1, -12 },
  { 1256, 9, 12, 9, 0, -12 },
  { 1270, 14, 12, 14, 0, -12 },
  { 1291, 9, 12, 9, 0, -12 },
  { 1305, 9, 17, 9, 0, -12 },
  { 1325, 7, 12, 7, 0, -12 },
  { 1336, 7, 20, 8, 0, -16 },
  { 1354, 2, 22, 9, 4, -17 },
  { 1360, 6, 20, 8, 1, -16 },
  { 1375, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD22PT7B_H_
