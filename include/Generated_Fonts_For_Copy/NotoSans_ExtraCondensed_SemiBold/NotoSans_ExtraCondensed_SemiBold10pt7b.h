#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF4, 0x32, 0xBE, 0xAF, 0x31, 0x80, 0x27, 0xE6, 0x23, 0xB6,
  0x20, 0x69, 0x52, 0xC3, 0xF1, 0xA5, 0x49, 0x80, 0x72, 0x98, 0xDB, 0xC9,
  0xE0, 0xC0, 0x69, 0x2C, 0x92, 0x20, 0xC9, 0x32, 0x92, 0x80, 0x2B, 0x67,
  0x22, 0xF2, 0x20, 0x70, 0xE0, 0x80, 0x12, 0x24, 0x44, 0x80, 0x75, 0xDD,
  0xD5, 0x60, 0x75, 0x54, 0xF1, 0x12, 0x64, 0xF0, 0xF1, 0x16, 0x11, 0xF0,
  0x33, 0x55, 0x9F, 0x10, 0x74, 0x47, 0x11, 0xE0, 0x74, 0xAD, 0xD5, 0x70,
  0xF1, 0x32, 0x26, 0x40, 0x7D, 0x76, 0xD9, 0x70, 0x79, 0x97, 0x11, 0x60,
  0x88, 0x40, 0x70, 0x16, 0xC3, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4,
  0xA4, 0x10, 0x38, 0x89, 0xED, 0x5A, 0xAF, 0x90, 0x1C, 0x22, 0x94, 0xA7,
  0x6E, 0x20, 0xEB, 0xAE, 0xBB, 0xE0, 0x74, 0x4C, 0x44, 0x70, 0xEB, 0x99,
  0x9B, 0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x7A, 0x11, 0xB4, 0xA5,
  0xE0, 0x99, 0x9F, 0x99, 0x90, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xC0,
  0xBA, 0xCC, 0xAA, 0xB0, 0x92, 0x49, 0x38, 0x8F, 0x3D, 0x75, 0xB6, 0xDA,
  0x40, 0x9D, 0xDB, 0xBB, 0x90, 0x7A, 0x73, 0x94, 0xA5, 0xC0, 0xF6, 0xF9,
  0x20, 0x7A, 0x73, 0x94, 0xA5, 0xC2, 0x08, 0xEA, 0xAE, 0xAA, 0xB0, 0x7C,
  0x46, 0x11, 0xE0, 0xF6, 0x66, 0x66, 0x60, 0x99, 0x99, 0x99, 0xE0, 0x8C,
  0x94, 0xA5, 0x30, 0x80, 0x93, 0x37, 0x6B, 0x56, 0xCD, 0x99, 0x00, 0xD7,
  0x62, 0x65, 0x90, 0x95, 0x66, 0x22, 0x20, 0xF2, 0x24, 0x4C, 0xF0, 0xEA,
  0xAA, 0xC0, 0x84, 0x44, 0x22, 0x10, 0xD5, 0x55, 0xC0, 0x22, 0x95, 0x30,
  0xF0, 0xCC, 0x25, 0x17, 0x97, 0x93, 0x5B, 0x6F, 0x25, 0xCC, 0x46, 0x11,
  0x57, 0xDD, 0xD7, 0x25, 0xDF, 0x47, 0x69, 0x74, 0x92, 0x47, 0xDD, 0xD7,
  0x17, 0x93, 0x5B, 0x6D, 0xDF, 0x51, 0x55, 0x70, 0x88, 0x8A, 0xCC, 0xAB,
  0xFF, 0x4A, 0xFA, 0x69, 0xA6, 0x90, 0x56, 0xDB, 0x40, 0x25, 0xDD, 0x57,
  0x56, 0xDB, 0xE4, 0x47, 0xDD, 0xD7, 0x11, 0x7A, 0xA0, 0x5F, 0x33, 0xC0,
  0x4B, 0xA4, 0x98, 0xB6, 0xDE, 0x95, 0x66, 0x60, 0xB7, 0xD6, 0xDB, 0x68,
  0xF6, 0x66, 0x90, 0x95, 0x66, 0x66, 0xC0, 0xED, 0x2E, 0x69, 0x2C, 0x92,
  0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 3, 2, 4, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -7 },
  { 26, 3, 9, 3, 0, -7 },
  { 30, 3, 9, 3, 0, -7 },
  { 34, 4, 4, 4, 0, -8 },
  { 36, 4, 5, 5, 0, -6 },
  { 39, 2, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 2, 7, 4, 1, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 4, 7, 4, 0, -7 },
  { 80, 4, 7, 4, 0, -7 },
  { 84, 1, 5, 2, 1, -5 },
  { 85, 2, 6, 2, 0, -5 },
  { 87, 4, 5, 5, 0, -6 },
  { 90, 4, 3, 5, 0, -5 },
  { 92, 4, 5, 5, 0, -6 },
  { 95, 3, 7, 4, 0, -7 },
  { 98, 7, 8, 7, 0, -7 },
  { 105, 5, 7, 5, 0, -7 },
  { 110, 4, 7, 5, 1, -7 },
  { 114, 4, 7, 5, 0, -7 },
  { 118, 4, 7, 5, 1, -7 },
  { 122, 3, 7, 4, 1, -7 },
  { 125, 3, 7, 4, 1, -7 },
  { 128, 5, 7, 6, 0, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 3, 7, 3, 0, -7 },
  { 140, 3, 9, 3, -1, -7 },
  { 144, 4, 7, 5, 1, -7 },
  { 148, 3, 7, 4, 1, -7 },
  { 151, 6, 7, 8, 1, -7 },
  { 157, 4, 7, 6, 1, -7 },
  { 161, 5, 7, 6, 0, -7 },
  { 166, 3, 7, 5, 1, -7 },
  { 169, 5, 9, 6, 0, -7 },
  { 175, 4, 7, 5, 1, -7 },
  { 179, 4, 7, 4, 0, -7 },
  { 183, 4, 7, 4, 0, -7 },
  { 187, 4, 7, 6, 1, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 7, 7, 7, 0, -7 },
  { 203, 4, 7, 4, 0, -7 },
  { 207, 4, 7, 4, 0, -7 },
  { 211, 4, 7, 4, 0, -7 },
  { 215, 2, 9, 3, 1, -7 },
  { 218, 4, 7, 4, 0, -7 },
  { 222, 2, 9, 3, 0, -7 },
  { 225, 5, 4, 5, 0, -7 },
  { 228, 4, 1, 4, 0, 1 },
  { 229, 3, 2, 3, 0, -8 },
  { 230, 4, 6, 4, 0, -6 },
  { 233, 3, 8, 5, 1, -8 },
  { 236, 4, 6, 4, 0, -6 },
  { 239, 4, 8, 5, 0, -8 },
  { 243, 4, 6, 4, 0, -6 },
  { 246, 3, 8, 3, 0, -8 },
  { 249, 4, 8, 5, 0, -6 },
  { 253, 3, 8, 5, 1, -8 },
  { 256, 1, 8, 2, 1, -8 },
  { 257, 2, 10, 2, 0, -8 },
  { 260, 4, 8, 5, 1, -8 },
  { 264, 1, 8, 2, 1, -8 },
  { 265, 6, 6, 7, 1, -6 },
  { 270, 3, 6, 5, 1, -6 },
  { 273, 4, 6, 5, 0, -6 },
  { 276, 3, 8, 5, 1, -6 },
  { 279, 4, 8, 5, 0, -6 },
  { 283, 2, 6, 3, 1, -6 },
  { 285, 3, 6, 4, 0, -6 },
  { 288, 3, 7, 3, 0, -7 },
  { 291, 3, 5, 5, 1, -5 },
  { 293, 4, 5, 4, 0, -5 },
  { 296, 6, 5, 7, 0, -5 },
  { 300, 4, 5, 4, 0, -5 },
  { 303, 4, 7, 4, 0, -5 },
  { 307, 3, 5, 3, 0, -5 },
  { 309, 3, 9, 4, 0, -7 },
  { 313, 1, 10, 4, 2, -8 },
  { 315, 3, 9, 4, 0, -7 },
  { 319, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD10PT7B_H_
