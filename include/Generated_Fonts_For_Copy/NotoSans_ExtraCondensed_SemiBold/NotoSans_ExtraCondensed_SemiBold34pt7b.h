#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0xCF, 0x7F, 0xFE, 0xF3, 0xFE, 0x7B, 0xCF, 0x78, 0xEF, 0x1D, 0xE3,
  0xBC, 0x77, 0x0E, 0xE1, 0xC0, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x01, 0xCE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xE0,
  0x71, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFC, 0x71, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70,
  0x18, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0xC3, 0xFF, 0xBF, 0xF9,
  0xEC, 0xCE, 0x60, 0xF3, 0x03, 0x98, 0x1E, 0xC0, 0xFE, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1B, 0xC0, 0xDF, 0x06, 0xFC, 0x37,
  0xFF, 0xFB, 0xFF, 0x87, 0xF8, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x7C, 0x07, 0x01, 0xFC, 0x0E, 0x03, 0xB8, 0x38, 0x0E,
  0x38, 0x70, 0x1C, 0x70, 0xE0, 0x38, 0xE3, 0x80, 0x71, 0xC7, 0x00, 0xE3,
  0x8C, 0x01, 0xC7, 0x38, 0x03, 0x8E, 0x73, 0xC7, 0x9D, 0xCF, 0xC7, 0x73,
  0x9F, 0xCF, 0xE7, 0x73, 0x8F, 0x9C, 0xE7, 0x06, 0x39, 0xC7, 0x00, 0x73,
  0x8E, 0x01, 0xC7, 0x1C, 0x03, 0x8E, 0x38, 0x0E, 0x1C, 0x70, 0x1C, 0x39,
  0xC0, 0x38, 0x73, 0x80, 0xE0, 0xFF, 0x01, 0xC0, 0xFC, 0x07, 0x80, 0xF8,
  0x03, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0x8F, 0x01, 0xC7,
  0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x79, 0xEF, 0x3D, 0xE7, 0x9E, 0xF1, 0xFE,
  0x78, 0x7F, 0x3C, 0x3F, 0x9E, 0x0F, 0x8F, 0x07, 0xC7, 0xC7, 0xE1, 0xFF,
  0xF8, 0xFF, 0xDE, 0x1F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x0F,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x0F, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x0F, 0x00, 0x38,
  0x01, 0xC1, 0x0E, 0x2F, 0x7F, 0x7F, 0xFB, 0xFF, 0xE1, 0xF0, 0x1F, 0x81,
  0xEE, 0x1E, 0x78, 0x71, 0xC1, 0x08, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7D, 0xE7, 0x9E,
  0x79, 0xC7, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF0, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x06, 0x00, 0xFE, 0x0F, 0xF8, 0x7F, 0xC7, 0x8F, 0x3C, 0x79, 0xE1,
  0xCE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1E, 0xF0, 0xE7, 0x8F, 0x3E,
  0x78, 0xFF, 0x83, 0xFC, 0x0F, 0xC0, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF,
  0xFF, 0xDE, 0xCF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x01, 0xFE,
  0x1F, 0xF9, 0xFF, 0xE7, 0x0F, 0x10, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0x01, 0xFE, 0x3F, 0xF8, 0xFF, 0xE6, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x3F, 0x81, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0xE0, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0x73,
  0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0x43, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0xC3, 0xEF, 0xFC, 0xFF, 0xCF,
  0xF0, 0x00, 0xE0, 0x3F, 0x87, 0xFC, 0x3F, 0xE3, 0xE0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x8C, 0x3D, 0xF9, 0xFF, 0xEF, 0xFF, 0x7C, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF0, 0xF7, 0x87, 0xBE,
  0x78, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x02, 0x00, 0xFE,
  0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0x38, 0x3D, 0xC1, 0xEE, 0x0F, 0x78, 0xF3,
  0xE7, 0x8F, 0xF8, 0x3F, 0x80, 0xF8, 0x1F, 0xF1, 0xF7, 0xCF, 0x1E, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7D, 0xFF, 0xC7, 0xFC,
  0x1F, 0xC0, 0x06, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0x8F, 0x78, 0x7B,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x8F, 0xBF,
  0xFC, 0xFF, 0xE7, 0xEF, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x67, 0xBF, 0xFF, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x9E, 0xFF, 0xBC, 0x11, 0xE7, 0xDE, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x79, 0xE7, 0x9E, 0x71, 0xCF,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3C,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x10, 0x00, 0x04, 0x0F,
  0xF3, 0xFF, 0x3F, 0xF6, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0x07, 0x81, 0xE0, 0x0E, 0x0E, 0x00,
  0x78, 0xE0, 0x01, 0xC7, 0x0F, 0xC6, 0x70, 0xFE, 0x3B, 0x8F, 0x71, 0xDC,
  0x73, 0x8E, 0xE7, 0x1C, 0x76, 0x38, 0xE3, 0xF1, 0xC7, 0x1F, 0x8E, 0x38,
  0xFC, 0x71, 0xC7, 0xE3, 0x8E, 0x3B, 0x1C, 0x71, 0xDC, 0x77, 0xDC, 0xE3,
  0xF7, 0xE7, 0x0F, 0x3E, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x1C, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x1F, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F,
  0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC1,
  0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF3, 0xC3, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x03, 0x80, 0x7F, 0xC7,
  0xFE, 0x7F, 0xF7, 0xC1, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x08, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1,
  0xF7, 0x83, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xFF, 0x7F, 0xEF, 0xFD, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xE3,
  0xE0, 0xCF, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC1, 0xEF, 0xC3, 0xCF, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFC, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7F, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1,
  0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF7, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF8, 0x78,
  0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xDF, 0xFC, 0x0F, 0xFE, 0xE0, 0x7F, 0xF7, 0x07,
  0xFF, 0xB8, 0x3B, 0xFD, 0xE1, 0xDF, 0xE7, 0x1E, 0xFF, 0x38, 0xE7, 0xF9,
  0xE7, 0x3F, 0xCF, 0x39, 0xFE, 0x3B, 0xCF, 0xF1, 0xDC, 0x7F, 0x8F, 0xE3,
  0xFC, 0x3F, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC1,
  0xE1, 0xFE, 0x0E, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xF7, 0x07, 0xF7, 0x87, 0xF7, 0x87,
  0xF3, 0xC7, 0xF3, 0xC7, 0xF1, 0xE7, 0xF1, 0xE7, 0xF0, 0xE7, 0xF0, 0xF7,
  0xF0, 0xF7, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0x80, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3C, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x7E, 0x7C,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE3,
  0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F,
  0xE7, 0xEF, 0xFF, 0x7F, 0xF3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x0F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8,
  0x1E, 0x78, 0x3E, 0x7E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x8F, 0xCF, 0x0F, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0x3C, 0xF0, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x07, 0x9E, 0x0F, 0x3C, 0x0F, 0x78, 0x1F, 0x06, 0x01, 0xFE, 0x3F,
  0xF7, 0xFF, 0x78, 0x6F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xFF, 0x3E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xF3, 0xC1, 0xE7, 0xC7, 0xCF, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1C,
  0x38, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F,
  0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xF0, 0x1C, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xEE, 0x07,
  0xC0, 0xE7, 0x83, 0xE0, 0xF3, 0xC1, 0xF0, 0x79, 0xE1, 0xDC, 0x3C, 0xF0,
  0xEE, 0x1E, 0x38, 0x77, 0x0F, 0x1E, 0x3B, 0x8F, 0x0F, 0x1D, 0xC7, 0x87,
  0x9E, 0xF3, 0xC3, 0xCE, 0x39, 0xE0, 0xE7, 0x1C, 0xF0, 0x73, 0x8E, 0xF0,
  0x3D, 0xC7, 0x78, 0x1F, 0xE3, 0xBC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x7F,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x03,
  0xE0, 0x0F, 0x01, 0xF0, 0x78, 0x3E, 0xF0, 0x78, 0xF1, 0xF1, 0xE3, 0xC1,
  0xC7, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x1E, 0xF0,
  0x3D, 0xE0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78,
  0x0F, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE3, 0xC7, 0x87, 0x8F,
  0x07, 0x1E, 0x0F, 0x78, 0x1E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x0E, 0x38, 0x3C,
  0x78, 0x70, 0x71, 0xE0, 0xF3, 0x80, 0xEF, 0x01, 0xFC, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xFE, 0x3F,
  0xE3, 0x9F, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1F, 0xF7, 0xFF, 0x7C,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0x7F, 0xF7, 0xF7, 0x3E,
  0x70, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x70, 0xF7, 0xE7, 0xFF, 0xBF, 0xFD, 0xF1, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xE3, 0xDF, 0xFE, 0xEF, 0xE7, 0x3E, 0x00, 0x07, 0x83, 0xFC, 0xFF,
  0x9F, 0xE7, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE1, 0x3F, 0xE7, 0xFC, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC3,
  0x8F, 0x1F, 0xBC, 0xFE, 0xF7, 0xFF, 0xDE, 0x1F, 0x78, 0x7F, 0xC1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D,
  0xE1, 0xF7, 0x8F, 0xDF, 0xFF, 0x3F, 0xBC, 0x7C, 0xF0, 0x07, 0x80, 0xFE,
  0x0F, 0xF8, 0xF9, 0xE7, 0x87, 0x38, 0x3D, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x82, 0x3F,
  0xF0, 0xFF, 0x83, 0xF8, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0x23, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7F, 0x9F, 0xF3, 0xFE, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x0E, 0x00, 0x7E, 0xF3, 0xFB, 0xDF, 0xFF, 0x78,
  0x7D, 0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3D, 0xC1, 0xF7, 0x87, 0xDF, 0x3F, 0x7F, 0xFC, 0xFE, 0xF1,
  0xF3, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x98, 0x3E, 0x7F, 0xF1,
  0xFF, 0x83, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x3C, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x6F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xF1,
  0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xFE,
  0xFD, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x7F, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C, 0x7B,
  0xC3, 0xDE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3E, 0xF1, 0xE7, 0x8F, 0x1E,
  0x78, 0xF3, 0xC3, 0xDE, 0x1E, 0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC3,
  0xC7, 0x3F, 0x3F, 0x3B, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x8F, 0x8F, 0x78,
  0x7C, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83,
  0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3,
  0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1E,
  0x03, 0x8E, 0x7E, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x70, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC,
  0x78, 0x79, 0xE1, 0xE7, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xE7, 0x87, 0x9F, 0x1E, 0x3F, 0xF0, 0x7F,
  0x80, 0xFC, 0x00, 0x03, 0x87, 0x3F, 0x3F, 0xFD, 0xFB, 0xEF, 0x8F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFF, 0x1E, 0xFF, 0xF7, 0xFF, 0x3D, 0xF1, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0E,
  0x00, 0x7E, 0xF3, 0xFB, 0xDF, 0xFF, 0x78, 0x7D, 0xE1, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC1, 0xF7,
  0x87, 0xDF, 0x3F, 0x7F, 0xFC, 0xFE, 0xF1, 0xF3, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0xF3, 0xFB, 0xFD, 0xFF, 0xC7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0xF7,
  0xFF, 0xE6, 0xF0, 0xBC, 0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xC0, 0xF0, 0x3F, 0x0F, 0xFF, 0xFF, 0xEF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x7F, 0xBF, 0xEF, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x7F, 0x1F, 0xC3,
  0xF0, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7,
  0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x3D, 0xC0, 0xF7, 0x87, 0x9E, 0x1E, 0x78,
  0x78, 0xE1, 0xC3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0x73, 0x81, 0xCE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x78, 0x3D, 0xC1, 0xF0, 0xF7, 0x8F, 0xC3, 0x9E, 0x3F, 0x1E, 0x78,
  0xFC, 0x78, 0xE3, 0xB1, 0xE3, 0x8C, 0xE7, 0x0F, 0x73, 0x9C, 0x3D, 0xCE,
  0xF0, 0xF7, 0x3B, 0xC1, 0xDC, 0xEF, 0x07, 0x71, 0xB8, 0x1D, 0x86, 0xE0,
  0x76, 0x1B, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x79, 0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1F, 0xE0, 0x7F,
  0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1D,
  0xE0, 0xF3, 0x83, 0xCF, 0x1E, 0x3C, 0x78, 0x7B, 0xC1, 0xF0, 0xF0, 0x3D,
  0xE0, 0xF7, 0x87, 0x9E, 0x1E, 0x38, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C,
  0x1C, 0xF0, 0x73, 0x81, 0xEE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xF0, 0xFC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x3F,
  0x0F, 0x03, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xFC, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0x0F,
  0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1F, 0x03, 0xF0, 0x3C, 0x3F, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x8F, 0xC3, 0xF0, 0xF8, 0x00, 0x10, 0x0B,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x20,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 24, 8, 2, -24 },
  { 16, 11, 9, 14, 2, -24 },
  { 29, 15, 24, 17, 1, -24 },
  { 74, 13, 28, 15, 1, -26 },
  { 120, 23, 25, 25, 1, -25 },
  { 192, 17, 25, 18, 1, -25 },
  { 246, 4, 9, 8, 2, -24 },
  { 251, 8, 29, 10, 2, -24 },
  { 280, 8, 29, 10, 1, -24 },
  { 309, 13, 13, 15, 1, -26 },
  { 331, 13, 16, 15, 1, -20 },
  { 357, 6, 8, 8, 1, -4 },
  { 363, 8, 4, 10, 1, -11 },
  { 367, 4, 5, 8, 2, -5 },
  { 370, 13, 24, 13, 0, -24 },
  { 409, 13, 25, 15, 1, -25 },
  { 450, 9, 24, 15, 2, -24 },
  { 477, 13, 25, 15, 1, -25 },
  { 518, 13, 25, 15, 1, -25 },
  { 559, 14, 24, 15, 1, -24 },
  { 601, 12, 24, 15, 2, -24 },
  { 637, 13, 25, 15, 1, -25 },
  { 678, 13, 24, 15, 1, -24 },
  { 717, 13, 25, 15, 1, -25 },
  { 758, 13, 25, 15, 1, -25 },
  { 799, 5, 19, 8, 2, -19 },
  { 811, 6, 23, 8, 1, -19 },
  { 829, 13, 16, 15, 1, -20 },
  { 855, 13, 10, 15, 1, -17 },
  { 872, 13, 16, 15, 1, -20 },
  { 898, 11, 25, 12, 0, -25 },
  { 933, 21, 28, 24, 1, -25 },
  { 1007, 17, 24, 17, 0, -24 },
  { 1058, 14, 24, 17, 2, -24 },
  { 1100, 13, 25, 16, 2, -25 },
  { 1141, 15, 24, 18, 2, -24 },
  { 1186, 11, 24, 14, 2, -24 },
  { 1219, 11, 24, 14, 2, -24 },
  { 1252, 15, 25, 19, 2, -25 },
  { 1299, 15, 24, 19, 2, -24 },
  { 1344, 8, 24, 10, 1, -24 },
  { 1368, 8, 31, 9, -2, -24 },
  { 1399, 15, 24, 17, 2, -24 },
  { 1444, 11, 24, 13, 2, -24 },
  { 1477, 21, 24, 26, 2, -24 },
  { 1540, 16, 24, 21, 2, -24 },
  { 1588, 16, 25, 20, 2, -25 },
  { 1638, 13, 24, 16, 2, -24 },
  { 1677, 16, 31, 20, 2, -25 },
  { 1739, 15, 24, 17, 2, -24 },
  { 1784, 12, 25, 14, 1, -25 },
  { 1822, 14, 24, 14, 0, -24 },
  { 1864, 15, 24, 19, 2, -24 },
  { 1909, 16, 24, 16, 0, -24 },
  { 1957, 25, 24, 25, 0, -24 },
  { 2032, 15, 24, 15, 0, -24 },
  { 2077, 15, 24, 15, 0, -24 },
  { 2122, 12, 24, 13, 1, -24 },
  { 2158, 8, 29, 11, 2, -24 },
  { 2187, 13, 24, 13, 0, -24 },
  { 2226, 7, 29, 11, 1, -24 },
  { 2252, 15, 14, 17, 1, -24 },
  { 2279, 14, 2, 14, 0, 3 },
  { 2283, 8, 5, 10, 1, -26 },
  { 2288, 12, 19, 15, 1, -19 },
  { 2317, 13, 26, 17, 2, -26 },
  { 2360, 11, 19, 13, 1, -19 },
  { 2387, 14, 26, 17, 1, -26 },
  { 2433, 13, 19, 15, 1, -19 },
  { 2464, 11, 26, 10, 0, -26 },
  { 2500, 14, 27, 17, 1, -19 },
  { 2548, 12, 26, 16, 2, -26 },
  { 2587, 4, 26, 8, 2, -26 },
  { 2600, 7, 34, 8, -1, -26 },
  { 2630, 13, 26, 15, 2, -26 },
  { 2673, 4, 26, 8, 2, -26 },
  { 2686, 21, 19, 25, 2, -19 },
  { 2736, 12, 19, 16, 2, -19 },
  { 2765, 14, 19, 16, 1, -19 },
  { 2799, 13, 27, 17, 2, -19 },
  { 2843, 14, 27, 17, 1, -19 },
  { 2891, 9, 19, 11, 2, -19 },
  { 2913, 10, 19, 12, 1, -19 },
  { 2937, 10, 22, 10, 0, -22 },
  { 2965, 12, 18, 16, 2, -18 },
  { 2992, 14, 18, 14, 0, -18 },
  { 3024, 22, 18, 22, 0, -18 },
  { 3074, 14, 18, 14, 0, -18 },
  { 3106, 14, 26, 14, 0, -18 },
  { 3152, 10, 18, 12, 1, -18 },
  { 3175, 10, 29, 12, 1, -24 },
  { 3212, 3, 34, 14, 6, -26 },
  { 3225, 10, 29, 12, 1, -24 },
  { 3262, 13, 6, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD34PT7B_H_
