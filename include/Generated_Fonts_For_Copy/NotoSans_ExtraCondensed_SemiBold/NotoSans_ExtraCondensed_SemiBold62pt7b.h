#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x83, 0xF3, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xC7, 0xE1, 0x80, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xBF, 0xCE, 0x1C, 0xFE, 0x38, 0x13, 0xF0, 0xE0, 0x0F, 0xC3, 0x80, 0x3F,
  0x0E, 0x00, 0xFC, 0x38, 0x03, 0xF8, 0xE0, 0x0F, 0xE3, 0x80, 0x1F, 0xEE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xEF, 0xF0, 0x03, 0x9F, 0xC0, 0x0E, 0x3F, 0x00, 0x38,
  0xFC, 0x00, 0xE3, 0xF0, 0x03, 0x8F, 0xE0, 0x0E, 0x3F, 0xC0, 0x39, 0xFF,
  0xE0, 0xEF, 0xEF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xC0, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0xFC,
  0x03, 0xE0, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x01, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0xFC, 0x00, 0x1F,
  0x83, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x87, 0xC0, 0x00, 0x3F,
  0x07, 0xC3, 0xE0, 0xFC, 0x0F, 0x83, 0xE3, 0xF1, 0xFF, 0x87, 0xC3, 0xF1,
  0xF1, 0xFF, 0xC3, 0xF1, 0xF9, 0xF8, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFC, 0x7C, 0x7E, 0x7E, 0x3F, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F,
  0xFE, 0x3E, 0x3F, 0x0F, 0xC3, 0xFC, 0x1F, 0x1F, 0x87, 0xE0, 0x7C, 0x1F,
  0x8F, 0x83, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0xFE, 0x0F, 0xFF, 0x81, 0xFC, 0x3F, 0xFF, 0x83, 0xF8,
  0x7F, 0xFF, 0x07, 0xF1, 0xFE, 0xFF, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xF0, 0xFE, 0x7F, 0x1F, 0xC1, 0xFE, 0xFE, 0x3F, 0x81, 0xFF, 0xF8, 0x7F,
  0x01, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0x83, 0xF8,
  0x03, 0xFF, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xE0, 0x7F, 0xFE,
  0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x16, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x1C,
  0x1F, 0x07, 0x3F, 0x3E, 0x7E, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x3F, 0xC1, 0xF8, 0x3E, 0x00, 0xE0, 0x78, 0x00, 0xC0, 0x40,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xCF, 0xF3, 0xFC, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x3F, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xF7, 0xF9, 0xFF, 0xFC, 0x7F, 0x3E, 0x3F,
  0xC7, 0x0F, 0xF0, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xE7, 0xFE, 0x1F, 0x01, 0xFE, 0x38, 0x03, 0xFC,
  0x20, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xC3, 0xFF, 0x1E, 0x01, 0xFE, 0x10, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0x7F, 0x00, 0x07, 0xDF, 0xC0, 0x01, 0xF7, 0xF0,
  0x00, 0xF9, 0xFC, 0x00, 0x3E, 0x7F, 0x00, 0x1F, 0x1F, 0xC0, 0x07, 0xC7,
  0xF0, 0x03, 0xE1, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0,
  0x7C, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x07, 0xE0, 0x1F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xC3, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x80,
  0x07, 0xFB, 0xC0, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFE, 0x08, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x06, 0x00, 0x7E, 0x3F, 0xC0, 0x7E, 0x7F, 0xF0, 0xFE, 0xFF, 0xF8,
  0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE,
  0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE7, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF8,
  0x3F, 0xC7, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFE,
  0x7F, 0x01, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFB, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xEF, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7E,
  0x7F, 0xFE, 0xFC, 0x7F, 0xF9, 0xF8, 0x7F, 0xE3, 0xF0, 0x7F, 0x8F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x1E, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x3F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xCF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0x7F, 0x1F, 0x86, 0x00, 0x0F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x1F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFC, 0xFF, 0xC7, 0x00, 0xFE, 0x10, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x01,
  0xF0, 0xF8, 0x07, 0xFF, 0x87, 0xC3, 0xE0, 0x3F, 0xFE, 0x1F, 0x9F, 0x81,
  0xFF, 0xF8, 0x3E, 0x7C, 0x0F, 0xE7, 0xE0, 0xF9, 0xF0, 0x7E, 0x1F, 0x83,
  0xEF, 0xC1, 0xF8, 0x7E, 0x0F, 0xBF, 0x07, 0xC1, 0xF8, 0x3E, 0xF8, 0x3F,
  0x07, 0xE0, 0xFB, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xE0, 0x7E, 0x0F,
  0xFE, 0x0F, 0x81, 0xF8, 0x3F, 0xF8, 0x3E, 0x07, 0xE0, 0xFB, 0xE0, 0xF8,
  0x1F, 0x83, 0xEF, 0x83, 0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0x81, 0xF8, 0x3E,
  0xF8, 0x3E, 0x07, 0xC0, 0xFB, 0xE0, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xE0,
  0xFC, 0x1F, 0xBE, 0x0F, 0xC3, 0xF8, 0x7C, 0xF8, 0x1F, 0x0F, 0xE3, 0xF3,
  0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xC1, 0xFF, 0xCF, 0xFE, 0x1F, 0x03, 0xFF,
  0x3F, 0xF0, 0x7C, 0x07, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0x80, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x02, 0x00, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xFD, 0xFC, 0x01,
  0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFC,
  0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x1F, 0xFB, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFB, 0xF8, 0x3F, 0xE0, 0x1C, 0x1F, 0xE0, 0x02, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x10, 0x7F, 0xE0, 0x38, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0xC7, 0xF0, 0x0F, 0xF8, 0xFE, 0x00, 0xFF,
  0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xE0,
  0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xF3, 0xF8, 0x03, 0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x3F, 0xF1, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0xC0, 0xFF, 0x80, 0x1C, 0x1F, 0xF0, 0x00,
  0x41, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07,
  0xF7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F,
  0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xFC, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF0, 0x3C, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xF8, 0x03, 0xFE, 0x7F,
  0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xEF,
  0xFF, 0xFE, 0x00, 0x1F, 0xBF, 0xFE, 0xFC, 0x00, 0x7E, 0xFF, 0xFB, 0xF0,
  0x03, 0xF3, 0xFF, 0xEF, 0xC0, 0x0F, 0xDF, 0xFF, 0x9F, 0x80, 0x3F, 0x7F,
  0xFE, 0x7E, 0x00, 0xFD, 0xFF, 0xF9, 0xF8, 0x07, 0xE7, 0xFF, 0xE7, 0xE0,
  0x1F, 0x9F, 0xFF, 0x8F, 0xC0, 0x7E, 0x7F, 0xFE, 0x3F, 0x01, 0xF1, 0xFF,
  0xF8, 0xFC, 0x0F, 0xC7, 0xFF, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0x87, 0xE0,
  0xFC, 0x7F, 0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0x83, 0xF1, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF,
  0xC1, 0xFF, 0xF8, 0x3F, 0x3F, 0x07, 0xFF, 0xE0, 0x7E, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xC0, 0x1F,
  0xFF, 0x7F, 0x00, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xFE,
  0x7F, 0x01, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0xFC, 0x7F,
  0x03, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0x87,
  0xFF, 0xC1, 0xFC, 0x3F, 0xFE, 0x07, 0xE1, 0xFF, 0xF0, 0x3F, 0x8F, 0xFF,
  0x81, 0xFC, 0x7F, 0xFC, 0x07, 0xF3, 0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0x00,
  0xFE, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xC0, 0x1F, 0xBF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xE3, 0xF8, 0x0F,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F,
  0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF0, 0x3C, 0x7F, 0x80, 0x31, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFB, 0xC0, 0x1F, 0xEF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFD, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x1D, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF7, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xDF, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF3, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x3F, 0x07, 0xF0,
  0x0F, 0xE0, 0xF8, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE3, 0xF0, 0x7F, 0x00,
  0xFE, 0x1F, 0x87, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x1F, 0x8F, 0xE0, 0x07,
  0xE1, 0xF8, 0x7E, 0x3F, 0x80, 0x1F, 0xCF, 0xC1, 0xF8, 0xFE, 0x00, 0x7F,
  0x3F, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0x07, 0xF3,
  0xF0, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0xFD, 0xFC, 0x00, 0x3F, 0x3E,
  0x03, 0xF7, 0xF0, 0x00, 0xFC, 0xF8, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x01,
  0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF3, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFE, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3E, 0x3F, 0xE0, 0xE0, 0x3F, 0x82, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0xDF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xEF, 0xCF, 0xFF, 0x3F, 0x1F, 0xF8, 0x7C, 0x3F, 0xC1, 0xF0,
  0x18, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x7F, 0xE0,
  0xFE, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0x83, 0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFC, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFD, 0xFF, 0xF8, 0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xE0, 0xF8, 0x3F, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xE0, 0x63, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x13, 0xFC,
  0x03, 0x3F, 0xF1, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xE3,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF,
  0x1F, 0x03, 0xFC, 0x1F, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFC, 0xFF,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xFD,
  0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x11, 0xFE, 0x00, 0x61, 0xFF, 0x07, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xF7,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x07, 0xFE,
  0x3F, 0x03, 0xFC, 0x3F, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x40, 0x00,
  0xFE, 0x30, 0x01, 0xFE, 0x3E, 0x07, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0xFF, 0x0F, 0xE7, 0xFE, 0x3F, 0x3F, 0xFC, 0xFD, 0xFF, 0xFB,
  0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x18,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x01, 0x80,
  0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE9, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x07, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFD, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x9F,
  0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x3F,
  0xC0, 0x7F, 0x87, 0xC3, 0xFF, 0x07, 0xFE, 0x3F, 0x3F, 0xFC, 0x7F, 0xF9,
  0xFB, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF,
  0x03, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0x00,
  0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80,
  0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0xF8, 0x3F, 0xC3, 0xE1, 0xFF, 0x8F, 0xCF, 0xFF, 0x3F, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x7F,
  0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF8,
  0x1F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0xF8, 0x3F, 0x80, 0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8,
  0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x01, 0xFE,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFC,
  0xFF, 0xEF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8, 0xFC, 0xFF, 0xF0,
  0xFE, 0x7F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x07, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F,
  0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF,
  0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF,
  0x3F, 0xC1, 0xFF, 0x3F, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF,
  0x0F, 0xFF, 0x3F, 0x07, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFD, 0xFF, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xBF, 0x3F, 0x80, 0xE7, 0xF0, 0x04, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x70, 0x0F, 0xEF, 0xEF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x70, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xCF, 0xFF, 0xBF,
  0x1F, 0xFC, 0x7C, 0x3F, 0xC1, 0xF0, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x7F, 0x00, 0xFF, 0x80,
  0xFE, 0x3F, 0x01, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x3F,
  0x81, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xF7, 0xC0, 0xFC, 0x3F, 0x81, 0xF7,
  0xC1, 0xFC, 0x1F, 0x83, 0xF7, 0xC1, 0xFC, 0x1F, 0xC3, 0xE7, 0xC1, 0xFC,
  0x1F, 0xC3, 0xE7, 0xC1, 0xF8, 0x1F, 0xC3, 0xE7, 0xE3, 0xF8, 0x1F, 0xC3,
  0xE3, 0xE3, 0xF8, 0x0F, 0xC7, 0xE3, 0xE3, 0xF8, 0x0F, 0xE7, 0xC3, 0xE3,
  0xF0, 0x0F, 0xE7, 0xC3, 0xE3, 0xF0, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x07,
  0xE7, 0xC3, 0xF7, 0xF0, 0x07, 0xE7, 0xC1, 0xF7, 0xF0, 0x07, 0xE7, 0xC1,
  0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xFF, 0x81, 0xF7, 0xE0,
  0x03, 0xFF, 0x81, 0xF7, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x02, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x3F, 0xE0, 0x01, 0x7F,
  0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 45, 15, 3, -44 },
  { 52, 20, 16, 26, 3, -44 },
  { 92, 28, 44, 30, 1, -44 },
  { 246, 22, 51, 28, 3, -47 },
  { 387, 41, 46, 45, 2, -45 },
  { 623, 31, 46, 33, 2, -45 },
  { 802, 8, 16, 14, 3, -44 },
  { 818, 15, 55, 19, 3, -45 },
  { 922, 15, 55, 19, 1, -45 },
  { 1026, 23, 23, 26, 2, -47 },
  { 1093, 24, 30, 28, 2, -37 },
  { 1183, 10, 15, 15, 2, -7 },
  { 1202, 14, 7, 18, 2, -20 },
  { 1215, 9, 10, 15, 3, -9 },
  { 1227, 23, 45, 24, 1, -45 },
  { 1357, 24, 46, 28, 2, -45 },
  { 1495, 18, 44, 28, 3, -44 },
  { 1594, 23, 45, 28, 2, -45 },
  { 1724, 23, 46, 28, 2, -45 },
  { 1857, 26, 44, 28, 1, -44 },
  { 2000, 22, 45, 28, 3, -44 },
  { 2124, 24, 46, 28, 2, -45 },
  { 2262, 24, 44, 28, 2, -44 },
  { 2394, 24, 46, 28, 2, -45 },
  { 2532, 23, 46, 28, 2, -45 },
  { 2665, 9, 35, 15, 3, -34 },
  { 2705, 10, 42, 15, 2, -34 },
  { 2758, 24, 29, 28, 2, -37 },
  { 2845, 24, 18, 28, 2, -31 },
  { 2899, 24, 29, 28, 2, -37 },
  { 2986, 21, 46, 22, 0, -45 },
  { 3107, 38, 50, 43, 3, -45 },
  { 3345, 31, 44, 31, 0, -44 },
  { 3516, 25, 44, 32, 4, -44 },
  { 3654, 25, 46, 29, 3, -45 },
  { 3798, 27, 44, 34, 4, -44 },
  { 3947, 19, 44, 26, 4, -44 },
  { 4052, 19, 44, 26, 4, -44 },
  { 4157, 28, 46, 34, 3, -45 },
  { 4318, 27, 44, 35, 4, -44 },
  { 4467, 15, 44, 19, 2, -44 },
  { 4550, 14, 57, 16, -3, -44 },
  { 4650, 27, 44, 30, 4, -44 },
  { 4799, 19, 44, 24, 4, -44 },
  { 4904, 38, 44, 47, 4, -44 },
  { 5113, 29, 44, 38, 4, -44 },
  { 5273, 30, 46, 36, 3, -45 },
  { 5446, 23, 44, 29, 4, -44 },
  { 5573, 30, 56, 36, 3, -45 },
  { 5783, 26, 44, 31, 4, -44 },
  { 5926, 22, 46, 26, 2, -45 },
  { 6053, 24, 44, 25, 1, -44 },
  { 6185, 26, 45, 34, 4, -44 },
  { 6332, 30, 44, 30, 0, -44 },
  { 6497, 46, 44, 46, 0, -44 },
  { 6750, 27, 44, 28, 0, -44 },
  { 6899, 27, 44, 27, 0, -44 },
  { 7048, 22, 44, 24, 1, -44 },
  { 7169, 14, 55, 19, 4, -45 },
  { 7266, 23, 45, 24, 1, -45 },
  { 7396, 13, 55, 19, 2, -45 },
  { 7486, 29, 26, 31, 1, -44 },
  { 7581, 26, 4, 26, 0, 5 },
  { 7594, 14, 9, 18, 2, -47 },
  { 7610, 22, 35, 28, 2, -34 },
  { 7707, 24, 48, 30, 4, -47 },
  { 7851, 20, 35, 24, 2, -34 },
  { 7939, 24, 48, 30, 2, -47 },
  { 8083, 23, 35, 27, 2, -34 },
  { 8184, 18, 47, 17, 1, -47 },
  { 8290, 24, 49, 30, 2, -34 },
  { 8437, 22, 47, 30, 4, -47 },
  { 8567, 8, 47, 14, 3, -47 },
  { 8614, 12, 62, 14, -1, -47 },
  { 8707, 24, 47, 28, 4, -47 },
  { 8848, 7, 47, 14, 4, -47 },
  { 8890, 37, 34, 45, 4, -34 },
  { 9048, 22, 34, 30, 4, -34 },
  { 9142, 25, 35, 29, 2, -34 },
  { 9252, 24, 49, 30, 4, -34 },
  { 9399, 24, 49, 30, 2, -34 },
  { 9546, 16, 34, 21, 4, -34 },
  { 9614, 19, 35, 22, 2, -34 },
  { 9698, 17, 42, 19, 1, -41 },
  { 9788, 22, 35, 30, 4, -34 },
  { 9885, 26, 34, 26, 0, -34 },
  { 9996, 40, 34, 40, 0, -34 },
  { 10166, 25, 34, 25, 0, -34 },
  { 10273, 26, 49, 26, 0, -34 },
  { 10433, 19, 34, 21, 1, -34 },
  { 10514, 18, 54, 22, 1, -44 },
  { 10636, 6, 62, 26, 10, -47 },
  { 10683, 18, 54, 22, 2, -44 },
  { 10805, 24, 10, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD62PT7B_H_
