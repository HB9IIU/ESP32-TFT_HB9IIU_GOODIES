#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x10, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1F, 0x9F, 0x07, 0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C, 0x0F, 0x9F,
  0x03, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xDC, 0x78,
  0xFC, 0xE0, 0x47, 0xE7, 0x00, 0x7E, 0x38, 0x03, 0xF1, 0xC0, 0x0F, 0x8E,
  0x00, 0x7E, 0x70, 0x03, 0xFB, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1D, 0xFC, 0x00, 0xE7, 0xE0, 0x07, 0x1F, 0x80,
  0x38, 0xFC, 0x01, 0xC7, 0xE0, 0x0E, 0x3F, 0x80, 0x71, 0xFF, 0x03, 0x9F,
  0xBE, 0x1D, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF0,
  0x07, 0xC0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x3E, 0x7E, 0x01, 0xF0, 0x01,
  0xF1, 0xF0, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x7C, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0xF8, 0x00, 0x1F, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x3E,
  0x3E, 0x04, 0x07, 0xC3, 0xE3, 0xE1, 0xFC, 0x3E, 0x1F, 0x1F, 0x1F, 0xF0,
  0xF8, 0xF8, 0xF1, 0xFF, 0xC7, 0xCF, 0xCF, 0x8F, 0xFE, 0x3F, 0xFC, 0x7C,
  0xF8, 0xF8, 0xFF, 0xE7, 0xC7, 0xC7, 0xC3, 0xFE, 0x3E, 0x3E, 0x1E, 0x0F,
  0xE1, 0xF1, 0xE0, 0xF8, 0x08, 0x1F, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0xF8,
  0x3E, 0x00, 0x07, 0x87, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x3C, 0x00, 0x3C, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x1F, 0x1F, 0x00,
  0x1F, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x0F,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x1F, 0x87, 0xF7,
  0xE1, 0xFC, 0x3F, 0xBF, 0x8F, 0xE3, 0xF8, 0xFE, 0x7E, 0x1F, 0x83, 0xF3,
  0xF0, 0xFC, 0x1F, 0xFF, 0x8F, 0xE0, 0x7F, 0xF8, 0x7F, 0x01, 0xFF, 0xC3,
  0xF8, 0x0F, 0xFE, 0x1F, 0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0x81, 0xFF, 0xF1, 0xFE,
  0x07, 0xFE, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x60, 0xF0, 0x6F, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFB, 0xF0, 0x1F, 0x9F, 0x83, 0xF0, 0xFC, 0x7F, 0x0F,
  0xE1, 0xE0, 0x78, 0x06, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x9F, 0xCF,
  0xC7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x7F, 0xFE, 0x7F,
  0x7C, 0x7F, 0x38, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x40,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xF8, 0x7F, 0x87, 0x00, 0xFE, 0x30, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x40,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xF0, 0x7F, 0x86, 0x00, 0xFE, 0x20, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xB0, 0x03, 0xFD, 0xE0, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xDF, 0x80, 0x0F, 0xBF, 0x00,
  0x1E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x07,
  0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x07,
  0xE0, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7C, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE8, 0x01, 0xFE, 0xF0, 0x7F, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x05, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xF8, 0x08, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x1F, 0x8F, 0xF0, 0xFC, 0xFF, 0xC7,
  0xEF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0x7F, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x07,
  0xEF, 0xC0, 0x7F, 0x7F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xE3, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x83, 0xF8, 0xFE, 0x3F, 0x83, 0xFB, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x07, 0xF7, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x20, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xC7, 0xF1, 0xFC, 0x1F, 0x9F,
  0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xF7, 0xE3, 0xFF, 0x3F, 0x0F, 0xF1, 0xF8, 0x1F,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x10, 0x1F,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E,
  0x10, 0x0C, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xFD, 0xFC, 0x7E, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0x0F, 0xF1,
  0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x1F,
  0x01, 0xFF, 0xC3, 0xC3, 0xE0, 0x7F, 0xF8, 0x7C, 0x7C, 0x1F, 0xFF, 0x0F,
  0x9F, 0x07, 0xE3, 0xE1, 0xF3, 0xE0, 0xF8, 0x7C, 0x1E, 0x7C, 0x3F, 0x0F,
  0x83, 0xCF, 0x87, 0xC1, 0xF0, 0x7D, 0xE0, 0xF8, 0x3E, 0x0F, 0xBC, 0x1F,
  0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xF8, 0x3F, 0xF0, 0x78, 0x1F, 0x07, 0xFE,
  0x1F, 0x03, 0xE0, 0xFF, 0xC3, 0xE0, 0x7C, 0x1E, 0xF8, 0x3C, 0x0F, 0x83,
  0xDF, 0x07, 0x83, 0xF0, 0xFB, 0xE0, 0xF8, 0x7E, 0x1F, 0x3C, 0x1F, 0x0F,
  0xC3, 0xE7, 0xC3, 0xE3, 0xF8, 0xF8, 0xF8, 0x3F, 0xF7, 0xFF, 0x1F, 0x07,
  0xFE, 0xFF, 0xC3, 0xE0, 0x7F, 0x8F, 0xF0, 0x3E, 0x07, 0xE1, 0xFC, 0x07,
  0xC0, 0x30, 0x06, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x08, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xF0, 0xFF, 0xEF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC, 0x03,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x3F, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x0F, 0x8F, 0xF0, 0x04,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x87, 0xFE, 0x1E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x03,
  0xF8, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0x78, 0x3F, 0xC0,
  0x0C, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0,
  0x0F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF,
  0xE7, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01,
  0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F,
  0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFE,
  0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF7, 0xC0, 0x0F, 0xBF, 0xFD, 0xF0, 0x03, 0xEF,
  0xFF, 0x7E, 0x01, 0xFB, 0xFF, 0xDF, 0x80, 0x7C, 0xFF, 0xF3, 0xE0, 0x1F,
  0x3F, 0xFC, 0xF8, 0x07, 0xCF, 0xFF, 0x3F, 0x03, 0xF3, 0xFF, 0xCF, 0xC0,
  0xF8, 0xFF, 0xF1, 0xF0, 0x3E, 0x3F, 0xFC, 0x7C, 0x1F, 0x8F, 0xFF, 0x1F,
  0x87, 0xE3, 0xFF, 0xC3, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7C, 0x3F, 0xFC,
  0x3E, 0x3F, 0x0F, 0xFF, 0x0F, 0xCF, 0x83, 0xFF, 0xC1, 0xF3, 0xE0, 0xFF,
  0xF0, 0x7C, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F,
  0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xF8,
  0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0xC0, 0xFF, 0xF3, 0xF0, 0x3F, 0xFC,
  0x7E, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xC7, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F,
  0xFC, 0x3F, 0x0F, 0xFF, 0x07, 0xE3, 0xFF, 0xC1, 0xF8, 0xFF, 0xF0, 0x7F,
  0x3F, 0xFC, 0x0F, 0xCF, 0xFF, 0x03, 0xFB, 0xFF, 0xC0, 0x7E, 0xFF, 0xF0,
  0x1F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFC, 0x7F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x8F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xF0,
  0xFF, 0x01, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0xFE,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0xBF, 0x03, 0xFD, 0xF8, 0x7F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F, 0xC1,
  0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x0F, 0xF9,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x03,
  0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F,
  0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFE,
  0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x1F, 0xE3, 0xF1, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x07,
  0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x00, 0x20, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xF0, 0x1C, 0xFE, 0x00, 0x4F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xEC, 0x00,
  0xFE, 0xF0, 0x1F, 0xEF, 0xF7, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFF, 0x0F, 0xF3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF0, 0x01, 0xFB, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xFE, 0x00,
  0xFC, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x0F, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xDF, 0x01, 0xF8, 0x3F, 0x01,
  0xF7, 0xC0, 0x7E, 0x0F, 0xE0, 0x7D, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x7C,
  0x0F, 0xE0, 0x7E, 0x07, 0xDF, 0x83, 0xF0, 0x1F, 0x83, 0xF3, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0xF8, 0x3F, 0x01, 0xFC, 0x3E, 0x3E, 0x1F, 0xC0, 0x3F,
  0x0F, 0x8F, 0x87, 0xF0, 0x0F, 0xC3, 0xE3, 0xE1, 0xF8, 0x03, 0xF1, 0xF8,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x07, 0xC7,
  0xE0, 0x07, 0xE7, 0xC1, 0xF3, 0xF8, 0x01, 0xF9, 0xF0, 0x7C, 0xFC, 0x00,
  0x7E, 0xFC, 0x1F, 0xBF, 0x00, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0x07, 0xEF,
  0x80, 0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x0F,
  0xBF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xEF, 0xC0,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xE0, 0xFE, 0x08, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFB, 0xF3, 0xFF, 0x1F, 0x1F, 0xE1, 0xF0, 0x20, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x03,
  0xF9, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF,
  0xBF, 0xCF, 0xF8, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xBF, 0xC0, 0x7E, 0xFF, 0x03, 0xFB, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F,
  0x7F, 0xFC, 0xFD, 0xFF, 0xE3, 0xF3, 0xFF, 0x0F, 0xC7, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFB, 0xE3, 0xF8, 0x11, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x4F, 0xE0, 0x73,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0,
  0xFC, 0x1F, 0xE3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0,
  0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x03, 0xFC, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFE, 0xFC, 0x3F, 0xF1, 0xF0, 0x7F, 0x87, 0xC0,
  0x10, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x11, 0xFC, 0x03, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xE3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0,
  0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x03, 0xFC, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xBF, 0x1F, 0xFE, 0xFC, 0x3F, 0xF3, 0xF0, 0x7F, 0x8F, 0xC0,
  0x20, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x80, 0x0F, 0xE3, 0xC0, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x7E, 0x3F, 0xE3,
  0xF3, 0xFF, 0x9F, 0xBF, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xE1,
  0xFD, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7E, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xD3, 0xFB, 0xFF, 0x7F, 0xEF, 0xF9, 0xFE, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xEF,
  0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0,
  0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFB, 0xF0, 0x3F, 0xC7,
  0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF8,
  0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x80, 0xFE, 0xFE,
  0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x3E, 0x1F, 0xF0, 0xFF, 0x8F, 0xCF, 0xFC, 0x7F, 0xF3, 0xF7,
  0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xC1, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x80,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0xFE,
  0x03, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0xFF,
  0xF8, 0x0F, 0xC0, 0x3F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0xFE, 0x03, 0xF0,
  0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x07, 0xC3, 0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFE, 0x1F, 0xDF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x3F,
  0xC3, 0xF8, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xF7,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F,
  0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0x03, 0xF1, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFD,
  0xFF, 0xF3, 0xFF, 0xBF, 0xCF, 0xF8, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01,
  0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xBF, 0xC0, 0x7E, 0xFF, 0x03, 0xFB, 0xFE, 0x1F, 0xEF,
  0xFF, 0xFF, 0x3F, 0x7F, 0xFC, 0xFC, 0xFF, 0xE3, 0xFB, 0xFF, 0x0F, 0xE3,
  0xF8, 0x3F, 0x81, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xDF, 0xC0, 0xFF, 0x7E,
  0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x03, 0xFC, 0xFE, 0x1F,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0x1F, 0xFE, 0xFC, 0x3F, 0xF3, 0xF0,
  0x7F, 0x8F, 0xC0, 0x20, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xF0, 0xF3, 0xF0, 0x19, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x70, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xC0, 0x0A, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE1, 0x1F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x08, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFF,
  0x7F, 0x0F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFB, 0xF1, 0xFF,
  0x8F, 0x87, 0xF8, 0x7C, 0x02, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01,
  0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xC0, 0x3F, 0x7E, 0x03, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0xE0, 0x7E, 0x7F, 0x03, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xE0,
  0x7E, 0x3F, 0x07, 0xFE, 0x07, 0xE3, 0xF0, 0x7D, 0xE0, 0xFC, 0x3F, 0x07,
  0xDE, 0x0F, 0xC1, 0xF8, 0x79, 0xF0, 0xFC, 0x1F, 0x87, 0x9F, 0x0F, 0xC1,
  0xF8, 0xF9, 0xF0, 0xF8, 0x1F, 0x8F, 0x8F, 0x1F, 0x81, 0xF8, 0xF8, 0xF1,
  0xF8, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0xFC, 0xF0, 0xF9, 0xF8, 0x0F, 0xCF,
  0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x07, 0xBF, 0x00,
  0x7D, 0xF0, 0x7B, 0xF0, 0x07, 0xDF, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x7B,
  0xE0, 0x07, 0xFE, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x7F, 0x01, 0xFF, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x08, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x02, 0x7F, 0xE0, 0x0D, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0x40, 0x03, 0xF8,
  0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 41, 14, 3, -40 },
  { 42, 18, 14, 23, 3, -40 },
  { 74, 25, 40, 27, 1, -40 },
  { 199, 21, 46, 25, 2, -43 },
  { 320, 37, 42, 41, 2, -41 },
  { 515, 29, 42, 29, 1, -41 },
  { 668, 7, 14, 13, 3, -40 },
  { 681, 13, 49, 17, 3, -40 },
  { 761, 13, 49, 17, 1, -40 },
  { 841, 20, 21, 24, 2, -43 },
  { 894, 22, 27, 25, 2, -33 },
  { 969, 9, 13, 13, 2, -6 },
  { 984, 13, 6, 16, 2, -18 },
  { 994, 8, 9, 14, 3, -8 },
  { 1003, 20, 40, 22, 1, -40 },
  { 1103, 21, 42, 25, 2, -41 },
  { 1214, 16, 40, 25, 3, -40 },
  { 1294, 21, 41, 25, 2, -41 },
  { 1402, 21, 42, 25, 2, -41 },
  { 1513, 23, 40, 25, 1, -40 },
  { 1628, 20, 41, 25, 3, -40 },
  { 1731, 21, 41, 25, 2, -40 },
  { 1839, 22, 40, 25, 1, -40 },
  { 1949, 21, 41, 25, 2, -40 },
  { 2057, 21, 41, 25, 2, -40 },
  { 2165, 8, 32, 14, 3, -31 },
  { 2197, 9, 38, 14, 2, -31 },
  { 2240, 22, 26, 25, 2, -33 },
  { 2312, 22, 17, 25, 2, -28 },
  { 2359, 22, 26, 25, 2, -33 },
  { 2431, 19, 42, 20, 0, -41 },
  { 2531, 35, 45, 39, 2, -40 },
  { 2728, 28, 40, 28, 0, -40 },
  { 2868, 22, 40, 28, 4, -40 },
  { 2978, 22, 42, 26, 3, -41 },
  { 3094, 24, 40, 30, 4, -40 },
  { 3214, 17, 40, 24, 4, -40 },
  { 3299, 17, 40, 23, 4, -40 },
  { 3384, 25, 42, 31, 3, -41 },
  { 3516, 24, 40, 32, 4, -40 },
  { 3636, 13, 40, 17, 2, -40 },
  { 3701, 13, 51, 14, -3, -40 },
  { 3784, 24, 40, 27, 4, -40 },
  { 3904, 17, 40, 22, 4, -40 },
  { 3989, 34, 40, 42, 4, -40 },
  { 4159, 26, 40, 34, 4, -40 },
  { 4289, 27, 42, 32, 3, -41 },
  { 4431, 21, 40, 26, 4, -40 },
  { 4536, 27, 51, 32, 3, -41 },
  { 4709, 23, 40, 28, 4, -40 },
  { 4824, 20, 42, 23, 2, -41 },
  { 4929, 21, 40, 23, 1, -40 },
  { 5034, 23, 41, 31, 4, -40 },
  { 5152, 27, 40, 27, 0, -40 },
  { 5287, 42, 40, 41, 0, -40 },
  { 5497, 25, 40, 25, 0, -40 },
  { 5622, 25, 40, 25, 0, -40 },
  { 5747, 20, 40, 22, 1, -40 },
  { 5847, 12, 49, 17, 4, -40 },
  { 5921, 20, 40, 22, 1, -40 },
  { 6021, 12, 49, 17, 2, -40 },
  { 6095, 26, 23, 28, 1, -40 },
  { 6170, 24, 4, 23, 0, 5 },
  { 6182, 12, 9, 16, 2, -43 },
  { 6196, 20, 32, 25, 2, -31 },
  { 6276, 22, 44, 27, 3, -43 },
  { 6397, 18, 32, 21, 2, -31 },
  { 6469, 22, 44, 27, 2, -43 },
  { 6590, 21, 32, 25, 2, -31 },
  { 6674, 17, 43, 16, 0, -43 },
  { 6766, 22, 44, 27, 2, -31 },
  { 6887, 21, 43, 27, 3, -43 },
  { 7000, 7, 42, 13, 3, -42 },
  { 7037, 11, 55, 13, -1, -42 },
  { 7113, 22, 43, 25, 3, -43 },
  { 7232, 7, 43, 13, 3, -43 },
  { 7270, 34, 31, 40, 3, -31 },
  { 7402, 21, 31, 27, 3, -31 },
  { 7484, 22, 32, 26, 2, -31 },
  { 7572, 22, 44, 27, 3, -31 },
  { 7693, 22, 44, 27, 2, -31 },
  { 7814, 15, 31, 19, 3, -31 },
  { 7873, 17, 32, 20, 2, -31 },
  { 7941, 15, 38, 17, 1, -37 },
  { 8013, 21, 31, 27, 3, -30 },
  { 8095, 23, 30, 23, 0, -30 },
  { 8182, 36, 30, 36, 0, -30 },
  { 8317, 22, 30, 23, 0, -30 },
  { 8400, 23, 43, 23, 0, -30 },
  { 8524, 17, 30, 19, 1, -30 },
  { 8588, 17, 49, 20, 1, -40 },
  { 8693, 6, 56, 24, 9, -43 },
  { 8735, 16, 49, 20, 2, -40 },
  { 8833, 23, 9, 25, 1, -24 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD56PT7B_H_
