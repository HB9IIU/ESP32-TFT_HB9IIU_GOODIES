#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x0C, 0x7B, 0xFF, 0xFF, 0x78, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7B, 0xE3, 0xCF, 0x1E,
  0x70, 0xF3, 0x87, 0x9C, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x1E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE3, 0xC0, 0x38, 0xF0, 0x0E, 0x38, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C,
  0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x07, 0xFC, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBE,
  0xC2, 0xF3, 0x03, 0xCC, 0x0F, 0x30, 0x3E, 0xC0, 0xFF, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x37, 0xC0, 0xCF, 0x03, 0x3C,
  0x0C, 0xF8, 0x33, 0xF0, 0xDF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x07, 0xF0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0xF0,
  0x0E, 0x00, 0xFF, 0x03, 0xC0, 0x3D, 0xE0, 0x78, 0x07, 0x1C, 0x0E, 0x00,
  0xE3, 0xC3, 0xC0, 0x3C, 0x78, 0x70, 0x07, 0x8F, 0x0E, 0x00, 0xF1, 0xE3,
  0xC0, 0x1E, 0x3C, 0x70, 0x03, 0xC7, 0x9E, 0x00, 0x78, 0xF3, 0xC2, 0x07,
  0x1E, 0x71, 0xF0, 0xE3, 0x9E, 0x7F, 0x1E, 0xF3, 0x9F, 0xF1, 0xFE, 0x73,
  0x8E, 0x3F, 0x9E, 0x71, 0xC1, 0xE3, 0x9E, 0x3C, 0x00, 0xF3, 0xC7, 0x80,
  0x1E, 0x78, 0xF0, 0x03, 0x8F, 0x1E, 0x00, 0xF1, 0xE3, 0xC0, 0x1C, 0x3C,
  0x78, 0x03, 0x83, 0x8F, 0x00, 0xF0, 0x71, 0xC0, 0x1C, 0x0F, 0x38, 0x07,
  0x81, 0xFF, 0x00, 0xF0, 0x1F, 0xC0, 0x1C, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC1, 0xE3, 0xFE,
  0x3E, 0x7D, 0xE3, 0xE7, 0xDF, 0x3E, 0xF8, 0xFB, 0xCF, 0x87, 0xFC, 0xF8,
  0x7F, 0xCF, 0x83, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x87,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xBE, 0x1F, 0xE1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0x73, 0x9C, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C,
  0x00, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x02, 0x1C, 0x27, 0xB9, 0xDF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF3, 0xC7,
  0xC7, 0xC3, 0x86, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x7C, 0xF1, 0xE7,
  0xCF, 0x9E, 0x3C, 0x79, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xEF,
  0xFF, 0xF9, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xE7, 0xC7, 0x87, 0x9F, 0x0F, 0xBE, 0x1F, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDF,
  0x0F, 0xBE, 0x1F, 0x3C, 0x7C, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0x7E,
  0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0x7F, 0xEF,
  0x79, 0xE6, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF,
  0xE7, 0x87, 0xC6, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xC4, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0xFF,
  0x81, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0x7C, 0x07, 0x7C, 0x0E, 0x7C, 0x0E, 0x7C, 0x1C, 0x7C, 0x1C, 0x7C, 0x3C,
  0x7C, 0x38, 0x7C, 0x78, 0x7C, 0x70, 0x7C, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF9, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x90, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0x00, 0xFC, 0x03, 0xFC,
  0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x79, 0xF0, 0x7B, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFC, 0x3E, 0xFC, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E,
  0x3C, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8,
  0x3E, 0xFC, 0x7C, 0x7E, 0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xC7, 0xCF,
  0x87, 0x9E, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x83, 0xEF, 0x07, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xBC,
  0x3C, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x00, 0x7B, 0xEF, 0xFF,
  0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF,
  0xFD, 0xE0, 0x3C, 0x79, 0xFB, 0xF7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xE3, 0xC7, 0x9F, 0x3C, 0x78,
  0xF3, 0xC0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF7, 0x0F, 0xA0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x3F, 0x8E, 0x70, 0xFF, 0x8F,
  0x70, 0xFF, 0x8F, 0xF1, 0xE3, 0x87, 0xF1, 0xC3, 0x87, 0xE1, 0xC3, 0x87,
  0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC7, 0x87, 0xE3, 0xC7, 0x87,
  0xE3, 0xC7, 0x8F, 0xE3, 0xC7, 0x8F, 0xE1, 0xC7, 0x8E, 0xE1, 0xFF, 0xDE,
  0xF1, 0xFD, 0xFC, 0xF0, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7B, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF9, 0xF0,
  0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0,
  0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0xFE, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFE, 0x3F, 0x0E, 0x3E, 0x02, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x02, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0x83, 0xF3, 0xC0, 0xFD, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x07,
  0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xF7,
  0x80, 0xFB, 0xC0, 0xFD, 0xE0, 0x7C, 0xF0, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x83, 0x8F, 0xC0, 0x27, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x7D, 0xF8, 0x1F, 0x3F, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0xCF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0xFF, 0xFF, 0xDF, 0xCF, 0xC0,
  0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0xCF, 0x07, 0xC7, 0x83,
  0xE3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF1, 0xF0, 0x79, 0xF8, 0x3C, 0xF8, 0x1E,
  0xFC, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7E, 0xF8, 0x3E, 0x7C, 0x1E, 0x1E, 0x0F, 0x0F, 0x87, 0x87, 0xC3, 0xC1,
  0xF1, 0xE0, 0xF8, 0xF0, 0x3E, 0x78, 0x1F, 0x3C, 0x07, 0xDE, 0x03, 0xEF,
  0x01, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0x00,
  0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0x83,
  0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0x8F, 0xF1, 0xE7,
  0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFD, 0xE0, 0xFF,
  0x7C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0xF8, 0xFF, 0x1E, 0x3F, 0xC7,
  0xCF, 0xF0, 0xF3, 0xFC, 0x3E, 0xFF, 0x07, 0xBF, 0xC1, 0xEF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF,
  0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF,
  0x3F, 0xDE, 0x0F, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x07, 0xDE, 0x0F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC3, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC,
  0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF3, 0xFC, 0xF0,
  0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0x07,
  0xE0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7F, 0x79, 0xF0, 0x27, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x01, 0xFF, 0x00, 0x3D,
  0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x07, 0x9F, 0x01, 0xF1,
  0xE0, 0x3E, 0x3C, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xEF,
  0x80, 0xF8, 0x07, 0xBE, 0x03, 0xE0, 0x3E, 0x78, 0x0F, 0xC0, 0xF9, 0xE0,
  0x3F, 0x03, 0xE7, 0x80, 0xFC, 0x0F, 0x1F, 0x07, 0xF0, 0x3C, 0x7C, 0x1F,
  0xC1, 0xF0, 0xF0, 0x77, 0x87, 0xC3, 0xC1, 0xDE, 0x1F, 0x0F, 0x0F, 0x78,
  0x78, 0x3E, 0x3D, 0xE1, 0xE0, 0xF8, 0xF3, 0x87, 0x81, 0xE3, 0xCF, 0x3E,
  0x07, 0x8E, 0x3C, 0xF8, 0x1E, 0x78, 0xF3, 0xE0, 0x7D, 0xE3, 0xCF, 0x01,
  0xF7, 0x87, 0x3C, 0x03, 0xDE, 0x1D, 0xF0, 0x0F, 0x70, 0x7F, 0xC0, 0x3D,
  0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xC0, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x7C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0x78, 0x3E,
  0x1F, 0x0F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xFE, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x0F, 0x87,
  0xC3, 0xE1, 0xE0, 0x78, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x00, 0xF3, 0xC0,
  0x3D, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xF0,
  0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x0F, 0x1F,
  0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x0F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x1F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFD, 0xF3, 0xFB, 0xFE,
  0xF7, 0xF9, 0xE7, 0xE3, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xFC, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0x7E, 0xFF,
  0xFC, 0xF3, 0xFC, 0xF1, 0xF0, 0x0F, 0xE1, 0xFF, 0x3F, 0xF7, 0xFF, 0x7C,
  0x2F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC1, 0x7E, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x1F, 0x1E, 0x7F, 0x3D, 0xFF, 0x7B, 0xFF,
  0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFD, 0xFB, 0xFB, 0xFF, 0xF3, 0xFD, 0xE3, 0xF3, 0xC0, 0x0F,
  0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x17, 0xE3, 0x8F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xC0, 0x00, 0x80, 0x7F, 0x0F, 0xF1, 0xFF, 0x1F, 0x21, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xE1, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x1F, 0x1E, 0x7F, 0xBD, 0xFF, 0x7B, 0xFF, 0xFF, 0xC7, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFD, 0xFF,
  0xFB, 0xFE, 0xF3, 0xFD, 0xE3, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7E, 0x01, 0xF3, 0x87, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x03,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xC0, 0x77, 0xFF,
  0xF7, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x1F, 0x1F, 0x1F, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xBF, 0xFE, 0xFE, 0xFC, 0x60, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF0, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFC, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0xF8,
  0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xF0, 0x7C, 0x79, 0xFC, 0xFF, 0x3D, 0xFF,
  0x7F, 0xDF, 0xFF, 0xFF, 0xEF, 0xC7, 0xF1, 0xF7, 0xE1, 0xF0, 0x7B, 0xE0,
  0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F,
  0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0,
  0x7C, 0xF1, 0xF1, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF, 0xC3, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF0, 0x79, 0xFB, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0xF1, 0xF0, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xFC,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1E, 0xFC,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9, 0xF0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x1E, 0x7F, 0xBD, 0xFF, 0x7B, 0xFF,
  0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFD, 0xFF, 0xFB, 0xFE, 0xF3, 0xFD, 0xE3, 0xF3, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF1, 0xFE, 0x7F, 0xDF, 0xFB, 0xFF, 0xFD,
  0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0xC3, 0xFF, 0x7F, 0xF7, 0xFE, 0xF8, 0x2F, 0x80, 0xF8, 0x0F, 0x80,
  0x7E, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xF8, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xFC, 0xFF, 0x1F, 0xC7, 0xF0, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3E, 0xF8, 0xFD, 0xFF, 0xFB, 0xFF, 0xF3, 0xFD, 0xE3, 0xF3, 0xC0,
  0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xCF, 0x81, 0xE7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xF8,
  0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xF7, 0x83, 0xF0, 0x79, 0xE0, 0xFC, 0x1E,
  0x7C, 0x3F, 0x07, 0x9F, 0x0F, 0xE3, 0xE3, 0xC7, 0xF8, 0xF0, 0xF1, 0xCE,
  0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x9C, 0xE3, 0xC3, 0xE7, 0x39, 0xF0, 0x7B,
  0xCF, 0x78, 0x1E, 0xF3, 0xDE, 0x07, 0xB8, 0x77, 0x81, 0xEE, 0x1D, 0xE0,
  0x3B, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78,
  0x1F, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3C,
  0x3C, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0x9E,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x80, 0xF7, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x0B, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x60, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFC,
  0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F,
  0xE0, 0xFC, 0x1F, 0x87, 0xF1, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xFE, 0x1F, 0x83,
  0xE0, 0x00, 0x3E, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE,
  0x80, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 29, 10, 2, -29 },
  { 23, 13, 11, 17, 2, -29 },
  { 41, 18, 29, 19, 1, -29 },
  { 107, 14, 32, 18, 2, -30 },
  { 163, 27, 29, 29, 1, -29 },
  { 261, 20, 29, 21, 1, -29 },
  { 334, 5, 11, 9, 2, -29 },
  { 341, 9, 35, 12, 2, -29 },
  { 381, 9, 35, 12, 1, -29 },
  { 421, 15, 15, 17, 1, -30 },
  { 450, 16, 19, 18, 1, -24 },
  { 488, 7, 10, 10, 1, -5 },
  { 497, 10, 4, 12, 1, -13 },
  { 502, 6, 6, 10, 2, -6 },
  { 507, 14, 29, 16, 1, -29 },
  { 558, 15, 29, 18, 1, -29 },
  { 613, 11, 29, 18, 2, -29 },
  { 653, 15, 29, 18, 1, -29 },
  { 708, 15, 29, 18, 1, -29 },
  { 763, 16, 29, 18, 1, -29 },
  { 821, 14, 29, 18, 2, -29 },
  { 872, 16, 29, 18, 1, -29 },
  { 930, 16, 29, 18, 1, -29 },
  { 988, 16, 29, 18, 1, -29 },
  { 1046, 15, 29, 18, 1, -29 },
  { 1101, 6, 22, 10, 2, -22 },
  { 1118, 7, 27, 10, 1, -22 },
  { 1142, 16, 19, 18, 1, -24 },
  { 1180, 16, 12, 18, 1, -20 },
  { 1204, 16, 19, 18, 1, -24 },
  { 1242, 13, 29, 14, 0, -29 },
  { 1290, 24, 32, 28, 2, -29 },
  { 1386, 20, 29, 20, 0, -29 },
  { 1459, 16, 29, 20, 3, -29 },
  { 1517, 16, 29, 19, 2, -29 },
  { 1575, 17, 29, 22, 3, -29 },
  { 1637, 12, 29, 17, 3, -29 },
  { 1681, 12, 29, 16, 3, -29 },
  { 1725, 18, 29, 22, 2, -29 },
  { 1791, 17, 29, 23, 3, -29 },
  { 1853, 10, 29, 12, 1, -29 },
  { 1890, 9, 37, 10, -2, -29 },
  { 1932, 17, 29, 20, 3, -29 },
  { 1994, 12, 29, 16, 3, -29 },
  { 2038, 24, 29, 30, 3, -29 },
  { 2125, 18, 29, 24, 3, -29 },
  { 2191, 19, 29, 23, 2, -29 },
  { 2260, 15, 29, 19, 3, -29 },
  { 2315, 19, 36, 23, 2, -29 },
  { 2401, 16, 29, 20, 3, -29 },
  { 2459, 14, 29, 17, 1, -29 },
  { 2510, 15, 29, 16, 1, -29 },
  { 2565, 16, 29, 22, 3, -29 },
  { 2623, 19, 29, 19, 0, -29 },
  { 2692, 30, 29, 29, 0, -29 },
  { 2801, 18, 29, 18, 0, -29 },
  { 2867, 18, 29, 18, 0, -29 },
  { 2933, 14, 29, 16, 1, -29 },
  { 2984, 8, 35, 12, 3, -29 },
  { 3019, 15, 29, 16, 0, -29 },
  { 3074, 9, 35, 12, 1, -29 },
  { 3114, 18, 17, 20, 1, -29 },
  { 3153, 17, 3, 17, 0, 3 },
  { 3160, 8, 7, 12, 2, -31 },
  { 3167, 15, 22, 18, 1, -22 },
  { 3209, 16, 30, 19, 2, -30 },
  { 3269, 12, 22, 15, 2, -22 },
  { 3302, 15, 30, 19, 2, -30 },
  { 3359, 14, 22, 18, 2, -22 },
  { 3398, 12, 31, 11, 0, -31 },
  { 3445, 15, 32, 19, 2, -22 },
  { 3505, 15, 30, 19, 2, -30 },
  { 3562, 5, 30, 9, 2, -30 },
  { 3581, 8, 40, 9, -1, -30 },
  { 3621, 16, 30, 18, 2, -30 },
  { 3681, 5, 30, 9, 2, -30 },
  { 3700, 25, 22, 29, 2, -22 },
  { 3769, 15, 22, 19, 2, -22 },
  { 3811, 15, 22, 19, 2, -22 },
  { 3853, 16, 32, 19, 2, -22 },
  { 3917, 15, 32, 19, 2, -22 },
  { 3977, 11, 22, 13, 2, -22 },
  { 4008, 12, 22, 14, 1, -22 },
  { 4041, 10, 26, 12, 1, -26 },
  { 4074, 15, 22, 19, 2, -22 },
  { 4116, 17, 22, 17, 0, -22 },
  { 4163, 26, 22, 26, 0, -22 },
  { 4235, 16, 22, 16, 0, -22 },
  { 4279, 17, 32, 17, 0, -22 },
  { 4347, 12, 22, 14, 1, -22 },
  { 4380, 12, 35, 14, 1, -29 },
  { 4433, 4, 40, 17, 7, -31 },
  { 4453, 11, 35, 14, 2, -29 },
  { 4502, 16, 6, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD40PT7B_H_
