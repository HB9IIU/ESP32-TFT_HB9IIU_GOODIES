#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF,
  0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x08, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x7F, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB,
  0xE1, 0xF7, 0x83, 0xE0, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7E, 0xDF, 0x7E, 0x61, 0xBE, 0x30, 0x1F, 0x18, 0x0F,
  0x8C, 0x07, 0xC6, 0x03, 0xF3, 0x00, 0xFD, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0x7E, 0x01,
  0x9F, 0x00, 0xCF, 0x80, 0x63, 0xC0, 0x33, 0xF0, 0x19, 0xFE, 0x0D, 0xFF,
  0xF7, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xF8, 0x03, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x7F, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x78, 0x03, 0xFF, 0x01, 0xE0,
  0x0F, 0x9E, 0x03, 0xC0, 0x1E, 0x3C, 0x0F, 0x80, 0x3C, 0x3C, 0x1E, 0x00,
  0x78, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x01, 0xE1, 0xE1, 0xE0, 0x03,
  0xC3, 0xC3, 0xC0, 0x07, 0x87, 0x8F, 0x00, 0x0F, 0x0F, 0x1E, 0x00, 0x1E,
  0x1E, 0x7C, 0x38, 0x3C, 0x3C, 0xF1, 0xFC, 0x78, 0xF1, 0xE7, 0xFC, 0xF9,
  0xE7, 0x8F, 0xF8, 0xFF, 0xCF, 0x3E, 0xF9, 0xFF, 0x1E, 0x78, 0xF1, 0xFE,
  0x78, 0xF1, 0xE1, 0xF0, 0xF1, 0xE3, 0xE0, 0x03, 0xE7, 0xC7, 0xC0, 0x07,
  0x8F, 0x8F, 0x80, 0x0F, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0x78,
  0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0xF8, 0x03, 0xC0, 0xF1, 0xF0, 0x07, 0x81,
  0xE3, 0xC0, 0x0F, 0x03, 0xC7, 0x80, 0x3C, 0x07, 0xDF, 0x00, 0x78, 0x07,
  0xFC, 0x01, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xFC, 0x7C, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7E, 0xFC, 0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8,
  0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xF0,
  0x7F, 0xBF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0x7E,
  0x0F, 0xF8, 0x7F, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x78, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x78, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xCF, 0x83, 0xF3, 0xF0, 0xF8, 0x7C, 0x0E, 0x1C, 0x01, 0x02, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF,
  0xBE, 0x7C, 0xF9, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x23, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xF3, 0xFB, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7E,
  0xFF, 0xF3, 0xF3, 0x8F, 0xC4, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x07, 0xE3, 0x00,
  0xF8, 0x40, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xF3, 0x81, 0xF8, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x03, 0xFF, 0x87, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xDF,
  0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x03, 0xCF, 0x80, 0x79, 0xF0, 0x1E, 0x3E,
  0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFC,
  0x03, 0xF7, 0xC7, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1,
  0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x86, 0x07, 0xCF, 0xE3, 0xEF, 0xF9, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0x83,
  0xF7, 0xE1, 0xFB, 0xF9, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0xFC,
  0x1F, 0x9F, 0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x3F, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x3F, 0x7E, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xDF, 0x83, 0xF1,
  0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xE0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xF7, 0xC1, 0xF1, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x08, 0x3F, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8,
  0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0xF9, 0xFB,
  0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xEF, 0x9F, 0x3C,
  0x78, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x7E, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE1, 0xE0,
  0x3F, 0x0F, 0x8F, 0x07, 0xFE, 0x3C, 0xF0, 0x7F, 0xF1, 0xE7, 0x87, 0xC7,
  0x8F, 0x3C, 0x3C, 0x3C, 0x3F, 0xE3, 0xE3, 0xE1, 0xFE, 0x1E, 0x1F, 0x0F,
  0xF0, 0xF0, 0xF8, 0x7F, 0x87, 0x87, 0xC3, 0xFC, 0x3C, 0x3C, 0x1F, 0xE1,
  0xE1, 0xE0, 0xFF, 0x0F, 0x0F, 0x07, 0x78, 0x78, 0x78, 0x7B, 0xC3, 0xC3,
  0xC3, 0xDE, 0x1E, 0x1E, 0x1E, 0xF0, 0xF9, 0xF9, 0xE7, 0xC3, 0xFD, 0xFF,
  0x1E, 0x1F, 0xEF, 0xF0, 0xF0, 0x7E, 0x3F, 0x07, 0xC0, 0xC0, 0x70, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x02, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7E, 0x01, 0xF0, 0xFC,
  0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0xFF, 0xC0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x3F,
  0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F,
  0x7E, 0x03, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E, 0x0F, 0xEF, 0xC0, 0xFD,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x83, 0x8F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x04, 0x3F, 0xEF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xF0, 0x18, 0xFE, 0x00, 0x47, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x3E,
  0x7E, 0x01, 0xF3, 0xF8, 0x0F, 0x8F, 0xF1, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x1F, 0xA7, 0xF7, 0xFE, 0xFF, 0x9F, 0xF3, 0xF8, 0x3C, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7,
  0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xDE, 0x00, 0xF7, 0xFE, 0xF8, 0x07, 0xBF, 0xF7, 0xC0, 0x7D,
  0xFF, 0x9E, 0x03, 0xEF, 0xFC, 0xF0, 0x1E, 0x7F, 0xE7, 0xC0, 0xF3, 0xFF,
  0x3E, 0x0F, 0x9F, 0xF8, 0xF0, 0x7C, 0xFF, 0xC7, 0x83, 0xC7, 0xFE, 0x3E,
  0x3E, 0x3F, 0xF1, 0xF1, 0xF1, 0xFF, 0x87, 0x8F, 0x0F, 0xFC, 0x3C, 0x78,
  0x7F, 0xE1, 0xF7, 0xC3, 0xFF, 0x0F, 0xBE, 0x1F, 0xF8, 0x3D, 0xE0, 0xFF,
  0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0x81,
  0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x01, 0xF0,
  0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xBE, 0x07, 0xFE, 0xF8, 0x1F, 0xF9, 0xF0, 0x7F, 0xE7, 0xC1, 0xFF,
  0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF1, 0xFF, 0x87,
  0xC7, 0xFE, 0x0F, 0x9F, 0xF8, 0x3E, 0x7F, 0xE0, 0x7D, 0xFF, 0x81, 0xF7,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00,
  0x1F, 0xBE, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xFD, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xC1,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC, 0x7F, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF8,
  0x3F, 0x83, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xC7, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xC7, 0xC0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFE, 0x1E, 0xFC, 0x02, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xFC,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x01, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xFF, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x7E, 0x01, 0xF8,
  0x03, 0xE7, 0xC0, 0x3F, 0x00, 0x7C, 0xF8, 0x07, 0xF0, 0x1F, 0x9F, 0x00,
  0xFE, 0x03, 0xF3, 0xE0, 0x1F, 0xC0, 0x7C, 0x7E, 0x07, 0xF8, 0x0F, 0x87,
  0xC0, 0xFF, 0x01, 0xF0, 0xF8, 0x1E, 0xF0, 0x7E, 0x1F, 0x03, 0xDE, 0x0F,
  0xC3, 0xE0, 0x7B, 0xC1, 0xF0, 0x7E, 0x1F, 0x78, 0x3E, 0x07, 0xC3, 0xCF,
  0x07, 0xC0, 0xF8, 0x79, 0xF0, 0xF8, 0x1F, 0x0F, 0x3E, 0x3F, 0x03, 0xE3,
  0xE3, 0xC7, 0xC0, 0x7C, 0x7C, 0x78, 0xF8, 0x07, 0xCF, 0x8F, 0x1F, 0x00,
  0xF9, 0xE1, 0xF3, 0xE0, 0x1F, 0x3C, 0x3E, 0xFC, 0x03, 0xE7, 0x83, 0xDF,
  0x80, 0x7D, 0xF0, 0x7B, 0xE0, 0x07, 0xBE, 0x0F, 0x7C, 0x00, 0xFF, 0x81,
  0xEF, 0x80, 0x1F, 0xF0, 0x3D, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0,
  0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC,
  0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x78, 0x03, 0xE3, 0xE0, 0x1F,
  0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x87, 0xC0, 0x7C,
  0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF3, 0xF8, 0x40, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFD, 0xFC,
  0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7,
  0xC1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xEF, 0x3F, 0xE7, 0x8F, 0xE3,
  0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x8F, 0x83, 0xE7, 0xF8, 0xFB, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8,
  0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF8,
  0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0x3F, 0xE3, 0xC7, 0xF0, 0x03, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0xC0, 0x9F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x2F, 0xE1, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x7C,
  0x7F, 0x9F, 0x3F, 0xF7, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xF8, 0x7F, 0x7C,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0x7C, 0x3F, 0x8F, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3D, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x13, 0xF8, 0x18, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xC3, 0xC7, 0xF9, 0xF3, 0xFF, 0x7C, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0x87, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF,
  0x8F, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xF7, 0xC3, 0xF1, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF9, 0x00, 0x7E,
  0x7C, 0x7F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x1F,
  0x7F, 0xCF, 0xBF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00,
  0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x1F, 0xDF, 0xFF, 0xDF, 0xEF, 0xE7, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0xF8, 0x1F,
  0xBE, 0x0F, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F,
  0x9F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xBE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E,
  0x3E, 0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xEF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF8, 0x1F, 0x8F, 0x3F, 0xE3, 0xFC, 0xF3, 0xFE,
  0x7F, 0xEF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x3F,
  0xFC, 0x1F, 0xC3, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81,
  0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81,
  0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8,
  0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF,
  0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF0, 0xF8,
  0x79, 0xFF, 0x3C, 0xFF, 0xDE, 0xFF, 0xEF, 0xFF, 0xF7, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x7D, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xF0, 0xF8, 0x3C, 0x7F, 0x8F, 0x3F, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x8F, 0xEF, 0xFF, 0xF3, 0xEF, 0xFC, 0xFB,
  0xFE, 0x3E, 0x7F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xC7, 0xF9, 0xF3, 0xFF, 0x7C,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x87, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x8F, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F,
  0xF7, 0xC3, 0xF1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0xF8,
  0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0x8F, 0x81, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xDE,
  0x1F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x11, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xFD, 0xFF, 0xFE, 0xFF, 0xDF, 0x3F,
  0xE7, 0x8F, 0xE3, 0xC0, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE,
  0x03, 0xF7, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x1E,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F,
  0x01, 0xF7, 0xC0, 0xFE, 0x07, 0xDF, 0x03, 0xF8, 0x1F, 0x7C, 0x0F, 0xE0,
  0xF9, 0xF8, 0x7F, 0x83, 0xE3, 0xE1, 0xEE, 0x0F, 0x8F, 0x87, 0xBC, 0x3E,
  0x3E, 0x1E, 0xF0, 0xF8, 0xF8, 0x7B, 0xC7, 0xC3, 0xF3, 0xCF, 0x1F, 0x07,
  0xCF, 0x3C, 0x7C, 0x1F, 0x3C, 0x71, 0xF0, 0x7C, 0xF1, 0xEF, 0x81, 0xF3,
  0xC7, 0xBE, 0x03, 0xCE, 0x1E, 0xF8, 0x0F, 0xF8, 0x7B, 0xE0, 0x3F, 0xE1,
  0xEF, 0x80, 0xFF, 0x83, 0xBC, 0x03, 0xFE, 0x0E, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xCF, 0xC1,
  0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xEF,
  0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F,
  0x0F, 0x83, 0xE3, 0xF0, 0x7E, 0x7C, 0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0,
  0x07, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x5F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0xE0, 0xFE,
  0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x01,
  0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFC, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x2F, 0xFC, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 34, 12, 3, -34 },
  { 27, 15, 13, 20, 2, -34 },
  { 52, 21, 34, 23, 1, -34 },
  { 142, 17, 39, 21, 2, -36 },
  { 225, 31, 34, 34, 2, -34 },
  { 357, 24, 34, 25, 1, -34 },
  { 459, 6, 13, 11, 2, -34 },
  { 469, 11, 41, 14, 2, -34 },
  { 526, 11, 41, 14, 1, -34 },
  { 583, 18, 18, 20, 1, -36 },
  { 624, 19, 23, 21, 1, -28 },
  { 679, 7, 11, 11, 2, -5 },
  { 689, 12, 5, 14, 1, -15 },
  { 697, 6, 7, 11, 3, -7 },
  { 703, 17, 34, 18, 1, -34 },
  { 776, 17, 34, 21, 2, -34 },
  { 849, 14, 34, 21, 2, -34 },
  { 909, 18, 34, 21, 1, -34 },
  { 986, 17, 34, 21, 2, -34 },
  { 1059, 19, 34, 21, 1, -34 },
  { 1140, 17, 34, 21, 2, -34 },
  { 1213, 17, 34, 21, 2, -34 },
  { 1286, 19, 34, 21, 1, -34 },
  { 1367, 19, 34, 21, 1, -34 },
  { 1448, 18, 34, 21, 1, -34 },
  { 1525, 6, 26, 12, 3, -26 },
  { 1545, 7, 32, 12, 2, -26 },
  { 1573, 19, 22, 21, 1, -28 },
  { 1626, 19, 13, 21, 1, -23 },
  { 1657, 19, 22, 21, 1, -28 },
  { 1710, 16, 34, 16, 0, -34 },
  { 1778, 29, 38, 33, 2, -34 },
  { 1916, 23, 34, 23, 0, -34 },
  { 2014, 19, 34, 24, 3, -34 },
  { 2095, 19, 34, 22, 2, -34 },
  { 2176, 20, 34, 26, 3, -34 },
  { 2261, 15, 34, 20, 3, -34 },
  { 2325, 15, 34, 19, 3, -34 },
  { 2389, 21, 34, 26, 2, -34 },
  { 2479, 20, 34, 27, 3, -34 },
  { 2564, 12, 34, 14, 1, -34 },
  { 2615, 11, 44, 12, -2, -34 },
  { 2676, 20, 34, 23, 3, -34 },
  { 2761, 15, 34, 18, 3, -34 },
  { 2825, 29, 34, 35, 3, -34 },
  { 2949, 22, 34, 29, 3, -34 },
  { 3043, 23, 34, 27, 2, -34 },
  { 3141, 18, 34, 22, 3, -34 },
  { 3218, 23, 42, 27, 2, -34 },
  { 3339, 20, 34, 23, 3, -34 },
  { 3424, 16, 34, 20, 2, -34 },
  { 3492, 18, 34, 19, 1, -34 },
  { 3569, 20, 34, 26, 3, -34 },
  { 3654, 23, 34, 23, 0, -34 },
  { 3752, 35, 34, 35, 0, -34 },
  { 3901, 21, 34, 21, 0, -34 },
  { 3991, 21, 34, 21, 0, -34 },
  { 4081, 17, 34, 18, 1, -34 },
  { 4154, 10, 42, 15, 3, -34 },
  { 4207, 17, 34, 18, 1, -34 },
  { 4280, 11, 42, 15, 1, -34 },
  { 4338, 21, 20, 23, 1, -34 },
  { 4391, 20, 3, 20, 0, 4 },
  { 4399, 10, 8, 14, 2, -36 },
  { 4409, 17, 26, 21, 1, -26 },
  { 4465, 18, 36, 23, 3, -36 },
  { 4546, 15, 26, 18, 2, -26 },
  { 4595, 18, 36, 23, 2, -36 },
  { 4676, 17, 26, 21, 2, -26 },
  { 4732, 15, 36, 13, 0, -36 },
  { 4800, 18, 37, 23, 2, -26 },
  { 4884, 17, 36, 23, 3, -36 },
  { 4961, 5, 35, 11, 3, -35 },
  { 4983, 9, 46, 11, -1, -35 },
  { 5035, 18, 36, 21, 3, -36 },
  { 5116, 5, 36, 11, 3, -36 },
  { 5139, 28, 26, 34, 3, -26 },
  { 5230, 17, 26, 23, 3, -26 },
  { 5286, 18, 26, 22, 2, -26 },
  { 5345, 18, 37, 23, 3, -26 },
  { 5429, 18, 37, 23, 2, -26 },
  { 5513, 12, 26, 16, 3, -26 },
  { 5552, 15, 26, 17, 1, -26 },
  { 5601, 12, 31, 14, 1, -31 },
  { 5648, 17, 26, 23, 3, -26 },
  { 5704, 19, 26, 20, 0, -26 },
  { 5766, 30, 26, 31, 0, -26 },
  { 5864, 19, 26, 19, 0, -26 },
  { 5926, 19, 37, 20, 0, -26 },
  { 6014, 14, 26, 16, 1, -26 },
  { 6060, 14, 42, 17, 1, -34 },
  { 6134, 4, 47, 20, 8, -36 },
  { 6158, 14, 42, 17, 2, -34 },
  { 6232, 19, 7, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD47PT7B_H_
