#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFD, 0xE0, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00,
  0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x0F, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x0F, 0xFF,
  0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0x7C, 0xC3, 0x3F, 0x30, 0x0F,
  0x8C, 0x03, 0xE3, 0x00, 0xF8, 0xC0, 0x3F, 0x30, 0x07, 0xEC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0D, 0xF8, 0x03, 0x3E, 0x00, 0xC7, 0xC0, 0x31, 0xF0,
  0x0C, 0x7E, 0x03, 0x3E, 0xE0, 0xDF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0xFF, 0x00, 0x78, 0x03, 0xFF, 0x00, 0xF0, 0x07, 0x9E, 0x03, 0xE0,
  0x1E, 0x3E, 0x07, 0x80, 0x3C, 0x3C, 0x0F, 0x00, 0x78, 0x78, 0x3C, 0x00,
  0xF0, 0xF0, 0x78, 0x01, 0xE1, 0xE0, 0xF0, 0x03, 0xC3, 0xC3, 0xC0, 0x07,
  0x87, 0x87, 0x80, 0x0F, 0x0F, 0x1F, 0x00, 0x1E, 0x1E, 0x3C, 0x00, 0x3C,
  0x3C, 0x78, 0x7C, 0x78, 0x79, 0xE3, 0xFC, 0xF1, 0xF3, 0xCF, 0xFC, 0xF3,
  0xC7, 0x9F, 0xF9, 0xFF, 0x9E, 0x3C, 0xF9, 0xFE, 0x3C, 0xF0, 0xF1, 0xF8,
  0xF9, 0xE1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC0, 0x03, 0xC7, 0x87, 0x80, 0x0F,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x3C, 0x00, 0xF0,
  0x78, 0x78, 0x01, 0xE0, 0xF0, 0xF0, 0x07, 0xC1, 0xE1, 0xE0, 0x0F, 0x03,
  0xC3, 0xC0, 0x1E, 0x03, 0xCF, 0x80, 0x78, 0x07, 0xFE, 0x00, 0xF0, 0x0F,
  0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x3E, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x3F, 0x7C, 0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xFC,
  0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0,
  0x7E, 0x0F, 0xF0, 0x7F, 0xBF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFE, 0x7E, 0x0F, 0xF8, 0x3F, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x18, 0x78, 0x27, 0xDE, 0x79, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xEF, 0x81,
  0xF3, 0xF0, 0xFC, 0x7E, 0x1E, 0x1E, 0x01, 0x83, 0x00, 0x20, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0xF9,
  0xF3, 0xE7, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x33, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xCF, 0xC7, 0xE1,
  0xF1, 0xF0, 0x7E, 0x7C, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xF9, 0xF0, 0x7E,
  0x7C, 0x1F, 0x9F, 0x87, 0xC3, 0xF7, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07,
  0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0xFE, 0xFD, 0xF3, 0xF3, 0x8F, 0xC4,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xE1, 0xF9, 0xC0, 0x7E, 0x40, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1E, 0x0F, 0xC6, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0xA0, 0x0F, 0xEF, 0x0F, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3D, 0xF0, 0x03, 0xDF, 0x00, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0xF1,
  0xF0, 0x0F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3C,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0C, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0xC0, 0x3F, 0xBE, 0x3F, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x3E, 0x0F, 0x9F, 0xE3, 0xEF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xE1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C,
  0x0F, 0x9F, 0x87, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0xC0, 0xF9,
  0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xF0, 0xF8, 0x3F, 0x3F, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xF1, 0xF8, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xE0, 0x3F, 0x7C, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF,
  0xC3, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7E, 0x3F, 0x1F, 0x83, 0xE3, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0xFB,
  0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB,
  0xE0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC3, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1,
  0xFF, 0x7C, 0x1F, 0xEF, 0x81, 0xF1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x08,
  0x3F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x3C, 0xFD, 0xFB, 0xF7,
  0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0x78,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF8,
  0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x78, 0x7F, 0x20, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xF1, 0xF0, 0x0C, 0x07, 0x8F, 0x03, 0xFE, 0x3C, 0xF8, 0x3F,
  0xF0, 0xF7, 0x83, 0xFF, 0x87, 0xBC, 0x3E, 0x3C, 0x3D, 0xE1, 0xE1, 0xE1,
  0xFF, 0x1F, 0x0F, 0x0F, 0xF0, 0xF0, 0x78, 0x7F, 0x87, 0x83, 0xC3, 0xFC,
  0x3C, 0x1E, 0x1F, 0xE1, 0xE0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8, 0x78,
  0x7C, 0x3F, 0xC3, 0xC3, 0xE1, 0xFE, 0x1E, 0x1F, 0x0F, 0xF0, 0xF8, 0xF8,
  0xF7, 0xC3, 0xCF, 0xC7, 0x9E, 0x1F, 0xF7, 0xFC, 0xF0, 0x7F, 0x3F, 0xC7,
  0x81, 0xF0, 0xFC, 0x3E, 0x02, 0x01, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x03, 0xF0, 0x03,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC7, 0xFD, 0xF8, 0x1F,
  0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xF1, 0xFF, 0x7E, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xC3, 0x87, 0xE0, 0x11,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x0F, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xC1, 0xE1, 0xFC, 0x01, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF1, 0xFF, 0x3F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE7,
  0xF7, 0xFE, 0xFF, 0x9F, 0xF3, 0xFC, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x3F,
  0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0xF0, 0x03, 0xDF,
  0xFB, 0xC0, 0x0F, 0x7F, 0xEF, 0x80, 0x7D, 0xFF, 0xBE, 0x01, 0xFF, 0xFF,
  0x78, 0x07, 0xBF, 0xFD, 0xF0, 0x3E, 0xFF, 0xF7, 0xC0, 0xFB, 0xFF, 0xDF,
  0x03, 0xCF, 0xFF, 0x3C, 0x0F, 0x3F, 0xFC, 0xF8, 0x7C, 0xFF, 0xF3, 0xE1,
  0xF3, 0xFF, 0xCF, 0x87, 0x8F, 0xFF, 0x1E, 0x1E, 0x3F, 0xFC, 0x7C, 0xF8,
  0xFF, 0xF1, 0xF3, 0xE3, 0xFF, 0xC7, 0xCF, 0x0F, 0xFF, 0x0F, 0x7C, 0x3F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF,
  0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC0,
  0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xF7, 0xC0, 0x7F, 0xEF, 0xC0, 0xFF, 0xCF, 0x81,
  0xFF, 0xDF, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0x3E, 0x0F, 0xFE, 0x7E, 0x1F,
  0xFC, 0x7C, 0x3F, 0xF8, 0xFC, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1, 0xF1, 0xFF,
  0xC1, 0xF3, 0xFF, 0x83, 0xE7, 0xFF, 0x07, 0xEF, 0xFE, 0x07, 0xDF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7E, 0xFC, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC7, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFE, 0x06, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xFD, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0,
  0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7E, 0x03,
  0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x3E, 0xFC, 0x01, 0xF8, 0x03, 0xEF,
  0xC0, 0x1F, 0x80, 0x7E, 0x7C, 0x03, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x80,
  0x7C, 0x7C, 0x03, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0xC0, 0x7C, 0x7E, 0x03,
  0xFC, 0x0F, 0xC3, 0xE0, 0x7B, 0xC0, 0xFC, 0x3E, 0x07, 0xBC, 0x0F, 0x83,
  0xE0, 0x7B, 0xC0, 0xF8, 0x3F, 0x07, 0xBE, 0x0F, 0x81, 0xF0, 0xFB, 0xE1,
  0xF8, 0x1F, 0x0F, 0x9E, 0x1F, 0x81, 0xF0, 0xF9, 0xE1, 0xF0, 0x1F, 0x0F,
  0x1E, 0x1F, 0x01, 0xF8, 0xF1, 0xF1, 0xF0, 0x1F, 0x9F, 0x1F, 0x3F, 0x00,
  0xF9, 0xF0, 0xF3, 0xF0, 0x0F, 0x9F, 0x0F, 0x3E, 0x00, 0xF9, 0xE0, 0xF3,
  0xE0, 0x0F, 0x9E, 0x0F, 0xBE, 0x00, 0x79, 0xE0, 0xFB, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x03, 0xF9, 0xF0, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0xCF,
  0x80, 0x7C, 0x7E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F,
  0x81, 0xF0, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE3,
  0xE0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x87,
  0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7D, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8,
  0x78, 0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x60, 0x01, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0x07, 0xE0, 0x80, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x03,
  0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x07, 0xF7, 0xE3, 0xFD,
  0xFF, 0xFF, 0x3F, 0xF7, 0xCF, 0xF9, 0xF1, 0xFC, 0x3C, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x04, 0x03, 0xE3, 0xF0, 0x7D,
  0xFF, 0x0F, 0xBF, 0xF1, 0xFF, 0xFF, 0x3F, 0xC7, 0xE7, 0xF0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x83, 0xF7, 0xF8,
  0xFC, 0xFF, 0xFF, 0x9F, 0x7F, 0xE3, 0xEF, 0xF8, 0x78, 0x7E, 0x00, 0x00,
  0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCF, 0xE1, 0x9F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x5F, 0xC3, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x20, 0xFC, 0x3F, 0x9F, 0x8F, 0xFB, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF,
  0xC7, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F,
  0xCF, 0x87, 0xF1, 0xF0, 0x00, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x27, 0xF0, 0x30, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC1, 0xF8, 0x83, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x7C, 0x7F, 0xCF, 0x9F, 0xFD,
  0xF3, 0xFF, 0xFE, 0xFE, 0x3F, 0xDF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0xDF, 0xCF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFE, 0xFC, 0x3F, 0x9F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x40, 0x0F, 0xCF, 0x07, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x60, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x18, 0x3E, 0x7F, 0x1F,
  0x7F, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF0, 0x7B, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x00,
  0x0F, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x07, 0x83, 0xE0, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE9, 0xFB, 0xFE, 0xFF, 0x3F, 0xCF, 0xE0, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x7C, 0x07,
  0xCF, 0x81, 0xF9, 0xF0, 0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C,
  0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xDF, 0x83, 0xF1, 0xF0,
  0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xFC,
  0xF8, 0x1F, 0x9F, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x02,
  0x07, 0x8F, 0xE0, 0xFE, 0x3C, 0xFF, 0x8F, 0xF9, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0xF1, 0xFB, 0xF0, 0x7F, 0x07, 0xFF, 0x83,
  0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F,
  0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0,
  0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8,
  0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F,
  0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3E, 0x00,
  0x20, 0x78, 0xFE, 0x3C, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F,
  0x83, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x7E, 0x03, 0xE7, 0xC0, 0xFC, 0xFC,
  0x1F, 0x9F, 0xC7, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0x20, 0x1E, 0x3F, 0x83, 0xEF, 0xF8, 0x7D, 0xFF, 0x8F,
  0xFF, 0xF9, 0xFE, 0x3F, 0x3F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x1F, 0xBF, 0xC7, 0xE7, 0xFF, 0xFC, 0xFB,
  0xFF, 0x1F, 0x3F, 0xC3, 0xE3, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0x00, 0x01, 0xFC, 0x7C, 0x7F, 0xCF, 0x9F, 0xFD, 0xF3, 0xFF, 0xFE, 0xFE,
  0x3F, 0xDF, 0x83, 0xFB, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFE, 0xFC, 0x1F, 0xDF, 0xC7, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFE,
  0xFC, 0x3F, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x2F, 0x0F, 0xF1,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x80, 0x1F, 0xF0, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0x83,
  0xBF, 0x01, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF1, 0xFF, 0x80, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x8F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x11, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF3, 0xFD, 0xFF, 0xFE, 0xFF, 0xEF, 0x3F,
  0xE7, 0x8F, 0xE3, 0xC0, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F,
  0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x7B,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0xF8, 0x1F, 0xC0, 0xFD, 0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x03,
  0xE7, 0xE0, 0xFF, 0x07, 0xCF, 0xC1, 0xDE, 0x0F, 0x8F, 0x87, 0xBC, 0x3F,
  0x1F, 0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x7E, 0x3D, 0xE1, 0xF0,
  0x7C, 0x79, 0xE3, 0xE0, 0xF9, 0xE3, 0xCF, 0x81, 0xF3, 0xC7, 0x9F, 0x03,
  0xE7, 0x8F, 0x3E, 0x07, 0xCF, 0x1E, 0x7C, 0x07, 0xDE, 0x1C, 0xF8, 0x0F,
  0xBC, 0x3F, 0xE0, 0x1F, 0x70, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x07, 0xEF, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0x87, 0xC1,
  0xF1, 0xF8, 0x3F, 0x3E, 0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F,
  0xCF, 0x81, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x83, 0xE3, 0xF0, 0x7E, 0x7E,
  0x07, 0xDF, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x4F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x07, 0xF8, 0x3F, 0xC0,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFC, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC3, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFC, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x27, 0xF8, 0x05, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xF4, 0x00, 0x10,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 34, 12, 3, -34 },
  { 27, 16, 12, 20, 2, -34 },
  { 51, 22, 34, 23, 1, -34 },
  { 145, 18, 39, 22, 2, -36 },
  { 233, 31, 35, 35, 2, -35 },
  { 369, 24, 35, 25, 1, -35 },
  { 474, 6, 12, 11, 2, -34 },
  { 483, 12, 42, 15, 2, -34 },
  { 546, 11, 42, 15, 1, -34 },
  { 604, 18, 19, 21, 1, -37 },
  { 647, 19, 22, 22, 1, -28 },
  { 700, 7, 12, 11, 2, -6 },
  { 711, 12, 6, 14, 1, -16 },
  { 720, 6, 7, 12, 3, -7 },
  { 726, 17, 35, 19, 1, -35 },
  { 801, 18, 35, 22, 2, -35 },
  { 880, 14, 34, 22, 2, -34 },
  { 940, 17, 35, 22, 2, -35 },
  { 1015, 18, 35, 22, 2, -35 },
  { 1094, 20, 34, 22, 1, -34 },
  { 1179, 18, 34, 22, 2, -34 },
  { 1256, 18, 35, 22, 2, -35 },
  { 1335, 19, 34, 22, 1, -34 },
  { 1416, 19, 35, 22, 1, -35 },
  { 1500, 19, 35, 22, 1, -35 },
  { 1584, 6, 26, 12, 3, -26 },
  { 1604, 7, 32, 12, 2, -26 },
  { 1632, 19, 22, 22, 1, -28 },
  { 1685, 19, 14, 22, 1, -24 },
  { 1719, 19, 22, 22, 1, -28 },
  { 1772, 16, 35, 17, 0, -35 },
  { 1842, 29, 39, 33, 2, -35 },
  { 1984, 24, 34, 24, 0, -34 },
  { 2086, 19, 34, 24, 3, -34 },
  { 2167, 19, 35, 23, 2, -35 },
  { 2251, 21, 34, 26, 3, -34 },
  { 2341, 15, 34, 20, 3, -34 },
  { 2405, 15, 34, 20, 3, -34 },
  { 2469, 22, 35, 27, 2, -35 },
  { 2566, 21, 34, 27, 3, -34 },
  { 2656, 12, 34, 15, 1, -34 },
  { 2707, 11, 44, 12, -2, -34 },
  { 2768, 21, 34, 23, 3, -34 },
  { 2858, 15, 34, 19, 3, -34 },
  { 2922, 30, 34, 36, 3, -34 },
  { 3050, 23, 34, 29, 3, -34 },
  { 3148, 24, 35, 28, 2, -35 },
  { 3253, 18, 34, 23, 3, -34 },
  { 3330, 24, 43, 28, 2, -35 },
  { 3459, 20, 34, 24, 3, -34 },
  { 3544, 16, 35, 20, 2, -35 },
  { 3614, 18, 34, 20, 1, -34 },
  { 3691, 20, 34, 27, 3, -34 },
  { 3776, 23, 34, 23, 0, -34 },
  { 3874, 36, 34, 35, 0, -34 },
  { 4027, 21, 34, 21, 0, -34 },
  { 4117, 21, 34, 21, 0, -34 },
  { 4207, 17, 34, 19, 1, -34 },
  { 4280, 11, 42, 15, 3, -34 },
  { 4338, 17, 35, 19, 1, -35 },
  { 4413, 11, 42, 15, 1, -34 },
  { 4471, 22, 20, 24, 1, -34 },
  { 4526, 20, 3, 20, 0, 4 },
  { 4534, 10, 8, 14, 2, -37 },
  { 4544, 18, 27, 21, 1, -27 },
  { 4605, 19, 36, 23, 3, -36 },
  { 4691, 15, 27, 18, 2, -27 },
  { 4742, 19, 36, 23, 2, -36 },
  { 4828, 18, 27, 21, 2, -27 },
  { 4889, 15, 37, 14, 0, -37 },
  { 4959, 19, 39, 23, 2, -27 },
  { 5052, 17, 36, 23, 3, -36 },
  { 5129, 6, 36, 11, 3, -36 },
  { 5156, 10, 48, 11, -1, -36 },
  { 5216, 19, 36, 22, 3, -36 },
  { 5302, 5, 36, 11, 3, -36 },
  { 5325, 29, 27, 35, 3, -27 },
  { 5423, 17, 27, 23, 3, -27 },
  { 5481, 19, 27, 23, 2, -27 },
  { 5546, 19, 39, 23, 3, -27 },
  { 5639, 19, 39, 23, 2, -27 },
  { 5732, 12, 27, 16, 3, -27 },
  { 5773, 15, 27, 17, 1, -27 },
  { 5824, 13, 32, 15, 1, -32 },
  { 5876, 17, 26, 23, 3, -26 },
  { 5932, 20, 26, 20, 0, -26 },
  { 5997, 31, 26, 31, 0, -26 },
  { 6098, 19, 26, 19, 0, -26 },
  { 6160, 20, 38, 20, 0, -26 },
  { 6255, 14, 26, 16, 1, -26 },
  { 6301, 14, 42, 17, 1, -34 },
  { 6375, 5, 48, 20, 8, -37 },
  { 6405, 14, 42, 17, 2, -34 },
  { 6479, 19, 8, 22, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD48PT7B_H_
