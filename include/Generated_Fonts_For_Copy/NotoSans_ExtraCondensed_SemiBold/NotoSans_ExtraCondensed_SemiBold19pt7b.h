#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xED, 0xB6, 0xD8, 0x2F, 0xC0, 0xCF, 0x3C, 0xF3, 0xCC, 0x1B,
  0x0D, 0x86, 0xC2, 0x47, 0xFB, 0xFC, 0xC8, 0x6C, 0xFF, 0x7F, 0x89, 0x84,
  0x82, 0x43, 0x60, 0x10, 0xFF, 0xF6, 0x8D, 0x1A, 0x1C, 0x1E, 0x1E, 0x2E,
  0x5F, 0xEF, 0x82, 0x04, 0x00, 0x60, 0x8F, 0x18, 0xD1, 0x89, 0xB0, 0x9B,
  0x09, 0xA0, 0xD6, 0xEF, 0x6B, 0x65, 0xB0, 0xD9, 0x0D, 0x90, 0x9B, 0x18,
  0xB1, 0x0E, 0x1C, 0x0F, 0x83, 0x61, 0x98, 0x36, 0x0F, 0x03, 0xC1, 0xF7,
  0x6D, 0x99, 0xEE, 0x79, 0x8C, 0x7F, 0x8F, 0x70, 0xFF, 0xC0, 0x13, 0x66,
  0x6C, 0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0x30, 0xC3, 0x08, 0x63, 0x0C, 0x63,
  0x18, 0xC6, 0x33, 0x18, 0xCC, 0xE0, 0x31, 0x6B, 0xF1, 0x97, 0x99, 0x92,
  0x00, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0xFB, 0x60, 0xFF,
  0x5F, 0x00, 0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0xC3,
  0x06, 0x18, 0x00, 0x30, 0xFB, 0xB6, 0x6C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x3E, 0x67, 0xCF, 0x00, 0x19, 0xDF, 0xF5, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x71, 0xFB, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x38, 0x61, 0x86, 0x0F,
  0xFF, 0xC0, 0x79, 0xFA, 0x30, 0x60, 0xC1, 0x9E, 0x3E, 0x0C, 0x1C, 0x38,
  0x7F, 0xDF, 0x00, 0x06, 0x0E, 0x0E, 0x1E, 0x16, 0x36, 0x26, 0x66, 0x46,
  0xFF, 0xFF, 0x06, 0x06, 0x06, 0xFD, 0xFB, 0x06, 0x0C, 0x1A, 0x3F, 0x4E,
  0x0E, 0x0C, 0x3C, 0x6F, 0xDF, 0x00, 0x1C, 0xF9, 0x86, 0x0C, 0x1B, 0x3F,
  0x67, 0xC7, 0x8F, 0x1E, 0x77, 0xCF, 0x00, 0xFF, 0xFF, 0x03, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x38, 0xFB, 0x3E,
  0x3C, 0xFD, 0x9E, 0x3C, 0xCD, 0x8F, 0x1E, 0x3F, 0xCF, 0x80, 0x30, 0xFB,
  0x36, 0x7C, 0x78, 0xF3, 0xFF, 0x76, 0x0C, 0x30, 0x6F, 0x9E, 0x00, 0xFC,
  0x00, 0x02, 0xFC, 0xFC, 0x00, 0x00, 0xFB, 0x60, 0x02, 0x1C, 0xE7, 0x0E,
  0x0F, 0x07, 0x83, 0x02, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81, 0xC1, 0xE0,
  0xF0, 0xE7, 0xBC, 0x60, 0x80, 0x3B, 0xF4, 0xC3, 0x0C, 0x31, 0x8C, 0x30,
  0xC0, 0x0C, 0x30, 0xC0, 0x0E, 0x07, 0xF1, 0xC3, 0x30, 0x3C, 0xF7, 0xB2,
  0x76, 0xCC, 0xD9, 0x9B, 0x33, 0x67, 0x7F, 0xE6, 0x64, 0x00, 0xC1, 0x0F,
  0xE0, 0x20, 0x1C, 0x0E, 0x07, 0x83, 0xC3, 0x61, 0xB0, 0xDC, 0x66, 0x7F,
  0x3F, 0x98, 0xEC, 0x3E, 0x1F, 0x0C, 0xF8, 0xFE, 0xE6, 0xE7, 0xE7, 0xE6,
  0xFC, 0xFE, 0xE7, 0xE3, 0xE3, 0xE7, 0xFE, 0xFC, 0x1C, 0x7D, 0xCF, 0x0E,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x07, 0xE7, 0xC0, 0xF0, 0xFE, 0xEE,
  0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFE, 0xFC, 0xFF,
  0xFE, 0x38, 0xE3, 0x8F, 0xFF, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xFF, 0xFE,
  0x38, 0xE3, 0x8E, 0x3F, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x0E, 0x3F, 0x71,
  0x60, 0xE0, 0xC0, 0xC0, 0xC7, 0xC7, 0xC3, 0xE3, 0x63, 0x7F, 0x3F, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xFF, 0x66, 0x66, 0x66, 0x66, 0x66, 0xFF, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0xF7, 0x00, 0xE3, 0xE7, 0xE6, 0xEE,
  0xEC, 0xFC, 0xF8, 0xF8, 0xEC, 0xEC, 0xEE, 0xE6, 0xE7, 0xE3, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xE0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xD0, 0xFD, 0x9B, 0xD9, 0xBD, 0x9B, 0xCD, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xC6, 0x3C, 0x63, 0xE1, 0xF0, 0xFC, 0x7E, 0x3D, 0x9E,
  0xCF, 0x77, 0x9B, 0xCD, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1C, 0x1C, 0x3F,
  0x99, 0xDC, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xEC, 0x67,
  0xF1, 0xF0, 0xF1, 0xFB, 0xBF, 0x3E, 0x7C, 0xF9, 0xFF, 0xFD, 0xC3, 0x87,
  0x0E, 0x1C, 0x00, 0x1C, 0x3F, 0x99, 0xDC, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0xEC, 0x67, 0xF1, 0xF0, 0x18, 0x0E, 0x03, 0x80, 0xF0,
  0xFC, 0xEE, 0xE6, 0xE6, 0xE6, 0xEE, 0xFC, 0xFC, 0xEC, 0xEE, 0xE6, 0xE7,
  0xE3, 0x39, 0xFE, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE3, 0xFF, 0xE0,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0x7F, 0x3E, 0xC1, 0xE0, 0xD8, 0x6C, 0x66, 0x33, 0x19, 0xCC,
  0x6C, 0x36, 0x1B, 0x0D, 0x83, 0x81, 0xC0, 0xE0, 0xC3, 0x0F, 0x0C, 0x3C,
  0x31, 0xD9, 0xE6, 0x67, 0x99, 0x9E, 0x66, 0x79, 0x99, 0x26, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0x70, 0x61, 0xC0, 0xE3, 0x67, 0x66,
  0x36, 0x3E, 0x3C, 0x1C, 0x1C, 0x3C, 0x3E, 0x36, 0x66, 0x67, 0xE3, 0xC3,
  0xE3, 0x67, 0x66, 0x36, 0x3E, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFC, 0x18, 0x60, 0xC3, 0x86, 0x1C, 0x30, 0x61, 0x83, 0x0F,
  0xFF, 0xC0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0,
  0xC1, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x08, 0x06, 0x07,
  0x03, 0xC3, 0x61, 0x99, 0x8D, 0xC3, 0xFF, 0xCE, 0x70, 0x13, 0xF4, 0xC3,
  0x0D, 0xFC, 0xF3, 0xCF, 0xFF, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xEE,
  0xC6, 0xC6, 0xC7, 0xC7, 0xC6, 0xE6, 0xFE, 0xDC, 0x11, 0xFE, 0xB0, 0xC3,
  0x0C, 0x30, 0xC3, 0xF7, 0xC0, 0x06, 0x0C, 0x19, 0x37, 0xFD, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3F, 0xEE, 0xC0, 0x7D, 0xDB, 0x1E, 0x3F, 0xF8, 0x30,
  0x60, 0x7C, 0xF8, 0x08, 0xF7, 0x5C, 0x63, 0xE6, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x00, 0x20, 0xFF, 0xBE, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD,
  0xD8, 0x30, 0x71, 0xFF, 0x18, 0xC1, 0x83, 0x06, 0x4F, 0xDD, 0xF9, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xC0, 0xF0, 0xFF, 0xFF, 0xF0, 0x6C, 0x06,
  0xDB, 0x6D, 0xB6, 0xDB, 0x7E, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC,
  0xDC, 0xD8, 0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0,
  0x08, 0x4F, 0xDE, 0xEF, 0x6C, 0x67, 0xC6, 0x7C, 0x67, 0xC6, 0x7C, 0x67,
  0xC6, 0x7C, 0x67, 0xC6, 0x70, 0x09, 0xFB, 0xBE, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0x10, 0xFB, 0xBE, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xF9,
  0xF0, 0x08, 0xDC, 0xE6, 0xC6, 0xC6, 0xC7, 0xC7, 0xC6, 0xE6, 0xFE, 0xDC,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x20, 0xFF, 0xBE, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xFD, 0xD8, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0xFF, 0xCC, 0x63, 0x18,
  0xC6, 0x30, 0x27, 0xF3, 0x8E, 0x78, 0xE3, 0x1F, 0xFC, 0x21, 0x19, 0xF6,
  0x31, 0x8C, 0x63, 0x18, 0xF3, 0x80, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xFE, 0xEC, 0xC7, 0x66, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x3C,
  0x18, 0xC7, 0x36, 0x73, 0x6F, 0x36, 0xD6, 0x6D, 0x66, 0x96, 0x39, 0xE3,
  0x9E, 0x39, 0xC3, 0x9C, 0xE6, 0x6E, 0x3C, 0x3C, 0x38, 0x38, 0x3C, 0x6C,
  0x66, 0xE7, 0xC7, 0x66, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x18, 0x18,
  0x18, 0x38, 0x30, 0x70, 0x40, 0x7C, 0x31, 0x86, 0x30, 0xC7, 0x18, 0xFF,
  0xF0, 0x04, 0x73, 0x8C, 0x30, 0xC3, 0x0C, 0xE3, 0xC3, 0x0C, 0x30, 0xC3,
  0x07, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0x18, 0xC6, 0x31, 0x8E,
  0x39, 0xD8, 0xC6, 0x31, 0x9C, 0xC0, 0x79, 0xFF, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 9, 14, 9, 0, -14 },
  { 27, 7, 15, 9, 1, -14 },
  { 41, 12, 14, 14, 1, -14 },
  { 62, 10, 14, 10, 0, -14 },
  { 80, 2, 5, 4, 1, -14 },
  { 82, 4, 17, 6, 1, -14 },
  { 91, 5, 17, 6, 0, -14 },
  { 102, 7, 7, 8, 1, -14 },
  { 109, 7, 9, 9, 1, -11 },
  { 117, 3, 4, 5, 1, -2 },
  { 119, 4, 2, 6, 1, -6 },
  { 120, 3, 3, 5, 1, -3 },
  { 122, 7, 14, 7, 0, -14 },
  { 135, 7, 14, 9, 1, -14 },
  { 148, 5, 14, 9, 1, -14 },
  { 157, 7, 14, 9, 1, -14 },
  { 170, 7, 14, 9, 1, -14 },
  { 183, 8, 14, 9, 0, -14 },
  { 197, 7, 14, 9, 1, -14 },
  { 210, 7, 14, 9, 1, -14 },
  { 223, 8, 14, 9, 0, -14 },
  { 237, 7, 14, 9, 1, -14 },
  { 250, 7, 14, 9, 1, -14 },
  { 263, 3, 10, 5, 1, -10 },
  { 267, 3, 12, 5, 1, -10 },
  { 272, 7, 9, 9, 1, -11 },
  { 280, 7, 5, 9, 1, -9 },
  { 285, 7, 9, 9, 1, -11 },
  { 293, 6, 14, 7, 0, -14 },
  { 304, 11, 16, 13, 1, -14 },
  { 326, 9, 14, 9, 0, -14 },
  { 342, 8, 14, 10, 1, -14 },
  { 356, 7, 14, 9, 1, -14 },
  { 369, 8, 14, 10, 1, -14 },
  { 383, 6, 14, 8, 1, -14 },
  { 394, 6, 14, 8, 1, -14 },
  { 405, 8, 14, 11, 1, -14 },
  { 419, 8, 14, 11, 1, -14 },
  { 433, 4, 14, 6, 1, -14 },
  { 440, 5, 18, 5, -1, -14 },
  { 452, 8, 14, 9, 1, -14 },
  { 466, 6, 14, 7, 1, -14 },
  { 477, 12, 14, 14, 1, -14 },
  { 498, 9, 14, 12, 1, -14 },
  { 514, 9, 14, 11, 1, -14 },
  { 530, 7, 14, 9, 1, -14 },
  { 543, 9, 17, 11, 1, -14 },
  { 563, 8, 14, 9, 1, -14 },
  { 577, 6, 14, 8, 1, -14 },
  { 588, 8, 14, 8, 0, -14 },
  { 602, 8, 14, 11, 1, -14 },
  { 616, 9, 14, 9, 0, -14 },
  { 632, 14, 14, 14, 0, -14 },
  { 657, 8, 14, 8, 0, -14 },
  { 671, 8, 14, 8, 0, -14 },
  { 685, 7, 14, 7, 0, -14 },
  { 698, 4, 17, 6, 1, -14 },
  { 707, 7, 14, 7, 0, -14 },
  { 720, 4, 17, 6, 1, -14 },
  { 729, 9, 8, 9, 0, -14 },
  { 738, 8, 1, 8, 0, 2 },
  { 739, 4, 3, 6, 1, -15 },
  { 741, 6, 11, 8, 1, -11 },
  { 750, 8, 14, 9, 1, -14 },
  { 764, 6, 11, 7, 1, -11 },
  { 773, 7, 14, 9, 1, -14 },
  { 786, 7, 10, 8, 1, -10 },
  { 795, 6, 15, 5, 0, -15 },
  { 807, 7, 16, 9, 1, -11 },
  { 821, 7, 14, 9, 1, -14 },
  { 834, 2, 14, 4, 1, -14 },
  { 838, 3, 19, 4, 0, -14 },
  { 846, 8, 14, 9, 1, -14 },
  { 860, 2, 14, 4, 1, -14 },
  { 864, 12, 11, 14, 1, -11 },
  { 881, 7, 11, 9, 1, -11 },
  { 891, 7, 11, 9, 1, -11 },
  { 901, 8, 16, 9, 1, -11 },
  { 917, 7, 16, 9, 1, -11 },
  { 931, 5, 11, 6, 1, -11 },
  { 938, 5, 11, 7, 1, -11 },
  { 945, 5, 13, 6, 0, -13 },
  { 954, 7, 10, 9, 1, -10 },
  { 963, 8, 10, 8, 0, -10 },
  { 973, 12, 10, 12, 0, -10 },
  { 988, 8, 10, 8, 0, -10 },
  { 998, 8, 15, 8, 0, -10 },
  { 1013, 6, 10, 6, 0, -10 },
  { 1021, 6, 17, 7, 0, -14 },
  { 1034, 2, 19, 8, 3, -15 },
  { 1039, 5, 17, 7, 1, -14 },
  { 1050, 8, 3, 9, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD19PT7B_H_
