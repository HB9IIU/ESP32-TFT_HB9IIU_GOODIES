#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFF, 0xF7, 0xC0, 0xFE, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1E,
  0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x83, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7E, 0xCF, 0xBF, 0x30, 0x4F, 0x8C, 0x03, 0xE3, 0x00, 0xF8, 0xC0,
  0x3F, 0x30, 0x07, 0xCC, 0x01, 0xFB, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0D, 0xF8, 0x03,
  0x3F, 0x00, 0xC7, 0xC0, 0x31, 0xF0, 0x0C, 0x7C, 0x03, 0x1F, 0xC0, 0xCF,
  0xFC, 0x33, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0xE0, 0x1F,
  0x00, 0x7F, 0xE0, 0x1E, 0x00, 0xF9, 0xF0, 0x1E, 0x00, 0xF0, 0xF0, 0x3C,
  0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x78,
  0x00, 0xF0, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0xF0,
  0x00, 0xF0, 0xF8, 0xF0, 0x00, 0xF0, 0xF1, 0xE0, 0x40, 0xF0, 0xF1, 0xE3,
  0xF8, 0xF0, 0xF3, 0xE7, 0xFC, 0xF8, 0xF3, 0xC7, 0xFE, 0x7F, 0xE3, 0xCF,
  0xBE, 0x7F, 0xE7, 0xCF, 0x1E, 0x3F, 0xC7, 0x8F, 0x1F, 0x1F, 0x87, 0x9F,
  0x1F, 0x00, 0x0F, 0x1F, 0x0F, 0x00, 0x0F, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x0F, 0x00, 0x1E, 0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x0F, 0x00, 0x3E, 0x1F,
  0x0F, 0x00, 0x3C, 0x1F, 0x0F, 0x00, 0x3C, 0x0F, 0x1F, 0x00, 0x78, 0x0F,
  0x1F, 0x00, 0x78, 0x0F, 0x1E, 0x00, 0x78, 0x0F, 0xFE, 0x00, 0xF0, 0x07,
  0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF3, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x1F, 0x87, 0xFE, 0x0F, 0xC7, 0xFF, 0x87, 0xC7,
  0xE7, 0xE3, 0xE3, 0xF1, 0xF3, 0xF1, 0xF0, 0xFD, 0xF9, 0xF8, 0x3F, 0xF8,
  0xFC, 0x1F, 0xFC, 0x7E, 0x07, 0xFE, 0x3F, 0x01, 0xFE, 0x1F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x7E, 0x0F, 0xFF, 0x1F, 0x81, 0xFE, 0x0F, 0xE0, 0xFE,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x01,
  0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x04, 0x1F, 0x04, 0xF1, 0xC7, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xE4, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x0E,
  0x0E, 0x00, 0xC1, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x7D, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0xF9, 0xF3, 0xE7,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7,
  0xE1, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xDF, 0xFC, 0xFF, 0xC7, 0xDC, 0x3E, 0x41,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1E, 0x07, 0xE2, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7E, 0xFF, 0x9C, 0x07, 0xE2, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0xEF, 0x8F, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0E, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xDF, 0x80, 0x3D, 0xF8, 0x07, 0x9F,
  0x80, 0x79, 0xF8, 0x0F, 0x1F, 0x80, 0xF1, 0xF8, 0x1E, 0x1F, 0x81, 0xE1,
  0xF8, 0x3E, 0x1F, 0x83, 0xC1, 0xF8, 0x7C, 0x1F, 0x87, 0x81, 0xF8, 0xF8,
  0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE2, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xB0, 0x0F, 0xEF, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xF1, 0x8F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x20, 0x3E, 0x7F, 0x0F, 0xBF,
  0xF3, 0xEF, 0xFC, 0xFF, 0xFF, 0xBF, 0xCF, 0xEF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0x87, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x0F,
  0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFC, 0xF8, 0x1F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x3F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF1, 0xFC,
  0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F, 0xDF, 0xC3, 0xF9,
  0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x3F,
  0x7E, 0x0F, 0xEF, 0xE3, 0xFC, 0xFF, 0xFF, 0x9F, 0xFD, 0xF1, 0xFF, 0xBE,
  0x1F, 0xE7, 0xC0, 0x71, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x0C, 0x3F, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7B, 0xFF,
  0xFF, 0xFF, 0xF7, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3C, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7E, 0xFF, 0x30, 0x3F, 0x20,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x1F, 0xC1, 0xE3, 0xC1,
  0xFF, 0xC7, 0x9F, 0x0F, 0xFF, 0x1E, 0x78, 0x3E, 0x7C, 0x7D, 0xE1, 0xF1,
  0xF0, 0xF7, 0x87, 0x87, 0xC3, 0xFE, 0x1E, 0x1F, 0x0F, 0xF0, 0xF8, 0x7C,
  0x3F, 0xC3, 0xC1, 0xE0, 0xFF, 0x0F, 0x07, 0x83, 0xFC, 0x3C, 0x1E, 0x0F,
  0xF0, 0xF0, 0x78, 0x3F, 0xC3, 0xC1, 0xE0, 0xFF, 0x0F, 0x07, 0x87, 0xFC,
  0x3E, 0x3E, 0x1E, 0xF0, 0x78, 0xF8, 0x7B, 0xE1, 0xF7, 0x73, 0xE7, 0x87,
  0xFD, 0xFF, 0x1E, 0x0F, 0xE7, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x04, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0,
  0x03, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0,
  0x07, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xC0, 0x43, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x61, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x0F, 0xF3, 0xF0,
  0x3F, 0x9F, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0xFE, 0x7E,
  0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFD, 0xF8, 0x7F, 0x80, 0x61, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFD, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7D,
  0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x80, 0x7C, 0x7F,
  0x01, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF8, 0x7E, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x7F, 0x3F, 0x03, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80,
  0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xF7, 0xFF, 0x78, 0x07, 0xDF,
  0xFD, 0xF0, 0x1F, 0x7F, 0xF7, 0xC0, 0x79, 0xFF, 0xDF, 0x01, 0xE7, 0xFF,
  0x3C, 0x0F, 0x9F, 0xFC, 0xF8, 0x3E, 0x7F, 0xF3, 0xE0, 0xF1, 0xFF, 0xC7,
  0x87, 0xC7, 0xFF, 0x1F, 0x1F, 0x1F, 0xFC, 0x7C, 0x7C, 0x7F, 0xF1, 0xF1,
  0xE1, 0xFF, 0xC3, 0xCF, 0x87, 0xFF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3E, 0xF0,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x1F,
  0xFC, 0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0x81, 0xFF, 0xC0, 0xFE, 0x07, 0xFF,
  0x03, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xC0,
  0x7C, 0x07, 0xC0, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xEF,
  0x81, 0xFF, 0xDF, 0x83, 0xFF, 0x9F, 0x07, 0xFF, 0x3E, 0x0F, 0xFE, 0x7E,
  0x1F, 0xFC, 0x7C, 0x3F, 0xF8, 0xFC, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1, 0xF9,
  0xFF, 0xC3, 0xF3, 0xFF, 0x83, 0xE7, 0xFF, 0x07, 0xEF, 0xFE, 0x07, 0xDF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F,
  0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x7F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xFB, 0xF8,
  0x1D, 0xF8, 0x04, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x01, 0xFB, 0xC0, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x81, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F,
  0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x3F, 0x7C, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x3E, 0x7E,
  0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07,
  0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x07, 0xFE, 0x07, 0xC3, 0xE0, 0x7F,
  0xE0, 0xFC, 0x3F, 0x07, 0x9E, 0x0F, 0xC3, 0xF0, 0x79, 0xE0, 0xFC, 0x1F,
  0x07, 0x9E, 0x0F, 0x81, 0xF0, 0xF9, 0xF0, 0xF8, 0x1F, 0x0F, 0x9F, 0x1F,
  0x81, 0xF8, 0xF9, 0xF1, 0xF8, 0x1F, 0x8F, 0x0F, 0x1F, 0x80, 0xF8, 0xF0,
  0xF1, 0xF8, 0x0F, 0x9F, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0xF9, 0xF0, 0x0F,
  0x9F, 0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0x7B, 0xF0, 0x07, 0xDE, 0x07, 0xBF,
  0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xFE, 0x07, 0xBE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x07, 0xE0,
  0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x3E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x00, 0xF8, 0x7C,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0xFC,
  0x00, 0xFD, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x7E, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x07,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xE7, 0xF0, 0x80, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE1, 0xFF,
  0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x7F, 0xEF, 0xBF, 0xE3, 0xCF, 0xE1, 0xE0, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x7C,
  0xFF, 0x0F, 0xBF, 0xF1, 0xF7, 0xFF, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xF0,
  0x7E, 0xFF, 0x1F, 0xDF, 0xFF, 0xF3, 0xEF, 0xFE, 0x7C, 0xFF, 0x8F, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F,
  0x04, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x02, 0x7F, 0x8E, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x1F, 0x8F, 0xFB, 0xF1,
  0xFF, 0xBE, 0x7F, 0xF7, 0xDF, 0xFF, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F,
  0x1F, 0xE7, 0xFF, 0xFC, 0xFF, 0xEF, 0x8F, 0xF9, 0xF0, 0xFE, 0x3E, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x23, 0xF0, 0x38, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFC, 0x41, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x3F, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xC3,
  0xE1, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F, 0xFD, 0xF7, 0xFF, 0xFE, 0xFC, 0x3F,
  0xDF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0x7E,
  0xFC, 0x1F, 0xDF, 0xCF, 0xF9, 0xFF, 0xDF, 0x3F, 0xFB, 0xE3, 0xFE, 0xFC,
  0x3F, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x40, 0x0F, 0xCE, 0x03, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xC3, 0xE7, 0xF8, 0xFB, 0xFF,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7E, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x73, 0xEF, 0xFF, 0xFF, 0xE7,
  0x00, 0x00, 0x0F, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x07,
  0x03, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0xFF, 0xBF, 0xCF, 0xF3, 0xF8, 0x78,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x0F,
  0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0xFC,
  0x0F, 0x9F, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x83, 0xF9, 0xF0, 0x7E, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7E,
  0x3E, 0x0F, 0xC7, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F, 0x01, 0xFB, 0xE0, 0x3F,
  0x7C, 0x03, 0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xFC, 0x0F, 0xC3, 0xC7, 0xF8, 0x7F,
  0x8F, 0xBF, 0xF3, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xF8, 0x7F, 0x87, 0xEF, 0xC1, 0xFC, 0x1F, 0xBF, 0x03, 0xF0, 0x3E, 0xFC,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x03,
  0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8,
  0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03,
  0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF,
  0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xF8,
  0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xC0, 0xF0,
  0xFC, 0x3C, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFC,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xF7,
  0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xC7, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF0, 0xFC, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC,
  0x7D, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xEF, 0xC0, 0xFD, 0xFC, 0x1F, 0xBF, 0xC7, 0xF7,
  0xFF, 0xFC, 0xFB, 0xFF, 0x9F, 0x3F, 0xE3, 0xE3, 0xF8, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC3, 0xE1, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F, 0xFD, 0xF7,
  0xFF, 0xFE, 0xFC, 0x3F, 0xDF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x1F, 0xDF, 0xC7, 0xF9, 0xFF, 0xDF, 0x3F,
  0xFB, 0xE3, 0xFE, 0xFC, 0x3F, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xF0,
  0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xEF, 0xFF, 0x7F, 0xFB, 0xFC, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xFF,
  0xFB, 0xFF, 0xE7, 0xF7, 0xCF, 0x81, 0xBF, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x31, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xF7, 0xFD, 0xFF, 0xFF, 0x7F, 0xF7, 0xCF, 0xF9,
  0xF1, 0xFC, 0x7C, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0,
  0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F,
  0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0,
  0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3E, 0x7C,
  0x0F, 0xF0, 0x3E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7C, 0x3E,
  0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x1E, 0x78, 0x7C, 0x3F,
  0x1E, 0x78, 0xFC, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x1E, 0x78, 0xF8, 0x1F,
  0x1E, 0x78, 0xF8, 0x1F, 0x3C, 0x78, 0xF8, 0x1F, 0xBC, 0x3D, 0xF0, 0x0F,
  0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F,
  0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xE0, 0x07, 0xB8, 0x3F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x07, 0xEF, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xCF, 0x81, 0xF9,
  0xF0, 0x3E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E, 0x7E, 0x07, 0xCF, 0xC0,
  0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xE0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xF0, 0x7C,
  0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x7D,
  0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x3F, 0xC1,
  0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x17, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 35, 12, 3, -35 },
  { 28, 16, 13, 21, 2, -35 },
  { 54, 22, 35, 24, 1, -35 },
  { 151, 18, 40, 22, 2, -37 },
  { 241, 32, 35, 36, 2, -35 },
  { 381, 25, 35, 26, 1, -35 },
  { 491, 7, 13, 11, 2, -35 },
  { 503, 12, 43, 15, 2, -35 },
  { 568, 12, 43, 15, 1, -35 },
  { 633, 19, 18, 21, 1, -37 },
  { 676, 20, 23, 22, 1, -29 },
  { 734, 7, 12, 12, 2, -6 },
  { 745, 12, 5, 14, 1, -16 },
  { 753, 6, 7, 12, 3, -7 },
  { 759, 18, 35, 19, 1, -35 },
  { 838, 18, 35, 22, 2, -35 },
  { 917, 13, 35, 22, 3, -35 },
  { 974, 18, 35, 22, 2, -35 },
  { 1053, 18, 35, 22, 2, -35 },
  { 1132, 20, 35, 22, 1, -35 },
  { 1220, 18, 35, 22, 2, -35 },
  { 1299, 18, 35, 22, 2, -35 },
  { 1378, 19, 35, 22, 1, -35 },
  { 1462, 19, 35, 22, 1, -35 },
  { 1546, 19, 35, 22, 1, -35 },
  { 1630, 6, 27, 12, 3, -27 },
  { 1651, 8, 33, 12, 2, -27 },
  { 1684, 20, 23, 22, 1, -29 },
  { 1742, 20, 14, 22, 1, -24 },
  { 1777, 20, 23, 22, 1, -29 },
  { 1835, 16, 35, 17, 0, -35 },
  { 1905, 30, 39, 34, 2, -35 },
  { 2052, 24, 35, 24, 0, -35 },
  { 2157, 20, 35, 25, 3, -35 },
  { 2245, 20, 36, 23, 2, -36 },
  { 2335, 21, 35, 27, 3, -35 },
  { 2427, 15, 35, 21, 3, -35 },
  { 2493, 15, 35, 20, 3, -35 },
  { 2559, 22, 35, 27, 2, -35 },
  { 2656, 21, 35, 28, 3, -35 },
  { 2748, 12, 35, 15, 1, -35 },
  { 2801, 12, 45, 13, -3, -35 },
  { 2869, 21, 35, 24, 3, -35 },
  { 2961, 15, 35, 19, 3, -35 },
  { 3027, 30, 35, 37, 3, -35 },
  { 3159, 23, 35, 30, 3, -35 },
  { 3260, 24, 35, 28, 2, -35 },
  { 3365, 19, 35, 23, 3, -35 },
  { 3449, 24, 43, 28, 2, -35 },
  { 3578, 21, 35, 24, 3, -35 },
  { 3670, 17, 36, 21, 2, -36 },
  { 3747, 19, 35, 20, 1, -35 },
  { 3831, 21, 35, 27, 3, -35 },
  { 3923, 24, 35, 24, 0, -35 },
  { 4028, 36, 35, 36, 0, -35 },
  { 4186, 22, 35, 22, 0, -35 },
  { 4283, 22, 35, 22, 0, -35 },
  { 4380, 17, 35, 19, 1, -35 },
  { 4455, 11, 43, 15, 3, -35 },
  { 4515, 18, 35, 19, 1, -35 },
  { 4594, 11, 43, 15, 1, -35 },
  { 4654, 22, 20, 24, 1, -35 },
  { 4709, 21, 3, 21, 0, 4 },
  { 4717, 10, 8, 14, 2, -38 },
  { 4727, 17, 27, 22, 2, -27 },
  { 4785, 19, 37, 24, 3, -37 },
  { 4873, 16, 27, 19, 2, -27 },
  { 4927, 19, 37, 24, 2, -37 },
  { 5015, 18, 27, 22, 2, -27 },
  { 5076, 15, 37, 14, 0, -37 },
  { 5146, 19, 39, 24, 2, -27 },
  { 5239, 18, 37, 24, 3, -37 },
  { 5323, 6, 37, 11, 3, -37 },
  { 5351, 10, 49, 11, -1, -37 },
  { 5413, 19, 37, 22, 3, -37 },
  { 5501, 5, 37, 11, 3, -37 },
  { 5525, 30, 27, 35, 3, -27 },
  { 5627, 18, 27, 24, 3, -27 },
  { 5688, 19, 27, 23, 2, -27 },
  { 5753, 19, 39, 24, 3, -27 },
  { 5846, 19, 39, 24, 2, -27 },
  { 5939, 13, 27, 16, 3, -27 },
  { 5983, 15, 27, 18, 1, -27 },
  { 6034, 13, 32, 15, 1, -32 },
  { 6086, 18, 27, 24, 3, -27 },
  { 6147, 20, 27, 20, 0, -27 },
  { 6215, 32, 27, 32, 0, -27 },
  { 6323, 19, 27, 20, 0, -27 },
  { 6388, 20, 39, 20, 0, -27 },
  { 6486, 15, 27, 17, 1, -27 },
  { 6537, 14, 43, 17, 1, -35 },
  { 6613, 5, 48, 21, 8, -37 },
  { 6643, 14, 43, 17, 2, -35 },
  { 6719, 20, 7, 22, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD49PT7B_H_
