#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0xF3, 0xB9, 0xDC,
  0xEE, 0x77, 0x3B, 0x9D, 0x8E, 0x0C, 0xE0, 0xCC, 0x1C, 0xC1, 0xCC, 0x18,
  0xC1, 0x8C, 0xFF, 0xFF, 0xFF, 0x19, 0x83, 0x98, 0x39, 0x83, 0x98, 0xFF,
  0xEF, 0xFE, 0x33, 0x83, 0x38, 0x33, 0x07, 0x30, 0x73, 0x06, 0x30, 0x04,
  0x01, 0x01, 0xF9, 0xFF, 0x7F, 0xF9, 0x0E, 0x43, 0x90, 0x74, 0x1F, 0x03,
  0xF0, 0x3E, 0x07, 0xC1, 0x70, 0x4C, 0x13, 0xC5, 0xFF, 0xFF, 0xF8, 0x30,
  0x04, 0x01, 0x00, 0x40, 0x3C, 0x0C, 0x0F, 0x83, 0x83, 0xB8, 0x60, 0x73,
  0x1C, 0x0C, 0x63, 0x01, 0x8C, 0x60, 0x31, 0x9C, 0x06, 0x33, 0x00, 0xE6,
  0x67, 0x9D, 0xDD, 0xF9, 0xF3, 0x37, 0x1E, 0xEE, 0x60, 0x19, 0xCC, 0x03,
  0x39, 0xC0, 0xE7, 0x38, 0x18, 0xE6, 0x03, 0x1C, 0xC0, 0xE1, 0x98, 0x18,
  0x3F, 0x07, 0x03, 0xC0, 0x1F, 0x00, 0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x07, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE3, 0xBD,
  0xCE, 0xE7, 0xFB, 0x8F, 0xCE, 0x3F, 0x38, 0x78, 0xF1, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xCF, 0xF7, 0x77, 0x77, 0x60, 0x0E, 0x38, 0x71, 0xC3, 0x8E,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC1,
  0xC3, 0x87, 0x07, 0x07, 0xE1, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0x1E, 0x03,
  0x08, 0xC7, 0xFF, 0xFF, 0xC7, 0x83, 0xF0, 0xFC, 0x73, 0x8C, 0xC0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x77, 0x77, 0xEE, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x1F, 0x07, 0xF1, 0xFE,
  0x39, 0xEF, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3F, 0x87, 0xF0,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x8E, 0x73, 0xCF, 0xF0, 0xFE, 0x0F, 0x80,
  0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0x27, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x3F, 0x3F, 0xEF, 0xFD,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E,
  0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0xEF,
  0xFD, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x3F, 0x0F, 0x83, 0xF8, 0x0F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x83, 0xFF, 0xFF, 0xFB, 0xFC, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0D, 0xC1, 0xDC, 0x19, 0xC3,
  0x9C, 0x31, 0xC7, 0x1C, 0x61, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xF8, 0x7F, 0x9F, 0xE4, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x83, 0xFF, 0xFF, 0xF9, 0xFC, 0x0F, 0xC3, 0xF8, 0xFF, 0x3C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x38, 0xEF, 0x9F, 0xFB, 0xC7, 0x70, 0xEE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x8E, 0x71, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x00, 0x3F, 0x0F, 0xF1, 0xEF, 0x78, 0xEE, 0x1D, 0xC3, 0x9C, 0x73, 0xDC,
  0x3F, 0x83, 0xC0, 0xFE, 0x3D, 0xEF, 0x1D, 0xC3, 0xF8, 0x3F, 0x07, 0xE1,
  0xFE, 0x79, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0xE7, 0xFB, 0xCF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xFD, 0xFF, 0x3D, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x9F, 0xE7, 0xF1, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x77, 0x77, 0x00, 0x00, 0x00, 0x00, 0x77, 0x77, 0xEE, 0xE0, 0x00, 0x60,
  0x3C, 0x1F, 0x8F, 0xC7, 0xC1, 0xE0, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0xF8, 0x7E, 0x3F, 0x1F, 0x83, 0xC0, 0x60, 0x08, 0x00, 0x7E, 0x7F, 0xDF,
  0xE8, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x00, 0x00, 0x18, 0x1E, 0x0F, 0x03, 0x80, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0x03, 0x87, 0x00, 0xE3, 0x00, 0x33, 0x87, 0x9D, 0x8F, 0xE6, 0xC6,
  0x73, 0xE7, 0x31, 0xF3, 0x18, 0xF9, 0x8C, 0x7C, 0xC6, 0x3E, 0x63, 0x1F,
  0x31, 0x8F, 0x9D, 0xEC, 0xC7, 0xBE, 0x61, 0x8E, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x81, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x37, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x83, 0x8F, 0x0E, 0x1C, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x70,
  0x39, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xFF, 0xDF, 0xE3, 0xFF, 0x70, 0xFE, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFF, 0xFB, 0xFF, 0x7F, 0x80, 0x0F, 0xE3,
  0xFC, 0xFF, 0x9C, 0x17, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x27, 0xFC, 0x7F,
  0x87, 0xF0, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE1, 0xEE, 0x0E, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xEE, 0x1E, 0xE3, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0x7F, 0xBF, 0xDC, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0x78, 0x27, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x03,
  0xB8, 0x1D, 0xC0, 0xEF, 0x07, 0x38, 0x39, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFD, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF3, 0xFF, 0xF0,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFE, 0xFB, 0x80, 0xE0, 0xFE, 0x1E, 0xE1,
  0xCE, 0x3C, 0xE3, 0x8E, 0x78, 0xE7, 0x0E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFF,
  0x0F, 0x70, 0xE7, 0x0E, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0,
  0xEE, 0x0F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xB0, 0x6F, 0xD8, 0x77, 0xEE, 0x3B, 0xF7, 0x1D, 0xF9, 0x8C,
  0xFC, 0xEE, 0x7E, 0x77, 0x3F, 0x3B, 0x9F, 0x8D, 0x8F, 0xC7, 0xC7, 0xE3,
  0xE3, 0xF1, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x70, 0xF0, 0x3F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xB8, 0xFD, 0xC7, 0xEE, 0x3F, 0x39,
  0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0xF0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x78, 0x39, 0xC0, 0xE7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x78, 0x78, 0xFF,
  0xC1, 0xFE, 0x03, 0xF0, 0xFE, 0x3F, 0xEF, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xFF, 0xFB, 0xFC, 0xF8, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x78, 0x39, 0xC0, 0xE7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x78, 0x78, 0xFF,
  0xC1, 0xFE, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE3, 0xCF, 0xF8, 0xFF, 0x8F, 0xF0, 0xE7, 0x0E, 0x78, 0xE3, 0x8E,
  0x3C, 0xE1, 0xCE, 0x1C, 0xE1, 0xEE, 0x0F, 0x3F, 0x9F, 0xF7, 0xFB, 0xC2,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80,
  0xF0, 0x1C, 0x0F, 0x83, 0xBF, 0xEF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0xE0, 0x3F, 0x80, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x71, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE0, 0xE3, 0x81,
  0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x00, 0xDC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x70, 0x7F, 0x03, 0x83, 0xFC, 0x3C,
  0x1C, 0xE1, 0xE0, 0xE7, 0x0F, 0x87, 0x38, 0x7C, 0x79, 0xC3, 0x63, 0xCE,
  0x3B, 0x1C, 0x39, 0xD8, 0xE1, 0xCE, 0xE7, 0x0E, 0x67, 0x38, 0x73, 0x3B,
  0xC3, 0xB8, 0xDC, 0x0D, 0xC6, 0xE0, 0x7E, 0x37, 0x03, 0xE1, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0x70, 0xF7,
  0x0E, 0x38, 0xE3, 0x9E, 0x39, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0xDC, 0x3D, 0xC3, 0x9E, 0x38, 0xE7,
  0x8E, 0x70, 0xFF, 0x07, 0xF0, 0x77, 0x07, 0x70, 0xE7, 0x8E, 0x38, 0xE3,
  0x9C, 0x3D, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xCF,
  0xF9, 0xFF, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x83, 0x98, 0x39, 0xC3, 0x1C, 0x70, 0xE6, 0x0E, 0xE0, 0x7E, 0x07,
  0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0x87, 0x7F, 0x1F, 0xE2, 0x3C, 0x07, 0x01,
  0xC0, 0x73, 0xFD, 0xFF, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xF7, 0xFF, 0xF7,
  0xDC, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFC,
  0xF3, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xE1,
  0xDC, 0x3B, 0xEF, 0x7F, 0xCC, 0xF0, 0x3F, 0x9F, 0xDE, 0x4E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0xB9, 0xFC, 0x7C, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF, 0xBB, 0xFF, 0x7B, 0xFE,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xEE, 0x3D,
  0xEF, 0xBF, 0xF3, 0xEE, 0x3F, 0x1F, 0xE7, 0x1D, 0xC7, 0xE1, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0xCF, 0xF1, 0xF8, 0x1F,
  0x8F, 0x8F, 0x47, 0x03, 0x81, 0xC1, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x3E,
  0xEF, 0xFD, 0xEF, 0xF8, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC3, 0xF8, 0xF7, 0xBE, 0xFD, 0xCF, 0xB8, 0x07, 0x00, 0xE0, 0x3D,
  0x07, 0x3F, 0xE7, 0xF8, 0x3C, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0xFB, 0xFE, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xFF, 0xA0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x71, 0xC2, 0x00, 0x01, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3F,
  0xEF, 0x98, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x77,
  0x1C, 0xE7, 0x9C, 0xE3, 0xB8, 0x77, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0x38,
  0xE7, 0x9C, 0x73, 0x8F, 0x70, 0xEE, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xCF, 0xBE, 0x6F, 0xDF, 0xBD, 0xF9, 0xDC, 0x78, 0xFE,
  0x1C, 0x7F, 0x0E, 0x3F, 0x87, 0x1F, 0xC3, 0x8F, 0xE1, 0xC7, 0xF0, 0xE3,
  0xF8, 0x71, 0xFC, 0x38, 0xFE, 0x1C, 0x7F, 0x0E, 0x3F, 0x87, 0x1E, 0xCF,
  0xB7, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x3F, 0x8F, 0xF9, 0xE7, 0x38, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xB8, 0xF7, 0xBC,
  0x7F, 0x87, 0xC0, 0xCF, 0x9F, 0xF3, 0xCF, 0x70, 0xEE, 0x1D, 0xC3, 0xB8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3B, 0x87, 0x70, 0xEF, 0xFD, 0xFF, 0x3B, 0xC7,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x3E, 0xEF,
  0xFD, 0xEF, 0xF8, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF8, 0xF7, 0xBE, 0xFD, 0xCF, 0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0xCF, 0xBF, 0xFF, 0x8E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x7F, 0xFF, 0xE2, 0xE0, 0xE0,
  0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x07, 0x87, 0xFF, 0xFF, 0xFE, 0x18, 0x38,
  0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3D, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xFF, 0xFF, 0xF7, 0xDC, 0xE0,
  0xF7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x3B,
  0x81, 0xB8, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE1, 0xE1,
  0xDC, 0x78, 0x77, 0x1E, 0x39, 0xC7, 0xCE, 0x73, 0xF3, 0x9C, 0xEC, 0xE3,
  0xB3, 0x38, 0xEC, 0xDC, 0x3B, 0x37, 0x0E, 0xCF, 0xC1, 0xB3, 0xF0, 0x7C,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF1, 0xEE, 0x38, 0xE7,
  0x1D, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xF0, 0xEE, 0x1D,
  0xE7, 0x1C, 0xE3, 0xBC, 0x38, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x1E, 0x71,
  0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x1B, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0xC0, 0x78,
  0x07, 0x00, 0xFF, 0xFF, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70,
  0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0x1F, 0x1E, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x1F,
  0x0F, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0,
  0x78, 0x3F, 0xCF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 9, 7, 12, 1, -20 },
  { 17, 12, 20, 14, 1, -20 },
  { 47, 10, 23, 13, 1, -21 },
  { 76, 19, 20, 20, 1, -20 },
  { 124, 14, 20, 15, 1, -20 },
  { 159, 4, 7, 6, 1, -20 },
  { 163, 7, 24, 9, 1, -20 },
  { 184, 6, 24, 9, 1, -20 },
  { 202, 10, 10, 12, 1, -21 },
  { 215, 11, 14, 13, 1, -17 },
  { 235, 4, 7, 7, 1, -3 },
  { 239, 6, 3, 8, 1, -9 },
  { 242, 3, 4, 7, 2, -4 },
  { 244, 11, 20, 11, 0, -20 },
  { 272, 11, 20, 13, 1, -20 },
  { 300, 8, 20, 13, 1, -20 },
  { 320, 10, 20, 13, 1, -20 },
  { 345, 10, 20, 13, 1, -20 },
  { 370, 12, 20, 13, 0, -20 },
  { 400, 10, 20, 13, 1, -20 },
  { 425, 11, 20, 13, 1, -20 },
  { 453, 11, 20, 13, 1, -20 },
  { 481, 11, 20, 13, 1, -20 },
  { 509, 10, 20, 13, 1, -20 },
  { 534, 3, 15, 7, 2, -15 },
  { 540, 4, 19, 7, 1, -15 },
  { 550, 11, 13, 13, 1, -16 },
  { 568, 11, 8, 13, 1, -14 },
  { 579, 11, 13, 13, 1, -16 },
  { 597, 9, 20, 10, 0, -20 },
  { 620, 17, 22, 19, 1, -20 },
  { 667, 14, 20, 14, 0, -20 },
  { 702, 11, 20, 14, 2, -20 },
  { 730, 11, 20, 13, 1, -20 },
  { 758, 12, 20, 15, 2, -20 },
  { 788, 9, 20, 12, 2, -20 },
  { 811, 8, 20, 12, 2, -20 },
  { 831, 13, 20, 16, 1, -20 },
  { 864, 12, 20, 16, 2, -20 },
  { 894, 7, 20, 8, 1, -20 },
  { 912, 6, 26, 7, -1, -20 },
  { 932, 12, 20, 14, 2, -20 },
  { 962, 9, 20, 11, 2, -20 },
  { 985, 17, 20, 21, 2, -20 },
  { 1028, 13, 20, 17, 2, -20 },
  { 1061, 14, 20, 16, 1, -20 },
  { 1096, 10, 20, 13, 2, -20 },
  { 1121, 14, 25, 16, 1, -20 },
  { 1165, 12, 20, 14, 2, -20 },
  { 1195, 10, 20, 12, 1, -20 },
  { 1220, 11, 20, 12, 0, -20 },
  { 1248, 12, 20, 15, 2, -20 },
  { 1278, 14, 20, 14, 0, -20 },
  { 1313, 21, 20, 21, 0, -20 },
  { 1366, 12, 20, 12, 0, -20 },
  { 1396, 12, 20, 12, 0, -20 },
  { 1426, 11, 20, 11, 0, -20 },
  { 1454, 6, 24, 9, 2, -20 },
  { 1472, 11, 20, 11, 0, -20 },
  { 1500, 6, 24, 9, 1, -20 },
  { 1518, 12, 12, 14, 1, -20 },
  { 1536, 12, 2, 12, 0, 2 },
  { 1539, 6, 4, 8, 1, -21 },
  { 1542, 10, 15, 12, 1, -15 },
  { 1561, 11, 21, 14, 2, -21 },
  { 1590, 9, 15, 11, 1, -15 },
  { 1607, 11, 21, 14, 1, -21 },
  { 1636, 10, 15, 12, 1, -15 },
  { 1655, 9, 21, 8, 0, -21 },
  { 1679, 11, 22, 14, 1, -15 },
  { 1710, 10, 21, 14, 2, -21 },
  { 1737, 3, 21, 7, 2, -21 },
  { 1745, 6, 28, 7, -1, -21 },
  { 1766, 11, 21, 13, 2, -21 },
  { 1795, 3, 21, 6, 2, -21 },
  { 1803, 17, 15, 20, 2, -15 },
  { 1835, 10, 15, 14, 2, -15 },
  { 1854, 11, 15, 13, 1, -15 },
  { 1875, 11, 22, 14, 2, -15 },
  { 1906, 11, 22, 14, 1, -15 },
  { 1937, 7, 15, 9, 2, -15 },
  { 1951, 8, 15, 10, 1, -15 },
  { 1966, 8, 18, 8, 0, -18 },
  { 1984, 10, 15, 14, 2, -15 },
  { 2003, 12, 15, 12, 0, -15 },
  { 2026, 18, 15, 18, 0, -15 },
  { 2060, 11, 15, 11, 0, -15 },
  { 2081, 12, 22, 12, 0, -15 },
  { 2114, 8, 15, 9, 1, -15 },
  { 2129, 8, 24, 10, 1, -20 },
  { 2153, 2, 28, 12, 5, -21 },
  { 2160, 8, 24, 10, 1, -20 },
  { 2184, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD28PT7B_H_
