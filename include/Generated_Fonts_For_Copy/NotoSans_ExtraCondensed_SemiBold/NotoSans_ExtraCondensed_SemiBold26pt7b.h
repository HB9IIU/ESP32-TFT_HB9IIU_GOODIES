#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x60, 0x06, 0x7F, 0x70, 0xF7,
  0xF3, 0xF9, 0xCC, 0x66, 0x33, 0x19, 0x8C, 0x1C, 0xC3, 0x38, 0x66, 0x0C,
  0xC1, 0x98, 0x33, 0x3F, 0xFF, 0xFF, 0x31, 0x86, 0x70, 0xCC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCC, 0xC3, 0x98, 0x67, 0x0C, 0xE1, 0x98, 0x00, 0x0C, 0x03,
  0x01, 0xE1, 0xFE, 0x7F, 0xBB, 0x2E, 0xC3, 0xB0, 0x7C, 0x1F, 0x03, 0xF0,
  0x3E, 0x0F, 0x83, 0x70, 0xDE, 0x36, 0xFF, 0xBF, 0xC1, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x38, 0x18, 0x3E, 0x1C, 0x3B, 0x0C, 0x19, 0xC6, 0x0C, 0xE7,
  0x06, 0x73, 0x03, 0x39, 0x81, 0x9D, 0x80, 0xCE, 0xCF, 0x76, 0xEF, 0x9F,
  0x66, 0xE7, 0x37, 0x30, 0x3B, 0x98, 0x19, 0xCC, 0x0C, 0xE6, 0x0C, 0x73,
  0x06, 0x1B, 0x87, 0x0F, 0x83, 0x03, 0xC0, 0x1C, 0x01, 0xF8, 0x1F, 0xC0,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xDC, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x9D, 0xDC, 0xEE, 0x77, 0x71, 0xF3, 0x8F, 0x9C, 0x38, 0xF7, 0xE3, 0xFF,
  0x8F, 0x9E, 0xFE, 0xE6, 0x66, 0x60, 0x0C, 0x71, 0x8E, 0x31, 0xC7, 0x18,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71, 0xC7, 0x0E, 0x38, 0x60, 0xC0,
  0xC3, 0x86, 0x1C, 0x30, 0xE3, 0x86, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC6,
  0x38, 0xE3, 0x9C, 0x73, 0x8C, 0x00, 0x1C, 0x0E, 0x07, 0x1D, 0xFF, 0xF9,
  0xF0, 0xF8, 0xEE, 0x77, 0x91, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x77, 0x7E, 0xEE,
  0xFF, 0xF0, 0x6F, 0xF7, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x0E, 0x00, 0x1C, 0x0F, 0xC7, 0xF1, 0xCE, 0xE3, 0xB8, 0xEE,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E, 0x39, 0xCE,
  0x77, 0x9F, 0xC3, 0xE0, 0x07, 0x0F, 0x1F, 0x3F, 0x77, 0xE7, 0x27, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1C,
  0x1F, 0xCF, 0xF9, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E,
  0x3F, 0xCF, 0xF9, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x3F, 0x0F, 0x83,
  0xF0, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0xC7, 0xBF, 0xCF, 0xE0, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x58, 0x1B, 0x03, 0x60, 0xCC, 0x19, 0x86,
  0x30, 0xC6, 0x30, 0xC6, 0x19, 0xFF, 0xFF, 0xF8, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xF0,
  0xFF, 0x3F, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0xEF, 0xBF,
  0xCF, 0xE0, 0x07, 0x87, 0xE3, 0xF9, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0xBC,
  0xFF, 0xBF, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0x7F, 0x9F,
  0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x80, 0x1E, 0x1F, 0xC7, 0xFB, 0x8E, 0xE1, 0xB8, 0x67, 0x39, 0xDE,
  0x3F, 0x0F, 0x87, 0xF3, 0xCE, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0x9F,
  0xE3, 0xF0, 0x1C, 0x1F, 0xC7, 0xF3, 0x8E, 0xE3, 0xB8, 0x6E, 0x1F, 0x87,
  0xE3, 0xFC, 0xF7, 0xFD, 0xF6, 0x01, 0x80, 0xE0, 0x38, 0x1E, 0x8F, 0x1F,
  0x87, 0xC0, 0x7F, 0x76, 0x00, 0x00, 0x00, 0x67, 0xF7, 0x7F, 0x76, 0x00,
  0x00, 0x00, 0x07, 0x77, 0xEE, 0xE0, 0x00, 0xC0, 0xF0, 0xFC, 0xFC, 0xFC,
  0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0C, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x7C, 0x7C, 0x7C, 0x3C, 0x0C, 0x02, 0x00, 0x3C, 0x7F,
  0x9F, 0xC8, 0xF0, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x38, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0x0F, 0xF0,
  0x1C, 0x3C, 0x38, 0x0C, 0x30, 0x06, 0x61, 0xE6, 0x63, 0xF7, 0x67, 0x73,
  0xE6, 0x73, 0xCE, 0x63, 0xCE, 0x63, 0xCE, 0x63, 0xCE, 0x63, 0xC6, 0x66,
  0xE7, 0xFE, 0x63, 0x9C, 0x60, 0x00, 0x70, 0x00, 0x38, 0x10, 0x1F, 0xF0,
  0x07, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xE0,
  0x77, 0x03, 0xB8, 0x19, 0xC1, 0xC7, 0x0E, 0x38, 0x7F, 0xC3, 0xFE, 0x3F,
  0xF9, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x83, 0xF8, 0x0E, 0xFC, 0x3F, 0xCF,
  0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xFF, 0x3F, 0xCF, 0xFB, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xFF, 0xEF, 0xF0, 0x07, 0x83, 0xFC,
  0xFF, 0x3C, 0x27, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3E, 0xC7, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0xE3, 0xFE, 0x71, 0xEE, 0x1D, 0xC3, 0xB8, 0x7F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xB8, 0x77, 0x1E, 0xFF, 0x9F,
  0xE3, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE,
  0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xC1, 0xFF, 0x3F, 0xE3, 0xC2, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x1F, 0xE1, 0xFE, 0x07, 0xF0,
  0x77, 0x07, 0x70, 0x77, 0x87, 0x3C, 0xF3, 0xFF, 0x0F, 0xE0, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0xFF, 0xF7, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0xFF, 0xC0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xEF, 0xBC, 0xE1, 0xFC,
  0x3B, 0x8F, 0x71, 0xCE, 0x79, 0xCE, 0x3B, 0x87, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0E, 0x71, 0xCE, 0x38, 0xE7, 0x1C, 0xE3, 0xDC, 0x3B, 0x87,
  0x80, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x37, 0xFC, 0x37,
  0xEC, 0x77, 0xEC, 0x77, 0xEE, 0x67, 0xEE, 0xE7, 0xE6, 0xE7, 0xE6, 0xC7,
  0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xC7, 0xEE, 0x7E,
  0xE7, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x0F, 0xE0, 0xF0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38,
  0x3B, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x07,
  0xB8, 0x39, 0xC1, 0xCF, 0x1E, 0x3D, 0xE1, 0xFF, 0x03, 0xE0, 0xF0, 0x7F,
  0xBF, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF7, 0xFF, 0xDF, 0xCE,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x0F, 0x80, 0xFE, 0x0F,
  0xF8, 0xF1, 0xE7, 0x07, 0x38, 0x3B, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xB8, 0x39, 0xC1, 0xCF, 0x1E, 0x3D, 0xE1,
  0xFF, 0x07, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x1F,
  0xE3, 0xFE, 0x73, 0xCE, 0x39, 0xC7, 0xB8, 0xF7, 0x1C, 0xE3, 0x9F, 0xE3,
  0xF8, 0x7F, 0x0E, 0x71, 0xCE, 0x39, 0xE7, 0x1C, 0xE3, 0xDC, 0x3B, 0x87,
  0x80, 0x1E, 0x3F, 0xDF, 0xFE, 0x2E, 0x07, 0x03, 0x81, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0xFF, 0x7F, 0xBF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0E, 0xFB, 0xCF, 0xF0,
  0xFC, 0x00, 0xE0, 0x3F, 0x03, 0x98, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x71,
  0xC3, 0x87, 0x1C, 0x38, 0xE1, 0xCE, 0x0E, 0x70, 0x33, 0x81, 0xDC, 0x0E,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0xE0, 0xE0, 0xFC,
  0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x77, 0x1F, 0x1C, 0xE3, 0x63, 0x9C,
  0x6C, 0x73, 0x8D, 0x8E, 0x71, 0xB1, 0xC7, 0x77, 0x38, 0xEE, 0xEE, 0x1D,
  0xCD, 0xC3, 0xB1, 0xB8, 0x76, 0x37, 0x06, 0xC6, 0xE0, 0xF8, 0xF8, 0x1F,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0xF0, 0xE7, 0x0E, 0x71, 0xC3,
  0x9C, 0x39, 0xC1, 0xB8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x83, 0xB8, 0x39, 0xC3, 0x9C, 0x71, 0xC7, 0x0E, 0xE0, 0xF0,
  0xE0, 0xFF, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC3, 0x9C, 0x3B, 0x81, 0xB8,
  0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xE0, 0xE0, 0x18, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0xFF, 0xFE, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x04,
  0x01, 0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x77, 0x0C, 0xE3, 0x8E, 0x61, 0xDC,
  0x1F, 0x83, 0x80, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3, 0x87, 0x7F, 0x3F, 0x88,
  0xE0, 0x70, 0x38, 0xFD, 0xFF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFF, 0xDB,
  0xCC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xF3, 0x7E, 0xF3,
  0xB8, 0xEE, 0x1B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x8E, 0xE3, 0xBC, 0xED,
  0xF3, 0x7C, 0x3F, 0x7F, 0x71, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0x71, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x73,
  0xDD, 0xFF, 0x73, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xDC, 0xF7, 0xFC, 0xF3, 0x3F, 0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0xB8,
  0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x01, 0xC2, 0x7F, 0x8F, 0xE0, 0x0F,
  0x1F, 0x3F, 0x38, 0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0xDF, 0xF7, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCF, 0x7F, 0xCF,
  0x70, 0x1C, 0x07, 0x01, 0xD8, 0xE7, 0xF9, 0xFC, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x7D, 0xFF, 0xF7, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x70, 0x6F, 0xF6, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x18, 0xF3, 0xC6, 0x00, 0x01, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0xAE, 0xFB,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x3B, 0x9E, 0xE7,
  0x3B, 0x8C, 0xE3, 0x70, 0xFC, 0x3F, 0x8E, 0xE3, 0x9C, 0xE7, 0x38, 0xEE,
  0x3B, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xFE, 0xFF, 0xDF,
  0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF0, 0xE3, 0xE1, 0xC7, 0xC3, 0x8F,
  0x87, 0x1F, 0x0E, 0x3E, 0x1C, 0x7C, 0x38, 0xF8, 0x71, 0xC0, 0xDF, 0x7F,
  0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1C, 0x3F, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x87, 0xC0, 0xDF, 0x37, 0xEF, 0x3B,
  0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xEE, 0x3B, 0xDE, 0xDF,
  0x33, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3C, 0xDF, 0xF7,
  0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCF,
  0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xDF, 0x7F,
  0xF8, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7F, 0xFE, 0xE2,
  0xE0, 0xE0, 0xF0, 0x7C, 0x3E, 0x0E, 0x07, 0x07, 0xCE, 0xFE, 0xFC, 0x38,
  0x70, 0xE3, 0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x9F, 0x1E, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF8, 0xFC, 0xFF, 0xFB, 0xCC, 0xE0, 0xEC, 0x39, 0xC7, 0x38, 0xE7,
  0x1C, 0x67, 0x0E, 0xE1, 0xDC, 0x3B, 0x03, 0x60, 0x7C, 0x0F, 0x81, 0xE0,
  0x1C, 0x00, 0xE1, 0xC3, 0xB0, 0xE1, 0x9C, 0xF9, 0xCE, 0x6C, 0xE7, 0x36,
  0x73, 0x9B, 0x38, 0xCD, 0x98, 0x7E, 0xDC, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF1, 0xDC, 0xE3, 0xB8,
  0xEE, 0x3F, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x0F, 0xC3, 0xB9, 0xCE, 0x71,
  0xF8, 0x70, 0xE0, 0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0x67, 0x0E, 0xE1,
  0xDC, 0x1B, 0x03, 0x60, 0x7C, 0x0F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x17, 0x81, 0xE0, 0x3C, 0x00, 0xFF, 0xFC, 0x38, 0xE1, 0xC7, 0x8E,
  0x1C, 0x70, 0xE3, 0x87, 0x0F, 0xFF, 0xC0, 0x06, 0x3C, 0xF9, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x71, 0xE7, 0x8F, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xC3, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x1E, 0x0F, 0x1F, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0,
  0xF0, 0xF8, 0x7F, 0xFD, 0xFE, 0x0C,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 19, 6, 1, -19 },
  { 11, 9, 7, 11, 1, -19 },
  { 19, 11, 19, 13, 1, -19 },
  { 46, 10, 22, 12, 1, -20 },
  { 74, 17, 19, 19, 1, -19 },
  { 115, 13, 19, 14, 1, -19 },
  { 146, 4, 7, 6, 1, -19 },
  { 150, 6, 23, 8, 1, -19 },
  { 168, 6, 23, 8, 1, -19 },
  { 186, 9, 10, 11, 1, -20 },
  { 198, 10, 12, 12, 1, -15 },
  { 213, 4, 6, 6, 1, -3 },
  { 216, 6, 2, 8, 1, -8 },
  { 218, 4, 4, 6, 1, -4 },
  { 220, 10, 19, 10, 0, -19 },
  { 244, 10, 19, 12, 1, -19 },
  { 268, 8, 19, 12, 1, -19 },
  { 287, 10, 19, 12, 1, -19 },
  { 311, 10, 19, 12, 1, -19 },
  { 335, 11, 19, 12, 0, -19 },
  { 362, 10, 19, 12, 1, -19 },
  { 386, 10, 19, 12, 1, -19 },
  { 410, 10, 19, 12, 1, -19 },
  { 434, 10, 19, 12, 1, -19 },
  { 458, 10, 19, 12, 1, -19 },
  { 482, 4, 14, 6, 1, -14 },
  { 489, 4, 17, 6, 1, -14 },
  { 498, 10, 12, 12, 1, -15 },
  { 513, 10, 8, 12, 1, -13 },
  { 523, 10, 12, 12, 1, -15 },
  { 538, 9, 19, 9, 0, -19 },
  { 560, 16, 21, 18, 1, -19 },
  { 602, 13, 19, 13, 0, -19 },
  { 633, 10, 19, 13, 2, -19 },
  { 657, 11, 19, 12, 1, -19 },
  { 684, 11, 19, 14, 2, -19 },
  { 711, 8, 19, 11, 2, -19 },
  { 730, 8, 19, 11, 2, -19 },
  { 749, 12, 19, 14, 1, -19 },
  { 778, 11, 19, 15, 2, -19 },
  { 805, 6, 19, 8, 1, -19 },
  { 820, 6, 24, 7, -1, -19 },
  { 838, 11, 19, 13, 2, -19 },
  { 865, 8, 19, 10, 2, -19 },
  { 884, 16, 19, 20, 2, -19 },
  { 922, 12, 19, 16, 2, -19 },
  { 951, 13, 19, 15, 1, -19 },
  { 982, 9, 19, 12, 2, -19 },
  { 1004, 13, 23, 15, 1, -19 },
  { 1042, 11, 19, 13, 2, -19 },
  { 1069, 9, 19, 11, 1, -19 },
  { 1091, 10, 19, 11, 0, -19 },
  { 1115, 11, 19, 14, 2, -19 },
  { 1142, 13, 19, 13, 0, -19 },
  { 1173, 19, 19, 19, 0, -19 },
  { 1219, 12, 19, 12, 0, -19 },
  { 1248, 12, 19, 12, 0, -19 },
  { 1277, 10, 19, 10, 0, -19 },
  { 1301, 5, 23, 8, 2, -19 },
  { 1316, 10, 19, 10, 0, -19 },
  { 1340, 5, 23, 8, 1, -19 },
  { 1355, 11, 11, 13, 1, -19 },
  { 1371, 11, 2, 11, 0, 2 },
  { 1374, 6, 4, 8, 1, -20 },
  { 1377, 9, 14, 12, 1, -14 },
  { 1393, 10, 20, 13, 2, -20 },
  { 1418, 8, 14, 10, 1, -14 },
  { 1432, 10, 20, 13, 1, -20 },
  { 1457, 10, 14, 11, 1, -14 },
  { 1475, 8, 20, 7, 0, -20 },
  { 1495, 10, 20, 13, 1, -14 },
  { 1520, 9, 20, 13, 2, -20 },
  { 1543, 4, 20, 6, 1, -20 },
  { 1553, 6, 26, 6, -1, -20 },
  { 1573, 10, 20, 12, 2, -20 },
  { 1598, 2, 20, 6, 2, -20 },
  { 1603, 15, 14, 19, 2, -14 },
  { 1630, 9, 14, 13, 2, -14 },
  { 1646, 10, 14, 12, 1, -14 },
  { 1664, 10, 20, 13, 2, -14 },
  { 1689, 10, 20, 13, 1, -14 },
  { 1714, 6, 14, 9, 2, -14 },
  { 1725, 8, 14, 9, 1, -14 },
  { 1739, 7, 17, 8, 0, -17 },
  { 1754, 9, 14, 13, 2, -14 },
  { 1770, 11, 14, 11, 0, -14 },
  { 1790, 17, 14, 17, 0, -14 },
  { 1820, 10, 14, 11, 0, -14 },
  { 1838, 11, 20, 11, 0, -14 },
  { 1866, 7, 14, 9, 1, -14 },
  { 1879, 7, 23, 9, 1, -19 },
  { 1900, 3, 26, 11, 4, -20 },
  { 1910, 8, 23, 9, 1, -19 },
  { 1933, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD26PT7B_H_
