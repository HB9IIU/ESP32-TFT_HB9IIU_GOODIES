#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x81, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE0, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xDC, 0x38, 0xFC, 0xE0, 0x4F, 0xC7, 0x00, 0x7E,
  0x38, 0x03, 0xF1, 0xC0, 0x0F, 0x8E, 0x00, 0x7E, 0x70, 0x03, 0xFB, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1D, 0xFC,
  0x00, 0xE7, 0xE0, 0x07, 0x1F, 0x00, 0x38, 0xFC, 0x01, 0xC7, 0xD0, 0x0E,
  0x3E, 0xC0, 0x73, 0xF7, 0xC3, 0xBF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x03,
  0xE0, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0x07, 0xCF,
  0x80, 0x7C, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0xF8, 0x00,
  0xF8, 0x7C, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0xF0, 0x00, 0xF8, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x1E, 0x00, 0x0F, 0x83,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC7, 0xC0, 0x00,
  0xF8, 0x7C, 0x7C, 0x3F, 0x0F, 0x87, 0xC7, 0x87, 0xF8, 0x78, 0x7C, 0xF8,
  0xFF, 0xC7, 0xC7, 0x8F, 0x9F, 0xFE, 0x7F, 0xF8, 0xF1, 0xF3, 0xE3, 0xFF,
  0x9F, 0x1E, 0x1E, 0x3F, 0xF1, 0xF3, 0xE1, 0xF1, 0xFE, 0x3E, 0x3E, 0x1F,
  0x07, 0x83, 0xE3, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE1, 0xF0, 0x00,
  0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x1F,
  0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x3E, 0x01,
  0xE1, 0xF0, 0x03, 0xE0, 0x1F, 0x3E, 0x00, 0x3C, 0x01, 0xFF, 0xE0, 0x07,
  0xC0, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF,
  0x0F, 0xC3, 0xFB, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC7, 0xE1, 0xFD, 0xFC,
  0x7E, 0x0F, 0xDF, 0x8F, 0xE0, 0x7F, 0xF8, 0xFE, 0x07, 0xFF, 0x8F, 0xE0,
  0x3F, 0xF0, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0xE0,
  0xFF, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x09, 0xE1, 0xE3,
  0xCF, 0xEF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x7E, 0x01, 0xF9, 0xF0,
  0x1F, 0x8F, 0xC1, 0xFC, 0x3F, 0x03, 0xC1, 0xF0, 0x0E, 0x06, 0x00, 0x20,
  0x20, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x3F,
  0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFE, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFB, 0xC3,
  0xF3, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7C, 0x0F, 0xE3, 0x80, 0x7E,
  0x20, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFF,
  0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x78,
  0x0F, 0xE3, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F,
  0x3F, 0x00, 0x1E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF1, 0xF8, 0x03, 0xE3,
  0xF0, 0x07, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3C, 0x1F, 0x80, 0xF8, 0x3F,
  0x01, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0,
  0x7C, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7C, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE2, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xDE, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x2C, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x8F,
  0xE0, 0xFC, 0xFF, 0x87, 0xEF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xF8, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x3F,
  0x8F, 0xE3, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xCF, 0xF1, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x87, 0xF3,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF3, 0xFC, 0x7F, 0x0F,
  0xF3, 0xF0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xBF, 0x81, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC,
  0x3F, 0x9F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE7,
  0xF9, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xF7, 0xC7, 0xFF, 0x3E, 0x1F, 0xFB,
  0xF0, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE,
  0x7E, 0x18, 0x1E, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xF8, 0xFC, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9,
  0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0x81, 0xFC, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x07, 0xF8, 0x3E, 0x3E, 0x07, 0xFF, 0x8F, 0x8F, 0x83, 0xFF,
  0xE1, 0xE3, 0xC1, 0xFF, 0xF8, 0x79, 0xF0, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E,
  0x0F, 0x87, 0xDF, 0x0F, 0x83, 0xC1, 0xF7, 0x83, 0xE0, 0xF0, 0x7D, 0xE0,
  0xF0, 0x3C, 0x1F, 0xF8, 0x7C, 0x1F, 0x07, 0xFE, 0x1F, 0x07, 0xC1, 0xFF,
  0x87, 0xC1, 0xF0, 0x7F, 0xE1, 0xF0, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0x07,
  0xFE, 0x1F, 0x07, 0xC1, 0xEF, 0x87, 0xC1, 0xF0, 0x7B, 0xE0, 0xF0, 0x7C,
  0x3E, 0x78, 0x3E, 0x3F, 0x8F, 0x9F, 0x0F, 0xDF, 0xE7, 0xC7, 0xC1, 0xFF,
  0x3F, 0xF1, 0xF0, 0x7F, 0xCF, 0xF8, 0x7C, 0x0F, 0xE1, 0xFC, 0x0F, 0x80,
  0xF0, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x04, 0x00,
  0x1F, 0xC0, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0,
  0x3F, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F,
  0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xCF, 0xC0, 0x7F,
  0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00,
  0xFE, 0xFC, 0x07, 0xFB, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0x81, 0xC7, 0xF8, 0x02, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x87, 0xFC, 0x1C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0x87, 0xFE, 0x3F, 0x01, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8,
  0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF,
  0x00, 0xFE, 0x7E, 0x03, 0xFC, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFD, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x1E, 0x3F, 0xC0, 0x02,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x3F, 0x80, 0x3F, 0x3F, 0xC0, 0x3F, 0x1F, 0xF0, 0x7F, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x06, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFF,
  0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F,
  0x1F, 0x80, 0xFE, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xDF, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xF8, 0x7F,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC,
  0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xE7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xFF, 0x00, 0x3E,
  0xFF, 0xF7, 0xC0, 0x1F, 0xBF, 0xFD, 0xF0, 0x07, 0xDF, 0xFF, 0x7C, 0x01,
  0xF7, 0xFF, 0xDF, 0x80, 0x7D, 0xFF, 0xF3, 0xE0, 0x3F, 0x7F, 0xFC, 0xF8,
  0x0F, 0x9F, 0xFF, 0x3E, 0x03, 0xE7, 0xFF, 0xCF, 0xC1, 0xF9, 0xFF, 0xF1,
  0xF0, 0x7C, 0x7F, 0xFC, 0x7C, 0x1F, 0x1F, 0xFF, 0x1F, 0x87, 0xC7, 0xFF,
  0xC7, 0xE3, 0xF1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7F, 0xFC, 0x3E, 0x3E, 0x1F,
  0xFF, 0x0F, 0xDF, 0x87, 0xFF, 0xC1, 0xF7, 0xC1, 0xFF, 0xF0, 0x7D, 0xF0,
  0x7F, 0xFC, 0x1F, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFC,
  0x07, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x3E, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0xC0,
  0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xC7,
  0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x07, 0xE3, 0xFF,
  0xC1, 0xF8, 0xFF, 0xF0, 0x7F, 0x3F, 0xFC, 0x0F, 0xCF, 0xFF, 0x03, 0xF3,
  0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x1F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC3, 0xFE,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0x03, 0xFC, 0x7E,
  0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03,
  0xF8, 0xFC, 0x0F, 0xF1, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7E, 0x3F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0,
  0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xE1,
  0xF3, 0xF8, 0x04, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xFC, 0x03, 0xFB, 0xF9, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0x7F, 0x00,
  0x7E, 0xFF, 0x01, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xBF, 0x80,
  0x1F, 0xC0, 0x0F, 0xDF, 0xC0, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0,
  0x03, 0xF3, 0xF0, 0x07, 0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xFF, 0x00, 0xFC, 0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x1F, 0x80,
  0x7F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x87, 0xE0, 0x3E, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0x7C, 0x0F, 0xC1, 0xFC, 0x0F, 0xBE, 0x07, 0xE0,
  0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x3F, 0x07, 0xCF, 0x83, 0xF8, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x0F, 0xC1, 0xF3, 0xF0, 0xFC, 0x07, 0xF0, 0xF8, 0xF8,
  0x7E, 0x01, 0xF8, 0xFC, 0x7C, 0x3F, 0x00, 0xFC, 0x7E, 0x3E, 0x3F, 0x80,
  0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F,
  0x83, 0xE7, 0xE0, 0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0xF9,
  0xF8, 0x01, 0xFB, 0xE0, 0x7D, 0xF8, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00,
  0x7E, 0xF8, 0x0F, 0x7E, 0x00, 0x1F, 0x7C, 0x07, 0xFF, 0x00, 0x0F, 0xBE,
  0x03, 0xFF, 0x80, 0x07, 0xDE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x3F,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xF7, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xE3, 0xF0, 0x0F,
  0xE3, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0x81, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07,
  0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xE7, 0xE0,
  0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x1F, 0xC4, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xBF,
  0xFD, 0xF3, 0xFF, 0x3E, 0x3F, 0x83, 0xC1, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xF3, 0xFF, 0x0F,
  0xDF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xCF, 0xF0,
  0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F,
  0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80,
  0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE,
  0xFF, 0x87, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFC,
  0xFF, 0xC3, 0xE1, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE0, 0xC7, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0x3F, 0x81, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x7F, 0x1F, 0x87, 0xFC, 0xFC, 0x7F, 0xF7, 0xE7, 0xFF, 0xDF,
  0x3F, 0xFF, 0xFB, 0xFC, 0x3F, 0xDF, 0xC0, 0xFE, 0xFC, 0x07, 0xF7, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xDF, 0x0F, 0xFC, 0xF8, 0x3F, 0xC7, 0xC0, 0x20, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x02, 0x3F,
  0x80, 0x63, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0x98, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0x3E, 0x7F, 0xFD, 0xF3, 0xFF, 0xFF,
  0x9F, 0xC3, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFB,
  0xF0, 0xFF, 0xDF, 0x83, 0xF8, 0xFC, 0x02, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF6, 0x00, 0x7F,
  0x3E, 0x07, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7F,
  0x8F, 0xCF, 0xFC, 0xFD, 0xFF, 0xEF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFC, 0x07, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x9F, 0xDF, 0xFB, 0xFE, 0x7F,
  0xCF, 0xF1, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xFC,
  0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFE, 0xFC, 0x0F, 0xF3, 0xF0, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF8,
  0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x3F, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7F, 0x83, 0xFC,
  0x3E, 0x3F, 0xF1, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0x0F, 0xEF, 0xF0, 0x7F,
  0x81, 0xFB, 0xF8, 0x1F, 0xE0, 0x7E, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFC,
  0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x01, 0xFF,
  0xF0, 0x0F, 0xC0, 0x7F, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xFC, 0x03, 0xF0,
  0x1F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xF0, 0x0F,
  0xC0, 0x7F, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xFC, 0x03, 0xF0, 0x1F, 0xFF,
  0x00, 0xFC, 0x07, 0xF0, 0xF8, 0x7F, 0x8F, 0x8F, 0xFC, 0xFD, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xBF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x7F, 0x03,
  0xF3, 0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFE,
  0x1F, 0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07,
  0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F,
  0xBF, 0xC0, 0xFE, 0xFF, 0x87, 0xF3, 0xFF, 0xFF, 0xCF, 0xDF, 0xFE, 0x3F,
  0x7F, 0xF8, 0xFC, 0xFF, 0xC3, 0xF1, 0xFE, 0x0F, 0xC0, 0x40, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0xF8, 0x7F,
  0xE7, 0xC7, 0xFF, 0x3E, 0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0x9F, 0xC3, 0xFD,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F,
  0x87, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFB, 0xF0, 0xFF, 0xDF,
  0x83, 0xF8, 0xFC, 0x03, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xEF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xF8,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFC, 0x0E, 0xFC, 0x02,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x05, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x8F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x06, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x0F,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFD, 0xF3, 0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0xFF,
  0x1F, 0x01, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xEF,
  0xC0, 0x7F, 0x80, 0xFD, 0xF8, 0x0F, 0xF0, 0x1F, 0xBF, 0x01, 0xFE, 0x03,
  0xF7, 0xE0, 0x3F, 0xC0, 0x7E, 0xFE, 0x0F, 0xF8, 0x1F, 0x8F, 0xC1, 0xFF,
  0x83, 0xF1, 0xF8, 0x3F, 0xF0, 0x7E, 0x3F, 0x07, 0xBE, 0x0F, 0xC7, 0xE0,
  0xF3, 0xC1, 0xF0, 0x7E, 0x1E, 0x78, 0x7E, 0x0F, 0xC7, 0xCF, 0x0F, 0xC1,
  0xF8, 0xF9, 0xF1, 0xF8, 0x3F, 0x1E, 0x3E, 0x3F, 0x07, 0xE3, 0xC3, 0xCF,
  0xC0, 0x7E, 0x78, 0x79, 0xF8, 0x0F, 0xDF, 0x0F, 0x3F, 0x01, 0xFB, 0xE1,
  0xE7, 0xE0, 0x3F, 0x7C, 0x3E, 0xF8, 0x03, 0xEF, 0x07, 0xDF, 0x00, 0x7D,
  0xE0, 0xFF, 0xE0, 0x0F, 0xBC, 0x0F, 0xFC, 0x01, 0xF7, 0x81, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFD, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x80,
  0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x09, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x04, 0x7F, 0x80, 0x17, 0xFF, 0x80, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x80,
  0x00, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 17, 14, 23, 3, -39 },
  { 71, 25, 39, 27, 1, -39 },
  { 193, 21, 45, 25, 2, -42 },
  { 312, 36, 41, 40, 2, -40 },
  { 497, 28, 41, 29, 1, -40 },
  { 641, 7, 14, 12, 3, -39 },
  { 654, 13, 48, 17, 3, -39 },
  { 732, 13, 48, 17, 1, -39 },
  { 810, 21, 21, 23, 1, -42 },
  { 866, 21, 27, 25, 2, -33 },
  { 937, 9, 13, 13, 2, -6 },
  { 952, 13, 6, 16, 2, -18 },
  { 962, 7, 9, 13, 3, -8 },
  { 970, 20, 40, 22, 1, -40 },
  { 1070, 21, 41, 25, 2, -40 },
  { 1178, 15, 39, 25, 3, -39 },
  { 1252, 20, 40, 25, 2, -40 },
  { 1352, 20, 41, 25, 2, -40 },
  { 1455, 23, 39, 25, 1, -39 },
  { 1568, 19, 40, 25, 3, -39 },
  { 1663, 21, 41, 25, 2, -40 },
  { 1771, 22, 39, 25, 1, -39 },
  { 1879, 21, 41, 25, 2, -40 },
  { 1987, 21, 41, 25, 2, -40 },
  { 2095, 8, 31, 14, 3, -30 },
  { 2126, 9, 37, 14, 2, -30 },
  { 2168, 22, 25, 25, 1, -32 },
  { 2237, 21, 16, 25, 2, -27 },
  { 2279, 21, 25, 25, 2, -32 },
  { 2345, 18, 41, 19, 0, -40 },
  { 2438, 34, 44, 38, 2, -40 },
  { 2625, 27, 39, 27, 0, -39 },
  { 2757, 22, 39, 28, 4, -39 },
  { 2865, 21, 41, 26, 3, -40 },
  { 2973, 23, 39, 30, 4, -39 },
  { 3086, 17, 39, 23, 4, -39 },
  { 3169, 17, 39, 23, 4, -39 },
  { 3252, 24, 41, 31, 3, -40 },
  { 3375, 23, 39, 31, 4, -39 },
  { 3488, 13, 39, 17, 2, -39 },
  { 3552, 13, 50, 14, -3, -39 },
  { 3634, 23, 39, 27, 4, -39 },
  { 3747, 17, 39, 22, 4, -39 },
  { 3830, 34, 39, 41, 4, -39 },
  { 3996, 26, 39, 33, 4, -39 },
  { 4123, 26, 41, 32, 3, -40 },
  { 4257, 20, 39, 26, 4, -39 },
  { 4355, 26, 49, 32, 3, -40 },
  { 4515, 23, 39, 27, 4, -39 },
  { 4628, 19, 41, 23, 2, -40 },
  { 4726, 21, 39, 23, 1, -39 },
  { 4829, 23, 40, 30, 4, -39 },
  { 4944, 27, 39, 27, 0, -39 },
  { 5076, 41, 39, 40, 0, -39 },
  { 5276, 24, 39, 25, 0, -39 },
  { 5393, 24, 39, 24, 0, -39 },
  { 5510, 20, 39, 22, 1, -39 },
  { 5608, 13, 48, 17, 3, -39 },
  { 5686, 20, 40, 22, 1, -40 },
  { 5786, 13, 48, 17, 1, -39 },
  { 5864, 25, 23, 27, 1, -39 },
  { 5936, 23, 3, 23, 0, 5 },
  { 5945, 12, 9, 16, 2, -42 },
  { 5959, 19, 31, 25, 2, -30 },
  { 6033, 22, 43, 27, 3, -42 },
  { 6152, 18, 31, 21, 2, -30 },
  { 6222, 21, 43, 27, 2, -42 },
  { 6335, 20, 31, 24, 2, -30 },
  { 6413, 17, 42, 16, 0, -42 },
  { 6503, 21, 43, 27, 2, -30 },
  { 6616, 20, 42, 27, 3, -42 },
  { 6721, 7, 41, 13, 3, -41 },
  { 6757, 11, 54, 13, -1, -41 },
  { 6832, 22, 42, 25, 3, -42 },
  { 6948, 6, 42, 13, 3, -42 },
  { 6980, 34, 30, 40, 3, -30 },
  { 7108, 20, 30, 27, 3, -30 },
  { 7183, 22, 31, 26, 2, -30 },
  { 7269, 22, 43, 27, 3, -30 },
  { 7388, 21, 43, 27, 2, -30 },
  { 7501, 15, 30, 18, 3, -30 },
  { 7558, 16, 31, 20, 2, -30 },
  { 7620, 15, 37, 17, 1, -36 },
  { 7690, 20, 31, 27, 3, -30 },
  { 7768, 23, 30, 23, 0, -30 },
  { 7855, 35, 30, 36, 0, -30 },
  { 7987, 22, 30, 22, 0, -30 },
  { 8070, 23, 43, 23, 0, -30 },
  { 8194, 17, 30, 19, 1, -30 },
  { 8258, 16, 48, 19, 1, -39 },
  { 8354, 5, 55, 23, 9, -42 },
  { 8389, 16, 48, 19, 2, -39 },
  { 8485, 22, 9, 25, 1, -24 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD55PT7B_H_
