#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0xFF, 0xFD, 0xF7,
  0xC0, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xE1, 0xF7,
  0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x80, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x70, 0xE0, 0x0E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x87, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFC, 0xF9, 0x8C, 0xF9, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF9,
  0x80, 0xF9, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xBE, 0x01, 0x9F, 0x01, 0x9F, 0x01,
  0x9F, 0x81, 0x9E, 0xF1, 0xBE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F,
  0x80, 0x3C, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x0E, 0x00, 0xFB, 0xC0,
  0xF0, 0x07, 0x9E, 0x07, 0x80, 0x3C, 0x70, 0x38, 0x01, 0xC3, 0xC3, 0xC0,
  0x0E, 0x1E, 0x1E, 0x00, 0xF0, 0xF1, 0xE0, 0x07, 0x87, 0x8F, 0x00, 0x3C,
  0x3C, 0x70, 0x00, 0xE1, 0xE7, 0x80, 0x07, 0x0F, 0x3C, 0x78, 0x3C, 0x71,
  0xC7, 0xF1, 0xE7, 0x9E, 0x7F, 0x8F, 0xBC, 0xF3, 0xFE, 0x3F, 0xCF, 0x3C,
  0xF0, 0xFE, 0x79, 0xE3, 0xC3, 0xE3, 0x8F, 0x1E, 0x00, 0x3C, 0x70, 0xF0,
  0x01, 0xE3, 0x87, 0x80, 0x0E, 0x1C, 0x3C, 0x00, 0xF0, 0xE1, 0xE0, 0x07,
  0x87, 0x0F, 0x00, 0x78, 0x3C, 0x78, 0x03, 0xC1, 0xE3, 0xC0, 0x1C, 0x0F,
  0x1C, 0x01, 0xE0, 0x79, 0xE0, 0x0F, 0x01, 0xFF, 0x00, 0x70, 0x07, 0xF0,
  0x07, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x3E,
  0x3F, 0xF0, 0xF9, 0xFF, 0xC7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3F, 0x7C, 0xF8,
  0x7D, 0xF3, 0xE0, 0xFF, 0x8F, 0x83, 0xFE, 0x3E, 0x07, 0xF0, 0xF8, 0x0F,
  0xC3, 0xF0, 0x3F, 0x07, 0xE3, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xE7, 0xE0, 0xFF, 0x0F, 0xC0, 0xFF, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E,
  0x79, 0xE7, 0x80, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x81, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0,
  0x78, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43,
  0xC2, 0x7B, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7E, 0x3C, 0x3C, 0x0C, 0x30, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F,
  0x3C, 0x78, 0xF3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7E,
  0xFC, 0x7C, 0x7C, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F,
  0xF1, 0xFF, 0x3F, 0xF7, 0xDF, 0xFD, 0xF7, 0x9F, 0x31, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE,
  0x7C, 0x7E, 0x30, 0x3F, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0x87, 0xE1, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x40,
  0x1F, 0xB8, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xBE, 0x01, 0xEF, 0x80, 0x73,
  0xE0, 0x3C, 0xF8, 0x0E, 0x3E, 0x07, 0x8F, 0x81, 0xC3, 0xE0, 0xF0, 0xF8,
  0x3C, 0x3E, 0x1E, 0x0F, 0x87, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x20, 0xFE, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x80, 0x7E, 0xE0, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0,
  0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFC, 0x10, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x0E, 0x07, 0x9F, 0xC3, 0xDF, 0xF1, 0xFF, 0xF8, 0xFE, 0xFE, 0xFE, 0x1F,
  0x7E, 0x0F, 0xBF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0x87, 0xC7,
  0xC7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC,
  0x1F, 0xBF, 0x0F, 0x8F, 0xCF, 0x83, 0xE7, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x07, 0xCF, 0xFF, 0xE3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC7, 0xE7, 0xE3, 0xE1, 0xF1, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0xFD,
  0xF0, 0x7E, 0xFC, 0x7F, 0x7F, 0xFF, 0x9F, 0xF7, 0x87, 0xFB, 0xC1, 0xF9,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00,
  0x11, 0xF7, 0xFF, 0xFD, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x9F, 0xFF, 0xF7, 0xDF, 0x08, 0x7C, 0xFB, 0xF3, 0xE7, 0xC7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xC7, 0x9E, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x78, 0xFC, 0x81, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x0F,
  0x87, 0x9E, 0x0F, 0xF8, 0xE7, 0x87, 0xFE, 0x3D, 0xC3, 0xE7, 0x8F, 0xF0,
  0xF1, 0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x87, 0x8F,
  0xF1, 0xE1, 0xE3, 0xF8, 0x78, 0x78, 0xFE, 0x1E, 0x1C, 0x3F, 0x87, 0x8F,
  0x0F, 0xF1, 0xE3, 0xC3, 0xFC, 0x78, 0xF8, 0xEF, 0x1F, 0x7E, 0x7B, 0xC3,
  0xFF, 0xFC, 0xF0, 0x7E, 0x7F, 0x1E, 0x0F, 0x0F, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x03,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xC0, 0x7E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x8F, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x83,
  0xE7, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7C, 0x1F, 0xBE,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFC, 0xF1, 0xF8, 0x08, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3E, 0x0F, 0xCF, 0x81,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0x9F, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFE,
  0x3C, 0x7F, 0x00, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x03,
  0xE7, 0xE0, 0x7C, 0xFE, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xE0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xE1, 0xE0, 0xF8, 0x07,
  0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F,
  0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xEF,
  0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0,
  0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x7C, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xDE, 0x01,
  0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xE0, 0x1E, 0xFF, 0xFC, 0x07, 0xBF, 0xEF,
  0x03, 0xCF, 0xFB, 0xC0, 0xF3, 0xFE, 0xF0, 0x3C, 0xFF, 0x9E, 0x1F, 0x3F,
  0xE7, 0x87, 0x8F, 0xF9, 0xE1, 0xE3, 0xFE, 0x7C, 0x78, 0xFF, 0x8F, 0x3C,
  0x3F, 0xE3, 0xCF, 0x0F, 0xF8, 0xF3, 0xC3, 0xFE, 0x3E, 0xF0, 0xFF, 0x87,
  0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xC0, 0xFF,
  0x83, 0xF0, 0x3F, 0xE0, 0xFC, 0x0F, 0xF8, 0x3F, 0x03, 0xFE, 0x07, 0x80,
  0xFF, 0x81, 0xE0, 0x3C, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xF7, 0x81, 0xFF, 0x7C, 0x1F, 0xFB, 0xC1, 0xFF, 0xBE, 0x1F, 0xFB, 0xE1,
  0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF9, 0xFF, 0x87,
  0x9F, 0xF8, 0x7D, 0xFF, 0x87, 0xCF, 0xF8, 0x3E, 0xFF, 0x83, 0xEF, 0xF8,
  0x1E, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF8, 0xFE, 0x1F,
  0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F,
  0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF8, 0xFE, 0x1F,
  0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F,
  0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x9F, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFC,
  0x07, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x04,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0xC0, 0x3E, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x03, 0xE7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x7C,
  0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xEF, 0x00,
  0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E,
  0xF8, 0x07, 0xE0, 0x3E, 0x78, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E,
  0x7C, 0x0F, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3C, 0x7C, 0x0F, 0xF0, 0x7C,
  0x3C, 0x0F, 0xF0, 0x7C, 0x3E, 0x0E, 0xF0, 0x7C, 0x3E, 0x1E, 0xF0, 0x7C,
  0x3E, 0x1E, 0xF0, 0x78, 0x3E, 0x1E, 0x78, 0xF8, 0x1E, 0x1E, 0x78, 0xF8,
  0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x3C, 0x78, 0xF8, 0x1F, 0x3C, 0x78, 0xF0,
  0x1F, 0x3C, 0x3D, 0xF0, 0x0F, 0x3C, 0x3D, 0xF0, 0x0F, 0x3C, 0x3D, 0xF0,
  0x0F, 0xF8, 0x3D, 0xF0, 0x0F, 0xF8, 0x3D, 0xE0, 0x0F, 0xF8, 0x1D, 0xE0,
  0x07, 0xF8, 0x1D, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x3F, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x0F,
  0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0x80, 0xF8,
  0xF8, 0x1F, 0x1F, 0x07, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xF8, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF0,
  0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x9E, 0x01, 0xE3,
  0xC0, 0x7C, 0x7C, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x01,
  0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x01,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1C, 0x3E, 0x10, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x7E, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0x7C, 0x3F, 0x7E, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x1F, 0x8F, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xE0, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF,
  0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0xFF, 0xFE, 0xF7,
  0xFC, 0xF7, 0xFC, 0xF3, 0xF8, 0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF7,
  0xF7, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x17, 0xFF, 0x9F, 0xFC, 0x7F, 0xE1, 0xFE, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x07, 0x0F, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xEF, 0x7E, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x3F, 0xEF,
  0x1F, 0xCF, 0x03, 0x80, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7C,
  0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x06, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xF8, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF9, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x00, 0x1F, 0xCF,
  0x3F, 0xEF, 0x7F, 0xEF, 0x7E, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F,
  0x7F, 0xFF, 0x3F, 0xEF, 0x3F, 0xEF, 0x1F, 0x8F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x60, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF8, 0x3F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0xC3, 0xCF,
  0xE7, 0xBF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3E, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x01, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0,
  0xFB, 0xFD, 0xFE, 0xFE, 0x7E, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0xF8,
  0xF1, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xF8, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x3C, 0x3C, 0xFE, 0x3F, 0xCF,
  0x7F, 0xDF, 0xF3, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0x1F, 0xC3,
  0xEF, 0x83, 0xF0, 0xFB, 0xE0, 0xF8, 0x1F, 0xF8, 0x3E, 0x07, 0xFC, 0x0F,
  0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E, 0x07, 0xFC,
  0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E, 0x07,
  0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E,
  0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0x00,
  0xE1, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0x03, 0xC0, 0x07, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xF7, 0xE3, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x9F, 0x07,
  0xCF, 0x87, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00,
  0xE0, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3E, 0xFF, 0xFE, 0xF7, 0xFC, 0xF7, 0xFC, 0xF3, 0xF8, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x1F, 0xCF, 0x3F,
  0xEF, 0x7F, 0xEF, 0x7E, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F,
  0xFF, 0x3F, 0xEF, 0x3F, 0xCF, 0x1F, 0x8F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0xFC, 0x7F, 0xDF, 0xFB, 0xFF, 0xFD, 0xFE, 0x7F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xC7, 0x7C, 0x0B, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xCF, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0xE7, 0xFC, 0x7F, 0x87, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF,
  0x3F, 0xEF, 0x1F, 0xCF, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E,
  0x07, 0x87, 0x81, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xF7, 0xC0, 0x3D, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF7,
  0x81, 0xF8, 0x1E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x3F,
  0xC3, 0xE3, 0xC3, 0xFC, 0x3C, 0x3C, 0x3F, 0xC3, 0xC3, 0xE3, 0x9C, 0x7C,
  0x3E, 0x39, 0xC7, 0xC3, 0xE7, 0x9E, 0x7C, 0x1E, 0x79, 0xE7, 0x81, 0xE7,
  0x9E, 0x78, 0x1F, 0x70, 0xEF, 0x81, 0xF7, 0x0E, 0xF8, 0x0F, 0x70, 0xEF,
  0x00, 0xF7, 0x0E, 0xF0, 0x0F, 0xF0, 0xEF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0xBE, 0x0F, 0x8F, 0x87, 0xC7,
  0xC7, 0xC1, 0xF3, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xC3, 0xC7,
  0xC1, 0xF3, 0xE0, 0xFB, 0xF0, 0x3E, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x1E, 0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x78, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xFF, 0x03, 0xF0, 0x3F, 0x0F, 0xF0, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0E, 0x00, 0x3F, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 31, 11, 2, -31 },
  { 25, 14, 11, 18, 2, -31 },
  { 45, 19, 31, 21, 1, -31 },
  { 119, 16, 36, 19, 2, -33 },
  { 191, 29, 31, 31, 1, -31 },
  { 304, 22, 31, 23, 1, -31 },
  { 390, 6, 11, 10, 2, -31 },
  { 399, 10, 38, 13, 2, -31 },
  { 447, 10, 38, 13, 1, -31 },
  { 495, 16, 16, 18, 1, -33 },
  { 527, 17, 20, 19, 1, -25 },
  { 570, 7, 11, 10, 1, -5 },
  { 580, 10, 5, 13, 1, -14 },
  { 587, 6, 6, 10, 2, -6 },
  { 592, 15, 31, 17, 1, -31 },
  { 651, 16, 31, 19, 2, -31 },
  { 713, 12, 31, 19, 2, -31 },
  { 760, 16, 31, 19, 1, -31 },
  { 822, 17, 31, 19, 1, -31 },
  { 888, 18, 31, 19, 1, -31 },
  { 958, 16, 31, 19, 2, -31 },
  { 1020, 17, 31, 19, 1, -31 },
  { 1086, 17, 31, 19, 1, -31 },
  { 1152, 17, 31, 19, 1, -31 },
  { 1218, 17, 31, 19, 1, -31 },
  { 1284, 6, 24, 11, 2, -24 },
  { 1302, 7, 30, 11, 1, -24 },
  { 1329, 17, 20, 19, 1, -25 },
  { 1372, 17, 12, 19, 1, -21 },
  { 1398, 17, 20, 19, 1, -25 },
  { 1441, 14, 31, 15, 0, -31 },
  { 1496, 26, 34, 30, 2, -31 },
  { 1607, 21, 31, 21, 0, -31 },
  { 1689, 17, 31, 22, 3, -31 },
  { 1755, 17, 31, 20, 2, -31 },
  { 1821, 18, 31, 23, 3, -31 },
  { 1891, 13, 31, 18, 3, -31 },
  { 1942, 13, 31, 18, 3, -31 },
  { 1993, 19, 31, 24, 2, -31 },
  { 2067, 18, 31, 24, 3, -31 },
  { 2137, 11, 31, 13, 1, -31 },
  { 2180, 10, 40, 11, -2, -31 },
  { 2230, 18, 31, 21, 3, -31 },
  { 2300, 13, 31, 17, 3, -31 },
  { 2351, 26, 31, 32, 3, -31 },
  { 2452, 20, 31, 26, 3, -31 },
  { 2530, 21, 31, 25, 2, -31 },
  { 2612, 16, 31, 20, 3, -31 },
  { 2674, 21, 38, 25, 2, -31 },
  { 2774, 18, 31, 21, 3, -31 },
  { 2844, 16, 31, 18, 1, -31 },
  { 2906, 16, 31, 18, 1, -31 },
  { 2968, 18, 31, 24, 3, -31 },
  { 3038, 21, 31, 21, 0, -31 },
  { 3120, 32, 31, 32, 0, -31 },
  { 3244, 19, 31, 19, 0, -31 },
  { 3318, 19, 31, 19, 0, -31 },
  { 3392, 15, 31, 17, 1, -31 },
  { 3451, 9, 38, 13, 3, -31 },
  { 3494, 15, 31, 17, 1, -31 },
  { 3553, 10, 38, 13, 1, -31 },
  { 3601, 19, 18, 21, 1, -31 },
  { 3644, 18, 3, 18, 0, 4 },
  { 3651, 9, 7, 13, 2, -33 },
  { 3659, 16, 24, 19, 1, -24 },
  { 3707, 16, 33, 21, 3, -33 },
  { 3773, 13, 24, 16, 2, -24 },
  { 3812, 16, 33, 21, 2, -33 },
  { 3878, 16, 24, 19, 2, -24 },
  { 3926, 13, 33, 12, 0, -33 },
  { 3980, 16, 34, 21, 2, -24 },
  { 4048, 15, 33, 21, 3, -33 },
  { 4110, 6, 32, 10, 2, -32 },
  { 4134, 9, 42, 10, -1, -32 },
  { 4182, 16, 33, 19, 3, -33 },
  { 4248, 4, 33, 10, 3, -33 },
  { 4265, 26, 24, 31, 3, -24 },
  { 4343, 15, 24, 21, 3, -24 },
  { 4388, 17, 24, 20, 2, -24 },
  { 4439, 16, 34, 21, 3, -24 },
  { 4507, 16, 34, 21, 2, -24 },
  { 4575, 11, 24, 14, 3, -24 },
  { 4608, 13, 24, 16, 1, -24 },
  { 4647, 11, 28, 13, 1, -28 },
  { 4686, 16, 23, 21, 2, -23 },
  { 4732, 18, 23, 18, 0, -23 },
  { 4784, 28, 23, 28, 0, -23 },
  { 4865, 17, 23, 17, 0, -23 },
  { 4914, 18, 33, 18, 0, -23 },
  { 4989, 13, 23, 15, 1, -23 },
  { 5027, 13, 38, 15, 1, -31 },
  { 5089, 4, 43, 18, 7, -33 },
  { 5111, 12, 38, 15, 2, -31 },
  { 5168, 17, 6, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD43PT7B_H_
