#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0x9F, 0x03, 0xF0, 0x00, 0x7C, 0x1E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3E,
  0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x1F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xBF,
  0x1F, 0xCE, 0x0C, 0x7E, 0x38, 0x01, 0xF8, 0xE0, 0x07, 0xE3, 0x80, 0x1F,
  0x8E, 0x00, 0x7E, 0x38, 0x01, 0xFC, 0xE0, 0x07, 0xFB, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3B, 0xFC, 0x00, 0xE7, 0xF0, 0x03, 0x8F, 0xC0, 0x0E, 0x3F, 0x00, 0x38,
  0xFC, 0x00, 0xE3, 0xFC, 0x03, 0x8F, 0xFC, 0x0E, 0x7E, 0xFE, 0x3F, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x3E, 0x00, 0x1F,
  0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x1F, 0x00, 0x07,
  0xC1, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE1,
  0xF0, 0x00, 0x3E, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x8F, 0x80, 0x00,
  0xF8, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xF0, 0xF8,
  0xF8, 0x7F, 0x83, 0xE1, 0xF1, 0xF1, 0xFF, 0x87, 0xC3, 0xE7, 0xE3, 0xFF,
  0x8F, 0xCF, 0x8F, 0x8F, 0xFF, 0x8F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0xFC,
  0x7C, 0x7C, 0x3E, 0x1F, 0xF8, 0xF8, 0xF8, 0x7E, 0x1F, 0xE1, 0xF1, 0xF0,
  0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x00,
  0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x1F, 0x8F, 0x80,
  0x07, 0xC0, 0x1F, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0xE0, 0xFE, 0x3F,
  0xFF, 0x83, 0xF0, 0xFE, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3,
  0xF9, 0xFC, 0x7F, 0x07, 0xF7, 0xE1, 0xF8, 0x0F, 0xFF, 0x8F, 0xE0, 0x3F,
  0xFE, 0x3F, 0x80, 0x7F, 0xF0, 0xFE, 0x01, 0xFF, 0xC1, 0xFC, 0x03, 0xFE,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xC1,
  0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0x9F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0x0F, 0x83, 0x1F,
  0x3E, 0x7E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFF, 0x07, 0xC1, 0xF8, 0x0F,
  0x07, 0x80, 0x08, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE, 0x7E,
  0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFE, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xF9,
  0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F,
  0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xBF, 0xDF, 0xFF, 0xCF, 0xEF,
  0xC7, 0xF3, 0xC3, 0xF8, 0xC1, 0xFC, 0x40, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xF1,
  0xFF, 0x0F, 0x01, 0xFE, 0x38, 0x03, 0xF8, 0x40, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xE0, 0xFF,
  0x8E, 0x01, 0xFE, 0x10, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0xC0, 0x07, 0xFB, 0xF0,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x3F, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x03,
  0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC4, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x1E, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xA0,
  0x03, 0xFD, 0x80, 0x3F, 0xEF, 0xC7, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x81, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x83, 0xF9, 0xFF,
  0x0F, 0xEF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xF8, 0x3F, 0xBF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0xFF, 0x9F, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F,
  0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8,
  0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC7, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF0,
  0x0F, 0xEF, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F,
  0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFD, 0xFC,
  0x1F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFE, 0xFC, 0x7F, 0xF3,
  0xF0, 0xFF, 0x8F, 0xC0, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x81, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x1F,
  0x0F, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0x7C, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3E,
  0x3F, 0xE3, 0x80, 0xFE, 0x20, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x01, 0xFF, 0x87, 0xC7, 0xE0, 0x7F, 0xFC,
  0x7E, 0x7C, 0x0F, 0xFF, 0xC3, 0xE7, 0xC1, 0xFF, 0xFC, 0x3E, 0x7C, 0x1F,
  0x8F, 0x83, 0xEF, 0x83, 0xF0, 0xF8, 0x3E, 0xF8, 0x3E, 0x0F, 0x83, 0xEF,
  0x83, 0xE0, 0xF8, 0x1F, 0xF8, 0x7E, 0x0F, 0x81, 0xFF, 0x87, 0xC0, 0xF8,
  0x1F, 0xF8, 0x7C, 0x0F, 0x81, 0xFF, 0x87, 0xC0, 0xF8, 0x1F, 0xF8, 0x7C,
  0x0F, 0x81, 0xEF, 0x87, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x0F, 0x83, 0xEF,
  0x87, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x1F, 0x83, 0xEF, 0x87, 0xE1, 0xF8,
  0x3E, 0xF8, 0x3E, 0x1F, 0x87, 0xCF, 0x83, 0xF3, 0xFC, 0xFC, 0xF8, 0x3F,
  0xFB, 0xFF, 0x8F, 0xC1, 0xFF, 0x9F, 0xF8, 0x7C, 0x0F, 0xF1, 0xFF, 0x07,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0x0F, 0xF0, 0x0C,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x11, 0xFF, 0x00, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xF1, 0xFC, 0x07, 0xFC, 0xFE, 0x01, 0xFE,
  0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x1F, 0xC1, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xE1, 0xF8, 0x7F, 0xC0, 0x0E, 0x1F, 0xE0, 0x00, 0x8F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0xE0, 0x03, 0xF3, 0xFC, 0x00, 0xFC,
  0xFF, 0x00, 0x3F, 0x1F, 0xE0, 0x0F, 0xC7, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE1, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xA1, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F,
  0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07,
  0xF8, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xF1,
  0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x80,
  0x7F, 0x9F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFD, 0xF8, 0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x1F, 0xBF, 0xFD,
  0xF8, 0x01, 0xFB, 0xFF, 0xCF, 0x80, 0x1F, 0xBF, 0xFC, 0xFC, 0x01, 0xF3,
  0xFF, 0xEF, 0xC0, 0x3F, 0x3F, 0xFE, 0xFC, 0x03, 0xF3, 0xFF, 0xE7, 0xC0,
  0x3E, 0x3F, 0xFE, 0x7E, 0x03, 0xE3, 0xFF, 0xE7, 0xE0, 0x7E, 0x3F, 0xFE,
  0x7E, 0x07, 0xE3, 0xFF, 0xE3, 0xE0, 0x7C, 0x3F, 0xFE, 0x3F, 0x0F, 0xC3,
  0xFF, 0xE3, 0xF0, 0xFC, 0x3F, 0xFE, 0x3F, 0x0F, 0xC3, 0xFF, 0xE1, 0xF0,
  0xF8, 0x3F, 0xFE, 0x1F, 0x9F, 0x83, 0xFF, 0xE1, 0xF9, 0xF8, 0x3F, 0xFE,
  0x0F, 0x9F, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xFE,
  0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFE, 0x03, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xFD, 0xFC, 0x07, 0xFF,
  0xCF, 0xC0, 0x7F, 0xFC, 0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0x7E,
  0x07, 0xFF, 0xE7, 0xF0, 0x7F, 0xFE, 0x3F, 0x07, 0xFF, 0xE3, 0xF8, 0x7F,
  0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE0,
  0xFC, 0x7F, 0xFE, 0x0F, 0xE7, 0xFF, 0xE0, 0x7E, 0x7F, 0xFE, 0x07, 0xF7,
  0xFF, 0xE0, 0x7F, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFE,
  0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE, 0xFE, 0x7F,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3,
  0xF8, 0x3F, 0xE1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x01,
  0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xF0, 0x1C, 0x7F, 0x00, 0x27, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFD, 0xC0, 0x0F, 0xEF, 0x80, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0,
  0x1F, 0xE7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xFE, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFB,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xBE, 0x03, 0xF8, 0x1F, 0x80, 0xFB, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xBF, 0x03, 0xF8, 0x1F, 0xC1, 0xF9, 0xF0, 0x3F,
  0x01, 0xFC, 0x1F, 0x9F, 0x03, 0xF0, 0x1F, 0xC1, 0xF9, 0xF0, 0x7F, 0x00,
  0xFC, 0x1F, 0x1F, 0x87, 0xF0, 0x0F, 0xC1, 0xF1, 0xF8, 0x7F, 0x00, 0xFC,
  0x3F, 0x1F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0xF8, 0x7E, 0x00, 0xFE, 0x3F,
  0x0F, 0x8F, 0xE0, 0x07, 0xE3, 0xE0, 0xFC, 0xFE, 0x00, 0x7E, 0x3E, 0x0F,
  0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x07, 0xCF,
  0xC0, 0x07, 0xF7, 0xE0, 0x7C, 0xFC, 0x00, 0x3F, 0x7C, 0x07, 0xDF, 0xC0,
  0x03, 0xF7, 0xC0, 0x7D, 0xFC, 0x00, 0x3F, 0x7C, 0x07, 0xFF, 0xC0, 0x03,
  0xF7, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF,
  0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x38, 0x1F, 0xC1, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFE, 0xFD, 0xFF, 0xF7, 0xE7,
  0xFF, 0x1F, 0x1F, 0xE0, 0xF8, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x20, 0x1F, 0xC7, 0xF8,
  0x3F, 0x9F, 0xF8, 0x7F, 0x7F, 0xF8, 0xFE, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0x0F, 0xF7, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xE0, 0x7F,
  0x7F, 0xE1, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xF3, 0xFF, 0xC7,
  0xE3, 0xFF, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xF8, 0x71, 0xFC, 0x02, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x9F, 0xF0, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x06, 0x07, 0xE0, 0x7F, 0x0F, 0xC3, 0xFF,
  0x9F, 0x8F, 0xFF, 0xBF, 0x1F, 0xFF, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF, 0x1F,
  0xFB, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F,
  0xBF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0x9F, 0xE1,
  0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x7F, 0xFD, 0xF8, 0x7F, 0xF1,
  0xF0, 0x3F, 0xC3, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3,
  0xF8, 0x3F, 0x0F, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x8F, 0xF0, 0x1E,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF8, 0xFC, 0x3F,
  0xF9, 0xF8, 0x7F, 0xFB, 0xF1, 0xFF, 0xF7, 0xE7, 0xFF, 0xFF, 0xCF, 0xF1,
  0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF,
  0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF9, 0xFE,
  0x3F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xFF, 0xDF, 0x87, 0xFF,
  0x3F, 0x03, 0xF8, 0x7E, 0x00, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x10, 0x00, 0xFE,
  0x38, 0x03, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x06, 0x03, 0xF8, 0xFF, 0x0F,
  0xE7, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFE,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFC, 0x7E, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0xBF, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x07,
  0xF1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8,
  0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xDF, 0x80, 0xFF, 0x3F, 0x81, 0xFC,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x81,
  0xFC, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x07,
  0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x1C, 0x0F, 0xC3, 0xFC, 0x0F, 0xF8, 0xFC,
  0x7F, 0xE1, 0xFF, 0xCF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF,
  0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0x03, 0xF0, 0xFF,
  0x0F, 0xC7, 0xFE, 0x3F, 0x3F, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x01, 0xF8,
  0x7F, 0x83, 0xF1, 0xFF, 0x87, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x3F, 0xF0, 0xFF, 0x7F, 0xC0, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFB, 0xFE,
  0x07, 0xF7, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x9F, 0xDF, 0xFF, 0x3F, 0xBF,
  0xFC, 0x7F, 0x3F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0x0E, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xF8, 0xFC, 0x3F, 0xF9, 0xF8, 0x7F, 0xFB, 0xF1,
  0xFF, 0xF7, 0xE7, 0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0x9F, 0xC0, 0xFF, 0x7F,
  0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE,
  0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF9, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xEF, 0xC7, 0xFF, 0x9F, 0x87, 0xFF, 0x3F, 0x03, 0xF8, 0x7E, 0x00,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1D, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xE2, 0xFF, 0x81, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x81, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xE0, 0x73, 0xF0, 0x04,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFB, 0xE1, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE3, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x60, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0x80,
  0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF,
  0x3F, 0xFE, 0xFC, 0xFF, 0xFB, 0xF1, 0xFF, 0xC7, 0xC3, 0xFE, 0x1F, 0x00,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F,
  0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0xC0, 0x7E, 0x7F, 0x01, 0xFF,
  0x01, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0xF0, 0x3F, 0x8F,
  0xC0, 0xFF, 0xC0, 0xFC, 0x3F, 0x83, 0xEF, 0x83, 0xF0, 0xFE, 0x0F, 0xBE,
  0x0F, 0xC1, 0xF8, 0x3C, 0xF8, 0x7F, 0x07, 0xE1, 0xF3, 0xE1, 0xFC, 0x1F,
  0x87, 0xCF, 0x87, 0xE0, 0x7F, 0x1F, 0x1E, 0x1F, 0x80, 0xFC, 0x7C, 0x7C,
  0x7E, 0x03, 0xF1, 0xE1, 0xF3, 0xF8, 0x0F, 0xCF, 0x87, 0xCF, 0xC0, 0x3F,
  0x3E, 0x1F, 0x3F, 0x00, 0xFE, 0xF8, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0xF3,
  0xF0, 0x07, 0xEF, 0x83, 0xCF, 0x80, 0x1F, 0xBE, 0x0F, 0xFE, 0x00, 0x7E,
  0xF0, 0x3F, 0xF8, 0x00, 0xFB, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0xFE, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x07, 0xE7, 0xE0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x87,
  0xE0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F,
  0x9F, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0,
  0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x02, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x40, 0x07, 0xFC, 0x80, 0x00, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 43, 15, 3, -42 },
  { 44, 19, 15, 25, 3, -42 },
  { 80, 27, 42, 29, 1, -42 },
  { 222, 22, 48, 27, 2, -45 },
  { 354, 39, 44, 43, 2, -43 },
  { 569, 30, 44, 31, 1, -43 },
  { 734, 7, 15, 13, 3, -42 },
  { 748, 14, 51, 18, 3, -42 },
  { 838, 14, 51, 18, 1, -42 },
  { 928, 22, 22, 25, 2, -45 },
  { 989, 23, 28, 27, 2, -35 },
  { 1070, 9, 15, 14, 2, -7 },
  { 1087, 14, 6, 17, 2, -19 },
  { 1098, 8, 9, 14, 3, -8 },
  { 1107, 22, 42, 23, 1, -42 },
  { 1223, 22, 44, 26, 2, -43 },
  { 1344, 17, 42, 26, 3, -42 },
  { 1434, 22, 43, 26, 2, -43 },
  { 1553, 22, 44, 26, 2, -43 },
  { 1674, 25, 42, 26, 1, -42 },
  { 1806, 21, 43, 26, 3, -42 },
  { 1919, 22, 44, 26, 2, -43 },
  { 2040, 24, 42, 26, 1, -42 },
  { 2166, 23, 44, 26, 2, -43 },
  { 2293, 22, 44, 26, 2, -43 },
  { 2414, 8, 33, 15, 3, -32 },
  { 2447, 10, 40, 15, 2, -32 },
  { 2497, 23, 28, 27, 2, -35 },
  { 2578, 23, 17, 27, 2, -29 },
  { 2627, 23, 28, 27, 2, -35 },
  { 2708, 20, 44, 21, 0, -43 },
  { 2818, 36, 48, 41, 3, -43 },
  { 3034, 29, 42, 29, 0, -42 },
  { 3187, 24, 42, 30, 4, -42 },
  { 3313, 23, 44, 28, 3, -43 },
  { 3440, 25, 42, 32, 4, -42 },
  { 3572, 18, 42, 25, 4, -42 },
  { 3667, 18, 42, 24, 4, -42 },
  { 3762, 26, 44, 33, 3, -43 },
  { 3905, 25, 42, 33, 4, -42 },
  { 4037, 14, 42, 18, 2, -42 },
  { 4111, 14, 54, 15, -3, -42 },
  { 4206, 25, 42, 29, 4, -42 },
  { 4338, 18, 42, 23, 4, -42 },
  { 4433, 36, 42, 44, 4, -42 },
  { 4622, 28, 42, 36, 4, -42 },
  { 4769, 28, 44, 34, 3, -43 },
  { 4923, 22, 42, 28, 4, -42 },
  { 5039, 28, 53, 34, 3, -43 },
  { 5225, 25, 42, 29, 4, -42 },
  { 5357, 21, 44, 25, 2, -43 },
  { 5473, 22, 42, 24, 1, -42 },
  { 5589, 25, 43, 33, 4, -42 },
  { 5724, 28, 42, 28, 0, -42 },
  { 5871, 44, 42, 43, 0, -42 },
  { 6102, 26, 42, 26, 0, -42 },
  { 6239, 26, 42, 26, 0, -42 },
  { 6376, 21, 42, 23, 1, -42 },
  { 6487, 13, 51, 18, 4, -42 },
  { 6570, 22, 42, 23, 1, -42 },
  { 6686, 13, 51, 18, 2, -42 },
  { 6769, 27, 24, 29, 1, -42 },
  { 6850, 25, 4, 25, 0, 5 },
  { 6863, 13, 9, 17, 2, -45 },
  { 6878, 21, 34, 26, 2, -33 },
  { 6968, 23, 46, 29, 3, -45 },
  { 7101, 19, 34, 22, 2, -33 },
  { 7182, 23, 46, 29, 2, -45 },
  { 7315, 22, 34, 26, 2, -33 },
  { 7409, 17, 45, 17, 1, -45 },
  { 7505, 23, 47, 29, 2, -33 },
  { 7641, 22, 45, 29, 3, -45 },
  { 7765, 8, 44, 14, 3, -44 },
  { 7809, 12, 58, 14, -1, -44 },
  { 7896, 23, 45, 27, 4, -45 },
  { 8026, 7, 45, 14, 3, -45 },
  { 8066, 36, 33, 43, 3, -33 },
  { 8215, 22, 33, 29, 3, -33 },
  { 8306, 24, 34, 28, 2, -33 },
  { 8408, 23, 47, 29, 3, -33 },
  { 8544, 23, 47, 29, 2, -33 },
  { 8680, 15, 33, 20, 4, -33 },
  { 8742, 18, 34, 21, 2, -33 },
  { 8819, 16, 40, 18, 1, -39 },
  { 8899, 22, 33, 29, 3, -32 },
  { 8990, 24, 32, 25, 0, -32 },
  { 9086, 38, 32, 38, 0, -32 },
  { 9238, 23, 32, 24, 0, -32 },
  { 9330, 24, 46, 25, 0, -32 },
  { 9468, 18, 32, 20, 1, -32 },
  { 9540, 18, 51, 21, 1, -42 },
  { 9655, 6, 59, 25, 10, -45 },
  { 9700, 17, 51, 21, 2, -42 },
  { 9809, 23, 9, 27, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD59PT7B_H_
