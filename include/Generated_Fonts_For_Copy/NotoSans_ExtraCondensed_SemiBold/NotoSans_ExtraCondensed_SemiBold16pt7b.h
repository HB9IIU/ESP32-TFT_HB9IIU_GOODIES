#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x16, 0x34, 0x34, 0x7F, 0x24,
  0x24, 0xFE, 0xFE, 0x28, 0x68, 0x68, 0x21, 0xEF, 0xA8, 0xE3, 0x83, 0x8E,
  0x2E, 0xEF, 0x88, 0x20, 0x41, 0x38, 0x8B, 0x22, 0xD8, 0xB4, 0x2F, 0x6E,
  0xBD, 0x29, 0x1A, 0x44, 0x91, 0x3C, 0xC6, 0x10, 0x3C, 0x6C, 0x6C, 0x6C,
  0x38, 0x7B, 0x7B, 0xCF, 0xC6, 0x6E, 0x7B, 0xFF, 0x74, 0xCC, 0xC8, 0x88,
  0xCC, 0xC4, 0x63, 0xE6, 0x23, 0x33, 0x33, 0x33, 0x26, 0x6C, 0x11, 0x5F,
  0xCE, 0x6C, 0xA0, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xFE, 0xFF,
  0xF0, 0x04, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x21, 0x84, 0x30, 0x21, 0xED,
  0xB2, 0x8E, 0x38, 0xE3, 0xCB, 0x6D, 0x9C, 0x37, 0xFB, 0x33, 0x33, 0x33,
  0x30, 0x23, 0xE9, 0x86, 0x18, 0x63, 0x0C, 0x63, 0x0F, 0xFF, 0x63, 0xE9,
  0x86, 0x19, 0xC7, 0x06, 0x0C, 0x6B, 0xBC, 0x0C, 0x38, 0x71, 0x62, 0xC9,
  0x93, 0x7F, 0xFE, 0x18, 0x30, 0xFB, 0x0C, 0x30, 0xFA, 0x60, 0x83, 0x1A,
  0xEF, 0x00, 0x19, 0xEC, 0x30, 0x82, 0xED, 0xA3, 0x8F, 0x3D, 0x9E, 0xFE,
  0x08, 0x30, 0x60, 0x83, 0x06, 0x08, 0x30, 0x61, 0x80, 0x10, 0xF9, 0x93,
  0x26, 0xC7, 0x0E, 0x36, 0x47, 0x8D, 0xB3, 0xE0, 0x10, 0xF9, 0xB2, 0x2C,
  0x68, 0xDF, 0x9A, 0x04, 0x19, 0x73, 0xC0, 0xFC, 0x03, 0xC0, 0xFC, 0x03,
  0xF8, 0x06, 0x39, 0xC7, 0x03, 0x81, 0xC0, 0x80, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0xC0, 0xE0, 0x70, 0x73, 0x9C, 0x20, 0x00, 0x27, 0xE6, 0x11, 0x9C,
  0xC4, 0x00, 0x18, 0xC0, 0x08, 0x1F, 0x98, 0x79, 0x19, 0xED, 0xB6, 0xDB,
  0x6D, 0xB6, 0xCD, 0xF0, 0x0C, 0x23, 0xE0, 0x18, 0x3C, 0x3C, 0x3C, 0x24,
  0x66, 0x7E, 0x7E, 0x66, 0xC3, 0xC3, 0xFF, 0x3C, 0xF3, 0xFF, 0xFC, 0xF1,
  0xCF, 0xFF, 0x80, 0x19, 0xF6, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x07, 0xCF,
  0xF9, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCD, 0xFB, 0xE0, 0xFE, 0x31,
  0x8F, 0xFF, 0x18, 0xC7, 0xFE, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x30,
  0x18, 0xFD, 0x8E, 0x0C, 0x18, 0x33, 0xE3, 0xC7, 0x8D, 0xF9, 0xF0, 0xC7,
  0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF6, 0x66, 0x66,
  0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xBE, 0xCF, 0x9B,
  0x66, 0xCF, 0x1E, 0x36, 0x6C, 0xCD, 0x9B, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC7, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0xF2, 0xF4, 0xBD, 0xEF,
  0x7B, 0xCC, 0xF3, 0x3C, 0xCC, 0xE3, 0xE3, 0xF3, 0xF3, 0xD3, 0xDB, 0xCB,
  0xCF, 0xCF, 0xC7, 0xC7, 0x10, 0x7C, 0xE6, 0xC6, 0xC6, 0xC2, 0xC3, 0xC2,
  0xC6, 0xC6, 0x7E, 0x3C, 0xFB, 0x3C, 0xF3, 0xCF, 0xEF, 0x30, 0xC3, 0x0C,
  0x00, 0x10, 0x7C, 0xE6, 0xC6, 0xC6, 0xC2, 0xC3, 0xC2, 0xC6, 0xC6, 0x7E,
  0x3C, 0x0C, 0x0E, 0x06, 0xF9, 0x9B, 0x36, 0x6C, 0xDF, 0x36, 0x6C, 0xCD,
  0x9B, 0x18, 0x27, 0xF3, 0x0C, 0x71, 0xC3, 0x18, 0xFF, 0xE0, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0xD9, 0xF0, 0xC3, 0xC6, 0x46, 0x66, 0x64, 0x64, 0x2C,
  0x3C, 0x38, 0x38, 0x18, 0xC6, 0x3C, 0x62, 0xC6, 0x64, 0xE6, 0x6F, 0x66,
  0xB6, 0x69, 0x46, 0x94, 0x39, 0xC3, 0x9C, 0x31, 0xC0, 0xE6, 0xD9, 0xB1,
  0xC3, 0x87, 0x0E, 0x16, 0x6C, 0xCB, 0x18, 0xC6, 0xC9, 0xB3, 0x63, 0x87,
  0x06, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x31, 0x86, 0x10, 0xC2, 0x18, 0x63,
  0xFF, 0xC0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0x06, 0x18,
  0x20, 0xC3, 0x04, 0x18, 0x20, 0xC3, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xFF, 0x18, 0x18, 0x3C, 0x24, 0x66, 0xC3, 0xFE, 0xCC, 0x39, 0xF0, 0xC3,
  0x7D, 0xBC, 0xDB, 0x74, 0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF, 0x3E,
  0xFE, 0x7F, 0xB1, 0x88, 0x43, 0x19, 0x78, 0x0C, 0x30, 0xDB, 0xFF, 0x38,
  0xE3, 0x8F, 0x3D, 0xDF, 0x73, 0xEC, 0xA2, 0xFE, 0x0C, 0x32, 0x78, 0x3B,
  0x58, 0xEF, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x6F, 0xFC, 0xF3, 0x8E, 0x3C,
  0xF7, 0x7C, 0x30, 0xFE, 0xF0, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xF3, 0xFF, 0xFF, 0x6C, 0x36, 0xDB, 0x6D, 0xB6, 0xFE, 0xC3,
  0x0C, 0x33, 0xDB, 0x6F, 0x3C, 0xDB, 0x6C, 0xF3, 0xFF, 0xFF, 0xFF, 0xBB,
  0xBF, 0xEC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xC0, 0xBB,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0x73, 0xEC, 0xE3, 0x8E, 0x3C, 0xF6,
  0x78, 0xBB, 0xFC, 0xF3, 0xCF, 0x3C, 0xFB, 0xFB, 0x0C, 0x30, 0xC0, 0x6F,
  0xFC, 0xF3, 0x8E, 0x3C, 0xF7, 0x7C, 0x30, 0xC3, 0x0C, 0x9F, 0xCC, 0xCC,
  0xCC, 0xC0, 0x3B, 0xF0, 0xC7, 0x0C, 0x3B, 0xF8, 0x23, 0x1D, 0xE6, 0x31,
  0x8C, 0x63, 0x4E, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0x7C, 0xC7, 0x99,
  0x33, 0x66, 0x8D, 0x0E, 0x1C, 0x30, 0xCC, 0x73, 0x34, 0xED, 0xAB, 0x7A,
  0x9E, 0xA7, 0x38, 0xCE, 0x33, 0x80, 0xCD, 0xB7, 0x8E, 0x30, 0xE7, 0x9B,
  0xCC, 0xC7, 0x99, 0x33, 0x66, 0x85, 0x0E, 0x1C, 0x30, 0x60, 0xC7, 0x0E,
  0x00, 0x7B, 0xC6, 0x63, 0x31, 0x8F, 0xF8, 0x39, 0x8C, 0x63, 0x1B, 0x06,
  0x31, 0x8C, 0x63, 0x84, 0xFF, 0xFF, 0xC6, 0x66, 0x66, 0x36, 0x66, 0x66,
  0xC8, 0x73, 0xFE, 0x10,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 13, 7, 1, -12 },
  { 28, 10, 12, 12, 1, -12 },
  { 43, 8, 12, 8, 0, -12 },
  { 55, 2, 4, 4, 1, -11 },
  { 56, 4, 14, 5, 1, -11 },
  { 63, 4, 14, 5, 0, -11 },
  { 70, 6, 6, 7, 0, -12 },
  { 75, 7, 7, 7, 0, -9 },
  { 82, 2, 4, 4, 1, -2 },
  { 83, 4, 2, 5, 0, -5 },
  { 84, 2, 2, 4, 1, -2 },
  { 85, 6, 12, 6, 0, -12 },
  { 94, 6, 12, 7, 1, -12 },
  { 103, 4, 11, 7, 1, -11 },
  { 109, 6, 12, 7, 1, -12 },
  { 118, 6, 12, 7, 1, -12 },
  { 127, 7, 11, 7, 0, -11 },
  { 137, 6, 11, 7, 1, -11 },
  { 146, 6, 12, 7, 1, -12 },
  { 155, 7, 11, 7, 0, -11 },
  { 165, 7, 12, 7, 0, -12 },
  { 176, 7, 12, 7, 0, -12 },
  { 187, 2, 9, 4, 1, -9 },
  { 190, 2, 11, 4, 1, -9 },
  { 193, 7, 7, 7, 0, -9 },
  { 200, 7, 5, 7, 0, -8 },
  { 205, 7, 7, 7, 0, -9 },
  { 212, 5, 12, 6, 0, -12 },
  { 220, 9, 13, 11, 1, -12 },
  { 235, 8, 11, 8, 0, -11 },
  { 246, 6, 11, 8, 1, -11 },
  { 255, 6, 12, 8, 1, -12 },
  { 264, 7, 11, 9, 1, -11 },
  { 274, 5, 11, 7, 1, -11 },
  { 281, 5, 11, 7, 1, -11 },
  { 288, 7, 12, 9, 1, -12 },
  { 299, 7, 11, 9, 1, -11 },
  { 309, 4, 11, 5, 0, -11 },
  { 315, 4, 14, 4, -1, -11 },
  { 322, 7, 11, 8, 1, -11 },
  { 332, 5, 11, 6, 1, -11 },
  { 339, 10, 11, 12, 1, -11 },
  { 353, 8, 11, 10, 1, -11 },
  { 364, 8, 12, 9, 1, -12 },
  { 376, 6, 11, 8, 1, -11 },
  { 385, 8, 15, 9, 1, -12 },
  { 400, 7, 11, 8, 1, -11 },
  { 410, 5, 12, 7, 1, -12 },
  { 418, 6, 11, 7, 0, -11 },
  { 427, 7, 11, 9, 1, -11 },
  { 437, 8, 11, 8, 0, -11 },
  { 448, 12, 11, 12, 0, -11 },
  { 465, 7, 11, 7, 0, -11 },
  { 475, 7, 11, 7, 0, -11 },
  { 485, 6, 11, 6, 0, -11 },
  { 494, 4, 14, 5, 1, -11 },
  { 501, 6, 12, 6, 0, -12 },
  { 510, 4, 14, 5, 0, -11 },
  { 517, 8, 6, 8, 0, -11 },
  { 523, 7, 1, 7, 0, 1 },
  { 524, 3, 2, 5, 1, -12 },
  { 525, 6, 9, 7, 0, -9 },
  { 532, 6, 12, 8, 1, -12 },
  { 541, 5, 9, 6, 1, -9 },
  { 547, 6, 12, 8, 1, -12 },
  { 556, 6, 9, 7, 1, -9 },
  { 563, 5, 12, 5, 0, -12 },
  { 571, 6, 13, 8, 1, -9 },
  { 581, 6, 12, 8, 1, -12 },
  { 590, 2, 12, 4, 1, -12 },
  { 593, 3, 16, 4, 0, -12 },
  { 599, 6, 12, 7, 1, -12 },
  { 608, 2, 12, 4, 1, -12 },
  { 611, 10, 9, 12, 1, -9 },
  { 623, 6, 9, 8, 1, -9 },
  { 630, 6, 9, 8, 1, -9 },
  { 637, 6, 13, 8, 1, -9 },
  { 647, 6, 13, 8, 1, -9 },
  { 657, 4, 9, 5, 1, -9 },
  { 662, 5, 9, 6, 0, -9 },
  { 668, 5, 11, 5, 0, -11 },
  { 675, 6, 9, 8, 1, -9 },
  { 682, 7, 9, 7, 0, -9 },
  { 690, 10, 9, 10, 0, -9 },
  { 702, 6, 9, 6, 0, -9 },
  { 709, 7, 13, 7, 0, -9 },
  { 721, 5, 9, 5, 0, -9 },
  { 727, 5, 14, 6, 0, -11 },
  { 736, 1, 16, 7, 3, -12 },
  { 738, 4, 14, 6, 1, -11 },
  { 745, 7, 3, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD16PT7B_H_
