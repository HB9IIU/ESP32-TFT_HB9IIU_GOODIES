#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC7, 0xC0, 0xDF, 0x7C, 0xB2, 0xC8, 0x1A, 0x12, 0x12,
  0x12, 0x7F, 0x36, 0x36, 0x34, 0xFF, 0x24, 0x24, 0x2C, 0x6C, 0x10, 0x47,
  0xF7, 0xD3, 0x4F, 0x1E, 0x1C, 0x71, 0x77, 0xF8, 0x41, 0x00, 0x61, 0x8F,
  0x10, 0x93, 0x09, 0x20, 0x92, 0x09, 0x6C, 0xF5, 0xE6, 0xD2, 0x0D, 0x30,
  0x93, 0x19, 0x21, 0x1A, 0x30, 0xE0, 0x3C, 0x0F, 0x06, 0x61, 0x98, 0x3C,
  0x0F, 0x03, 0x99, 0xB6, 0x6D, 0xB9, 0xC6, 0x71, 0xFC, 0x3D, 0xC0, 0xFF,
  0xC0, 0x32, 0x64, 0xCC, 0xCC, 0xCC, 0xCC, 0x66, 0x23, 0xC3, 0x08, 0x63,
  0x08, 0x63, 0x18, 0xC4, 0x63, 0x11, 0x98, 0x18, 0x31, 0x7F, 0xF3, 0x8D,
  0x89, 0x80, 0x30, 0x60, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0xFF, 0xFF,
  0xC0, 0x7C, 0x06, 0x08, 0x30, 0x61, 0x83, 0x04, 0x18, 0x30, 0x41, 0x83,
  0x0C, 0x00, 0x79, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x78,
  0x19, 0xDF, 0xB5, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x7B, 0xF8, 0xC3,
  0x0C, 0x31, 0x8E, 0x31, 0x8C, 0x3F, 0xFC, 0xFB, 0xF8, 0xC3, 0x0C, 0xE7,
  0x87, 0x0C, 0x30, 0xFF, 0xF8, 0x0E, 0x0E, 0x1E, 0x16, 0x36, 0x26, 0x66,
  0x46, 0xC6, 0xFF, 0x06, 0x06, 0x06, 0xFF, 0xFC, 0x30, 0xC3, 0xEF, 0xC3,
  0x0C, 0x30, 0xFF, 0xF8, 0x3D, 0xFE, 0x30, 0xC3, 0xEF, 0xF3, 0xCF, 0x3C,
  0xFF, 0x78, 0xFF, 0xFF, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x79, 0xFB, 0x36, 0x6C, 0xCF, 0x1E, 0x7E, 0xCD, 0x8F,
  0x37, 0xE7, 0x80, 0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x0C, 0x30, 0xFE,
  0xF0, 0xFC, 0x01, 0xF0, 0xDB, 0x00, 0x00, 0xFB, 0x60, 0x01, 0x07, 0x1E,
  0x78, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x81,
  0x83, 0xC1, 0xE0, 0xE7, 0xBC, 0x60, 0x80, 0x7B, 0xF8, 0xC3, 0x0C, 0x63,
  0x0C, 0x20, 0x02, 0x1C, 0x30, 0x1F, 0x06, 0x31, 0x83, 0x23, 0x2D, 0xF7,
  0x36, 0xE4, 0xDC, 0x9B, 0x93, 0x73, 0xEB, 0x37, 0x60, 0x06, 0x08, 0x7E,
  0x00, 0x1C, 0x0E, 0x05, 0x06, 0xC3, 0x61, 0xB0, 0xD8, 0xC6, 0x7F, 0x3F,
  0x98, 0xDC, 0x7C, 0x18, 0xFD, 0xFF, 0x1E, 0x3C, 0x7F, 0xFF, 0x63, 0xC7,
  0x8F, 0x1F, 0xFF, 0xC0, 0x3E, 0xFD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x83, 0xF3, 0xE0, 0xF8, 0xFE, 0xC6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0xC6, 0xFE, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3,
  0x0C, 0x3F, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xFF, 0xC3, 0x0C, 0x30,
  0xC0, 0x1E, 0x7F, 0x61, 0xE0, 0xC0, 0xC0, 0xCF, 0xCF, 0xC3, 0xC3, 0x63,
  0x7F, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFB, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xEF, 0x80,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC7, 0xC6, 0xCE,
  0xCC, 0xD8, 0xD8, 0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC7, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xE0, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFD, 0x1F, 0xB3, 0xF6, 0x5E, 0xDB, 0xCB, 0x79, 0xCF, 0x39, 0xE7,
  0x3C, 0x66, 0xE1, 0xF0, 0xFC, 0x7E, 0x3D, 0x9E, 0xCF, 0x67, 0x9B, 0xCD,
  0xE3, 0xF1, 0xF8, 0x7C, 0x38, 0x3C, 0x3F, 0x38, 0xD8, 0x6C, 0x36, 0x1F,
  0x0F, 0x87, 0xC3, 0x61, 0xB8, 0xCF, 0xC3, 0xC0, 0xF9, 0xFB, 0x3E, 0x3C,
  0x78, 0xFF, 0x7E, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3C, 0x3F, 0x38, 0xD8,
  0x6C, 0x36, 0x1F, 0x0F, 0x87, 0xC3, 0x61, 0xB8, 0xCF, 0xC3, 0xC0, 0x30,
  0x18, 0x06, 0xF8, 0xFC, 0xCE, 0xC6, 0xC6, 0xCE, 0xFC, 0xF8, 0xCC, 0xCC,
  0xCE, 0xC6, 0xC7, 0x7B, 0xFC, 0x70, 0xC3, 0x87, 0x8E, 0x0C, 0x38, 0xFE,
  0xF8, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x80, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7,
  0x7E, 0x3C, 0xC1, 0xE1, 0x98, 0xCC, 0x66, 0x33, 0x30, 0x98, 0x6C, 0x36,
  0x1A, 0x07, 0x03, 0x81, 0xC0, 0xC3, 0x1E, 0x38, 0xF1, 0xC6, 0xCE, 0x36,
  0x53, 0x32, 0xD9, 0xB6, 0xCD, 0xB6, 0x2D, 0xB1, 0xE5, 0x0E, 0x38, 0x71,
  0xC3, 0x8E, 0x00, 0xE7, 0x66, 0x66, 0x3C, 0x3C, 0x1C, 0x18, 0x3C, 0x3C,
  0x3E, 0x66, 0x66, 0xC3, 0xC3, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0x61, 0x83, 0x06, 0x18,
  0x30, 0xC1, 0x87, 0xFF, 0xE0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xFF, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x60, 0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x08, 0x0E, 0x07,
  0x06, 0xC3, 0x63, 0x19, 0x8D, 0x83, 0xFF, 0xC6, 0x30, 0x7B, 0xF0, 0xC3,
  0x7F, 0xBC, 0xF3, 0xDF, 0xF0, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xB1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3F, 0xDB, 0x80, 0x3B, 0xF1, 0x8C, 0x63, 0x18, 0xFB,
  0xC0, 0x06, 0x0C, 0x18, 0x37, 0x7F, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x7F,
  0xEE, 0xC0, 0x7B, 0xFC, 0xF3, 0xFF, 0xFC, 0x30, 0xED, 0xF0, 0x1C, 0xE6,
  0x18, 0x7B, 0xE6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x80, 0x77, 0xFF, 0x3E,
  0x3C, 0x78, 0xF1, 0xE7, 0xFE, 0xEC, 0x18, 0x2D, 0xDF, 0x00, 0xC1, 0x83,
  0x06, 0x0D, 0xDF, 0xB3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xC0, 0x7C,
  0xFF, 0xFF, 0xF0, 0x2D, 0x86, 0xDB, 0x6D, 0xB6, 0xDB, 0xFC, 0xC1, 0x83,
  0x06, 0x0C, 0x79, 0xB6, 0x6C, 0xF9, 0xF3, 0x66, 0x6C, 0xD8, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xDD, 0xDF, 0xFF, 0x39, 0xE3, 0x3C, 0x67, 0x8C, 0xF1,
  0x9E, 0x33, 0xC6, 0x78, 0xCC, 0xDD, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8C, 0x79, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE6, 0xFC, 0xF0, 0xDD,
  0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFD, 0xBB, 0x06, 0x0C, 0x18, 0x00,
  0x77, 0xFF, 0x3E, 0x3C, 0x78, 0xF1, 0xE7, 0xFE, 0xEC, 0x18, 0x30, 0x60,
  0xC0, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x77, 0xE1, 0x8E, 0x38,
  0x63, 0xFF, 0x80, 0x21, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x1E, 0x70, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xFE, 0xEC, 0xC7, 0x8D, 0x9B, 0x36,
  0xCD, 0x8B, 0x1E, 0x38, 0x30, 0xC6, 0x3C, 0xE6, 0x6E, 0x66, 0xF6, 0x6B,
  0x66, 0xB4, 0x69, 0xC2, 0x9C, 0x39, 0xC3, 0x9C, 0xE6, 0xD9, 0xB1, 0xE3,
  0x87, 0x0F, 0x36, 0x6D, 0x8C, 0xC7, 0x8D, 0x9B, 0x36, 0xC5, 0x8F, 0x1C,
  0x38, 0x30, 0x61, 0x8F, 0x1C, 0x00, 0x7D, 0xF1, 0x86, 0x30, 0xC6, 0x18,
  0xFF, 0xF0, 0x1C, 0xF3, 0x0C, 0x30, 0xC3, 0x3C, 0xF0, 0xC3, 0x0C, 0x30,
  0xC3, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x31, 0x87,
  0x3B, 0x18, 0xC6, 0x33, 0x98, 0x61, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 6, 5, 8, 1, -13 },
  { 9, 8, 13, 9, 0, -13 },
  { 22, 6, 15, 8, 1, -14 },
  { 34, 12, 13, 13, 1, -13 },
  { 54, 10, 13, 9, 0, -13 },
  { 71, 2, 5, 4, 1, -13 },
  { 73, 4, 16, 6, 1, -13 },
  { 81, 5, 16, 6, 0, -13 },
  { 91, 7, 7, 8, 0, -14 },
  { 98, 7, 9, 8, 1, -11 },
  { 106, 2, 4, 4, 1, -2 },
  { 107, 5, 2, 5, 0, -6 },
  { 109, 2, 3, 4, 1, -3 },
  { 110, 7, 13, 7, 0, -13 },
  { 122, 6, 13, 8, 1, -13 },
  { 132, 5, 13, 8, 1, -13 },
  { 141, 6, 13, 8, 1, -13 },
  { 151, 6, 13, 8, 1, -13 },
  { 161, 8, 13, 8, 0, -13 },
  { 174, 6, 13, 8, 1, -13 },
  { 184, 6, 13, 8, 1, -13 },
  { 194, 8, 13, 8, 0, -13 },
  { 207, 7, 13, 8, 1, -13 },
  { 219, 6, 13, 8, 1, -13 },
  { 229, 2, 10, 4, 1, -10 },
  { 232, 3, 12, 4, 1, -10 },
  { 237, 8, 9, 8, 0, -11 },
  { 246, 8, 5, 8, 0, -9 },
  { 251, 7, 9, 8, 1, -11 },
  { 259, 6, 13, 6, 0, -13 },
  { 269, 11, 14, 13, 1, -13 },
  { 289, 9, 13, 9, 0, -13 },
  { 304, 7, 13, 9, 1, -13 },
  { 316, 7, 13, 8, 1, -13 },
  { 328, 8, 13, 10, 1, -13 },
  { 341, 6, 13, 8, 1, -13 },
  { 351, 6, 13, 7, 1, -13 },
  { 361, 8, 13, 10, 1, -13 },
  { 374, 8, 13, 10, 1, -13 },
  { 387, 5, 13, 5, 0, -13 },
  { 396, 4, 17, 5, -1, -13 },
  { 405, 8, 13, 9, 1, -13 },
  { 418, 6, 13, 7, 1, -13 },
  { 428, 11, 13, 14, 1, -13 },
  { 446, 9, 13, 11, 1, -13 },
  { 461, 9, 13, 10, 1, -13 },
  { 476, 7, 13, 9, 1, -13 },
  { 488, 9, 16, 10, 1, -13 },
  { 506, 8, 13, 9, 1, -13 },
  { 519, 6, 13, 8, 1, -13 },
  { 529, 7, 13, 7, 0, -13 },
  { 541, 8, 13, 10, 1, -13 },
  { 554, 9, 13, 9, 0, -13 },
  { 569, 13, 13, 13, 0, -13 },
  { 591, 8, 13, 8, 0, -13 },
  { 604, 8, 13, 8, 0, -13 },
  { 617, 7, 13, 7, 0, -13 },
  { 629, 4, 16, 6, 1, -13 },
  { 637, 7, 13, 7, 0, -13 },
  { 649, 4, 16, 6, 0, -13 },
  { 657, 9, 8, 9, 0, -13 },
  { 666, 8, 1, 8, 0, 2 },
  { 667, 4, 3, 5, 1, -14 },
  { 669, 6, 10, 8, 1, -10 },
  { 677, 7, 14, 9, 1, -14 },
  { 690, 5, 10, 7, 1, -10 },
  { 697, 7, 14, 9, 1, -14 },
  { 710, 6, 10, 8, 1, -10 },
  { 718, 6, 14, 5, 0, -14 },
  { 729, 7, 14, 9, 1, -10 },
  { 742, 7, 14, 9, 1, -14 },
  { 755, 2, 14, 4, 1, -14 },
  { 759, 3, 18, 4, 0, -14 },
  { 766, 7, 14, 8, 1, -14 },
  { 779, 2, 14, 4, 1, -14 },
  { 783, 11, 10, 13, 1, -10 },
  { 797, 7, 10, 9, 1, -10 },
  { 806, 7, 10, 9, 1, -10 },
  { 815, 7, 14, 9, 1, -10 },
  { 828, 7, 14, 9, 1, -10 },
  { 841, 5, 10, 6, 1, -10 },
  { 848, 5, 10, 7, 1, -10 },
  { 855, 5, 12, 5, 0, -12 },
  { 863, 7, 10, 9, 1, -10 },
  { 872, 7, 10, 7, 0, -10 },
  { 881, 12, 10, 12, 0, -10 },
  { 896, 7, 10, 7, 0, -10 },
  { 905, 7, 14, 7, 0, -10 },
  { 918, 6, 10, 6, 0, -10 },
  { 926, 6, 16, 6, 0, -13 },
  { 938, 2, 18, 8, 3, -14 },
  { 943, 5, 16, 6, 1, -13 },
  { 953, 8, 3, 8, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD18PT7B_H_
