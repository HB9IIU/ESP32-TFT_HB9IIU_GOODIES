#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0xEC, 0x5F, 0x6F, 0x66, 0x27, 0xA6, 0x3B, 0x42, 0x42,
  0xAB, 0x2F, 0x5C, 0xB2, 0xC0, 0x23, 0x18, 0xDB, 0x49, 0xE0, 0xD0, 0x6A,
  0x48, 0x98, 0xD5, 0x5C, 0x4F, 0x66, 0x2F, 0x22, 0x60, 0xC0, 0xC0, 0x25,
  0x25, 0x00, 0x26, 0x99, 0x99, 0x60, 0x7C, 0x92, 0x40, 0x4A, 0x12, 0x24,
  0xF0, 0x4A, 0x16, 0x31, 0xE0, 0x26, 0x6A, 0xF2, 0x64, 0xE1, 0x1E, 0x24,
  0x8E, 0x99, 0x60, 0xF2, 0x22, 0x44, 0x2F, 0x96, 0xF9, 0x60, 0x4E, 0x9B,
  0x52, 0x60, 0xC0, 0xC0, 0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x54,
  0xA4, 0x10, 0x31, 0x27, 0x6D, 0xB6, 0xE4, 0x0E, 0x66, 0x57, 0x99, 0xF7,
  0x5B, 0xC0, 0x25, 0x4C, 0xC4, 0x70, 0xF6, 0xDB, 0xC0, 0xEE, 0xB0, 0xEE,
  0xA0, 0x25, 0x4D, 0xD5, 0x70, 0xB7, 0xDB, 0x40, 0xD5, 0x70, 0x55, 0x56,
  0xBB, 0x6B, 0x40, 0xAA, 0xB0, 0x9E, 0xF7, 0xBA, 0xD4, 0x9D, 0xDB, 0xBB,
  0x22, 0x93, 0x9C, 0xAD, 0xC0, 0xF6, 0xE9, 0x00, 0x22, 0x93, 0x9C, 0xAD,
  0xC2, 0x18, 0xF7, 0xEB, 0x40, 0x5E, 0x22, 0x78, 0xF4, 0x44, 0x44, 0xB6,
  0xDB, 0xC0, 0x99, 0x56, 0x66, 0x97, 0x69, 0xD3, 0x66, 0xCD, 0x80, 0xF6,
  0x66, 0x69, 0x96, 0x66, 0x66, 0xE5, 0x2D, 0xC0, 0xEA, 0xAC, 0x89, 0x12,
  0x40, 0xD5, 0x5C, 0x26, 0xD0, 0xF0, 0xD0, 0x65, 0xDE, 0x93, 0xDB, 0x78,
  0x7A, 0x46, 0x11, 0x79, 0x99, 0x70, 0x69, 0xF8, 0x60, 0x6B, 0x24, 0x90,
  0x79, 0x99, 0x71, 0x60, 0x93, 0xDB, 0x68, 0xC5, 0x54, 0xC5, 0x55, 0x80,
  0x92, 0xED, 0xA8, 0xFE, 0xFD, 0x6B, 0x5A, 0x80, 0xF6, 0xDA, 0x69, 0x99,
  0x60, 0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x71, 0x9E,
  0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0x9A, 0x66, 0x60, 0xB6, 0xD7, 0x9E, 0x58,
  0xB6, 0x46, 0xB0, 0x9A, 0x66, 0x64, 0xC0, 0xED, 0x2E, 0x69, 0x44, 0x98,
  0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xDA,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 6, 7, 7, 0, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 2, 7, 3, 0, -6 },
  { 28, 4, 4, 4, 0, -7 },
  { 30, 4, 4, 4, 0, -5 },
  { 32, 2, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 2, 1, 2, 0, -1 },
  { 35, 3, 6, 4, 0, -6 },
  { 38, 4, 7, 4, 0, -7 },
  { 42, 3, 6, 4, 0, -6 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 2, 5, 2, 0, -5 },
  { 76, 2, 6, 2, 0, -5 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 4, 2, 4, 0, -4 },
  { 81, 4, 4, 4, 0, -5 },
  { 83, 3, 7, 3, 0, -7 },
  { 86, 6, 8, 6, 0, -7 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 3, 6, 5, 1, -6 },
  { 98, 4, 7, 4, 0, -7 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 2, 6, 4, 1, -6 },
  { 107, 2, 6, 4, 1, -6 },
  { 109, 4, 7, 5, 0, -7 },
  { 113, 3, 6, 5, 1, -6 },
  { 116, 2, 6, 3, 0, -6 },
  { 118, 2, 8, 2, 0, -6 },
  { 120, 3, 6, 4, 1, -6 },
  { 123, 2, 6, 4, 1, -6 },
  { 125, 5, 6, 7, 1, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 3, 6, 4, 1, -6 },
  { 140, 5, 9, 5, 0, -7 },
  { 146, 3, 6, 4, 1, -6 },
  { 149, 3, 7, 4, 0, -7 },
  { 152, 4, 6, 4, 0, -6 },
  { 155, 3, 6, 5, 1, -6 },
  { 158, 4, 6, 4, 0, -6 },
  { 161, 7, 6, 7, 0, -6 },
  { 167, 4, 6, 4, 0, -6 },
  { 170, 4, 6, 4, 0, -6 },
  { 173, 3, 6, 4, 0, -6 },
  { 176, 2, 7, 3, 1, -6 },
  { 178, 3, 6, 4, 0, -6 },
  { 181, 2, 7, 3, 0, -6 },
  { 183, 4, 3, 4, 0, -6 },
  { 185, 4, 1, 4, 0, 1 },
  { 186, 2, 2, 3, 0, -7 },
  { 187, 3, 5, 4, 0, -5 },
  { 189, 3, 7, 4, 1, -7 },
  { 192, 3, 5, 3, 0, -5 },
  { 194, 4, 7, 4, 0, -7 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 3, 7, 3, 0, -7 },
  { 204, 4, 7, 4, 0, -5 },
  { 208, 3, 7, 4, 1, -7 },
  { 211, 2, 7, 2, 0, -7 },
  { 213, 2, 9, 2, 0, -7 },
  { 216, 3, 7, 4, 1, -7 },
  { 219, 1, 7, 2, 1, -7 },
  { 220, 5, 5, 7, 1, -5 },
  { 224, 3, 5, 4, 1, -5 },
  { 226, 4, 5, 4, 0, -5 },
  { 229, 3, 7, 4, 1, -5 },
  { 232, 4, 7, 4, 0, -5 },
  { 236, 2, 5, 3, 1, -5 },
  { 238, 3, 5, 3, 0, -5 },
  { 240, 3, 6, 3, 0, -6 },
  { 243, 3, 5, 4, 1, -5 },
  { 245, 4, 5, 4, 0, -5 },
  { 248, 6, 5, 6, 0, -5 },
  { 252, 4, 5, 4, 0, -5 },
  { 255, 4, 7, 4, 0, -5 },
  { 259, 3, 5, 3, 0, -5 },
  { 261, 3, 7, 3, 0, -6 },
  { 264, 1, 9, 4, 1, -7 },
  { 266, 3, 7, 3, 0, -6 },
  { 269, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD9PT7B_H_
