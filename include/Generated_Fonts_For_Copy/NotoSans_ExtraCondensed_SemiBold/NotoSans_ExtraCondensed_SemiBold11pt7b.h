#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0x80, 0x29, 0xBE, 0xA5, 0x7D, 0x4A, 0x23, 0xB8, 0xC3,
  0x1F, 0xC4, 0x20, 0x64, 0xA8, 0xA8, 0xAE, 0x75, 0x15, 0x15, 0x26, 0x71,
  0x45, 0x18, 0x6F, 0x6D, 0x9F, 0xE0, 0x6A, 0xAA, 0x90, 0xC9, 0x12, 0x4A,
  0x50, 0x2F, 0x75, 0x21, 0x09, 0xF2, 0x10, 0x70, 0xFC, 0xC0, 0x11, 0x22,
  0x64, 0x48, 0x72, 0xB5, 0xBD, 0xE9, 0x4E, 0x7F, 0xB6, 0xDB, 0xF5, 0x11,
  0x36, 0x4F, 0x79, 0x17, 0x31, 0x1F, 0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xF2,
  0x72, 0x4F, 0x32, 0x11, 0xED, 0x6D, 0x4E, 0xF8, 0x84, 0x22, 0x11, 0x88,
  0x72, 0x94, 0xE7, 0x6F, 0x6E, 0x72, 0xB5, 0xB7, 0x08, 0x4C, 0xCC, 0x50,
  0x1C, 0x1B, 0x38, 0x70, 0x80, 0xF8, 0x3E, 0xC1, 0x8F, 0xC8, 0x00, 0xEB,
  0x32, 0x44, 0x44, 0x3C, 0x8D, 0x6B, 0x5A, 0xB5, 0x55, 0x20, 0x3C, 0x31,
  0x9C, 0xA5, 0xBF, 0x31, 0xEB, 0x9E, 0xB9, 0x9E, 0x3B, 0x50, 0x8C, 0x21,
  0x07, 0xEB, 0x99, 0x99, 0xBE, 0xF2, 0x79, 0x27, 0xF2, 0x4F, 0x24, 0x7D,
  0x88, 0xB9, 0x97, 0x99, 0x9F, 0x99, 0x99, 0xE9, 0x24, 0x97, 0x24, 0x92,
  0x49, 0x3C, 0x9B, 0xAE, 0xEA, 0xB9, 0x92, 0x49, 0x27, 0xC7, 0x9F, 0x3E,
  0x7A, 0xF6, 0xED, 0xDB, 0x8E, 0x73, 0x5A, 0xDE, 0x73, 0x39, 0x24, 0xD3,
  0xCD, 0x34, 0x8E, 0xEB, 0x9B, 0xE8, 0x88, 0x39, 0x24, 0xD3, 0xCD, 0x34,
  0x8E, 0x18, 0x30, 0xEB, 0x9B, 0xEA, 0xB9, 0x75, 0xC6, 0x31, 0x9F, 0xF2,
  0x22, 0x22, 0x22, 0x99, 0x99, 0x99, 0x9F, 0x8E, 0x52, 0xA5, 0x28, 0xC4,
  0x99, 0x99, 0xDB, 0x5A, 0x5A, 0x66, 0x66, 0x66, 0xDA, 0x94, 0x42, 0x29,
  0x5B, 0x9A, 0x94, 0xE2, 0x10, 0x84, 0xF1, 0x22, 0x64, 0xCF, 0xEA, 0xAA,
  0xB0, 0x84, 0x46, 0x22, 0x11, 0xE4, 0x92, 0x49, 0x3C, 0x21, 0x94, 0x98,
  0x80, 0xF8, 0xE0, 0x71, 0x7D, 0xD7, 0x88, 0xEB, 0x99, 0xBE, 0x74, 0xCC,
  0x47, 0x18, 0xDE, 0xBD, 0xED, 0x6D, 0x75, 0xFC, 0x47, 0x6B, 0xA4, 0x92,
  0x6A, 0xF7, 0xB5, 0xBC, 0x6A, 0x60, 0x88, 0xEB, 0xBB, 0xBB, 0xBF, 0x45,
  0x55, 0x78, 0x88, 0xBA, 0xCA, 0xAB, 0xFF, 0xEE, 0xDB, 0x6D, 0xB6, 0xD0,
  0xEB, 0xBB, 0xBB, 0x72, 0xF3, 0x95, 0xB8, 0xEB, 0x99, 0xBE, 0x88, 0x80,
  0x6A, 0xF7, 0xB5, 0xBC, 0x63, 0x18, 0xF2, 0x49, 0x00, 0x7C, 0x42, 0x3E,
  0x5D, 0x24, 0x98, 0xBB, 0xBB, 0xBD, 0x9E, 0x94, 0xE6, 0x30, 0x93, 0xB5,
  0xBB, 0x66, 0xCD, 0x80, 0xD7, 0x66, 0x7D, 0x9E, 0x94, 0xE6, 0x10, 0x98,
  0xC0, 0xE2, 0x64, 0x4F, 0x2D, 0xBC, 0x9B, 0x64, 0xFF, 0xE0, 0xC4, 0x44,
  0x36, 0x44, 0x4C, 0x4D, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 5, 1, -8 },
  { 4, 5, 8, 5, 0, -8 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 8, 8, 8, 0, -8 },
  { 23, 6, 8, 6, 0, -8 },
  { 29, 1, 3, 2, 1, -8 },
  { 30, 2, 10, 3, 1, -8 },
  { 33, 3, 10, 3, 0, -8 },
  { 37, 4, 4, 5, 0, -8 },
  { 39, 5, 6, 5, 0, -7 },
  { 43, 2, 2, 3, 0, -1 },
  { 44, 3, 2, 3, 0, -4 },
  { 45, 1, 2, 3, 1, -2 },
  { 46, 4, 8, 4, 0, -8 },
  { 50, 5, 8, 5, 0, -8 },
  { 55, 3, 8, 5, 1, -8 },
  { 58, 4, 8, 5, 0, -8 },
  { 62, 4, 8, 5, 0, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 3, 8, 5, 1, -8 },
  { 74, 5, 8, 5, 0, -8 },
  { 79, 5, 8, 5, 0, -8 },
  { 84, 5, 8, 5, 0, -8 },
  { 89, 5, 8, 5, 0, -8 },
  { 94, 1, 6, 3, 1, -6 },
  { 95, 2, 7, 3, 0, -6 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 5, 3, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 4, 8, 4, 0, -8 },
  { 111, 7, 9, 8, 0, -8 },
  { 119, 5, 8, 5, 0, -8 },
  { 124, 4, 8, 6, 1, -8 },
  { 128, 5, 8, 5, 0, -8 },
  { 133, 4, 8, 6, 1, -8 },
  { 137, 3, 8, 5, 1, -8 },
  { 140, 3, 8, 5, 1, -8 },
  { 143, 4, 8, 6, 1, -8 },
  { 147, 4, 8, 6, 1, -8 },
  { 151, 3, 8, 3, 0, -8 },
  { 154, 3, 10, 3, -1, -8 },
  { 158, 4, 8, 5, 1, -8 },
  { 162, 3, 8, 4, 1, -8 },
  { 165, 7, 8, 8, 1, -8 },
  { 172, 5, 8, 7, 1, -8 },
  { 177, 6, 8, 6, 0, -8 },
  { 183, 4, 8, 5, 1, -8 },
  { 187, 6, 10, 6, 0, -8 },
  { 195, 4, 8, 5, 1, -8 },
  { 199, 4, 8, 5, 0, -8 },
  { 203, 4, 8, 5, 0, -8 },
  { 207, 4, 8, 6, 1, -8 },
  { 211, 5, 8, 5, 0, -8 },
  { 216, 8, 8, 8, 0, -8 },
  { 224, 5, 8, 5, 0, -8 },
  { 229, 5, 8, 5, 0, -8 },
  { 234, 4, 8, 4, 0, -8 },
  { 238, 2, 10, 3, 1, -8 },
  { 241, 4, 8, 4, 0, -8 },
  { 245, 3, 10, 3, 0, -8 },
  { 249, 5, 5, 5, 0, -8 },
  { 253, 5, 1, 5, 0, 1 },
  { 254, 3, 1, 3, 0, -8 },
  { 255, 4, 6, 5, 0, -6 },
  { 258, 4, 8, 5, 1, -8 },
  { 262, 4, 6, 4, 0, -6 },
  { 265, 5, 8, 5, 0, -8 },
  { 270, 4, 6, 5, 0, -6 },
  { 273, 3, 8, 3, 0, -8 },
  { 276, 5, 9, 5, 0, -6 },
  { 282, 4, 8, 5, 1, -8 },
  { 286, 1, 8, 3, 1, -8 },
  { 287, 2, 11, 3, 0, -8 },
  { 290, 4, 8, 5, 1, -8 },
  { 294, 1, 8, 3, 1, -8 },
  { 295, 6, 6, 8, 1, -6 },
  { 300, 4, 6, 5, 1, -6 },
  { 303, 5, 6, 5, 0, -6 },
  { 307, 4, 9, 5, 1, -6 },
  { 312, 5, 9, 5, 0, -6 },
  { 318, 3, 6, 4, 1, -6 },
  { 321, 4, 6, 4, 0, -6 },
  { 324, 3, 7, 3, 0, -7 },
  { 327, 4, 6, 5, 1, -6 },
  { 330, 5, 6, 5, 0, -6 },
  { 334, 7, 6, 7, 0, -6 },
  { 340, 4, 6, 4, 0, -6 },
  { 343, 5, 9, 5, 0, -6 },
  { 349, 4, 6, 4, 0, -6 },
  { 352, 3, 10, 4, 0, -8 },
  { 356, 1, 11, 5, 2, -8 },
  { 358, 4, 10, 4, 0, -8 },
  { 363, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD11PT7B_H_
