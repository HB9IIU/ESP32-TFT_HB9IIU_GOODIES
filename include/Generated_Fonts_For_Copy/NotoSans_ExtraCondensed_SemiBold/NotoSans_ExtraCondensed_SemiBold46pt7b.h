#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7F, 0xF8, 0xFD, 0xF1, 0xFB, 0xE3, 0xF7, 0xC3, 0xEF,
  0x87, 0xDF, 0x0F, 0xBE, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1,
  0xE0, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC1, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87,
  0x80, 0x1C, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7D, 0xC6, 0x7C,
  0xE1, 0x3E, 0x70, 0x1F, 0x38, 0x0F, 0x9C, 0x07, 0xCE, 0x01, 0xF7, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0x7E, 0x03, 0x9F, 0x01, 0xCF, 0x80, 0xE7, 0xE0,
  0x73, 0xF8, 0x3B, 0xEF, 0xDF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xC0,
  0x1E, 0xF8, 0x0F, 0x00, 0xF1, 0xE0, 0x78, 0x03, 0xC7, 0x81, 0xE0, 0x0F,
  0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xC3,
  0xC7, 0x80, 0x0F, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x78, 0x00, 0xF0, 0xF3,
  0xC0, 0x03, 0xC7, 0x8F, 0x1F, 0x8F, 0x1E, 0x3C, 0xFF, 0x3C, 0x79, 0xE7,
  0xFC, 0x7B, 0xE7, 0x9F, 0xF9, 0xFF, 0x3C, 0x79, 0xE3, 0xFC, 0xF3, 0xC3,
  0xC7, 0xC3, 0xCF, 0x0F, 0x00, 0x1E, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0xF0,
  0x01, 0xE3, 0xC3, 0xC0, 0x0F, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x3C, 0x01,
  0xE0, 0xF0, 0xF0, 0x07, 0x83, 0xC3, 0xC0, 0x1E, 0x0F, 0x0F, 0x00, 0xF0,
  0x1E, 0x78, 0x03, 0xC0, 0x7B, 0xE0, 0x0F, 0x01, 0xFF, 0x80, 0x78, 0x03,
  0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87,
  0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78,
  0x00, 0xF9, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x7C, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1, 0xF3,
  0xF7, 0xE7, 0xE7, 0xC7, 0xCF, 0x9F, 0x87, 0xDF, 0x3F, 0x0F, 0xFE, 0x7C,
  0x0F, 0xF8, 0xFC, 0x0F, 0xF1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xF0,
  0x7F, 0x07, 0xF3, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFE,
  0x7E, 0x0F, 0xF8, 0x7E, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7,
  0x9E, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x04,
  0x1E, 0x0B, 0xCF, 0x3D, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF8,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0xF9, 0xF0, 0xF8, 0xFC, 0x3C,
  0x3C, 0x04, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0xBE,
  0x7C, 0xF9, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xF7, 0xE3, 0xE1, 0xF1, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F,
  0x07, 0xCF, 0x87, 0xE7, 0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x7F, 0xE7, 0xDF, 0xFC, 0xFB, 0xC7, 0xCC, 0x3E, 0x21, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x7F, 0x0E, 0x07, 0xE1, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x87, 0xF3, 0x01,
  0xF9, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xD0, 0x07, 0xEE,
  0x0F, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x0E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1E,
  0x7C, 0x03, 0xCF, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0xC0, 0xF0,
  0xF8, 0x1E, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81,
  0xF1, 0xE0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x9C, 0x03, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x10, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xD0, 0x07, 0xEF, 0x0F, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xFC, 0x21, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0x87, 0xDF, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFE, 0x7F, 0x7E, 0x0F, 0xBE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xE3, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x1F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x1F, 0x3F,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0xFC, 0x7E, 0x7E, 0x1F, 0x9F, 0x03, 0xF7, 0xC0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x0F,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x7E, 0x3F,
  0xCF, 0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0xDF, 0x0F, 0xE7, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x20, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFD, 0xFB, 0xF7,
  0xEF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xE7, 0xCF, 0x9E, 0x3C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xCF, 0xE4, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xC1, 0xFF, 0x1E, 0x78,
  0x3F, 0xF1, 0xE7, 0x87, 0xFF, 0x0F, 0x78, 0x78, 0xF0, 0xFF, 0x0F, 0x0F,
  0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF,
  0x1F, 0x0F, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1, 0xE0,
  0xF0, 0xFF, 0x0F, 0x1F, 0x0F, 0xF0, 0xF1, 0xF1, 0xEF, 0x0F, 0x1F, 0x1E,
  0xF0, 0xFF, 0xBF, 0xC7, 0x87, 0xFB, 0xFC, 0x78, 0x3F, 0x1F, 0x87, 0x81,
  0xE0, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x40, 0x0F, 0xC0, 0x1C, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03,
  0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF0, 0x3F, 0xBE,
  0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C,
  0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF3, 0xE0, 0xFE, 0x7C, 0x07, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x3F, 0x7C, 0x07, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xE7, 0x8F, 0xE0, 0x23, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0x1F, 0xE3, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x83, 0xFC, 0xF8, 0x0F,
  0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0xFC,
  0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0x3F, 0x0F, 0xE0, 0x10, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0xC0,
  0x3E, 0x7F, 0x01, 0xF1, 0xFE, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFD, 0x3F, 0xBF, 0xF7,
  0xFC, 0xFF, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xBC, 0x03, 0xFF,
  0xFB, 0xC0, 0x3D, 0xFF, 0xBE, 0x03, 0xDF, 0xFB, 0xE0, 0x3D, 0xFF, 0x9E,
  0x07, 0xDF, 0xF9, 0xE0, 0x79, 0xFF, 0x9F, 0x07, 0x9F, 0xF8, 0xF0, 0xF9,
  0xFF, 0x8F, 0x0F, 0x9F, 0xF8, 0xF8, 0xF1, 0xFF, 0x8F, 0x8F, 0x1F, 0xF8,
  0x79, 0xF1, 0xFF, 0x87, 0x9E, 0x1F, 0xF8, 0x7D, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF,
  0x83, 0xFC, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F,
  0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x01, 0xF0, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xEF, 0x81,
  0xFF, 0xBE, 0x07, 0xFE, 0xF8, 0x1F, 0xF9, 0xF0, 0x7F, 0xE7, 0xC1, 0xFF,
  0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF1, 0xFF, 0x87,
  0xC7, 0xFE, 0x0F, 0x9F, 0xF8, 0x3E, 0x7F, 0xE0, 0x7D, 0xFF, 0x81, 0xF7,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0xCF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7E, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0xFE, 0x1F, 0xCF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xF0, 0x7F, 0x3E, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F,
  0x3E, 0x0F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0x8F, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC3, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x0C, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3E, 0xC0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xBF, 0x03, 0xF7, 0xF9, 0xFC,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C,
  0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3E, 0x7C, 0x03,
  0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x7F, 0x80, 0xF9, 0xF0,
  0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0x0F, 0x81, 0xFE, 0x07, 0xC3,
  0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x3D, 0xF0, 0x7C, 0x3E, 0x0F, 0x3C, 0x3F,
  0x0F, 0xC3, 0xCF, 0x0F, 0x81, 0xF0, 0xF3, 0xC3, 0xE0, 0x7C, 0x3C, 0xF0,
  0xF8, 0x1F, 0x1F, 0x3C, 0x3E, 0x07, 0xC7, 0x8F, 0x9F, 0x81, 0xF1, 0xE1,
  0xE7, 0xC0, 0x3E, 0x78, 0x79, 0xF0, 0x0F, 0xBE, 0x1E, 0x7C, 0x03, 0xEF,
  0x87, 0x9F, 0x00, 0xFB, 0xE1, 0xF7, 0xC0, 0x3E, 0xF0, 0x3F, 0xF0, 0x07,
  0xBC, 0x0F, 0xF8, 0x01, 0xEF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xF7, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x9F,
  0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xDF, 0x00,
  0xF9, 0xF0, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0, 0x7C,
  0x3F, 0x07, 0xC3, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x3E,
  0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81,
  0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x3C, 0x78, 0x03,
  0xE3, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xE1, 0xC1, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC1, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xFB, 0xF8, 0x7D, 0xF8, 0x3E,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xC3,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xCF, 0x1F, 0xC7, 0x80, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x9F, 0xC3, 0xEF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xE3, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3C, 0xFF, 0x8F, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF,
  0x7F, 0x09, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x01, 0x7E, 0x0C, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0xFC, 0x7F, 0x9F, 0x3F, 0xF7, 0xDF, 0xFF, 0xF7, 0xE3, 0xFD, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x07, 0xF7, 0xE1, 0xFD, 0xFF,
  0xFF, 0x3F, 0xF7, 0xC7, 0xF9, 0xF0, 0xFC, 0x7C, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x27, 0xE0, 0x31, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xC8, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF,
  0xFF, 0x7E, 0x3F, 0xDF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF0,
  0x7F, 0x7E, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0x9F, 0x0F, 0xCF,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE4,
  0x01, 0xF9, 0xFB, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F,
  0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x7F,
  0x1F, 0x7F, 0xCF, 0xFF, 0xE7, 0xFF, 0xFB, 0xF8, 0xFD, 0xF8, 0x3E, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xE0, 0x31, 0xF7, 0xFF, 0x7D, 0xF3, 0x00, 0x00, 0x07,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x06, 0x07, 0xC3, 0xE3, 0xF0,
  0xF8, 0x7C, 0x18, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0xDF, 0xFF, 0xDF, 0xEF, 0xE7, 0xE0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFB,
  0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8,
  0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFE, 0xF8, 0x3F, 0x3E, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7E, 0x3E, 0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xFC, 0x3F, 0x8F, 0x3F, 0xE7, 0xFC, 0xF7,
  0xFE, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3F, 0xC7, 0xEF, 0xC3, 0xF8,
  0x3E, 0xFC, 0x1F, 0x83, 0xEF, 0x81, 0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xFF,
  0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F,
  0x03, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3F,
  0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xFF, 0x81,
  0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x03,
  0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xF0, 0xF1, 0xFC, 0x79, 0xFF,
  0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x1F, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E,
  0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xF1,
  0xFC, 0x3C, 0xFF, 0x8F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0x3F, 0x07,
  0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFE, 0x3F, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xEF, 0xF8, 0xF9, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0xC7, 0xC7, 0xF9,
  0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7E, 0x3F, 0xDF, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFD, 0xF0, 0x7F, 0x7E, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C,
  0x7F, 0x9F, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFF, 0x7E, 0xFF,
  0xEF, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFE, 0x7C, 0x1B, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFC, 0x7F, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF1, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xBE, 0x7F, 0x9F, 0x1F, 0x8F, 0x80, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x7D, 0xF0, 0x3F,
  0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x07, 0xF8, 0x3E, 0x7C, 0x1F, 0xE0,
  0xF9, 0xF8, 0x7F, 0x87, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0x87, 0x78, 0x7C,
  0x3E, 0x3C, 0xE1, 0xF0, 0xF8, 0xF3, 0xC7, 0xC1, 0xF3, 0xCF, 0x3E, 0x07,
  0xCF, 0x3C, 0xF8, 0x1F, 0x3C, 0xF3, 0xE0, 0x7C, 0xE1, 0xCF, 0x81, 0xF7,
  0x87, 0x3C, 0x03, 0xDE, 0x1E, 0xF0, 0x0F, 0x78, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xDF, 0x83, 0xE3, 0xE0, 0xF8, 0xFC,
  0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C,
  0xFC, 0x3F, 0x1F, 0x0F, 0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x3F, 0xFC, 0x07,
  0xC0, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0,
  0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xEF,
  0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0xFC, 0x3F, 0xE1, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x81,
  0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0x83, 0xFC, 0x3F, 0xC1, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0x00, 0x0C, 0x00, 0x2F, 0xF0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xA0, 0x0F,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 33, 11, 3, -33 },
  { 26, 15, 12, 19, 2, -33 },
  { 49, 21, 33, 22, 1, -33 },
  { 136, 17, 38, 21, 2, -35 },
  { 217, 30, 33, 34, 2, -33 },
  { 341, 23, 33, 24, 1, -33 },
  { 436, 6, 12, 10, 2, -33 },
  { 445, 11, 40, 14, 2, -33 },
  { 500, 11, 40, 14, 1, -33 },
  { 555, 17, 17, 20, 1, -35 },
  { 592, 18, 22, 21, 1, -27 },
  { 642, 7, 11, 11, 2, -5 },
  { 652, 11, 5, 13, 1, -15 },
  { 659, 7, 6, 11, 2, -6 },
  { 665, 17, 33, 18, 1, -33 },
  { 736, 17, 33, 21, 2, -33 },
  { 807, 13, 33, 21, 2, -33 },
  { 861, 18, 33, 21, 1, -33 },
  { 936, 17, 33, 21, 2, -33 },
  { 1007, 19, 33, 21, 1, -33 },
  { 1086, 17, 33, 21, 2, -33 },
  { 1157, 17, 33, 21, 2, -33 },
  { 1228, 18, 33, 21, 1, -33 },
  { 1303, 18, 33, 21, 1, -33 },
  { 1378, 18, 33, 21, 1, -33 },
  { 1453, 6, 25, 11, 3, -25 },
  { 1472, 7, 31, 11, 2, -25 },
  { 1500, 18, 21, 21, 1, -27 },
  { 1548, 18, 14, 21, 1, -23 },
  { 1580, 19, 21, 21, 1, -27 },
  { 1630, 15, 33, 16, 0, -33 },
  { 1692, 28, 37, 32, 2, -33 },
  { 1822, 23, 33, 23, 0, -33 },
  { 1917, 19, 33, 23, 3, -33 },
  { 1996, 18, 33, 22, 2, -33 },
  { 2071, 20, 33, 25, 3, -33 },
  { 2154, 14, 33, 19, 3, -33 },
  { 2212, 14, 33, 19, 3, -33 },
  { 2270, 21, 33, 26, 2, -33 },
  { 2357, 20, 33, 26, 3, -33 },
  { 2440, 12, 33, 14, 1, -33 },
  { 2490, 11, 42, 12, -2, -33 },
  { 2548, 20, 33, 23, 3, -33 },
  { 2631, 14, 33, 18, 3, -33 },
  { 2689, 28, 33, 35, 3, -33 },
  { 2805, 22, 33, 28, 3, -33 },
  { 2896, 22, 33, 27, 2, -33 },
  { 2987, 17, 33, 22, 3, -33 },
  { 3058, 22, 41, 27, 2, -33 },
  { 3171, 19, 33, 23, 3, -33 },
  { 3250, 16, 33, 19, 2, -33 },
  { 3316, 17, 33, 19, 1, -33 },
  { 3387, 19, 33, 25, 3, -33 },
  { 3466, 22, 33, 22, 0, -33 },
  { 3557, 34, 33, 34, 0, -33 },
  { 3698, 20, 33, 21, 0, -33 },
  { 3781, 20, 33, 20, 0, -33 },
  { 3864, 16, 33, 18, 1, -33 },
  { 3930, 10, 40, 14, 3, -33 },
  { 3980, 17, 33, 18, 1, -33 },
  { 4051, 10, 40, 14, 1, -33 },
  { 4101, 21, 19, 23, 1, -33 },
  { 4151, 19, 3, 19, 0, 4 },
  { 4159, 10, 7, 14, 2, -35 },
  { 4168, 17, 25, 21, 1, -25 },
  { 4222, 18, 35, 22, 3, -35 },
  { 4301, 14, 25, 17, 2, -25 },
  { 4345, 18, 35, 22, 2, -35 },
  { 4424, 17, 25, 20, 2, -25 },
  { 4478, 14, 35, 13, 0, -35 },
  { 4540, 18, 36, 22, 2, -25 },
  { 4621, 17, 35, 22, 3, -35 },
  { 4696, 6, 35, 11, 2, -35 },
  { 4723, 9, 46, 11, -1, -35 },
  { 4775, 18, 35, 21, 3, -35 },
  { 4854, 5, 35, 11, 3, -35 },
  { 4876, 28, 25, 33, 3, -25 },
  { 4964, 17, 25, 22, 3, -25 },
  { 5018, 18, 25, 22, 2, -25 },
  { 5075, 18, 36, 22, 3, -25 },
  { 5156, 18, 36, 22, 2, -25 },
  { 5237, 12, 25, 15, 3, -25 },
  { 5275, 14, 25, 17, 1, -25 },
  { 5319, 12, 30, 14, 1, -30 },
  { 5364, 17, 25, 22, 3, -25 },
  { 5418, 19, 25, 19, 0, -25 },
  { 5478, 30, 25, 30, 0, -25 },
  { 5572, 18, 25, 19, 0, -25 },
  { 5629, 19, 36, 19, 0, -25 },
  { 5715, 14, 25, 16, 1, -25 },
  { 5759, 13, 40, 16, 1, -33 },
  { 5824, 4, 46, 20, 8, -35 },
  { 5847, 13, 40, 16, 2, -33 },
  { 5912, 19, 7, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD46PT7B_H_
