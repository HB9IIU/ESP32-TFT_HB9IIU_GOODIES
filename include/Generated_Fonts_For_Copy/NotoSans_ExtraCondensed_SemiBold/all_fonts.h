#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_SemiBold
// Headers: 67

#include "NotoSans_ExtraCondensed_SemiBold6pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold7pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold8pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold9pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold10pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold11pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold12pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold13pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold14pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold15pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold16pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold17pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold18pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold19pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold20pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold21pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold22pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold23pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold24pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold25pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold26pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold27pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold28pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold29pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold30pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold31pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold32pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold33pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold34pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold35pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold36pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold37pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold38pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold39pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold40pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold41pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold42pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold43pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold44pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold45pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold46pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold47pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold48pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold49pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold50pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold51pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold52pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold53pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold54pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold55pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold56pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold57pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold58pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold59pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold60pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold61pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold62pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold63pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold64pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold65pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold66pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold67pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold68pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold69pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold70pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold71pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBold72pt7b.h"
