#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDC, 0x00, 0x01, 0xFF, 0xFF, 0xDE, 0xF9, 0xFF, 0x9F, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xE7, 0x0E, 0x07, 0x8E, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x71, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x03, 0xF8, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBC, 0xC4, 0xF3, 0x03, 0xCC,
  0x0F, 0x30, 0x3C, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x37, 0x80, 0xDE, 0x03, 0x3C, 0x0C, 0xE8, 0x37, 0xBC,
  0xFE, 0xFF, 0xF3, 0xFF, 0x83, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x10, 0x0F, 0x80, 0x70, 0x0F, 0xE0, 0x38, 0x0F,
  0xF0, 0x3C, 0x07, 0x3C, 0x1C, 0x03, 0x8E, 0x0E, 0x03, 0xC7, 0x0E, 0x01,
  0xE3, 0x87, 0x00, 0xF1, 0xC7, 0x80, 0x78, 0xE3, 0x80, 0x3C, 0x71, 0xC0,
  0x1E, 0x39, 0xE3, 0x87, 0x1C, 0xE7, 0xE3, 0x9E, 0x73, 0xF9, 0xFE, 0x73,
  0xDE, 0x7F, 0x39, 0xC7, 0x1F, 0x3C, 0xE3, 0x82, 0x1C, 0x71, 0xC0, 0x0E,
  0x78, 0xE0, 0x0F, 0x3C, 0x70, 0x07, 0x1E, 0x38, 0x03, 0x87, 0x1C, 0x03,
  0x83, 0x8E, 0x01, 0xC1, 0xC7, 0x01, 0xE0, 0xE7, 0x80, 0xE0, 0x7F, 0xC0,
  0x70, 0x1F, 0xC0, 0x78, 0x07, 0xC0, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0xF1, 0xFE, 0x1E, 0x7D, 0xE7, 0xDF, 0x3E,
  0xFB, 0xE3, 0xDE, 0x78, 0x7F, 0xCF, 0x07, 0xF9, 0xE0, 0x7E, 0x3E, 0x0F,
  0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xDF, 0x0F, 0xE1,
  0xF0, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0x73, 0x80, 0x07, 0x87, 0x87, 0x83,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x63, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x81, 0xEF, 0x0F, 0x3C, 0x7C, 0x78, 0x61,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3C,
  0xF7, 0xDF, 0x79, 0xE7, 0x9C, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF7, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0x00, 0x1F, 0xC0, 0x7F, 0xC1,
  0xFF, 0xC3, 0xEF, 0x8F, 0x8F, 0x1E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE0, 0xF7, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x1F, 0x3E, 0x3E, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x03,
  0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFE, 0xFB, 0x9F, 0x23, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0x01, 0x00, 0x7F, 0x87, 0xFF, 0x3F, 0xFE, 0x78, 0xF8, 0xC1, 0xF2,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x7F, 0xC1, 0xFF, 0xC7, 0xFF, 0xC7, 0x8F, 0xC4,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC1, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x40, 0x3E, 0xF9,
  0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0x78, 0x07, 0x78, 0x0E,
  0x78, 0x0E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78,
  0x78, 0x70, 0x78, 0xF0, 0x78, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE8, 0x0F, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFC, 0x23, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF1, 0x01, 0xEF, 0xC7, 0xBF, 0xCF,
  0x7F, 0xDF, 0xCF, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0x9F, 0x0F, 0x1F, 0x7E, 0x3F, 0xF8,
  0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0x78, 0xF0, 0xFB, 0xE0, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x1F,
  0x7C, 0x7C, 0x7C, 0xF0, 0x7B, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x0F, 0xBE, 0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE3, 0xF7, 0xC7, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x7C,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x87, 0xEF, 0x9F,
  0xDF, 0xFF, 0x1F, 0xFE, 0x1F, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x31, 0xF8, 0x7F, 0xE0, 0xFF, 0x81, 0xFE,
  0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0x80, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x7D, 0xE7, 0x9E, 0x73, 0xC0, 0x00,
  0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0x02, 0x01, 0xFE, 0x3F, 0xF8, 0xFF, 0xE7, 0x9F, 0x20, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0x9F, 0x80, 0xF8, 0x07, 0x81, 0xC0, 0x07,
  0x87, 0x80, 0x07, 0x1E, 0x00, 0x0F, 0x38, 0x3F, 0x8E, 0x70, 0xFF, 0x1D,
  0xE3, 0xEE, 0x3F, 0x87, 0x1C, 0x7F, 0x1E, 0x38, 0x7E, 0x38, 0x70, 0xFC,
  0x70, 0xE1, 0xF8, 0xE1, 0xC3, 0xF1, 0xC3, 0x87, 0xE3, 0x87, 0x1F, 0xC7,
  0x1E, 0x3B, 0x8E, 0x3C, 0x77, 0x1E, 0x7D, 0xEE, 0x1F, 0xBF, 0x9E, 0x1F,
  0x3E, 0x1C, 0x0C, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x03, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B,
  0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x03,
  0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0xFB, 0xC3, 0xE7, 0xFF, 0xCF, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x78, 0x3E,
  0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xFB, 0xC7, 0xC0, 0x9F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x02, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0xFC,
  0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x20, 0x01, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xE3, 0xFC, 0xF1, 0xF0,
  0x09, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF0,
  0x1E, 0x7C, 0x0F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xDF, 0xE3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7E, 0x7F,
  0xFE, 0xFF, 0x7F, 0x3E, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7,
  0xC0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFB, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xEF,
  0xFF, 0x03, 0xDF, 0xEE, 0x07, 0xBF, 0xDE, 0x0E, 0x7F, 0xBC, 0x1C, 0xFF,
  0x78, 0x79, 0xFE, 0x70, 0xF3, 0xFC, 0xF1, 0xC7, 0xF9, 0xE7, 0x8F, 0xF1,
  0xCF, 0x1F, 0xE3, 0x9E, 0x3F, 0xC7, 0xB8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F,
  0xE1, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0x07, 0xF8, 0x7E, 0x0F, 0xF0, 0x7C,
  0x1F, 0xE0, 0xF0, 0x3F, 0xC1, 0xE0, 0x78, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFB, 0xC3, 0xFD, 0xE1, 0xFE, 0x78, 0xFF, 0x3C, 0x7F, 0x8F,
  0x3F, 0xC7, 0x9F, 0xE3, 0xEF, 0xF0, 0xF7, 0xF8, 0x7B, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0x3F, 0x1F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x1E, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x3F, 0x1F, 0x03, 0xE7, 0xC0, 0xF9,
  0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF9,
  0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0xF8, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0xF8, 0xF3, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xF3, 0xE0, 0xF1,
  0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x3F, 0x01, 0x00, 0x3F, 0xC3, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF9, 0xF0, 0x47, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xB8,
  0x3E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0xFF, 0xFE, 0x7F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF0, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D,
  0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x73, 0xC0,
  0x1E, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x1F, 0xF8, 0x0F, 0x01, 0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7,
  0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0xC1, 0xF8, 0x3E, 0x3C, 0x3F,
  0xC3, 0xC3, 0xC3, 0xFC, 0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C,
  0x3C, 0x39, 0xC7, 0xC1, 0xE7, 0x9E, 0x7C, 0x1E, 0x79, 0xE7, 0x81, 0xE7,
  0x9E, 0x78, 0x1E, 0x70, 0xE7, 0x81, 0xE7, 0x0E, 0xF8, 0x0F, 0xF0, 0xEF,
  0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0x07, 0x87,
  0xC7, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x81,
  0xE3, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x7C, 0x1F, 0x3C, 0x07,
  0xBE, 0x03, 0xE0, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xC3,
  0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3D, 0xE0, 0x1C, 0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83,
  0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFE, 0x10, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03,
  0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0x8F, 0x78, 0x3F, 0xE0, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE3, 0xF7, 0xFF, 0xDF, 0xEF, 0x3F, 0x3C, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF1, 0xE1, 0xE7, 0xF3, 0xDF, 0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x07,
  0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3D, 0xFC, 0xFB, 0xFF,
  0xE7, 0xBF, 0xCF, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7,
  0xC1, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x09, 0xF1, 0x8F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x1E, 0x3F, 0xBC, 0xFF,
  0xF9, 0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC,
  0x1F, 0x7C, 0x3E, 0xFC, 0xFC, 0xFF, 0xF8, 0xFE, 0xF0, 0xF8, 0xE0, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xBE, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x04, 0xF8, 0x73, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8,
  0x07, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3F, 0xC7, 0xFC, 0xFF, 0xCF, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x8E, 0x3F, 0xBC,
  0xFF, 0xF9, 0xFF, 0xF7, 0xC3, 0xEF, 0x87, 0xDE, 0x07, 0xBC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x1F, 0x7C, 0x3E, 0xFD, 0xFC, 0xFF, 0xF8, 0xFE, 0xF0, 0xF9, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0xC0, 0x79, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF1, 0xE3, 0xDF, 0xEF, 0x7F,
  0xBF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x27, 0xBF, 0xFF, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x04, 0x1E, 0x1F, 0x1F, 0x1E, 0x04, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xF0, 0x7B,
  0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x1F, 0x3E, 0x3E, 0x78, 0x7D, 0xE0, 0xF7,
  0xC1, 0xEF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xDE, 0x1F, 0x3E, 0x3E, 0x3C,
  0x7C, 0x7C, 0xF8, 0x79, 0xF0, 0xFB, 0xE0, 0xF7, 0xC1, 0xFF, 0x83, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE0, 0xF9, 0xEF, 0xE3,
  0xFB, 0xDF, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xFF, 0x0F, 0xC3,
  0xFE, 0x0F, 0x07, 0xFC, 0x1E, 0x0F, 0xF8, 0x3C, 0x1F, 0xF0, 0x78, 0x3F,
  0xE0, 0xF0, 0x7F, 0xC1, 0xE0, 0xFF, 0x83, 0xC1, 0xFF, 0x07, 0x83, 0xFE,
  0x0F, 0x07, 0xFC, 0x1E, 0x0F, 0xF8, 0x3C, 0x1F, 0xF0, 0x78, 0x3F, 0xE0,
  0xF0, 0x7F, 0xC1, 0xE0, 0xFF, 0x83, 0xC1, 0xE0, 0xF1, 0xE3, 0xDF, 0xEF,
  0x7F, 0xBF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x07, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x7C, 0x3E, 0x7C, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE,
  0x00, 0xF1, 0xE1, 0xE7, 0xF3, 0xDF, 0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x07,
  0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3D, 0xFC, 0xFB, 0xDF,
  0xE7, 0xBF, 0xCF, 0x3F, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x8E,
  0x3F, 0xBC, 0xFF, 0xF9, 0xFF, 0xF7, 0xC3, 0xEF, 0x87, 0xDE, 0x07, 0xBC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x1F, 0x7C, 0x3E, 0xFC, 0xFC, 0xFF, 0xF8, 0xFE, 0xF0,
  0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xF1, 0xFC, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xFE, 0x7F, 0xEF, 0xFE, 0xF0, 0x4F, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x07,
  0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x81, 0xFF,
  0x3E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x93, 0xFC, 0xFF,
  0x1F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7D, 0xF7, 0xF7, 0xFF, 0xCF,
  0xEF, 0x1F, 0x1C, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x1C, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xF0, 0x3E, 0x0F,
  0xFC, 0x1F, 0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x0F, 0xC1, 0xE7, 0x87, 0xF1,
  0xF3, 0xE3, 0xB8, 0xF0, 0xF1, 0xDC, 0x78, 0x78, 0xEE, 0x3C, 0x3C, 0xF7,
  0x1E, 0x1E, 0x73, 0x9E, 0x0F, 0xB8, 0xEF, 0x03, 0xDC, 0x77, 0x81, 0xEE,
  0x3B, 0xC0, 0xF7, 0x1D, 0xE0, 0x7B, 0x8E, 0xE0, 0x1F, 0x87, 0xF0, 0x0F,
  0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x78, 0x3E, 0xF8, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xE7,
  0x83, 0xDF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x7C, 0x3E, 0x78, 0x78,
  0xF9, 0xF0, 0xF3, 0xC1, 0xEF, 0x83, 0xE0, 0xF8, 0x1F, 0xF8, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x87, 0xE0, 0xF0, 0x1F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x7F, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x0F, 0xFF,
  0xFF, 0x3F, 0xF8, 0x1F, 0xD0, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 27, 9, 2, -27 },
  { 18, 12, 10, 16, 2, -27 },
  { 33, 17, 27, 18, 1, -27 },
  { 91, 14, 31, 17, 2, -29 },
  { 146, 25, 28, 28, 1, -28 },
  { 234, 19, 28, 20, 1, -28 },
  { 301, 5, 10, 9, 2, -27 },
  { 308, 9, 33, 12, 2, -27 },
  { 346, 9, 33, 12, 1, -27 },
  { 384, 14, 14, 16, 1, -29 },
  { 409, 15, 18, 17, 1, -22 },
  { 443, 6, 9, 9, 1, -4 },
  { 450, 9, 4, 11, 1, -12 },
  { 455, 5, 5, 9, 2, -5 },
  { 459, 15, 27, 15, 0, -27 },
  { 510, 15, 28, 17, 1, -28 },
  { 563, 11, 27, 17, 2, -27 },
  { 601, 14, 28, 17, 1, -28 },
  { 650, 15, 28, 17, 1, -28 },
  { 703, 16, 27, 17, 1, -27 },
  { 757, 14, 27, 17, 2, -27 },
  { 805, 15, 27, 17, 1, -27 },
  { 856, 15, 27, 17, 1, -27 },
  { 907, 15, 27, 17, 1, -27 },
  { 958, 15, 27, 17, 1, -27 },
  { 1009, 5, 21, 9, 2, -21 },
  { 1023, 6, 26, 9, 1, -21 },
  { 1043, 15, 17, 17, 1, -22 },
  { 1075, 15, 11, 17, 1, -19 },
  { 1096, 15, 17, 17, 1, -22 },
  { 1128, 13, 28, 13, 0, -28 },
  { 1174, 23, 30, 26, 2, -27 },
  { 1261, 19, 27, 19, 0, -27 },
  { 1326, 15, 27, 19, 3, -27 },
  { 1377, 15, 28, 18, 2, -28 },
  { 1430, 16, 27, 21, 3, -27 },
  { 1484, 11, 27, 16, 3, -27 },
  { 1522, 11, 27, 16, 3, -27 },
  { 1560, 17, 28, 21, 2, -28 },
  { 1620, 16, 27, 22, 3, -27 },
  { 1674, 9, 27, 12, 1, -27 },
  { 1705, 9, 35, 10, -2, -27 },
  { 1745, 16, 27, 19, 3, -27 },
  { 1799, 11, 27, 15, 3, -27 },
  { 1837, 23, 27, 29, 3, -27 },
  { 1915, 17, 27, 23, 3, -27 },
  { 1973, 18, 28, 22, 2, -28 },
  { 2036, 14, 27, 18, 3, -27 },
  { 2084, 18, 34, 22, 2, -28 },
  { 2161, 16, 27, 19, 3, -27 },
  { 2215, 14, 28, 16, 1, -28 },
  { 2264, 15, 27, 16, 0, -27 },
  { 2315, 16, 27, 21, 3, -27 },
  { 2369, 18, 27, 18, 0, -27 },
  { 2430, 28, 27, 28, 0, -27 },
  { 2525, 17, 27, 17, 0, -27 },
  { 2583, 17, 27, 17, 0, -27 },
  { 2641, 13, 27, 15, 1, -27 },
  { 2685, 9, 33, 12, 2, -27 },
  { 2723, 15, 27, 15, 0, -27 },
  { 2774, 8, 33, 12, 1, -27 },
  { 2807, 17, 16, 19, 1, -27 },
  { 2841, 16, 3, 16, 0, 3 },
  { 2847, 8, 6, 11, 2, -29 },
  { 2853, 14, 21, 17, 1, -21 },
  { 2890, 15, 29, 18, 2, -29 },
  { 2945, 13, 21, 14, 1, -21 },
  { 2980, 15, 29, 18, 1, -29 },
  { 3035, 14, 21, 17, 1, -21 },
  { 3072, 12, 29, 11, 0, -29 },
  { 3116, 15, 30, 18, 1, -21 },
  { 3173, 14, 29, 18, 2, -29 },
  { 3224, 5, 29, 9, 2, -29 },
  { 3243, 8, 38, 9, -1, -29 },
  { 3281, 15, 29, 17, 2, -29 },
  { 3336, 5, 29, 9, 2, -29 },
  { 3355, 23, 21, 27, 2, -21 },
  { 3416, 14, 21, 18, 2, -21 },
  { 3453, 15, 21, 18, 1, -21 },
  { 3493, 15, 30, 18, 2, -21 },
  { 3550, 15, 30, 18, 1, -21 },
  { 3607, 10, 21, 13, 2, -21 },
  { 3634, 12, 21, 14, 1, -21 },
  { 3666, 10, 25, 12, 1, -25 },
  { 3698, 14, 21, 18, 2, -21 },
  { 3735, 16, 21, 16, 0, -21 },
  { 3777, 25, 21, 25, 0, -21 },
  { 3843, 15, 21, 15, 0, -21 },
  { 3883, 16, 30, 16, 0, -21 },
  { 3943, 11, 21, 13, 1, -21 },
  { 3972, 11, 33, 13, 1, -27 },
  { 4018, 4, 38, 16, 6, -29 },
  { 4037, 12, 33, 13, 1, -27 },
  { 4087, 15, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD38PT7B_H_
