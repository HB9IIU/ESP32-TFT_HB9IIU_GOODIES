#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0x7F, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x80,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03,
  0xE1, 0xE0, 0x07, 0xC3, 0xC1, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3C,
  0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xDC, 0x73, 0xF3, 0x82, 0x7E, 0x70,
  0x0F, 0xCE, 0x01, 0xF9, 0xC0, 0x3F, 0x38, 0x03, 0xE7, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xEF, 0xC0, 0x1C, 0xFC, 0x03, 0x8F,
  0x80, 0x71, 0xF0, 0x0E, 0x3F, 0x01, 0xCF, 0xF8, 0x39, 0xF7, 0xC7, 0x7E,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x00, 0x40, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x7D, 0xF0, 0x0F, 0x00, 0x3E, 0x3C, 0x07,
  0xC0, 0x0F, 0x8F, 0x81, 0xE0, 0x03, 0xC3, 0xE0, 0x78, 0x00, 0xF0, 0x78,
  0x3E, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x87, 0xC0, 0x03, 0xC1,
  0xE1, 0xF0, 0x00, 0xF0, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x3E, 0x00, 0x0F,
  0x07, 0x8F, 0x00, 0x03, 0xC3, 0xE3, 0xC3, 0xF0, 0xF8, 0xF9, 0xF1, 0xFE,
  0x3E, 0x3C, 0x78, 0xFF, 0xC7, 0xDF, 0x3E, 0x7F, 0xF1, 0xFF, 0xCF, 0x9E,
  0x3E, 0x3F, 0xE3, 0xC7, 0x8F, 0x87, 0xF1, 0xF3, 0xE1, 0xE0, 0xF8, 0x78,
  0xF8, 0x78, 0x00, 0x1E, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x87, 0x80, 0x03,
  0xC3, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x1F, 0x00,
  0x1E, 0x0F, 0x87, 0x80, 0x0F, 0x83, 0xE1, 0xE0, 0x03, 0xC0, 0xF8, 0x78,
  0x00, 0xF0, 0x1E, 0x3E, 0x00, 0x7C, 0x07, 0x8F, 0x80, 0x1E, 0x01, 0xFF,
  0xC0, 0x07, 0x80, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x81, 0xF8, 0x7F, 0xF0, 0x7E, 0x3F, 0xFC, 0x1F, 0x8F, 0xDF,
  0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7C, 0x1F, 0xBE, 0x3F,
  0x03, 0xFF, 0x8F, 0xC0, 0xFF, 0xE3, 0xF0, 0x1F, 0xF0, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFB, 0xF0, 0x7F, 0xFC, 0xFE, 0x07,
  0xFC, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xC1, 0xE0, 0x9F, 0x3C, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03,
  0xE7, 0xC0, 0xFC, 0xFC, 0x3F, 0x0F, 0xC1, 0xE1, 0xE0, 0x18, 0x10, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x79, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x7F, 0x1F,
  0x87, 0xE3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x1F, 0x7E,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xE7, 0xC0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF8,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xF3, 0xF7, 0x8F, 0xCC,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFC, 0x7F, 0x1E, 0x07, 0xF1,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xF8,
  0x7F, 0x8C, 0x07, 0xF1, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xF6, 0x00, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x7E, 0x00, 0x7B, 0xF0, 0x07,
  0xDF, 0x80, 0x3C, 0xFC, 0x03, 0xE7, 0xE0, 0x1E, 0x3F, 0x01, 0xF1, 0xF8,
  0x0F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0,
  0xFC, 0x1E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF0, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFD, 0x00, 0x3F, 0xB8, 0x0F, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xC1, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x20, 0x3E, 0x3F, 0x87,
  0xCF, 0xF8, 0xFB, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0x07, 0xEF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x83, 0xF3, 0xF8, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0xFC, 0xFE, 0x3F, 0x0F, 0xEF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0x87, 0xF7, 0xE0, 0x7E, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0x7F, 0x3F, 0x87,
  0xE7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xEF,
  0xC7, 0xFD, 0xF8, 0x7E, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x08, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0x7F,
  0xFF, 0xFF, 0xF3, 0xE1, 0x00, 0x3C, 0x7E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF1, 0xE3, 0xFC, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF8, 0xF8, 0x0F, 0xE0, 0xF1, 0xE0, 0x7F, 0xF1, 0xE3, 0xC1, 0xFF,
  0xE3, 0xEF, 0x87, 0xEF, 0xC3, 0xDE, 0x0F, 0x8F, 0x87, 0xBC, 0x3E, 0x1F,
  0x0F, 0x78, 0x7C, 0x3E, 0x1F, 0xF0, 0xF0, 0x7C, 0x3F, 0xE1, 0xE0, 0xF0,
  0x7F, 0xC3, 0xC1, 0xE0, 0xFF, 0x8F, 0x83, 0xC1, 0xFE, 0x1F, 0x07, 0x83,
  0xFC, 0x3E, 0x0F, 0x07, 0xFC, 0x3C, 0x1E, 0x0F, 0xF8, 0x78, 0x7C, 0x3F,
  0xF0, 0xF0, 0xF8, 0x7B, 0xE1, 0xF1, 0xF8, 0xF3, 0xC3, 0xFF, 0x7F, 0xE7,
  0x83, 0xFE, 0xFF, 0x8F, 0x83, 0xF8, 0xFE, 0x1F, 0x03, 0xE0, 0xF8, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF9,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x03, 0xFB, 0xF0,
  0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xF8, 0x7F, 0xCF,
  0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFB, 0xF0, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0xF0, 0x7F, 0x00,
  0x87, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x06, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF0, 0x3F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC3, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x0F, 0x87, 0xF8,
  0x03, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xEF, 0xC0, 0xFF, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xF0,
  0x3F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF0, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F,
  0xCF, 0x80, 0xFC, 0x7C, 0x0F, 0xE3, 0xE0, 0x7E, 0x1F, 0x07, 0xF0, 0xF8,
  0x3F, 0x07, 0xC3, 0xF8, 0x3E, 0x3F, 0x81, 0xF1, 0xF8, 0x0F, 0x9F, 0xC0,
  0x7C, 0xFC, 0x03, 0xEF, 0xE0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03,
  0xF1, 0xF8, 0x1F, 0x0F, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x9F,
  0x00, 0xFC, 0xF8, 0x07, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFF, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF7, 0x80, 0x1F, 0xFF, 0xEF, 0x80, 0x3D, 0xFF, 0xDF, 0x00, 0xFB, 0xFF,
  0xBE, 0x01, 0xF7, 0xFF, 0x3E, 0x03, 0xEF, 0xFE, 0x7C, 0x0F, 0x9F, 0xFC,
  0xF8, 0x1F, 0x3F, 0xF9, 0xF0, 0x3E, 0x7F, 0xF1, 0xF0, 0x78, 0xFF, 0xE3,
  0xE1, 0xF1, 0xFF, 0xC7, 0xC3, 0xE3, 0xFF, 0x8F, 0x87, 0xC7, 0xFF, 0x0F,
  0x9F, 0x0F, 0xFE, 0x1F, 0x3E, 0x1F, 0xFC, 0x3E, 0x7C, 0x3F, 0xF8, 0x7C,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xF8,
  0x1F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80,
  0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC0, 0x7C, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xEF, 0x80, 0xFF, 0xDF, 0x81, 0xFF, 0x9F, 0x03, 0xFF, 0x3F,
  0x07, 0xFE, 0x7E, 0x0F, 0xFC, 0x7C, 0x1F, 0xF8, 0xFC, 0x3F, 0xF0, 0xF8,
  0x7F, 0xE1, 0xF8, 0xFF, 0xC3, 0xF1, 0xFF, 0x83, 0xF3, 0xFF, 0x07, 0xE7,
  0xFE, 0x07, 0xCF, 0xFC, 0x0F, 0xDF, 0xF8, 0x0F, 0xBF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0,
  0xFF, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1,
  0xF8, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0,
  0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF0, 0x7F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xE0, 0x33, 0xF0, 0x04, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xEC, 0x01, 0xFB, 0xC0,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01,
  0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03,
  0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0x00, 0x7E, 0x7C,
  0x01, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xE0,
  0x1F, 0x1F, 0x80, 0x7F, 0x80, 0xFC, 0x7E, 0x03, 0xFE, 0x03, 0xF0, 0xF8,
  0x0F, 0xF8, 0x0F, 0xC3, 0xF0, 0x3D, 0xF0, 0x3F, 0x0F, 0xC0, 0xF7, 0xC0,
  0xF8, 0x3F, 0x03, 0xDF, 0x07, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F, 0x81, 0xF0,
  0x7C, 0xF0, 0x7E, 0x07, 0xE1, 0xF3, 0xE1, 0xF8, 0x1F, 0x87, 0xCF, 0x87,
  0xC0, 0x7E, 0x1E, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0xF8, 0xFC, 0x03, 0xE3,
  0xE1, 0xE3, 0xF0, 0x0F, 0x8F, 0x87, 0x8F, 0xC0, 0x3F, 0x3E, 0x1F, 0x3E,
  0x00, 0xFC, 0xF0, 0x7C, 0xF8, 0x01, 0xF7, 0xC1, 0xF7, 0xE0, 0x07, 0xDF,
  0x03, 0xDF, 0x80, 0x1F, 0x7C, 0x0F, 0x7E, 0x00, 0x7D, 0xF0, 0x3D, 0xF0,
  0x01, 0xF7, 0x80, 0xF7, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF7,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xF8,
  0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x7F, 0x86, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0xF7, 0xDF, 0xFD, 0xF7, 0xFE, 0x7C,
  0xFF, 0x1F, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xFC,
  0xFF, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF,
  0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0,
  0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFF, 0x9F, 0xCF, 0xFF, 0xFC, 0xFB,
  0xFF, 0x8F, 0x9F, 0xF0, 0xF8, 0xFE, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0x02, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0x3F, 0xDF, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x3F, 0x0F, 0xF3, 0xF1, 0xFF, 0xBF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0x0F, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xC0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0xFF, 0x7F, 0x9F, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0x08, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0xFC,
  0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x31, 0xFC, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xC2, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xE1, 0xF0, 0xFF, 0x1F, 0x1F, 0xF9, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xF0, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x0F, 0xF7,
  0xFB, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xFB, 0xF0, 0xFE, 0x3F,
  0x01, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE4, 0x00, 0x7E, 0x70, 0x0F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0x0F, 0xDF,
  0xF1, 0xFF, 0xFF, 0x3E, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x0F, 0xDF, 0xC1,
  0xFB, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xF8, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x1F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFF, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xF7, 0xE0, 0xFE, 0x7E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xF8,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x07, 0xE1, 0xF3,
  0xFE, 0x1F, 0xF3, 0xEF, 0xFE, 0x7F, 0xE7, 0xDF, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xE3, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x1F, 0xFE, 0x07,
  0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x1F,
  0x01, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0x80, 0xF8,
  0x0F, 0xFF, 0x01, 0xF0, 0x1F, 0xFE, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xC0,
  0x7F, 0xF8, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x01, 0xFF, 0xE0, 0x3E, 0x03,
  0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0x80, 0xF8, 0x0F, 0xFF, 0x01, 0xF0, 0x1F,
  0xFE, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFF,
  0xF0, 0x1F, 0x01, 0xFF, 0xE0, 0x3E, 0x03, 0xF0, 0xF8, 0x7E, 0x1F, 0x3F,
  0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x1F, 0xBF, 0x83,
  0xF7, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0x07,
  0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x60, 0x00, 0xF8, 0x7E, 0x0F, 0x9F, 0xF0, 0xF9, 0xFF, 0x8F,
  0xBF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0xFF,
  0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFD, 0xFF, 0x0F,
  0xCF, 0xE0, 0xFC, 0x18, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0xFF,
  0x1F, 0x1F, 0xF9, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0xFF, 0x7E,
  0x07, 0xF7, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xF7, 0xE0, 0x7F, 0x7E, 0x0F, 0xF7, 0xFB, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xBF, 0x1F, 0xFB, 0xF0, 0xFE, 0x3F, 0x01, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0x81, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xE3, 0xFF, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x8F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x71, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x08, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x87, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0x7C, 0xFF, 0xCF, 0x8F,
  0xF1, 0xF0, 0x30, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7E,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xE0,
  0x7C, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0x81,
  0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xBE, 0x03,
  0xF8, 0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xCF, 0xC0, 0xFE, 0x03, 0xE7, 0xE0,
  0x7F, 0x83, 0xF3, 0xF0, 0x7F, 0xC1, 0xF8, 0xF8, 0x3D, 0xE0, 0xFC, 0x7C,
  0x1E, 0xF0, 0x7C, 0x3F, 0x0F, 0x78, 0x3E, 0x1F, 0x87, 0xBE, 0x3F, 0x07,
  0xC7, 0xCF, 0x1F, 0x83, 0xE3, 0xE7, 0x8F, 0x81, 0xF1, 0xE3, 0xC7, 0xC0,
  0xFC, 0xF1, 0xE3, 0xE0, 0x7E, 0x78, 0xF3, 0xF0, 0x1F, 0x3C, 0x7D, 0xF8,
  0x0F, 0xBE, 0x1E, 0xF8, 0x07, 0xDE, 0x0F, 0x7C, 0x03, 0xEF, 0x07, 0xBE,
  0x00, 0xFF, 0x83, 0xDF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x1F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xDF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0xFD, 0xF0, 0x0F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0,
  0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7,
  0xE0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x09, 0xFF, 0x00, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFB, 0x00, 0xFF, 0x90, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 16, 13, 21, 3, -36 },
  { 60, 23, 36, 25, 1, -36 },
  { 164, 19, 42, 23, 2, -39 },
  { 264, 34, 37, 37, 2, -37 },
  { 422, 26, 38, 27, 1, -37 },
  { 546, 6, 13, 11, 3, -36 },
  { 556, 13, 45, 16, 2, -37 },
  { 630, 12, 45, 16, 1, -37 },
  { 698, 19, 19, 22, 1, -39 },
  { 744, 20, 24, 23, 1, -30 },
  { 804, 8, 13, 12, 2, -6 },
  { 817, 13, 5, 15, 1, -16 },
  { 826, 7, 8, 12, 3, -7 },
  { 833, 19, 37, 20, 1, -37 },
  { 921, 19, 38, 23, 2, -37 },
  { 1012, 14, 36, 23, 3, -36 },
  { 1075, 19, 37, 23, 2, -37 },
  { 1163, 19, 38, 23, 2, -37 },
  { 1254, 21, 37, 23, 1, -37 },
  { 1352, 19, 37, 23, 2, -36 },
  { 1440, 19, 38, 23, 2, -37 },
  { 1531, 20, 36, 23, 1, -36 },
  { 1621, 19, 38, 23, 2, -37 },
  { 1712, 19, 38, 23, 2, -37 },
  { 1803, 7, 29, 13, 3, -28 },
  { 1829, 8, 35, 13, 2, -28 },
  { 1864, 21, 24, 23, 1, -30 },
  { 1927, 21, 15, 23, 1, -25 },
  { 1967, 21, 24, 23, 1, -30 },
  { 2030, 17, 38, 18, 0, -37 },
  { 2111, 31, 41, 35, 2, -37 },
  { 2270, 25, 36, 25, 0, -36 },
  { 2383, 21, 36, 26, 3, -36 },
  { 2478, 21, 38, 24, 2, -37 },
  { 2578, 22, 36, 28, 3, -36 },
  { 2677, 15, 36, 22, 4, -36 },
  { 2745, 15, 36, 21, 4, -36 },
  { 2813, 23, 38, 28, 2, -37 },
  { 2923, 21, 36, 29, 4, -36 },
  { 3018, 13, 36, 15, 1, -36 },
  { 3077, 12, 46, 13, -3, -36 },
  { 3146, 21, 36, 25, 4, -36 },
  { 3241, 16, 36, 20, 3, -36 },
  { 3313, 31, 36, 38, 4, -36 },
  { 3453, 23, 36, 31, 4, -36 },
  { 3557, 25, 38, 29, 2, -37 },
  { 3676, 20, 36, 24, 3, -36 },
  { 3766, 25, 46, 29, 2, -37 },
  { 3910, 22, 36, 25, 3, -36 },
  { 4009, 18, 38, 21, 2, -37 },
  { 4095, 19, 36, 21, 1, -36 },
  { 4181, 22, 37, 28, 3, -36 },
  { 4283, 25, 36, 25, 0, -36 },
  { 4396, 38, 36, 37, 0, -36 },
  { 4567, 23, 36, 23, 0, -36 },
  { 4671, 23, 36, 23, 0, -36 },
  { 4775, 18, 36, 20, 1, -36 },
  { 4856, 12, 45, 16, 3, -37 },
  { 4924, 18, 37, 20, 1, -37 },
  { 5008, 12, 45, 16, 1, -37 },
  { 5076, 23, 21, 25, 1, -36 },
  { 5137, 21, 4, 21, 0, 4 },
  { 5148, 11, 8, 15, 2, -39 },
  { 5159, 18, 29, 23, 2, -28 },
  { 5225, 20, 40, 25, 3, -39 },
  { 5325, 16, 29, 19, 2, -28 },
  { 5383, 20, 40, 25, 2, -39 },
  { 5483, 19, 29, 23, 2, -28 },
  { 5552, 16, 39, 14, 0, -39 },
  { 5630, 20, 40, 25, 2, -28 },
  { 5730, 19, 39, 25, 3, -39 },
  { 5823, 6, 38, 12, 3, -38 },
  { 5852, 10, 50, 12, -1, -38 },
  { 5915, 20, 39, 23, 3, -39 },
  { 6013, 6, 39, 12, 3, -39 },
  { 6043, 31, 28, 37, 3, -28 },
  { 6152, 19, 28, 25, 3, -28 },
  { 6219, 20, 29, 24, 2, -28 },
  { 6292, 20, 40, 25, 3, -28 },
  { 6392, 20, 40, 25, 2, -28 },
  { 6492, 13, 28, 17, 3, -28 },
  { 6538, 15, 29, 18, 2, -28 },
  { 6593, 14, 35, 15, 1, -34 },
  { 6655, 19, 29, 25, 3, -28 },
  { 6724, 21, 28, 21, 0, -28 },
  { 6798, 33, 28, 33, 0, -28 },
  { 6914, 20, 28, 21, 0, -28 },
  { 6984, 21, 40, 21, 0, -28 },
  { 7089, 15, 28, 17, 1, -28 },
  { 7142, 15, 45, 18, 1, -37 },
  { 7227, 5, 51, 22, 8, -39 },
  { 7259, 15, 45, 18, 2, -37 },
  { 7344, 21, 8, 23, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD51PT7B_H_
