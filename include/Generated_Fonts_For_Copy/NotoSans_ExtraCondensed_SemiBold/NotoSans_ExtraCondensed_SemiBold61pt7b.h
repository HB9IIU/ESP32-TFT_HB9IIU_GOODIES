#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xF3, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xC7, 0xE0, 0x80, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE,
  0x7E, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF,
  0xE3, 0xE3, 0xF9, 0xC0, 0xC7, 0xE3, 0x80, 0x0F, 0xC7, 0x00, 0x1F, 0x8E,
  0x00, 0x3F, 0x1C, 0x00, 0x7E, 0x38, 0x00, 0xFE, 0x70, 0x01, 0xFE, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0x9F, 0xC0, 0x07, 0x1F, 0xC0, 0x0E, 0x3F, 0x80,
  0x1C, 0x3F, 0x00, 0x38, 0x7E, 0x00, 0x70, 0xFE, 0x00, 0xE3, 0xFF, 0x01,
  0xC7, 0xFF, 0x83, 0x9F, 0xDF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x03, 0xE0, 0x00, 0xFC,
  0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x3F, 0x00, 0x01, 0xF8,
  0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x8F,
  0xC1, 0xE0, 0x3F, 0x0F, 0xC7, 0xC3, 0xFC, 0x0F, 0x87, 0xE3, 0xE3, 0xFF,
  0x07, 0xC3, 0xE3, 0xF1, 0xFF, 0xC3, 0xF1, 0xF1, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF9, 0xF8, 0xF9, 0xF8, 0x7F, 0xF8, 0xF8, 0xFC, 0x7E, 0x1F, 0xF8, 0x7C,
  0x7C, 0x3F, 0x07, 0xFC, 0x7E, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x8F, 0xC1, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x07, 0xC1,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00,
  0xFC, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0x8F,
  0xFF, 0xC0, 0xFE, 0x3F, 0xFF, 0x87, 0xF1, 0xFE, 0xFE, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x3F, 0xC7, 0xF9, 0xFC, 0xFE, 0x0F, 0xEF, 0xE3, 0xF8, 0x1F,
  0xFF, 0x8F, 0xE0, 0x7F, 0xFE, 0x3F, 0x80, 0xFF, 0xF0, 0xFE, 0x01, 0xFF,
  0xC3, 0xF8, 0x07, 0xFE, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xC0,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xC0, 0xFF,
  0xFC, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0x03, 0xF0, 0x27,
  0x87, 0x83, 0x9F, 0x9E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x0F, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC,
  0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x3F,
  0x1F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFE, 0x7E, 0x04, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81,
  0xF8, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F,
  0xCF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF8, 0x7F,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xEF, 0xFF, 0xE7, 0xF7, 0xE3,
  0xF9, 0xE1, 0xFC, 0x60, 0xFE, 0x10, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xC1, 0xFE, 0x1E, 0x01, 0xFC, 0x18, 0x03, 0xFC, 0x20, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0x81, 0xFE, 0x1C, 0x01,
  0xFE, 0x10, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE8, 0x00, 0x3F,
  0xDC, 0x00, 0xFF, 0xBF, 0xDF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x7E, 0x00, 0x07, 0xDF, 0x80,
  0x01, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x3F,
  0x80, 0x07, 0xCF, 0xE0, 0x03, 0xE3, 0xF8, 0x00, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x80, 0x1F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0x7C, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0x80, 0xFE,
  0x03, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7C, 0x03, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x08, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x80, 0x07, 0xFB, 0x80, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0xFC, 0xFF, 0xC3, 0xFB, 0xFF, 0xC7, 0xF7, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0x7F, 0xC0, 0xFE,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F,
  0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF3, 0xF8,
  0x1F, 0xC7, 0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F,
  0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F,
  0xEF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xC7, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF,
  0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF,
  0xE0, 0x7F, 0xDF, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFD, 0xFC, 0x3F, 0xF3, 0xF8, 0x3F, 0xC7, 0xE0, 0x0E, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x0E, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x1F, 0x9F, 0xCF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3F, 0x04, 0x00,
  0x1F, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xCF, 0xF3, 0xF8, 0x7E, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x3F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3E, 0x1F, 0xF3, 0x00, 0x7F, 0x20, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x1F, 0xFC, 0x3E, 0x1F, 0x01, 0xFF, 0xF0, 0xF9, 0xF8, 0x1F, 0xFF, 0x87,
  0xCF, 0x81, 0xFF, 0xFC, 0x3E, 0x7C, 0x1F, 0x87, 0xC1, 0xF7, 0xE0, 0xFC,
  0x3E, 0x0F, 0xFE, 0x07, 0xC1, 0xF0, 0x3F, 0xF0, 0x7E, 0x0F, 0x81, 0xFF,
  0x83, 0xE0, 0x7C, 0x0F, 0xFC, 0x1F, 0x03, 0xE0, 0x7F, 0xE0, 0xF8, 0x1F,
  0x03, 0xFF, 0x07, 0xC0, 0xF8, 0x1F, 0xF8, 0x3E, 0x07, 0xC0, 0xFF, 0xC3,
  0xF0, 0x3E, 0x07, 0xFE, 0x1F, 0x81, 0xF0, 0x3F, 0xF0, 0x7C, 0x1F, 0x83,
  0xEF, 0x83, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F, 0x07, 0xE0, 0xFB, 0xE0, 0xF8,
  0x3F, 0x07, 0xDF, 0x07, 0xE3, 0xF8, 0x7C, 0xF8, 0x1F, 0xBD, 0xF7, 0xE7,
  0xE0, 0xFF, 0xEF, 0xFE, 0x3F, 0x03, 0xFE, 0x3F, 0xF0, 0xF8, 0x0F, 0xF1,
  0xFF, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x00, 0x0F, 0xF0,
  0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0xF9, 0xFC, 0x03, 0xFC,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F,
  0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0xFE, 0x07, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF8, 0x3E, 0x1F, 0xF0, 0x04, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x02, 0x1F, 0xF8, 0x0E, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xF8, 0xFE, 0x01,
  0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFE, 0x03, 0xFE, 0x3F, 0x83, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x81,
  0xF0, 0xFF, 0xC0, 0x0C, 0x1F, 0xE0, 0x00, 0x47, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F,
  0xE0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x1F, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x1F, 0xFF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0,
  0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF9, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80,
  0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFD, 0xFF, 0xFB, 0xF0, 0x03, 0xF7, 0xFF,
  0xEF, 0xC0, 0x0F, 0xDF, 0xFF, 0xBF, 0x00, 0x3E, 0x7F, 0xFE, 0xFC, 0x01,
  0xF9, 0xFF, 0xF9, 0xF8, 0x07, 0xE7, 0xFF, 0xE7, 0xE0, 0x1F, 0x9F, 0xFF,
  0x9F, 0x80, 0xFC, 0x7F, 0xFE, 0x3E, 0x03, 0xF1, 0xFF, 0xF8, 0xFC, 0x0F,
  0xC7, 0xFF, 0xE3, 0xF0, 0x3E, 0x1F, 0xFF, 0x8F, 0xC1, 0xF8, 0x7F, 0xFE,
  0x1F, 0x87, 0xE1, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7C,
  0x1F, 0xFF, 0x87, 0xE3, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF, 0xC1, 0xFF, 0xF8,
  0x3F, 0x3F, 0x07, 0xFF, 0xE0, 0xFD, 0xF8, 0x1F, 0xFF, 0x83, 0xF7, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x7E, 0x01,
  0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFE, 0x7F, 0x03, 0xFF,
  0xF3, 0xF8, 0x1F, 0xFF, 0x8F, 0xC0, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xE1,
  0xF8, 0x3F, 0xFF, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC1, 0xFC,
  0x7F, 0xFE, 0x0F, 0xE3, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0x81, 0xFC, 0xFF,
  0xFC, 0x0F, 0xE7, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0x01, 0xFD, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xB8, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x03, 0xFE, 0xFE, 0x03, 0xFD,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC1,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xF0, 0xFE,
  0x03, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80,
  0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9,
  0xFF, 0x9F, 0xCF, 0xF0, 0x0E, 0x7F, 0x00, 0x13, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x7F, 0x9F, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xCF, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFB, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xDF, 0x00, 0xFE, 0x1F, 0xC0,
  0x3E, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF7, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0xBF, 0x03, 0xF8, 0x1F, 0xC0, 0xFD, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xEF,
  0xC0, 0xFE, 0x07, 0xF0, 0x3E, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF1, 0xF0,
  0x3F, 0x00, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x7E, 0x1F,
  0xC0, 0x3F, 0x87, 0xE3, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x1F, 0x87, 0xF0,
  0x0F, 0xE1, 0xF0, 0x7C, 0x3F, 0x00, 0x3F, 0x1F, 0x83, 0xF3, 0xF8, 0x01,
  0xF8, 0xFC, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xF0, 0x1F, 0x3F, 0x00, 0x0F, 0xDF,
  0x80, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x07, 0xDF, 0xC0, 0x03, 0xF7, 0xE0,
  0x3E, 0xFE, 0x00, 0x1F, 0xBF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x9F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xCF,
  0xF0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xE0, 0x7F, 0x82, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xDF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF,
  0xFB, 0xF7, 0xFF, 0xEF, 0xCF, 0xFF, 0x3F, 0x3F, 0xF8, 0xFC, 0x7F, 0xC3,
  0xF0, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xE0, 0x1F, 0x87, 0xF8, 0x3F, 0x3F, 0xF8, 0x7E,
  0x7F, 0xF8, 0xFD, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xF7, 0xF8,
  0x1F, 0xEF, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0xC1, 0xFE, 0xFF,
  0xC7, 0xFD, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0xE7, 0xEF, 0xFF, 0x8F, 0xCF,
  0xFE, 0x1F, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xE1, 0xC3, 0xFC, 0x04, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x02, 0x3F, 0xF1, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xF0, 0x7F, 0x03, 0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x0F, 0xFF, 0x7F,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0x81, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0x81, 0xFF,
  0x3F, 0xE3, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F,
  0x07, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFC, 0xFE,
  0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x43, 0xFE, 0x07, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x30, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F,
  0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0x81, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0x81, 0xFF,
  0x3F, 0xE7, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x7F,
  0x07, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x60, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x40, 0x00, 0xFE, 0x30, 0x01, 0xFE, 0x3F, 0x0F, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x0E, 0x03, 0xF1, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFD,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x03, 0xC0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x9F, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF,
  0x8F, 0xF0, 0x70, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC,
  0x00, 0xFD, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0x80, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x1E, 0x07, 0xC3, 0xFE, 0x07, 0xFC, 0x3E, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3,
  0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x3F, 0xFE, 0x7F, 0xDF, 0xE0, 0xFF, 0xC1, 0xFE, 0xFF, 0x03,
  0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x00, 0xFF,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xFC,
  0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0x00,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x7F,
  0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE,
  0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0x80,
  0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0x03, 0xE1, 0xFF, 0x0F, 0x8F, 0xFE, 0x3E, 0x7F, 0xFC, 0xFD, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0x80, 0xFE,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xE3, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0xFF, 0x83,
  0xE3, 0xFF, 0x87, 0xE7, 0xFF, 0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xF1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF7,
  0xFC, 0x1F, 0xEF, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0x7F, 0xFE, 0x7E,
  0x7F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF8, 0x7F, 0x83, 0xF0, 0x38, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x07, 0xFE, 0x3F,
  0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF,
  0x3F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0x3F, 0x81, 0xFF, 0x3F, 0xE7, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0x7F, 0x07, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x60, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7E,
  0xF8, 0xFE, 0xFD, 0xFE, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xF6, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xF0, 0x7B, 0xF8, 0x04, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF3, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xF3, 0xFF, 0xCF, 0xC7, 0xFE, 0x3F, 0x0F,
  0xF0, 0xFC, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFE, 0x01, 0xFD, 0xFC,
  0x03, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xEF, 0x81, 0xF8, 0x7F, 0x07, 0xDF,
  0x03, 0xF0, 0x7E, 0x0F, 0x9F, 0x0F, 0xE0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC1,
  0xFC, 0x3E, 0x7C, 0x3F, 0x83, 0xF8, 0xF8, 0xF8, 0x7E, 0x03, 0xF1, 0xF1,
  0xF0, 0xFC, 0x07, 0xE3, 0xE1, 0xF3, 0xF8, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0,
  0x1F, 0xCF, 0x87, 0xCF, 0xC0, 0x3F, 0x9F, 0x0F, 0x9F, 0x80, 0x3F, 0x7C,
  0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF0, 0x3D, 0xFC,
  0x01, 0xFB, 0xE0, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFE,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE3, 0xF8, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x7F,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 45, 15, 3, -44 },
  { 52, 20, 16, 26, 3, -44 },
  { 92, 28, 44, 30, 1, -44 },
  { 246, 23, 50, 28, 2, -46 },
  { 390, 41, 45, 45, 2, -44 },
  { 621, 30, 45, 32, 2, -44 },
  { 790, 8, 16, 14, 3, -44 },
  { 806, 14, 54, 19, 3, -44 },
  { 901, 15, 54, 19, 1, -44 },
  { 1003, 22, 23, 26, 2, -46 },
  { 1067, 24, 29, 28, 2, -36 },
  { 1154, 10, 15, 15, 2, -7 },
  { 1173, 14, 7, 18, 2, -20 },
  { 1186, 9, 10, 15, 3, -9 },
  { 1198, 22, 44, 24, 1, -44 },
  { 1319, 23, 45, 27, 2, -44 },
  { 1449, 17, 44, 27, 3, -44 },
  { 1543, 23, 44, 27, 2, -44 },
  { 1670, 23, 45, 27, 2, -44 },
  { 1800, 26, 44, 27, 1, -44 },
  { 1943, 22, 45, 27, 3, -44 },
  { 2067, 23, 45, 27, 2, -44 },
  { 2197, 23, 44, 27, 2, -44 },
  { 2324, 24, 45, 27, 2, -44 },
  { 2459, 23, 45, 27, 2, -44 },
  { 2589, 9, 34, 15, 3, -33 },
  { 2628, 10, 41, 15, 2, -33 },
  { 2680, 24, 28, 28, 2, -36 },
  { 2764, 24, 18, 28, 2, -30 },
  { 2818, 24, 28, 28, 2, -36 },
  { 2902, 20, 45, 21, 0, -44 },
  { 3015, 37, 49, 42, 3, -44 },
  { 3242, 30, 44, 30, 0, -44 },
  { 3407, 25, 44, 31, 4, -44 },
  { 3545, 24, 45, 29, 3, -44 },
  { 3680, 26, 44, 33, 4, -44 },
  { 3823, 19, 44, 26, 4, -44 },
  { 3928, 19, 44, 25, 4, -44 },
  { 4033, 27, 45, 34, 3, -44 },
  { 4185, 26, 44, 35, 4, -44 },
  { 4328, 15, 44, 18, 2, -44 },
  { 4411, 14, 56, 16, -3, -44 },
  { 4509, 26, 44, 30, 4, -44 },
  { 4652, 19, 44, 24, 4, -44 },
  { 4757, 38, 44, 46, 4, -44 },
  { 4966, 29, 44, 37, 4, -44 },
  { 5126, 29, 45, 35, 3, -44 },
  { 5290, 23, 44, 29, 4, -44 },
  { 5417, 29, 54, 35, 3, -44 },
  { 5613, 26, 44, 30, 4, -44 },
  { 5756, 21, 45, 26, 2, -44 },
  { 5875, 23, 44, 25, 1, -44 },
  { 6002, 26, 45, 34, 4, -44 },
  { 6149, 29, 44, 29, 0, -44 },
  { 6309, 45, 44, 45, 0, -44 },
  { 6557, 27, 44, 27, 0, -44 },
  { 6706, 27, 44, 27, 0, -44 },
  { 6855, 22, 44, 24, 1, -44 },
  { 6976, 13, 54, 19, 4, -44 },
  { 7064, 22, 44, 24, 1, -44 },
  { 7185, 13, 54, 19, 2, -44 },
  { 7273, 28, 26, 30, 1, -44 },
  { 7364, 26, 4, 26, 0, 5 },
  { 7377, 14, 10, 18, 2, -47 },
  { 7395, 22, 35, 27, 2, -34 },
  { 7492, 23, 47, 30, 4, -46 },
  { 7628, 20, 35, 23, 2, -34 },
  { 7716, 24, 47, 30, 2, -46 },
  { 7857, 23, 35, 27, 2, -34 },
  { 7958, 18, 47, 17, 1, -47 },
  { 8064, 24, 49, 30, 2, -34 },
  { 8211, 22, 46, 30, 4, -46 },
  { 8338, 8, 46, 14, 3, -46 },
  { 8384, 12, 61, 14, -1, -46 },
  { 8476, 24, 46, 28, 4, -46 },
  { 8614, 6, 46, 14, 4, -46 },
  { 8649, 37, 34, 44, 4, -34 },
  { 8807, 22, 34, 30, 4, -34 },
  { 8901, 24, 35, 29, 2, -34 },
  { 9006, 23, 49, 30, 4, -34 },
  { 9147, 24, 49, 30, 2, -34 },
  { 9294, 16, 34, 20, 4, -34 },
  { 9362, 18, 35, 22, 2, -34 },
  { 9441, 16, 41, 18, 1, -40 },
  { 9523, 22, 34, 30, 4, -33 },
  { 9617, 25, 33, 25, 0, -33 },
  { 9721, 39, 33, 40, 0, -33 },
  { 9882, 24, 33, 25, 0, -33 },
  { 9981, 25, 48, 25, 0, -33 },
  { 10131, 18, 33, 21, 1, -33 },
  { 10206, 18, 54, 21, 1, -44 },
  { 10328, 6, 61, 26, 10, -47 },
  { 10374, 18, 54, 21, 2, -44 },
  { 10496, 24, 9, 28, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD61PT7B_H_
