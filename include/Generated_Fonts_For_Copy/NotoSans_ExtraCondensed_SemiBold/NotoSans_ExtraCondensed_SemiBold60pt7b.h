#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0x3F,
  0x9F, 0x81, 0x80, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F,
  0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x0F,
  0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFD, 0xC3, 0xC7, 0xF3, 0x81, 0x0F, 0xC7, 0x00, 0x1F,
  0x8E, 0x00, 0x3F, 0x1C, 0x00, 0x7E, 0x38, 0x00, 0xFC, 0x70, 0x01, 0xFC,
  0xE0, 0x03, 0xFD, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xBF, 0xC0, 0x07, 0x3F, 0x80, 0x0E, 0x3F,
  0x00, 0x1C, 0x7E, 0x00, 0x38, 0x7E, 0x00, 0x71, 0xFE, 0x00, 0xE3, 0xF6,
  0x01, 0xC7, 0xEF, 0x83, 0x9F, 0xDF, 0xE7, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x3E,
  0x01, 0xF0, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x03, 0xE0,
  0x00, 0xF8, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x00, 0xF8,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x1F, 0x07, 0xE0, 0x7C, 0x3E,
  0x3F, 0x1F, 0xF0, 0x7C, 0x3E, 0x3E, 0x3F, 0xF8, 0x7C, 0x3E, 0x3E, 0x3F,
  0xFC, 0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x7E, 0x3F,
  0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0xF8, 0xF8, 0xFC, 0x3E, 0x07, 0xE0, 0xF8,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x3F,
  0x00, 0x01, 0xF0, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x3F, 0x00, 0x03,
  0xE0, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xF8,
  0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x3F, 0x00,
  0x0F, 0x80, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x1F, 0x80,
  0x7C, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x3F, 0xDF, 0xC3, 0xF8, 0x7F, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x9F, 0xC3, 0xF8, 0x3F, 0xBF, 0x87, 0xF0, 0x7F, 0x7F,
  0x0F, 0xE0, 0x7F, 0xFC, 0x1F, 0x80, 0x7F, 0xF8, 0x7F, 0x00, 0xFF, 0xE0,
  0x7F, 0x00, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF7, 0xF8, 0x1F,
  0xFF, 0x87, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x06, 0x0F, 0x81,
  0x9E, 0x3E, 0x3E, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x0F, 0xDF, 0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0x07, 0xC0, 0x1C, 0x0E, 0x00, 0x20, 0x20, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x03,
  0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F,
  0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xDF,
  0xDF, 0xEF, 0xFF, 0xE7, 0xF7, 0xE3, 0xF9, 0xE1, 0xFC, 0x60, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xE0, 0x7F, 0x8E, 0x00, 0xFE, 0x10, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xC0, 0x7F, 0x8C, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x07, 0xFB, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x14, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7F,
  0x00, 0x0F, 0xBF, 0x80, 0x0F, 0x9F, 0xC0, 0x07, 0xCF, 0xE0, 0x03, 0xC7,
  0xF0, 0x03, 0xE3, 0xF8, 0x01, 0xF1, 0xFC, 0x01, 0xF0, 0xFE, 0x00, 0xF8,
  0x7F, 0x00, 0xF8, 0x3F, 0x80, 0x7C, 0x1F, 0xC0, 0x7C, 0x0F, 0xE0, 0x3E,
  0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F,
  0x80, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xEE, 0x00, 0xFF, 0x7F, 0x7F, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0x00, 0x7E, 0x3F, 0xC1, 0xFC,
  0xFF, 0xC3, 0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xF8,
  0xFF, 0xBF, 0xE0, 0xFF, 0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xF9,
  0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xFD, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC,
  0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xCF, 0xF0, 0x7F, 0x0F, 0xF1, 0xFC, 0x0F, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xCF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x02, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0,
  0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF7, 0xF0, 0x3F, 0xEF, 0xF0, 0xFF,
  0xDF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x3F, 0xF9, 0xF8,
  0x3F, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x06, 0x1F, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x3F, 0x9F, 0xDF, 0xEF, 0xFF, 0xF9, 0xFC,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xCF, 0xEF,
  0xF7, 0xFF, 0xFC, 0xFE, 0x7E, 0x04, 0x00, 0x0E, 0x0F, 0xE3, 0xF9, 0xFE,
  0x7F, 0xDF, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x38, 0x0F, 0xF3, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x0F, 0xE0, 0x7E, 0x3E, 0x03, 0xFF, 0xC3,
  0xE7, 0xE0, 0x7F, 0xFC, 0x3E, 0x7C, 0x0F, 0xFF, 0xC3, 0xF7, 0xC1, 0xFC,
  0x7C, 0x1F, 0xFC, 0x1F, 0x87, 0xC1, 0xFF, 0x83, 0xF0, 0x7C, 0x1F, 0xF8,
  0x3E, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xC1,
  0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0x87, 0xE0,
  0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0xF8,
  0x7E, 0x0F, 0xC1, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0xF8, 0x3E, 0x0F, 0xC3,
  0xEF, 0x83, 0xE1, 0xFC, 0x3E, 0xF8, 0x3E, 0x1F, 0xC3, 0xEF, 0x83, 0xFB,
  0xFE, 0x7C, 0xF8, 0x1F, 0xFD, 0xFF, 0xCF, 0xC1, 0xFF, 0x9F, 0xF8, 0x7C,
  0x0F, 0xF0, 0xFF, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0x00, 0x07,
  0xF8, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFE, 0x07, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x07, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xF0, 0x1C, 0x1F, 0xE0, 0x04, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x02, 0x1F, 0xF0, 0x0E, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF, 0xE3, 0xF8, 0x0F, 0xF8, 0xFE, 0x01,
  0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07,
  0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF8, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0xE0,
  0xFF, 0x80, 0x04, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xF0,
  0x07, 0xF1, 0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x87, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x87, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x7E, 0x00, 0x3F, 0xFF,
  0xFB, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x7C, 0x00,
  0x7D, 0xFF, 0xFB, 0xF0, 0x07, 0xEF, 0xFF, 0xDF, 0x80, 0x3F, 0x7F, 0xFE,
  0xFC, 0x01, 0xF3, 0xFF, 0xF3, 0xF0, 0x1F, 0x9F, 0xFF, 0x9F, 0x80, 0xFC,
  0xFF, 0xFC, 0xFC, 0x07, 0xE7, 0xFF, 0xE7, 0xE0, 0x3E, 0x3F, 0xFF, 0x1F,
  0x83, 0xF1, 0xFF, 0xF8, 0xFC, 0x1F, 0x8F, 0xFF, 0xC7, 0xE0, 0xF8, 0x7F,
  0xFE, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0xFF, 0x87, 0xE3,
  0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x07, 0xFF, 0xE0, 0xF9, 0xF8, 0x3F, 0xFF,
  0x07, 0xEF, 0xC1, 0xFF, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0xC1, 0xFB, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xFF,
  0x80, 0x7E, 0x00, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0x80, 0x3F, 0xFD, 0xFC,
  0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFE, 0xFE, 0x03, 0xFF, 0xEF, 0xE0, 0x3F,
  0xFE, 0x7E, 0x03, 0xFF, 0xE7, 0xF0, 0x3F, 0xFE, 0x3F, 0x03, 0xFF, 0xE3,
  0xF8, 0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3,
  0xFF, 0xE0, 0xFC, 0x3F, 0xFE, 0x0F, 0xE3, 0xFF, 0xE0, 0x7E, 0x3F, 0xFE,
  0x07, 0xF3, 0xFF, 0xE0, 0x7F, 0x3F, 0xFE, 0x03, 0xFB, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFE, 0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x80,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x87, 0xFE, 0x7F,
  0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0x00,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F,
  0xEF, 0xE0, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0xFE,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F,
  0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC1, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF8, 0x3E, 0x7F, 0x80, 0x63, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0x7C, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0xFF, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF7, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x3E,
  0x03, 0xF0, 0x1F, 0xC0, 0xF9, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xCF, 0xC1,
  0xFC, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF3, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0x8F, 0x83, 0xF0, 0x07, 0xF0, 0xF8, 0x7C, 0x3F, 0x80,
  0x3F, 0x87, 0xC3, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF0, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x83, 0xE3, 0xF0, 0x01, 0xF8,
  0xF8, 0x1F, 0x1F, 0x80, 0x0F, 0xE7, 0xC0, 0xF9, 0xFC, 0x00, 0x7F, 0x7E,
  0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x81,
  0xFB, 0xF8, 0x00, 0x7E, 0xF8, 0x07, 0xDF, 0x80, 0x03, 0xF7, 0xC0, 0x3E,
  0xFC, 0x00, 0x1F, 0xBE, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xC7, 0xF8, 0x30, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFB, 0xFF, 0xEF, 0xDF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xF3, 0xE7, 0xFF, 0x1F, 0x1F, 0xF0, 0xF8, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xF0, 0x3F, 0x1F, 0xF0, 0x7E, 0x7F, 0xF0, 0xFD, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xCF, 0xF0, 0x3F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0xC0, 0x7F, 0x7F, 0x81, 0xFE, 0xFF, 0xC7, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xEF, 0xFF, 0x8F, 0x8F, 0xFE, 0x1F, 0x0F, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xF0, 0x31, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x9F, 0xF0, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F,
  0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x3F,
  0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x3F, 0x0F,
  0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x1F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0x7E, 0x7F, 0x01, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x8F, 0xF8,
  0x1E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFE, 0x10, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F,
  0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x3F,
  0xC7, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x0F, 0xFF, 0x7F, 0x0F,
  0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x20,
  0x01, 0xFE, 0x38, 0x03, 0xFC, 0x3F, 0x9F, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x0F, 0xCF, 0xFC, 0x3F, 0x7F, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F,
  0xFF, 0x00, 0x7F, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xE3,
  0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF7,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xBF, 0x81, 0xFE, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xFC,
  0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xF7,
  0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0x8F, 0xFC, 0x1F, 0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0x9F, 0xFF,
  0x7F, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x87, 0xFE, 0x0F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0xF8, 0x3F, 0x83, 0xE3, 0xFF, 0x0F, 0x9F, 0xFE, 0x3E, 0x7F, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0xF8, 0x3F, 0x81, 0xF0, 0xFF, 0x83, 0xE3, 0xFF, 0x87, 0xEF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xE0, 0xFE, 0x7F, 0x81,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0xFE, 0xFE,
  0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xF7, 0xFE, 0x3F, 0xCF, 0xFF,
  0xFF, 0x9F, 0xBF, 0xFE, 0x3F, 0x7F, 0xFC, 0x7E, 0x7F, 0xF0, 0xFC, 0x3F,
  0x81, 0xF8, 0x1C, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xFE, 0x3F,
  0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF,
  0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF,
  0x3F, 0x81, 0xFF, 0x3F, 0xC7, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F,
  0x0F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x40, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFD,
  0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xE7, 0xCF, 0xE0, 0x33, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE3, 0x1F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x60, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xDF,
  0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xF7,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFD, 0xF1, 0xFF, 0xE7, 0xC7, 0xFF, 0x1F,
  0x07, 0xF8, 0x7C, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0x01, 0xF9,
  0xF8, 0x07, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0xC0, 0x7E,
  0x1F, 0x81, 0xF7, 0xC0, 0xFC, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x7F, 0x07,
  0xDF, 0x07, 0xF0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC0, 0xFC, 0x1F, 0x7C, 0x1F,
  0x81, 0xFC, 0x7C, 0x7C, 0x3F, 0x03, 0xF8, 0xF8, 0xF8, 0xFE, 0x07, 0xF1,
  0xF1, 0xF1, 0xFC, 0x07, 0xE3, 0xE3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC7, 0xC7,
  0xE0, 0x1F, 0x8F, 0x87, 0x8F, 0xC0, 0x3F, 0xBE, 0x0F, 0xBF, 0x80, 0x3F,
  0x7C, 0x1F, 0x7E, 0x00, 0x7E, 0xF8, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x7D,
  0xF8, 0x01, 0xFB, 0xE0, 0xFB, 0xF0, 0x03, 0xF7, 0xC1, 0xF7, 0xE0, 0x03,
  0xEF, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF7,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x80,
  0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xEF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0x3F, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xC0, 0x1F,
  0xFC, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 44, 15, 3, -43 },
  { 51, 19, 16, 25, 3, -43 },
  { 89, 27, 43, 29, 1, -43 },
  { 235, 23, 49, 27, 2, -46 },
  { 376, 40, 44, 44, 2, -43 },
  { 596, 31, 44, 32, 1, -43 },
  { 767, 8, 16, 14, 3, -43 },
  { 783, 14, 52, 18, 3, -43 },
  { 874, 14, 52, 18, 1, -43 },
  { 965, 22, 23, 26, 2, -46 },
  { 1029, 23, 28, 27, 2, -35 },
  { 1110, 10, 15, 14, 2, -7 },
  { 1129, 14, 6, 18, 2, -19 },
  { 1140, 8, 9, 15, 3, -8 },
  { 1149, 22, 43, 24, 1, -43 },
  { 1268, 23, 44, 27, 2, -43 },
  { 1395, 17, 43, 27, 3, -43 },
  { 1487, 22, 43, 27, 2, -43 },
  { 1606, 22, 44, 27, 2, -43 },
  { 1727, 25, 43, 27, 1, -43 },
  { 1862, 21, 44, 27, 3, -43 },
  { 1978, 23, 44, 27, 2, -43 },
  { 2105, 24, 43, 27, 1, -43 },
  { 2234, 23, 44, 27, 2, -43 },
  { 2361, 23, 44, 27, 2, -43 },
  { 2488, 9, 34, 15, 3, -33 },
  { 2527, 10, 41, 15, 2, -33 },
  { 2579, 23, 28, 27, 2, -35 },
  { 2660, 23, 18, 27, 2, -30 },
  { 2712, 24, 28, 27, 2, -35 },
  { 2796, 20, 44, 21, 0, -43 },
  { 2906, 36, 48, 42, 3, -43 },
  { 3122, 30, 43, 30, 0, -43 },
  { 3284, 24, 43, 30, 4, -43 },
  { 3413, 24, 45, 28, 3, -44 },
  { 3548, 26, 43, 33, 4, -43 },
  { 3688, 19, 43, 25, 4, -43 },
  { 3791, 18, 43, 25, 4, -43 },
  { 3888, 27, 44, 33, 3, -43 },
  { 4037, 26, 43, 34, 4, -43 },
  { 4177, 14, 43, 18, 2, -43 },
  { 4253, 14, 55, 15, -3, -43 },
  { 4350, 26, 43, 29, 4, -43 },
  { 4490, 19, 43, 24, 4, -43 },
  { 4593, 37, 43, 45, 4, -43 },
  { 4792, 28, 43, 36, 4, -43 },
  { 4943, 29, 44, 35, 3, -43 },
  { 5103, 23, 43, 28, 4, -43 },
  { 5227, 29, 53, 35, 3, -43 },
  { 5420, 25, 43, 30, 4, -43 },
  { 5555, 21, 45, 25, 2, -44 },
  { 5674, 23, 43, 25, 1, -43 },
  { 5798, 25, 44, 33, 4, -43 },
  { 5936, 29, 43, 29, 0, -43 },
  { 6092, 45, 43, 44, 0, -43 },
  { 6334, 27, 43, 27, 0, -43 },
  { 6480, 27, 43, 27, 0, -43 },
  { 6626, 22, 43, 24, 1, -43 },
  { 6745, 13, 53, 19, 4, -43 },
  { 6832, 22, 43, 24, 1, -43 },
  { 6951, 13, 53, 19, 2, -43 },
  { 7038, 28, 25, 30, 1, -43 },
  { 7126, 25, 4, 25, 0, 5 },
  { 7139, 13, 10, 18, 2, -46 },
  { 7156, 21, 34, 27, 2, -33 },
  { 7246, 23, 47, 29, 4, -46 },
  { 7382, 19, 34, 23, 2, -33 },
  { 7463, 24, 47, 29, 2, -46 },
  { 7604, 22, 34, 27, 2, -33 },
  { 7698, 18, 46, 17, 1, -46 },
  { 7802, 24, 47, 29, 2, -33 },
  { 7943, 22, 46, 29, 4, -46 },
  { 8070, 8, 45, 14, 3, -45 },
  { 8115, 12, 59, 14, -1, -45 },
  { 8204, 23, 46, 27, 4, -46 },
  { 8337, 6, 46, 14, 4, -46 },
  { 8372, 36, 33, 43, 4, -33 },
  { 8521, 22, 33, 29, 4, -33 },
  { 8612, 24, 34, 28, 2, -33 },
  { 8714, 23, 47, 29, 4, -33 },
  { 8850, 24, 47, 29, 2, -33 },
  { 8991, 15, 33, 20, 4, -33 },
  { 9053, 18, 34, 22, 2, -33 },
  { 9130, 16, 41, 18, 1, -40 },
  { 9212, 22, 34, 29, 3, -33 },
  { 9306, 25, 33, 25, 0, -33 },
  { 9410, 39, 33, 39, 0, -33 },
  { 9571, 24, 33, 24, 0, -33 },
  { 9670, 25, 47, 25, 0, -33 },
  { 9817, 18, 33, 20, 1, -33 },
  { 9892, 18, 53, 21, 1, -43 },
  { 10012, 6, 60, 26, 10, -46 },
  { 10057, 18, 53, 21, 2, -43 },
  { 10177, 24, 9, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD60PT7B_H_
