#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF0, 0x00, 0x00, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBF, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE1, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x87, 0xC0, 0x0F, 0x87, 0xC0,
  0x0F, 0x87, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xF7, 0x7E, 0x7E, 0x70, 0x4F, 0xC7, 0x00, 0xFC, 0x70, 0x0F,
  0xC7, 0x00, 0xFC, 0x70, 0x07, 0xE7, 0x00, 0x7E, 0x70, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0x7E, 0x00, 0x73, 0xF0, 0x07,
  0x3F, 0x00, 0x71, 0xF0, 0x07, 0x1F, 0x00, 0x73, 0xFC, 0x07, 0x3F, 0xF0,
  0x77, 0xEF, 0xF7, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x3E, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x7C,
  0xF8, 0x07, 0xC0, 0x07, 0x8F, 0x80, 0x78, 0x00, 0xF8, 0x7C, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC1,
  0xF0, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0xF8, 0x7C, 0x7C, 0x00,
  0x0F, 0x87, 0xC7, 0xC1, 0xC0, 0xF8, 0x7C, 0x78, 0x7F, 0x0F, 0x87, 0xCF,
  0x8F, 0xF8, 0x78, 0x78, 0xF1, 0xFF, 0xC7, 0xCF, 0x9F, 0x1F, 0xFC, 0x7F,
  0xF1, 0xF3, 0xE3, 0xE3, 0xFF, 0x1E, 0x3E, 0x3E, 0x1F, 0xE3, 0xE3, 0xC3,
  0xE0, 0xFC, 0x3E, 0x3C, 0x1E, 0x00, 0x03, 0xC7, 0xC1, 0xE0, 0x00, 0x7C,
  0x7C, 0x1F, 0x00, 0x07, 0x87, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xC1,
  0xE0, 0x01, 0xF0, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC3, 0xE0, 0x03, 0xE0,
  0x3E, 0x3E, 0x00, 0x3E, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x00,
  0x7C, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFE, 0x0F, 0xC3, 0xFF, 0xE0, 0xFC, 0x3F, 0xBF, 0x0F, 0xC7, 0xF3, 0xF9,
  0xFC, 0x7E, 0x1F, 0x9F, 0x87, 0xE0, 0xFD, 0xF8, 0xFE, 0x0F, 0xFF, 0x8F,
  0xE0, 0x7F, 0xF0, 0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x01,
  0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x07, 0xF8, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xC0, 0xFF,
  0xF9, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF0, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x10, 0x7C, 0x11, 0xF3, 0xE7, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xEF, 0x80, 0x3F, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8,
  0x3F, 0x03, 0xC1, 0xE0, 0x04, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xEF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xF8, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFE, 0xFF, 0xF9, 0xFB,
  0xE3, 0xF3, 0x87, 0xE2, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xF3, 0xFC, 0x78, 0x0F, 0xE3, 0x00,
  0x7E, 0x20, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xE3, 0xFE, 0x30, 0x0F,
  0xE2, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xEE, 0x01, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x28, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xDF, 0x80, 0x0F, 0x7E, 0x00, 0x79, 0xF8, 0x01, 0xE7, 0xE0, 0x0F,
  0x9F, 0x80, 0x3C, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0x87, 0xE0, 0x3E, 0x1F,
  0x80, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x1E, 0x07, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x80, 0x1F, 0xDC, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0x04, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x0F,
  0xCF, 0xF0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFD, 0xFE,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x7E,
  0x3F, 0x83, 0xF0, 0xFE, 0x3F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFE, 0x7F, 0x0F, 0xE1, 0xFC, 0x7E, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x04, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFB, 0xFC, 0x7E, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0xBF, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xF0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x08, 0x1F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0x9F, 0xE3,
  0x01, 0xFC, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x3C,
  0x07, 0xC7, 0xC0, 0x7F, 0xE1, 0xE3, 0xE0, 0xFF, 0xF0, 0xF1, 0xE0, 0xFF,
  0xF8, 0x7D, 0xF0, 0x7C, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E,
  0x1F, 0x07, 0xBC, 0x1E, 0x0F, 0x83, 0xDE, 0x1F, 0x07, 0xC1, 0xFF, 0x0F,
  0x83, 0xE0, 0xFF, 0x87, 0xC1, 0xF0, 0x7F, 0xC3, 0xE0, 0xF8, 0x3F, 0xE1,
  0xF0, 0x7C, 0x1F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF8, 0x7C, 0x1F, 0x0F, 0xFC,
  0x3E, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xC3, 0xCF, 0x07, 0x87, 0xE1, 0xE7,
  0x83, 0xE7, 0xF9, 0xF3, 0xE1, 0xFF, 0xBF, 0xF1, 0xF0, 0x7F, 0xCF, 0xF0,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80,
  0x03, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x81, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xF7, 0xE1, 0xFE, 0x01, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x08, 0x7F, 0xC0, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0x07, 0xFC, 0x7E, 0x03, 0xFC, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80,
  0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x03, 0xFC, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFC, 0x7E, 0x1F, 0xE0,
  0x0C, 0x3F, 0xC0, 0x04, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xC0, 0x3F, 0x1F, 0xE0, 0x7F, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x04, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFC,
  0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0,
  0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0,
  0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xF8,
  0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x0F,
  0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F,
  0xBF, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFD,
  0xF0, 0x01, 0xFF, 0xFE, 0xF8, 0x01, 0xFF, 0xFF, 0x7C, 0x00, 0xFB, 0xFF,
  0xFF, 0x00, 0x7D, 0xFF, 0xEF, 0x80, 0x3E, 0xFF, 0xF7, 0xC0, 0x3E, 0x7F,
  0xFB, 0xF0, 0x1F, 0x3F, 0xFC, 0xF8, 0x0F, 0x9F, 0xFE, 0x7C, 0x0F, 0xCF,
  0xFF, 0x3E, 0x07, 0xC7, 0xFF, 0x9F, 0x83, 0xE3, 0xFF, 0xC7, 0xC1, 0xF1,
  0xFF, 0xE3, 0xE1, 0xF0, 0xFF, 0xF1, 0xF0, 0xF8, 0x7F, 0xF8, 0xFC, 0x7C,
  0x3F, 0xFC, 0x3E, 0x7E, 0x1F, 0xFE, 0x1F, 0x3E, 0x0F, 0xFF, 0x0F, 0x9F,
  0x07, 0xFF, 0x87, 0xEF, 0x83, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xF0, 0x1F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x80,
  0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0,
  0x1F, 0x80, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0xFC,
  0x07, 0xFF, 0x7E, 0x03, 0xFF, 0xBF, 0x01, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7,
  0xE0, 0x7F, 0xF9, 0xF8, 0x3F, 0xFC, 0xFC, 0x1F, 0xFE, 0x3F, 0x0F, 0xFF,
  0x1F, 0x87, 0xFF, 0x8F, 0xC3, 0xFF, 0xC3, 0xF1, 0xFF, 0xE1, 0xF8, 0xFF,
  0xF0, 0x7E, 0x7F, 0xF8, 0x3F, 0x3F, 0xFC, 0x0F, 0xDF, 0xFE, 0x07, 0xEF,
  0xFF, 0x03, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7,
  0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x1F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC,
  0x1F, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xC1, 0xFE, 0x3F,
  0x03, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC,
  0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFC, 0x7F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC0, 0xE7, 0xF0, 0x04, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7E, 0xE0, 0x1F, 0xDF, 0x87,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD,
  0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00,
  0x7E, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x3F,
  0x01, 0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF,
  0x80, 0xFC, 0x3F, 0x01, 0xEF, 0x81, 0xFC, 0x3F, 0x01, 0xEF, 0x81, 0xF8,
  0x1F, 0x83, 0xEF, 0x81, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC3,
  0xF0, 0x0F, 0x87, 0xC7, 0xC3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F,
  0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xCF, 0xC3,
  0xE7, 0xE0, 0x07, 0xCF, 0x83, 0xE7, 0xE0, 0x07, 0xCF, 0x81, 0xE7, 0xE0,
  0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF,
  0x81, 0xF7, 0xE0, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xF0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x3F,
  0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00,
  0x7C, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x07,
  0xC7, 0xE0, 0x03, 0xF3, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x01, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3C, 0x3F, 0x86, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0x87, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xEF, 0xFD, 0xFF, 0xEF, 0xBF,
  0xF9, 0xF3, 0xFF, 0x3E, 0x3F, 0x87, 0xC0, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x3C, 0x0F, 0xC7, 0xF8, 0x7E, 0x7F, 0xE3, 0xF7, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xCF, 0xF7, 0xF8, 0x3F, 0xBF, 0x80, 0xFD, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xBF, 0xC0, 0xFD, 0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xF7, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0x7F, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF,
  0x78, 0xFC, 0x04, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x01, 0x7F, 0x81, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0x83, 0xF0, 0xFF, 0x9F, 0x8F, 0xFE, 0xFC, 0x7F, 0xF7, 0xE7, 0xFF, 0xFF,
  0x3F, 0xDF, 0xFB, 0xF8, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xF3,
  0xE1, 0xFF, 0x9F, 0x07, 0xF0, 0xF8, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC,
  0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x02, 0x3F, 0x80, 0x63,
  0xFE, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0x08, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC7,
  0xC7, 0xFF, 0x3E, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x9F, 0xEF, 0xFD, 0xFC,
  0x1F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x07,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFB, 0xF0, 0xFF, 0x9F, 0x83,
  0xF8, 0xFC, 0x06, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE6, 0x00, 0x7F, 0x3F, 0x1F, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0xFC, 0xFF, 0x8F, 0xDF, 0xFC, 0xFD,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x38, 0xFB, 0xF7, 0xFF, 0xFF,
  0x9F, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x03, 0x80, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x1F, 0x81, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x9F, 0xDF, 0xFB, 0xFE, 0x7F, 0xCF, 0xF1, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFE, 0x03, 0xFB, 0xF0,
  0x1F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF0, 0x1F, 0xBF,
  0x00, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0x9F, 0x83, 0xF8, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x01, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x7F, 0xC3,
  0xFE, 0x3E, 0x7F, 0xF3, 0xFF, 0x9F, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x3F, 0xE0, 0xFF, 0xFC, 0x0F,
  0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0x80,
  0xFC, 0x07, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xE0,
  0x1F, 0x80, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC,
  0x03, 0xF0, 0x1F, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xFF,
  0x80, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0xFF,
  0xF0, 0x0F, 0xC0, 0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x1F,
  0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x7E, 0x03,
  0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0x1E, 0x0F,
  0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0x9F, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xFB,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F,
  0xCF, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3E,
  0x07, 0xC3, 0xFC, 0x3E, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xC7, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xDF, 0xE0,
  0x7E, 0xFF, 0x87, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFB, 0xFF, 0x8F,
  0xCF, 0xFC, 0x7E, 0x3F, 0x83, 0xF0, 0x20, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC7, 0xC7, 0xFF, 0x3E, 0x3F,
  0xFB, 0xF3, 0xFF, 0xFF, 0x9F, 0xEF, 0xFD, 0xFC, 0x1F, 0xEF, 0xC0, 0x7F,
  0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01,
  0xFD, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x07, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFB, 0xF0, 0xFF, 0x9F, 0x83, 0xF8, 0xFC, 0x06, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFE,
  0x1C, 0xFC, 0x04, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x02, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0x1F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x40, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x3F, 0xF9, 0xF1, 0xFF, 0x9F, 0x0F, 0xE1, 0xF0, 0x10, 0x00, 0xFE,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F,
  0x00, 0x7C, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xEF,
  0xC0, 0x7F, 0x00, 0xF9, 0xF8, 0x0F, 0xF0, 0x3F, 0x3F, 0x03, 0xFE, 0x07,
  0xE7, 0xE0, 0x7F, 0xC0, 0xFC, 0x7E, 0x0F, 0xF8, 0x1F, 0x8F, 0xC1, 0xEF,
  0x03, 0xE1, 0xF8, 0x3D, 0xE0, 0xFC, 0x3F, 0x07, 0xBE, 0x1F, 0x87, 0xE1,
  0xF7, 0xC3, 0xF0, 0x7E, 0x3E, 0x78, 0x7C, 0x0F, 0xC7, 0x8F, 0x1F, 0x81,
  0xF8, 0xF1, 0xE3, 0xF0, 0x3F, 0x1E, 0x3E, 0x7E, 0x03, 0xE7, 0xC7, 0xCF,
  0xC0, 0x7C, 0xF8, 0xF9, 0xF0, 0x0F, 0xDF, 0x0F, 0x7E, 0x01, 0xFB, 0xC1,
  0xEF, 0xC0, 0x3F, 0x78, 0x3D, 0xF8, 0x03, 0xEF, 0x07, 0xBE, 0x00, 0x7D,
  0xE0, 0xF7, 0xC0, 0x0F, 0xBC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x7F, 0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C,
  0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x2F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0x1F,
  0x80, 0x04, 0xFF, 0xC0, 0x37, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xA0, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 40, 13, 3, -39 },
  { 36, 17, 14, 23, 3, -39 },
  { 66, 24, 39, 26, 1, -39 },
  { 183, 20, 44, 24, 2, -41 },
  { 293, 36, 39, 39, 2, -39 },
  { 469, 28, 40, 28, 1, -39 },
  { 609, 6, 14, 12, 3, -39 },
  { 620, 12, 48, 17, 3, -39 },
  { 692, 13, 48, 17, 1, -39 },
  { 770, 21, 20, 23, 1, -41 },
  { 823, 21, 26, 24, 2, -32 },
  { 892, 8, 13, 13, 2, -6 },
  { 905, 12, 5, 16, 2, -17 },
  { 913, 7, 9, 13, 3, -8 },
  { 921, 20, 39, 21, 1, -39 },
  { 1019, 20, 40, 24, 2, -39 },
  { 1119, 15, 39, 24, 3, -39 },
  { 1193, 20, 39, 24, 2, -39 },
  { 1291, 20, 40, 24, 2, -39 },
  { 1391, 22, 39, 24, 1, -39 },
  { 1499, 19, 40, 24, 3, -39 },
  { 1594, 20, 40, 24, 2, -39 },
  { 1694, 22, 39, 24, 1, -39 },
  { 1802, 21, 40, 24, 2, -39 },
  { 1907, 20, 40, 24, 2, -39 },
  { 2007, 7, 31, 13, 3, -30 },
  { 2035, 9, 37, 13, 2, -30 },
  { 2077, 22, 25, 24, 1, -32 },
  { 2146, 21, 16, 24, 2, -27 },
  { 2188, 21, 25, 24, 2, -32 },
  { 2254, 18, 40, 19, 0, -39 },
  { 2344, 33, 43, 38, 2, -39 },
  { 2522, 27, 39, 27, 0, -39 },
  { 2654, 21, 39, 27, 4, -39 },
  { 2757, 22, 40, 25, 2, -39 },
  { 2867, 23, 39, 29, 4, -39 },
  { 2980, 16, 39, 23, 4, -39 },
  { 3058, 16, 39, 22, 4, -39 },
  { 3136, 24, 40, 30, 3, -39 },
  { 3256, 23, 39, 31, 4, -39 },
  { 3369, 13, 39, 16, 2, -39 },
  { 3433, 13, 50, 14, -3, -39 },
  { 3515, 23, 39, 26, 4, -39 },
  { 3628, 16, 39, 21, 4, -39 },
  { 3706, 33, 39, 41, 4, -39 },
  { 3867, 25, 39, 33, 4, -39 },
  { 3989, 27, 40, 31, 2, -39 },
  { 4124, 20, 39, 25, 4, -39 },
  { 4222, 27, 48, 31, 2, -39 },
  { 4384, 22, 39, 27, 4, -39 },
  { 4492, 19, 40, 23, 2, -39 },
  { 4587, 20, 39, 22, 1, -39 },
  { 4685, 22, 40, 30, 4, -39 },
  { 4795, 26, 39, 26, 0, -39 },
  { 4922, 40, 39, 40, 0, -39 },
  { 5117, 24, 39, 24, 0, -39 },
  { 5234, 24, 39, 24, 0, -39 },
  { 5351, 19, 39, 21, 1, -39 },
  { 5444, 12, 48, 17, 3, -39 },
  { 5516, 20, 39, 21, 1, -39 },
  { 5614, 12, 48, 17, 1, -39 },
  { 5686, 25, 23, 27, 1, -39 },
  { 5758, 23, 3, 23, 0, 5 },
  { 5767, 12, 8, 16, 2, -41 },
  { 5779, 19, 31, 24, 2, -30 },
  { 5853, 21, 42, 26, 3, -41 },
  { 5964, 17, 31, 21, 2, -30 },
  { 6030, 21, 42, 26, 2, -41 },
  { 6141, 20, 31, 24, 2, -30 },
  { 6219, 17, 41, 15, 0, -41 },
  { 6307, 21, 43, 26, 2, -30 },
  { 6420, 20, 41, 26, 3, -41 },
  { 6523, 7, 41, 13, 3, -41 },
  { 6559, 11, 54, 13, -1, -41 },
  { 6634, 21, 41, 24, 3, -41 },
  { 6742, 6, 41, 12, 3, -41 },
  { 6773, 33, 30, 39, 3, -30 },
  { 6897, 20, 30, 26, 3, -30 },
  { 6972, 21, 31, 25, 2, -30 },
  { 7054, 21, 43, 26, 3, -30 },
  { 7167, 21, 43, 26, 2, -30 },
  { 7280, 14, 30, 18, 3, -30 },
  { 7333, 16, 31, 20, 2, -30 },
  { 7395, 14, 37, 16, 1, -36 },
  { 7460, 20, 30, 26, 3, -29 },
  { 7535, 22, 29, 22, 0, -29 },
  { 7615, 35, 29, 35, 0, -29 },
  { 7742, 21, 29, 22, 0, -29 },
  { 7819, 22, 42, 22, 0, -29 },
  { 7935, 16, 29, 18, 1, -29 },
  { 7993, 16, 48, 19, 1, -39 },
  { 8089, 5, 54, 23, 9, -41 },
  { 8123, 16, 48, 19, 2, -39 },
  { 8219, 22, 8, 24, 1, -23 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD54PT7B_H_
