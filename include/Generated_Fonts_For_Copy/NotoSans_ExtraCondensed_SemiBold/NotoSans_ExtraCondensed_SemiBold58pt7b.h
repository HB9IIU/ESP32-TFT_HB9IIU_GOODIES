#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0xDF, 0x03, 0xE7, 0xC0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F,
  0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFB,
  0x8F, 0x1F, 0x8E, 0x04, 0x7E, 0x38, 0x01, 0xF8, 0xE0, 0x07, 0xE3, 0x80,
  0x1F, 0x8E, 0x00, 0x7E, 0x38, 0x01, 0xFC, 0xE0, 0x07, 0xFB, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0E, 0xFE,
  0x00, 0x39, 0xF8, 0x00, 0xE7, 0xF0, 0x03, 0x8F, 0xC0, 0x0E, 0x3F, 0x00,
  0x38, 0xFF, 0x00, 0xE7, 0xEF, 0x03, 0x9F, 0xBF, 0x0F, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x7C, 0x00,
  0x7F, 0xFC, 0x01, 0xF0, 0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0x07, 0xC7, 0xE0,
  0x3E, 0x00, 0x3F, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0xF8, 0x7F, 0x0F, 0xC3, 0xE3, 0xE3, 0xFE, 0x1F,
  0x0F, 0x9F, 0x1F, 0xFC, 0x7C, 0x7C, 0x7C, 0x7F, 0xF9, 0xFF, 0xF1, 0xF3,
  0xF3, 0xE3, 0xFF, 0x8F, 0x8F, 0x8F, 0x87, 0xFE, 0x3E, 0x3E, 0x1F, 0x0F,
  0xF1, 0xF1, 0xF8, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x00, 0x1F, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x7C, 0x00,
  0x0F, 0x87, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0xF8,
  0xFC, 0x00, 0x7C, 0x03, 0xF3, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0x80, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x0F, 0xC1, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE1, 0xFC,
  0x3F, 0xBF, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x7E, 0x1F,
  0xC3, 0xFB, 0xF8, 0x7E, 0x07, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0x0F, 0xE0,
  0x3F, 0xFC, 0x3F, 0x80, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0x81, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFB, 0xFC,
  0x0F, 0xFF, 0xC7, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF,
  0x9F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x20, 0x7C, 0x09, 0xC3, 0xE3, 0xDF, 0xDF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0xC1, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F, 0x00, 0x60, 0x30, 0x01, 0x01, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F,
  0xCF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xBF, 0x7F, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xE0, 0xFF,
  0x0E, 0x01, 0xFC, 0x10, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xC0, 0xFF, 0x0C, 0x01, 0xFE, 0x20,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE8, 0x00,
  0x3F, 0xB0, 0x01, 0xFE, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7B, 0xF0, 0x00, 0xFB, 0xF0,
  0x00, 0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xE3, 0xF0, 0x03, 0xE3, 0xF0,
  0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x10, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF4, 0x00, 0x7F, 0xB0,
  0x07, 0xF9, 0xF0, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x87, 0x80, 0xFE, 0x7F, 0x83, 0xF3, 0xFF, 0x8F, 0xDF,
  0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xEF, 0xF0, 0x3F,
  0xBF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0x80,
  0x7F, 0x7E, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F,
  0xE1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x8F, 0xF1, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0xFF,
  0x1F, 0xC1, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0x7F, 0x07, 0xFD, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0x1F,
  0xFD, 0xF8, 0x3F, 0xE7, 0xE0, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x20, 0x7F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x08, 0x0E, 0x1F, 0x8F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC,
  0x7E, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0x07, 0xF9, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x7C, 0x1F, 0x01,
  0xFF, 0xC3, 0xE3, 0xE0, 0x7F, 0xFC, 0x3E, 0x3E, 0x07, 0xFF, 0xC3, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1E, 0x7C, 0x1F, 0x87, 0xC1, 0xF7, 0xC1, 0xF0, 0x7C,
  0x1F, 0x7C, 0x1F, 0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0x7C, 0x1F, 0x7C, 0x3E,
  0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0x7C, 0x1F, 0x78, 0x3E, 0x07, 0xC1, 0xF7,
  0x83, 0xE0, 0xFC, 0x1F, 0xF8, 0x3E, 0x0F, 0xC1, 0xFF, 0x83, 0xE0, 0xFC,
  0x1F, 0x78, 0x3E, 0x0F, 0xC1, 0xE7, 0x83, 0xE0, 0xFC, 0x3E, 0x7C, 0x3E,
  0x0F, 0xC3, 0xE7, 0xC3, 0xF1, 0xFC, 0x3E, 0x7C, 0x1F, 0x1F, 0xC7, 0xC7,
  0xC1, 0xFF, 0xDF, 0xFC, 0x7C, 0x0F, 0xF9, 0xFF, 0x87, 0xE0, 0xFF, 0x8F,
  0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xBF, 0x80,
  0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0x7F, 0x01, 0xFC, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0x83, 0xFE, 0x7F,
  0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0x0E, 0x0F,
  0xF0, 0x04, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x61, 0xFF,
  0xCF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xF8, 0x1F, 0xF1, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0xF0, 0x7F, 0xC0, 0x0C,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7,
  0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE8,
  0x7F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x7E, 0x00,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7,
  0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xFD,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFD, 0xF0, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x1F, 0x7F,
  0xFD, 0xF8, 0x01, 0xF7, 0xFF, 0xCF, 0x80, 0x3F, 0x7F, 0xFC, 0xF8, 0x03,
  0xF7, 0xFF, 0xCF, 0xC0, 0x3E, 0x7F, 0xFC, 0xFC, 0x03, 0xE7, 0xFF, 0xC7,
  0xC0, 0x7E, 0x7F, 0xFC, 0x7C, 0x07, 0xC7, 0xFF, 0xC7, 0xE0, 0x7C, 0x7F,
  0xFC, 0x7E, 0x0F, 0xC7, 0xFF, 0xC3, 0xE0, 0xFC, 0x7F, 0xFC, 0x3F, 0x0F,
  0x87, 0xFF, 0xC3, 0xF0, 0xF8, 0x7F, 0xFC, 0x3F, 0x1F, 0x87, 0xFF, 0xC1,
  0xF1, 0xF8, 0x7F, 0xFC, 0x1F, 0x9F, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0x7F,
  0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xC0, 0xFB, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFC, 0x03, 0xFF, 0xDF, 0xC0, 0x7F, 0xF9, 0xF8, 0x0F, 0xFF, 0x3F,
  0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFC, 0x7E, 0x07, 0xFF, 0x8F, 0xE0, 0xFF,
  0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0xC1, 0xF8, 0x7F, 0xF8, 0x3F,
  0x0F, 0xFF, 0x07, 0xF1, 0xFF, 0xE0, 0x7E, 0x3F, 0xFC, 0x0F, 0xE7, 0xFF,
  0x80, 0xFC, 0xFF, 0xF0, 0x1F, 0xDF, 0xFE, 0x01, 0xFB, 0xFF, 0xC0, 0x3F,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80,
  0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xF9, 0xFF, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x87, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80,
  0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE,
  0x7F, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF8, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xC7, 0xE7, 0xF0, 0x0E, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0x87, 0xE0,
  0x1F, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xEF, 0x00, 0xFE, 0x1F, 0xC0, 0x7D,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0x7F, 0x01, 0xF7, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xDF, 0x03, 0xF8,
  0x1F, 0x81, 0xF3, 0xF0, 0x7F, 0x03, 0xF8, 0x3E, 0x7E, 0x0F, 0xC0, 0x7F,
  0x07, 0xC7, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x1F, 0x0F, 0xE0, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0x03, 0xF8, 0xF8, 0x7E,
  0x3F, 0x00, 0x7F, 0x1F, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0xF8, 0xFC,
  0x00, 0xFC, 0xFC, 0x1F, 0x3F, 0x80, 0x1F, 0x9F, 0x83, 0xF7, 0xF0, 0x03,
  0xF3, 0xE0, 0x7E, 0xFC, 0x00, 0x7F, 0x7C, 0x07, 0xDF, 0x80, 0x07, 0xEF,
  0x80, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0x7E, 0x00, 0x1F, 0xFE, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF9, 0xFC, 0x00,
  0xFE, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0x87, 0xF8, 0x30, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xBF, 0xFC, 0xFC, 0xFF, 0xC7, 0xE3,
  0xFC, 0x1F, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x1F, 0xCF, 0xF8, 0x3F, 0xBF, 0xF8,
  0x7F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xF7,
  0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF8, 0x07,
  0xEF, 0xF0, 0x1F, 0xDF, 0xF0, 0x3F, 0xBF, 0xF0, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xF9, 0xFF, 0xE3, 0xF1, 0xFF, 0x87, 0xE1, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xF0, 0x21, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x08, 0xFF, 0x07, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x0F, 0xE0,
  0xFF, 0x9F, 0xC3, 0xFF, 0xBF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFE, 0x0F, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD,
  0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xCF,
  0xE0, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7E, 0x3F, 0xFE, 0xFC, 0x3F,
  0xF9, 0xF8, 0x3F, 0xC3, 0xF0, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x1F,
  0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x43, 0xFC, 0x07, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0x18, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xF8, 0xFC, 0x3F, 0xF9, 0xF8, 0xFF, 0xFB,
  0xF3, 0xFF, 0xF7, 0xE7, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0xBF, 0x80, 0xFF,
  0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x01,
  0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xDF, 0xC3, 0xFF, 0x3F, 0x83, 0xFC, 0x7F, 0x00, 0x60, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x88, 0x00, 0x7F, 0x1C, 0x03, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0x83, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFD, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83,
  0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFD, 0xFC, 0x03, 0xF7,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xCF, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0,
  0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC7,
  0xFC, 0x1F, 0xF8, 0xFC, 0xFF, 0xE3, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFC,
  0xFD, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFE,
  0x0F, 0xEF, 0xF0, 0x3F, 0xE0, 0xFE, 0xFF, 0x03, 0xFC, 0x07, 0xEF, 0xF0,
  0x3F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F,
  0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F,
  0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F,
  0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0x8F,
  0xCF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF8,
  0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFD, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0x03,
  0xF8, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFC, 0x1F, 0x81,
  0xF8, 0xFF, 0x83, 0xF3, 0xFF, 0x87, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xFD, 0xFF, 0x3F, 0xE0, 0xFF, 0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFE,
  0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0x7F, 0x80, 0x7E, 0xFF, 0x01, 0xFD, 0xFF, 0x03, 0xFB,
  0xFF, 0x0F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xDF, 0xFE, 0x3F,
  0x9F, 0xF8, 0x7F, 0x1F, 0xE0, 0xFE, 0x04, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x7E, 0x0F, 0xF8, 0xFC, 0x3F, 0xF9, 0xF8, 0xFF, 0xFB, 0xF1, 0xFF, 0xF7,
  0xE7, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0xBF, 0x80, 0xFF, 0x7F, 0x01, 0xFE,
  0xFE, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x01, 0xFE, 0xFF, 0x07,
  0xFC, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF,
  0xC3, 0xFF, 0x3F, 0x83, 0xFC, 0x7F, 0x00, 0x40, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xF8,
  0x1F, 0xFC, 0x7F, 0xFC, 0x7E, 0xFC, 0xFE, 0xFD, 0xFE, 0xFD, 0xFE, 0xFF,
  0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF7, 0xF8, 0xFB, 0xF8, 0x09, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x01,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC3, 0x1F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xE0, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFF, 0x7E, 0x03, 0xFD, 0xFC, 0x1F, 0xF7, 0xF8, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFE, 0xFC, 0xFF, 0xF3, 0xF1, 0xFF, 0xCF, 0xC3, 0xFC, 0x3F,
  0x00, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xF0, 0x0F,
  0xDF, 0x80, 0x7F, 0x80, 0x7E, 0xFC, 0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x3F,
  0xE0, 0x3F, 0xBF, 0x81, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7F, 0xE0, 0x7E, 0x3F, 0x03, 0xFF, 0x07, 0xF1, 0xFC, 0x1E, 0xF8,
  0x3F, 0x07, 0xE1, 0xF3, 0xC1, 0xF8, 0x3F, 0x0F, 0x9F, 0x0F, 0xC1, 0xF8,
  0x7C, 0xF8, 0x7E, 0x0F, 0xC3, 0xE7, 0xC7, 0xF0, 0x7F, 0x1E, 0x3E, 0x3F,
  0x01, 0xF9, 0xF0, 0xF1, 0xF8, 0x0F, 0xCF, 0x87, 0x8F, 0xC0, 0x7E, 0x7C,
  0x3E, 0x7E, 0x03, 0xF3, 0xE1, 0xF7, 0xE0, 0x0F, 0x9F, 0x0F, 0xBF, 0x00,
  0x7E, 0xF0, 0x7D, 0xF8, 0x03, 0xF7, 0x83, 0xEF, 0xC0, 0x1F, 0xFC, 0x0F,
  0x7E, 0x00, 0xFF, 0xE0, 0x7B, 0xE0, 0x03, 0xFF, 0x03, 0xDF, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x7E,
  0x03, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC,
  0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x00,
  0x1E, 0x00, 0x02, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x40, 0x0F, 0xFC, 0x80,
  0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 42, 14, 3, -41 },
  { 43, 18, 15, 24, 3, -41 },
  { 77, 26, 41, 28, 1, -41 },
  { 211, 22, 47, 26, 2, -44 },
  { 341, 38, 43, 42, 2, -42 },
  { 546, 30, 43, 31, 1, -42 },
  { 708, 7, 15, 13, 3, -41 },
  { 722, 14, 51, 18, 3, -42 },
  { 812, 14, 51, 18, 1, -42 },
  { 902, 21, 22, 25, 2, -44 },
  { 960, 22, 27, 26, 2, -34 },
  { 1035, 9, 15, 14, 2, -7 },
  { 1052, 13, 7, 17, 2, -19 },
  { 1064, 8, 9, 14, 3, -8 },
  { 1073, 21, 42, 23, 1, -42 },
  { 1184, 22, 43, 26, 2, -42 },
  { 1303, 16, 41, 26, 3, -41 },
  { 1385, 22, 42, 26, 2, -42 },
  { 1501, 22, 43, 26, 2, -42 },
  { 1620, 24, 42, 26, 1, -42 },
  { 1746, 21, 42, 26, 3, -41 },
  { 1857, 22, 43, 26, 2, -42 },
  { 1976, 23, 41, 26, 1, -41 },
  { 2094, 22, 43, 26, 2, -42 },
  { 2213, 22, 43, 26, 2, -42 },
  { 2332, 8, 33, 14, 3, -32 },
  { 2365, 9, 40, 14, 2, -32 },
  { 2410, 23, 27, 26, 2, -34 },
  { 2488, 22, 17, 26, 2, -29 },
  { 2535, 23, 27, 26, 2, -34 },
  { 2613, 19, 43, 20, 0, -42 },
  { 2716, 36, 47, 40, 2, -42 },
  { 2928, 29, 41, 29, 0, -41 },
  { 3077, 23, 41, 29, 4, -41 },
  { 3195, 23, 43, 27, 3, -42 },
  { 3319, 25, 41, 32, 4, -41 },
  { 3448, 18, 41, 25, 4, -41 },
  { 3541, 18, 41, 24, 4, -41 },
  { 3634, 26, 43, 32, 3, -42 },
  { 3774, 25, 41, 33, 4, -41 },
  { 3903, 14, 41, 18, 2, -41 },
  { 3975, 14, 53, 15, -3, -41 },
  { 4068, 25, 41, 28, 4, -41 },
  { 4197, 18, 41, 23, 4, -41 },
  { 4290, 36, 41, 44, 4, -41 },
  { 4475, 27, 41, 35, 4, -41 },
  { 4614, 28, 43, 33, 3, -42 },
  { 4765, 22, 41, 27, 4, -41 },
  { 4878, 28, 52, 33, 3, -42 },
  { 5060, 24, 41, 29, 4, -41 },
  { 5183, 20, 43, 24, 2, -42 },
  { 5291, 22, 41, 24, 1, -41 },
  { 5404, 24, 42, 32, 4, -41 },
  { 5530, 28, 41, 28, 0, -41 },
  { 5674, 43, 41, 43, 0, -41 },
  { 5895, 26, 41, 26, 0, -41 },
  { 6029, 26, 41, 26, 0, -41 },
  { 6163, 21, 41, 23, 1, -41 },
  { 6271, 13, 51, 18, 4, -42 },
  { 6354, 21, 42, 23, 1, -42 },
  { 6465, 12, 51, 18, 2, -42 },
  { 6542, 27, 24, 29, 1, -41 },
  { 6623, 24, 4, 24, 0, 5 },
  { 6635, 13, 9, 17, 2, -44 },
  { 6650, 21, 33, 26, 2, -32 },
  { 6737, 23, 45, 28, 3, -44 },
  { 6867, 19, 33, 22, 2, -32 },
  { 6946, 23, 45, 28, 2, -44 },
  { 7076, 22, 33, 26, 2, -32 },
  { 7167, 17, 44, 16, 1, -44 },
  { 7261, 23, 46, 28, 2, -32 },
  { 7394, 22, 44, 28, 3, -44 },
  { 7515, 7, 44, 13, 3, -44 },
  { 7554, 11, 58, 13, -1, -44 },
  { 7634, 22, 44, 26, 4, -44 },
  { 7755, 7, 44, 13, 3, -44 },
  { 7794, 36, 32, 42, 3, -32 },
  { 7938, 22, 32, 28, 3, -32 },
  { 8026, 23, 33, 27, 2, -32 },
  { 8121, 23, 46, 28, 3, -32 },
  { 8254, 23, 46, 28, 2, -32 },
  { 8387, 16, 32, 19, 3, -32 },
  { 8451, 17, 33, 21, 2, -32 },
  { 8522, 16, 39, 18, 1, -38 },
  { 8600, 22, 33, 28, 3, -32 },
  { 8691, 24, 32, 24, 0, -32 },
  { 8787, 37, 32, 38, 0, -32 },
  { 8935, 23, 32, 23, 0, -32 },
  { 9027, 24, 46, 24, 0, -32 },
  { 9165, 18, 32, 20, 1, -32 },
  { 9237, 17, 51, 20, 1, -42 },
  { 9346, 5, 58, 25, 10, -44 },
  { 9383, 17, 51, 20, 2, -42 },
  { 9492, 23, 9, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD58PT7B_H_
