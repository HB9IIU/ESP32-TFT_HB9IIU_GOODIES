#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xB4, 0x7D, 0xFA, 0x79, 0x3C, 0xD7, 0x3E, 0x75, 0x80, 0x6A,
  0x5A, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xFC, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x29, 0x28, 0x76, 0xD6, 0x75, 0x40, 0xE5, 0x2E, 0xE5, 0x1E, 0x2E,
  0xF2, 0xF3, 0x9E, 0x73, 0xD6, 0xE5, 0x24, 0xF5, 0x5E, 0xF7, 0x9C, 0x90,
  0x98, 0x71, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xD4, 0x40, 0x75, 0x77, 0xF8,
  0x38, 0x4E, 0xFA, 0xF7, 0xDE, 0x72, 0x46, 0xF6, 0xDE, 0xF3, 0xCE, 0xF3,
  0xC8, 0x72, 0xD6, 0xB7, 0xDA, 0xD5, 0xC0, 0xFC, 0xB7, 0x5A, 0x92, 0x4E,
  0xCE, 0xF7, 0x5A, 0x80, 0xDD, 0xBB, 0x90, 0x69, 0x99, 0x60, 0xF7, 0xC8,
  0x69, 0x99, 0x63, 0xF7, 0xDA, 0xF1, 0x1C, 0xE9, 0x24, 0xB6, 0xD6, 0xB6,
  0xB4, 0xAD, 0x6A, 0xA5, 0x00, 0xA9, 0x2A, 0xB5, 0x24, 0xE9, 0x4E, 0xEA,
  0xB0, 0x91, 0x22, 0xD5, 0x70, 0x4E, 0x80, 0xE0, 0xC0, 0xCE, 0xF0, 0x9E,
  0xDE, 0x72, 0x20, 0x2E, 0xD6, 0x57, 0x30, 0xFA, 0x80, 0x76, 0xB3, 0x80,
  0x9E, 0xDA, 0xF8, 0xFE, 0x97, 0x5A, 0xF8, 0xF5, 0x6B, 0x50, 0xF6, 0xD0,
  0x76, 0xB0, 0xF6, 0xF9, 0x00, 0x76, 0xB2, 0x40, 0xEA, 0xE7, 0xBA, 0x40,
  0xB6, 0xB0, 0xB7, 0x20, 0xAD, 0x94, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00,
  0xDB, 0x57, 0x50, 0xFE, 0x95, 0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 3, 2, 3, 0, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 5, 5, 0, -5 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 1, 2, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 3, 2, 3, 0, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 2, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 3, 5, 3, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 2, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 1, 4, 2, 0, -4 },
  { 48, 1, 5, 2, 0, -4 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 2, 5, 2, 0, -5 },
  { 57, 5, 6, 5, 0, -5 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 3, 5, 4, 0, -5 },
  { 65, 3, 5, 3, 0, -5 },
  { 67, 3, 5, 4, 0, -5 },
  { 69, 3, 5, 3, 0, -5 },
  { 71, 3, 5, 3, 0, -5 },
  { 73, 3, 5, 4, 0, -5 },
  { 75, 3, 5, 4, 0, -5 },
  { 77, 2, 5, 2, 0, -5 },
  { 79, 1, 6, 2, 0, -5 },
  { 80, 3, 5, 3, 0, -5 },
  { 82, 3, 5, 3, 0, -5 },
  { 84, 5, 5, 5, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 3, 5, 3, 0, -5 },
  { 96, 4, 6, 4, 0, -5 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 3, 5, 3, 0, -5 },
  { 105, 3, 5, 4, 0, -5 },
  { 107, 3, 5, 3, 0, -5 },
  { 109, 5, 5, 5, 0, -5 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 2, 6, 2, 0, -5 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 2, 6, 2, 0, -5 },
  { 125, 3, 3, 3, 0, -5 },
  { 127, 3, 1, 3, 0, 0 },
  { 128, 2, 1, 2, 0, -5 },
  { 129, 3, 4, 3, 0, -4 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 3, 4, 3, 0, -4 },
  { 135, 3, 5, 3, 0, -5 },
  { 137, 3, 4, 3, 0, -4 },
  { 139, 2, 5, 2, 0, -5 },
  { 141, 3, 6, 3, 0, -4 },
  { 144, 3, 5, 3, 0, -5 },
  { 146, 1, 5, 2, 0, -5 },
  { 147, 1, 7, 2, 0, -5 },
  { 148, 3, 5, 3, 0, -5 },
  { 150, 1, 5, 2, 0, -5 },
  { 151, 5, 4, 5, 0, -4 },
  { 154, 3, 4, 3, 0, -4 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 3, 6, 3, 0, -4 },
  { 161, 3, 6, 3, 0, -4 },
  { 164, 2, 4, 2, 0, -4 },
  { 165, 2, 4, 3, 0, -4 },
  { 166, 2, 5, 2, 0, -5 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 5, 4, 5, 0, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 3, 6, 3, 0, -4 },
  { 180, 2, 4, 2, 0, -4 },
  { 181, 2, 6, 2, 0, -5 },
  { 183, 1, 7, 3, 1, -5 },
  { 184, 2, 6, 2, 0, -5 },
  { 186, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD7PT7B_H_
