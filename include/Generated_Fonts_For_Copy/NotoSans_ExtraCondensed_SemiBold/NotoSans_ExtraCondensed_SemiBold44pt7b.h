#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFD, 0xF7,
  0xC0, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xDE, 0x1F, 0x78, 0x7D, 0xE1, 0xF7,
  0x87, 0xDE, 0x1F, 0x78, 0x7D, 0xE1, 0xF7, 0x87, 0x80, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x78, 0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x1E, 0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x3C, 0x78, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xF8, 0x1F,
  0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0xFD, 0x9E, 0xF9, 0x82, 0xF9, 0x80, 0xF1,
  0x80, 0xF9, 0x80, 0xF9, 0x80, 0x7D, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xBF, 0x01, 0x9F, 0x01,
  0x9F, 0x01, 0x8F, 0x01, 0x9F, 0xC1, 0x9F, 0xF1, 0xBE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF8, 0x0F, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x0F, 0x00, 0x02, 0x00, 0x7F, 0x00, 0x70, 0x03, 0xFC,
  0x03, 0xC0, 0x0F, 0xF8, 0x0F, 0x00, 0x79, 0xE0, 0x78, 0x01, 0xE3, 0xC1,
  0xE0, 0x07, 0x8F, 0x07, 0x80, 0x1C, 0x3C, 0x3C, 0x00, 0x70, 0xF0, 0xF0,
  0x03, 0xC3, 0xC3, 0x80, 0x0F, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x78, 0x00,
  0x70, 0xF1, 0xC0, 0x01, 0xE3, 0xCF, 0x1F, 0x87, 0x8F, 0x3C, 0xFF, 0x1E,
  0x79, 0xE7, 0xFC, 0x3F, 0xE7, 0x9E, 0x78, 0xFF, 0x1C, 0x71, 0xE1, 0xFC,
  0xF3, 0xC7, 0x83, 0xC3, 0xCF, 0x0E, 0x00, 0x0E, 0x3C, 0x3C, 0x00, 0x78,
  0xF0, 0xF0, 0x01, 0xE3, 0xC3, 0xC0, 0x0F, 0x0F, 0x0F, 0x00, 0x3C, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0xE0, 0x07, 0x83, 0xC7, 0x80, 0x1E, 0x07, 0x1E,
  0x00, 0x70, 0x1E, 0x78, 0x03, 0xC0, 0x7F, 0xC0, 0x0F, 0x00, 0xFF, 0x00,
  0x78, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87,
  0x80, 0x3E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0xF8, 0xFF, 0xC3, 0xE7, 0xEF, 0x8F, 0x9F, 0x3E, 0x3E, 0xFC, 0x7D,
  0xF3, 0xE0, 0xFF, 0xCF, 0x83, 0xFF, 0x3E, 0x07, 0xF8, 0xF8, 0x1F, 0xE3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xCF, 0x83, 0xFC, 0x3F, 0xFF, 0xFF, 0xDE, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8,
  0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x03, 0x8E, 0x39,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0x01, 0xF7, 0x80, 0xF3, 0xE0, 0xF8, 0xF8, 0x38, 0x78, 0x04, 0x10, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0x78, 0xF3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79, 0xFF, 0xFF, 0x7D, 0xF0, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7C, 0x7E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF1, 0xFF, 0x9F, 0xFD, 0xFB, 0xFF, 0x9F, 0x78, 0xF9, 0x87, 0xC4, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC1, 0xF8, 0xC0, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0x81, 0xF8, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xCC, 0x0F, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xEF, 0x80,
  0x7B, 0xE0, 0x1C, 0xF8, 0x0F, 0x3E, 0x03, 0x8F, 0x81, 0xE3, 0xE0, 0x70,
  0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0xF0, 0x3E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7B,
  0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x80, 0x7E, 0xE0, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF0, 0x7F, 0xE0, 0x00, 0xFC, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF1, 0xF0, 0xF3, 0xFC, 0xF7, 0xFC, 0xFF, 0xFE, 0xFE,
  0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7E, 0x3E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xF3, 0xF3,
  0xF0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07,
  0xC7, 0xC3, 0xE3, 0xF3, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xDF, 0x8F, 0xC7, 0xE7, 0xC1, 0xFB, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDF, 0x03, 0xEF, 0x83,
  0xF7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3F, 0x7F, 0x7F, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFD, 0xF0, 0x78, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x83, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x79, 0xFF, 0xFF, 0x7D, 0xF1, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xFF, 0xF7, 0xDF, 0x38,
  0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF7, 0xCF, 0x9F, 0x3E, 0x79, 0xF3, 0xE7, 0x8F,
  0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xE3,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC6, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0xFC, 0x03,
  0xE0, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0x87, 0x03, 0xFC, 0x79, 0xE0, 0xFF, 0x8F, 0x3C, 0x3F, 0xF0,
  0xE7, 0x0F, 0x1E, 0x1F, 0xE1, 0xE3, 0xC3, 0xFC, 0x78, 0x78, 0x7F, 0x8F,
  0x0F, 0x0F, 0xF1, 0xE1, 0xE1, 0xFE, 0x3C, 0x3C, 0x3F, 0xC7, 0x87, 0x87,
  0xF8, 0xF0, 0xF0, 0xFF, 0x1E, 0x1E, 0x1D, 0xE3, 0xC3, 0xC7, 0xBC, 0x78,
  0xF8, 0xF7, 0x87, 0x9B, 0xBC, 0xF0, 0xFF, 0x7F, 0x8F, 0x0F, 0xCF, 0xE1,
  0xE0, 0xF0, 0xF8, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xCF, 0x00, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x0F, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE,
  0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81,
  0xFB, 0xE0, 0x7C, 0xF8, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xF8,
  0xFF, 0xFF, 0x3E, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x87,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x43,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x08, 0xFF,
  0x0E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x87, 0xF9, 0xF0, 0x3F,
  0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x1F, 0x9F, 0x07, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x06, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3F, 0x01, 0xF3, 0xF8, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFF, 0xFE,
  0xFF, 0xBF, 0xCF, 0xF3, 0xF0, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x7E,
  0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xF3, 0xE0, 0x7C, 0x7E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7E, 0x7C, 0x07, 0xCF,
  0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x78, 0x0F, 0x7F,
  0xEF, 0x01, 0xEF, 0xFD, 0xE0, 0x3D, 0xFF, 0xBE, 0x0F, 0xBF, 0xF3, 0xC1,
  0xE7, 0xFE, 0x78, 0x3C, 0xFF, 0xCF, 0x0F, 0x9F, 0xF9, 0xF1, 0xE3, 0xFF,
  0x1E, 0x3C, 0x7F, 0xE3, 0xC7, 0x8F, 0xFC, 0x79, 0xF1, 0xFF, 0x8F, 0xBC,
  0x3F, 0xF0, 0xF7, 0x87, 0xFE, 0x1E, 0xF0, 0xFF, 0xC3, 0xFC, 0x1F, 0xF8,
  0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F, 0x81,
  0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xF8, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xDE,
  0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xC1, 0xFF, 0x9F, 0x0F, 0xFC, 0xF8, 0x7F,
  0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC3, 0xE7, 0xFE, 0x1F,
  0x3F, 0xF0, 0x7D, 0xFF, 0x83, 0xEF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83,
  0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3F,
  0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xFB, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x7F, 0x1F,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xF8, 0x7F, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E,
  0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E,
  0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0x9F,
  0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE,
  0x03, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFE,
  0x3F, 0xFE, 0x7E, 0x0E, 0x7C, 0x02, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x3E, 0xFC, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01,
  0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x7C,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x81, 0xF1, 0xF0,
  0x1F, 0xC0, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x3C, 0x0F, 0xF0, 0x3E, 0x1F,
  0x07, 0xB8, 0x1F, 0x0F, 0x83, 0xDE, 0x1F, 0x07, 0xC1, 0xEF, 0x0F, 0x83,
  0xE1, 0xE7, 0x87, 0xC0, 0xF0, 0xF3, 0xC3, 0xE0, 0x7C, 0x79, 0xE1, 0xF0,
  0x3E, 0x3C, 0xF9, 0xF0, 0x1F, 0x1E, 0x3C, 0xF8, 0x0F, 0x9F, 0x1E, 0x7C,
  0x03, 0xCF, 0x0F, 0x3E, 0x01, 0xE7, 0x87, 0x9F, 0x00, 0xFB, 0xC3, 0xCF,
  0x80, 0x7D, 0xE0, 0xFF, 0x80, 0x3E, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x7C, 0x07, 0xE7, 0xC0, 0xF8, 0xF8,
  0x3F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3F, 0x1F, 0x03,
  0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0xFC, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xDF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF8,
  0x3E, 0x07, 0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01,
  0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFE, 0x18, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7C, 0x3F, 0x7F,
  0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x1F, 0x8F, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0xFC, 0x3C, 0xFF, 0x1E, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1,
  0xFB, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x83, 0xEF, 0xC3, 0xF7, 0xFF, 0xF3, 0xDF,
  0xF9, 0xEF, 0xF8, 0xF1, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0x8F,
  0xFE, 0x7E, 0x19, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x82, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xC7, 0xCF, 0xFB, 0xE7,
  0xFD, 0xF7, 0xFF, 0xFB, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xF7,
  0xC3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xDF, 0x1F, 0xC7, 0x80, 0x0F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x06, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x00,
  0xE0, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0xC7, 0x8F, 0xF7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xEF, 0x87, 0xF7, 0xFF, 0xF9, 0xFF, 0x7C, 0xFF, 0xBE,
  0x3F, 0x9F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF3, 0x01, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xF8, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF1, 0xF8, 0xF7, 0xFC,
  0xF7, 0xFE, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x79, 0xFF, 0xFF, 0x7C,
  0xE0, 0x00, 0x01, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x0F, 0x07, 0xC7,
  0xE3, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0xF8, 0x7D, 0xFE, 0xFF, 0x7F, 0x3F, 0x04, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0xFE, 0x0F, 0xDF, 0x07,
  0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7D,
  0xF0, 0x3D, 0xF0, 0x1E, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFB, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xF8, 0x7F, 0x3D, 0xFF,
  0x3F, 0xEF, 0x7F, 0xDF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFE,
  0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07,
  0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8, 0x1E,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8,
  0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78,
  0x1F, 0xF1, 0xF8, 0xF7, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x3E, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xF3,
  0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xE0, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF,
  0xCF, 0xC3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x07, 0xDF, 0x87, 0xEF, 0xFF,
  0xE7, 0xBF, 0xF3, 0xCF, 0xF1, 0xF3, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0x8F, 0xF7, 0xCF,
  0xFB, 0xEF, 0xFF, 0xF7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF,
  0x87, 0xF7, 0xFF, 0xF9, 0xFF, 0x7C, 0xFF, 0xBE, 0x3F, 0x9F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xE1, 0xFE,
  0x7F, 0xDF, 0xFB, 0xFF, 0xFF, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0xFC, 0x13, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xF8, 0x3E, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xCF, 0x3F, 0x8F, 0xF8, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x03, 0xE3, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF7, 0x81, 0xF8, 0x1F, 0x7C, 0x1F,
  0xC1, 0xF7, 0xC1, 0xFC, 0x1F, 0x7C, 0x1F, 0xC1, 0xE7, 0xC1, 0xFC, 0x3E,
  0x3C, 0x3D, 0xC3, 0xE3, 0xE3, 0xDC, 0x3E, 0x3E, 0x3D, 0xE3, 0xE3, 0xE3,
  0x9E, 0x3C, 0x1E, 0x39, 0xE7, 0xC1, 0xE7, 0x8E, 0x7C, 0x1F, 0x78, 0xE7,
  0xC1, 0xF7, 0x8E, 0x78, 0x1F, 0x78, 0xF7, 0x80, 0xF7, 0x0F, 0x78, 0x0F,
  0x70, 0xFF, 0x80, 0xF7, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xBE, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x0F, 0x7C, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0xFD, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x0F, 0x3E, 0x03,
  0xCF, 0x80, 0xFB, 0xC0, 0x3E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xFC, 0x3F, 0xC1, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xFC,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7E, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x5F, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xE8, 0x00, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 31, 11, 2, -31 },
  { 25, 14, 11, 18, 2, -31 },
  { 45, 20, 31, 21, 1, -31 },
  { 123, 16, 36, 20, 2, -33 },
  { 195, 30, 32, 32, 1, -32 },
  { 315, 22, 32, 23, 1, -32 },
  { 403, 6, 11, 10, 2, -31 },
  { 412, 11, 39, 13, 2, -32 },
  { 466, 10, 39, 13, 1, -32 },
  { 515, 17, 17, 19, 1, -34 },
  { 552, 18, 21, 20, 1, -26 },
  { 600, 7, 11, 11, 1, -5 },
  { 610, 11, 5, 13, 1, -14 },
  { 617, 6, 6, 11, 2, -6 },
  { 622, 16, 32, 17, 1, -32 },
  { 686, 16, 32, 20, 2, -32 },
  { 750, 13, 31, 20, 2, -31 },
  { 801, 17, 32, 20, 1, -32 },
  { 869, 17, 32, 20, 1, -32 },
  { 937, 18, 32, 20, 1, -32 },
  { 1009, 16, 31, 20, 2, -31 },
  { 1071, 16, 32, 20, 2, -32 },
  { 1135, 17, 31, 20, 1, -31 },
  { 1201, 17, 32, 20, 1, -32 },
  { 1269, 17, 32, 20, 1, -32 },
  { 1337, 6, 24, 11, 2, -24 },
  { 1355, 7, 30, 11, 2, -24 },
  { 1382, 18, 21, 20, 1, -26 },
  { 1430, 18, 13, 20, 1, -22 },
  { 1460, 18, 21, 20, 1, -26 },
  { 1508, 15, 32, 15, 0, -32 },
  { 1568, 27, 36, 31, 2, -32 },
  { 1690, 22, 31, 22, 0, -31 },
  { 1776, 18, 31, 22, 3, -31 },
  { 1846, 18, 32, 21, 2, -32 },
  { 1918, 19, 31, 24, 3, -31 },
  { 1992, 14, 31, 19, 3, -31 },
  { 2047, 13, 31, 18, 3, -31 },
  { 2098, 20, 32, 24, 2, -32 },
  { 2178, 19, 31, 25, 3, -31 },
  { 2252, 11, 31, 13, 1, -31 },
  { 2295, 10, 40, 11, -2, -31 },
  { 2345, 19, 31, 22, 3, -31 },
  { 2419, 14, 31, 17, 3, -31 },
  { 2474, 27, 31, 33, 3, -31 },
  { 2579, 21, 31, 27, 3, -31 },
  { 2661, 21, 32, 25, 2, -32 },
  { 2745, 16, 31, 21, 3, -31 },
  { 2807, 21, 39, 25, 2, -32 },
  { 2910, 18, 31, 22, 3, -31 },
  { 2980, 16, 32, 18, 1, -32 },
  { 3044, 17, 31, 18, 1, -31 },
  { 3110, 18, 31, 24, 3, -31 },
  { 3180, 21, 31, 21, 0, -31 },
  { 3262, 33, 31, 32, 0, -31 },
  { 3390, 19, 31, 20, 0, -31 },
  { 3464, 19, 31, 19, 0, -31 },
  { 3538, 16, 31, 17, 1, -31 },
  { 3600, 10, 39, 14, 3, -32 },
  { 3649, 16, 32, 17, 1, -32 },
  { 3713, 10, 39, 14, 1, -32 },
  { 3762, 20, 18, 22, 1, -31 },
  { 3807, 19, 3, 18, 0, 4 },
  { 3815, 9, 7, 13, 2, -34 },
  { 3823, 16, 24, 20, 1, -24 },
  { 3871, 17, 33, 21, 3, -33 },
  { 3942, 14, 24, 17, 2, -24 },
  { 3984, 17, 33, 21, 2, -33 },
  { 4055, 16, 24, 19, 2, -24 },
  { 4103, 14, 34, 12, 0, -34 },
  { 4163, 17, 35, 21, 2, -24 },
  { 4238, 16, 33, 21, 3, -33 },
  { 4304, 6, 33, 10, 2, -33 },
  { 4329, 9, 44, 10, -1, -33 },
  { 4379, 17, 33, 20, 3, -33 },
  { 4450, 5, 33, 10, 3, -33 },
  { 4471, 26, 24, 32, 3, -24 },
  { 4549, 16, 24, 21, 3, -24 },
  { 4597, 17, 24, 21, 2, -24 },
  { 4648, 17, 35, 21, 3, -24 },
  { 4723, 17, 35, 21, 2, -24 },
  { 4798, 11, 24, 15, 3, -24 },
  { 4831, 14, 24, 16, 1, -24 },
  { 4873, 12, 29, 13, 1, -29 },
  { 4917, 16, 24, 21, 3, -24 },
  { 4965, 18, 24, 18, 0, -24 },
  { 5019, 28, 24, 29, 0, -24 },
  { 5103, 17, 24, 18, 0, -24 },
  { 5154, 18, 35, 18, 0, -24 },
  { 5233, 13, 24, 15, 1, -24 },
  { 5272, 13, 39, 15, 1, -32 },
  { 5336, 5, 44, 19, 7, -34 },
  { 5364, 13, 39, 15, 2, -32 },
  { 5428, 18, 7, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD44PT7B_H_
