#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xA5, 0x20, 0x14, 0x68, 0x93, 0xF7, 0xE5,
  0x8A, 0x7F, 0x68, 0xD1, 0x20, 0x27, 0xFB, 0x4E, 0x38, 0xE5, 0xBF, 0x88,
  0x40, 0xE2, 0x53, 0x29, 0x14, 0x8A, 0xD5, 0x5F, 0xEA, 0x2D, 0x12, 0x99,
  0x48, 0xE0, 0x38, 0x78, 0x6C, 0x68, 0x38, 0x31, 0x7A, 0xCE, 0xCE, 0x6E,
  0x7B, 0xFA, 0x2D, 0x6D, 0x24, 0x9B, 0x26, 0xC6, 0x62, 0x33, 0x33, 0x33,
  0x26, 0xC0, 0x31, 0x7F, 0xCE, 0x68, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00,
  0x6D, 0x60, 0xFF, 0xF0, 0x0C, 0x21, 0x86, 0x10, 0xC2, 0x08, 0x61, 0x0C,
  0x00, 0x77, 0xB7, 0x39, 0xCE, 0x73, 0x9E, 0xDC, 0x37, 0xFB, 0x33, 0x33,
  0x33, 0x30, 0x3B, 0xF4, 0xC3, 0x0C, 0x61, 0x8C, 0x61, 0xFF, 0xC0, 0x7B,
  0xF0, 0xC3, 0x08, 0xC0, 0xC3, 0x0D, 0x37, 0x80, 0x08, 0x30, 0x61, 0x42,
  0x89, 0x12, 0x7F, 0xFE, 0x10, 0x20, 0xFF, 0xF1, 0x0F, 0x7C, 0x63, 0x1D,
  0xFC, 0x3B, 0xF1, 0x0B, 0x7E, 0x71, 0x9E, 0xDC, 0xFF, 0xF0, 0xC3, 0x08,
  0x61, 0x84, 0x30, 0xC6, 0x00, 0x39, 0xF4, 0xD3, 0x78, 0xE6, 0xD3, 0xC5,
  0xB7, 0x80, 0x39, 0xE4, 0xF3, 0xCD, 0xB7, 0x43, 0x0C, 0x67, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xA0, 0x04, 0x33, 0xB8, 0x70, 0x70, 0x40, 0xFC, 0x00,
  0x3F, 0x83, 0x83, 0x83, 0x1D, 0xCC, 0x00, 0x77, 0xC6, 0x31, 0x98, 0x84,
  0x03, 0x18, 0x1C, 0x31, 0x10, 0x53, 0xBB, 0x5D, 0x26, 0x93, 0x4B, 0x9F,
  0x60, 0x10, 0x87, 0xC0, 0x18, 0x70, 0xE1, 0x62, 0xCD, 0x99, 0x3F, 0x47,
  0x8F, 0x18, 0xF3, 0xEC, 0xF3, 0xCB, 0xEC, 0xF3, 0xCF, 0x7F, 0x80, 0x3D,
  0xEC, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xA7, 0x80, 0xF3, 0xEC, 0xF3, 0xC7,
  0x1C, 0x73, 0xCF, 0xEF, 0x00, 0xFF, 0xF1, 0x8C, 0x7B, 0x18, 0xC7, 0xFE,
  0xFF, 0xF1, 0x8C, 0x7B, 0xD8, 0xC6, 0x30, 0x3D, 0xFC, 0x30, 0xC3, 0x7D,
  0xF1, 0xC5, 0x97, 0xC0, 0xC7, 0x1C, 0x71, 0xC7, 0xFC, 0x71, 0xC7, 0x1C,
  0x40, 0xF7, 0x66, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xFE, 0xCF, 0x3D, 0xB6, 0xF3, 0xCD, 0x36, 0xDB, 0x3C, 0xC0, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE1, 0xF1, 0xF8, 0xFC, 0x5F, 0x2F,
  0xB7, 0x5B, 0xA9, 0xDC, 0xEE, 0x72, 0x20, 0xC7, 0xCF, 0x9F, 0x3F, 0x7A,
  0xF7, 0xE7, 0xCF, 0x9F, 0x18, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xD9, 0xE0, 0xF3, 0xEC, 0xF3, 0xCF, 0x6F, 0x30, 0xC3, 0x0C, 0x00,
  0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xD9, 0xE0, 0x60, 0xC0,
  0xC0, 0xF3, 0xEC, 0xF3, 0xCF, 0xEF, 0x36, 0xDB, 0x3C, 0xC0, 0x77, 0xE1,
  0x0C, 0x38, 0xC3, 0x1D, 0xBC, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x00, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xB7, 0x80, 0xC7,
  0x8D, 0x1A, 0x26, 0x4D, 0x8B, 0x14, 0x28, 0x70, 0x60, 0xC4, 0x78, 0xCF,
  0x39, 0xA5, 0x24, 0xA4, 0xD5, 0x9A, 0xF3, 0xDE, 0x3B, 0x86, 0x30, 0xC6,
  0x00, 0xC4, 0xD9, 0xB1, 0xC3, 0x86, 0x0E, 0x14, 0x6C, 0x9B, 0x18, 0xC7,
  0x99, 0xB3, 0x43, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFF, 0xF1, 0x86,
  0x10, 0xC2, 0x18, 0x63, 0xFF, 0xC0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6E, 0xC1,
  0x06, 0x18, 0x20, 0xC1, 0x04, 0x18, 0x20, 0xC0, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xF0, 0x10, 0x30, 0xE1, 0x66, 0x48, 0xF0, 0x80, 0xFC, 0xCC,
  0x79, 0x30, 0xDF, 0x6F, 0x34, 0xDF, 0xC3, 0x0C, 0x3E, 0xCB, 0x3C, 0xF3,
  0xCF, 0x6B, 0x80, 0x7D, 0x88, 0x88, 0xD7, 0x08, 0x43, 0xDD, 0xC6, 0x31,
  0x8E, 0xFA, 0x76, 0xE3, 0xF8, 0x43, 0x2F, 0x7B, 0x19, 0xE6, 0x31, 0x8C,
  0x63, 0x18, 0xEE, 0xE3, 0x18, 0xC7, 0x7D, 0x08, 0xFE, 0xC0, 0xC6, 0x31,
  0x7D, 0xE7, 0x39, 0xCE, 0x72, 0xE3, 0xFF, 0xFC, 0x68, 0x36, 0xDB, 0x6D,
  0xB7, 0xA0, 0xC3, 0x0C, 0x76, 0xDB, 0xCF, 0x3C, 0xDB, 0x6C, 0xC0, 0xFF,
  0xFF, 0xFC, 0xBF, 0xEE, 0xF2, 0x79, 0x3C, 0x9E, 0x4F, 0x27, 0x93, 0xBE,
  0xF3, 0x9C, 0xE7, 0x39, 0x73, 0x68, 0xA3, 0x8A, 0x2D, 0x9C, 0xBB, 0x2C,
  0xF3, 0xCF, 0x3D, 0xBE, 0xC3, 0x0C, 0x30, 0xEE, 0xE3, 0x18, 0xC7, 0x7D,
  0x08, 0x42, 0x10, 0xBF, 0xCC, 0xCC, 0xCC, 0x7E, 0x70, 0xE3, 0x8E, 0x7E,
  0x66, 0xF6, 0x66, 0x66, 0x77, 0xCE, 0x73, 0x9C, 0xE7, 0x7D, 0xCF, 0x34,
  0x9A, 0x78, 0xE3, 0x0C, 0xCC, 0xF3, 0x25, 0xD9, 0xDE, 0x77, 0x9C, 0xC3,
  0x30, 0xCC, 0xCD, 0xE7, 0x8C, 0x31, 0xE4, 0xB3, 0xCD, 0x34, 0x9A, 0x78,
  0xE3, 0x0C, 0x30, 0xCE, 0x30, 0xF8, 0x8C, 0x66, 0x31, 0x1F, 0x19, 0xC8,
  0x42, 0x13, 0x8C, 0x21, 0x08, 0x63, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x8C,
  0x44, 0x46, 0x77, 0x44, 0x44, 0xC0, 0xFE, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 6, 1, -11 },
  { 7, 7, 11, 7, 0, -11 },
  { 17, 5, 12, 7, 1, -11 },
  { 25, 9, 11, 11, 1, -11 },
  { 38, 8, 11, 8, 0, -11 },
  { 49, 2, 4, 3, 1, -11 },
  { 50, 3, 13, 5, 1, -11 },
  { 55, 4, 13, 5, 0, -11 },
  { 62, 6, 5, 6, 0, -11 },
  { 66, 6, 7, 7, 0, -9 },
  { 72, 3, 4, 4, 0, -2 },
  { 74, 4, 2, 4, 0, -5 },
  { 75, 2, 2, 4, 1, -2 },
  { 76, 6, 11, 6, 0, -11 },
  { 85, 5, 11, 7, 1, -11 },
  { 92, 4, 11, 7, 1, -11 },
  { 98, 6, 11, 7, 0, -11 },
  { 107, 6, 11, 7, 0, -11 },
  { 116, 7, 11, 7, 0, -11 },
  { 126, 5, 11, 7, 1, -11 },
  { 133, 5, 11, 7, 1, -11 },
  { 140, 6, 11, 7, 0, -11 },
  { 149, 6, 11, 7, 0, -11 },
  { 158, 6, 11, 7, 0, -11 },
  { 167, 2, 8, 4, 1, -8 },
  { 169, 2, 10, 4, 1, -8 },
  { 172, 6, 7, 7, 0, -9 },
  { 178, 6, 4, 7, 0, -7 },
  { 181, 6, 7, 7, 0, -9 },
  { 187, 5, 11, 5, 0, -11 },
  { 194, 9, 12, 10, 1, -11 },
  { 208, 7, 11, 7, 0, -11 },
  { 218, 6, 11, 8, 1, -11 },
  { 227, 6, 11, 7, 1, -11 },
  { 236, 6, 11, 8, 1, -11 },
  { 245, 5, 11, 6, 1, -11 },
  { 252, 5, 11, 6, 1, -11 },
  { 259, 6, 11, 8, 1, -11 },
  { 268, 6, 11, 9, 1, -11 },
  { 277, 4, 11, 5, 0, -11 },
  { 283, 4, 14, 4, -1, -11 },
  { 290, 6, 11, 7, 1, -11 },
  { 299, 5, 11, 6, 1, -11 },
  { 306, 9, 11, 11, 1, -11 },
  { 319, 7, 11, 9, 1, -11 },
  { 329, 7, 11, 9, 1, -11 },
  { 339, 6, 11, 7, 1, -11 },
  { 348, 7, 14, 9, 1, -11 },
  { 361, 6, 11, 7, 1, -11 },
  { 370, 5, 11, 6, 1, -11 },
  { 377, 6, 11, 6, 0, -11 },
  { 386, 6, 11, 8, 1, -11 },
  { 395, 7, 11, 7, 0, -11 },
  { 405, 11, 11, 11, 0, -11 },
  { 421, 7, 11, 7, 0, -11 },
  { 431, 7, 11, 7, 0, -11 },
  { 441, 6, 11, 6, 0, -11 },
  { 450, 3, 13, 5, 1, -11 },
  { 455, 6, 11, 6, 0, -11 },
  { 464, 4, 13, 5, 0, -11 },
  { 471, 7, 7, 7, 0, -11 },
  { 478, 6, 1, 6, 0, 1 },
  { 479, 3, 2, 4, 1, -11 },
  { 480, 6, 8, 7, 0, -8 },
  { 486, 6, 11, 7, 1, -11 },
  { 495, 4, 8, 6, 1, -8 },
  { 499, 5, 11, 7, 1, -11 },
  { 506, 5, 8, 7, 1, -8 },
  { 511, 5, 11, 4, 0, -11 },
  { 518, 5, 12, 7, 1, -8 },
  { 526, 5, 11, 7, 1, -11 },
  { 533, 2, 11, 3, 1, -11 },
  { 536, 3, 15, 3, 0, -11 },
  { 542, 6, 11, 7, 1, -11 },
  { 551, 2, 11, 3, 1, -11 },
  { 554, 9, 8, 11, 1, -8 },
  { 563, 5, 8, 7, 1, -8 },
  { 568, 6, 8, 7, 1, -8 },
  { 574, 6, 12, 7, 1, -8 },
  { 583, 5, 12, 7, 1, -8 },
  { 591, 4, 8, 5, 1, -8 },
  { 595, 5, 8, 5, 0, -8 },
  { 600, 4, 10, 5, 0, -10 },
  { 605, 5, 8, 7, 1, -8 },
  { 610, 6, 8, 6, 0, -8 },
  { 616, 10, 8, 10, 0, -8 },
  { 626, 6, 8, 6, 0, -8 },
  { 632, 6, 12, 6, 0, -8 },
  { 641, 5, 8, 5, 0, -8 },
  { 646, 5, 13, 5, 0, -11 },
  { 655, 2, 15, 6, 2, -11 },
  { 659, 4, 13, 5, 1, -11 },
  { 666, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD15PT7B_H_
