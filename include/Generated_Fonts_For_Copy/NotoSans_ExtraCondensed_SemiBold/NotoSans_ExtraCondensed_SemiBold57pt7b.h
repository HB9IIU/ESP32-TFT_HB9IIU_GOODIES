#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFC, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xF0,
  0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xCC, 0x18,
  0xFC, 0x60, 0x07, 0xE3, 0x00, 0x3E, 0x18, 0x01, 0xF0, 0xC0, 0x0F, 0xC6,
  0x00, 0x7E, 0x30, 0x03, 0xF9, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x0D, 0xFE, 0x00, 0x67, 0xF0, 0x03, 0x1F, 0x80,
  0x18, 0xFC, 0x00, 0xC3, 0xE0, 0x06, 0x3F, 0x80, 0x31, 0xFF, 0x01, 0x8F,
  0xFF, 0x0D, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x0F, 0xFE,
  0x00, 0x7C, 0x00, 0x7E, 0xFC, 0x03, 0xE0, 0x01, 0xF1, 0xF0, 0x0F, 0x80,
  0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x7C, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE0, 0xF9, 0xF0, 0xFF, 0x07, 0xC7, 0xC7,
  0xC7, 0xFE, 0x1F, 0x1F, 0x1F, 0x3F, 0xFC, 0x7E, 0xFC, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0x8F, 0x9F, 0x0F, 0x87, 0xFC, 0x7C,
  0x7C, 0x3E, 0x0F, 0xC1, 0xF1, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC3, 0xF0,
  0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0xFC, 0x00, 0x7C, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x3E, 0x00,
  0x3E, 0x00, 0xF9, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0x0F, 0xFF, 0x83, 0xF8,
  0x7F, 0xFC, 0x1F, 0xC7, 0xF7, 0xF0, 0xFC, 0x3F, 0x9F, 0xC7, 0xE3, 0xF8,
  0xFE, 0x7F, 0x1F, 0xC3, 0xFB, 0xF8, 0xFC, 0x0F, 0xDF, 0x8F, 0xE0, 0x7F,
  0xFC, 0x7F, 0x01, 0xFF, 0xC3, 0xF8, 0x07, 0xFE, 0x1F, 0xC0, 0x3F, 0xE0,
  0x7E, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x8F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xBF, 0x81, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x1B, 0xE3, 0xC7, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF3, 0xF0, 0x3F,
  0x9F, 0xC3, 0xF8, 0x7F, 0x07, 0xC1, 0xF0, 0x1C, 0x0E, 0x00, 0x20, 0x20,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFE,
  0x7F, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x9F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF,
  0x7F, 0xBF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x10, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xDF, 0xF1, 0xF0, 0x3F, 0xC7, 0x00,
  0xFE, 0x10, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x9F, 0xF8, 0xE0, 0x1F, 0xC6, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFD,
  0xF0, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7B,
  0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xF7, 0xF0, 0x01, 0xF7, 0xF0, 0x01, 0xE7,
  0xF0, 0x03, 0xE7, 0xF0, 0x03, 0xE7, 0xF0, 0x07, 0xC7, 0xF0, 0x07, 0xC7,
  0xF0, 0x0F, 0x87, 0xF0, 0x0F, 0x87, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0x07,
  0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7C, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xCE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0xC0,
  0x1F, 0xEF, 0x87, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF1, 0xC1,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0xFC, 0xFF, 0xC3, 0xF7, 0xFF, 0x8F, 0xDF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xCF, 0xF3, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80,
  0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F,
  0x01, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF3, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03,
  0xF9, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF3, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x1F,
  0xEF, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xF7, 0xF0, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xBF,
  0x1F, 0xF9, 0xF8, 0x7F, 0x8F, 0xC0, 0x30, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x80, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x3E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x1F, 0x1F, 0x9F, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F,
  0x8F, 0xC7, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8E, 0x07, 0xF9, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0xFF,
  0x83, 0xE3, 0xE0, 0x3F, 0xFC, 0x7C, 0x7C, 0x0F, 0xFF, 0x87, 0x8F, 0x83,
  0xFF, 0xF0, 0xFB, 0xE0, 0xFC, 0x3E, 0x1F, 0x7C, 0x1F, 0x0F, 0x83, 0xEF,
  0x83, 0xE1, 0xF0, 0x7D, 0xF0, 0xF8, 0x3E, 0x0F, 0xBE, 0x1F, 0x07, 0xC1,
  0xF7, 0x83, 0xE0, 0xF8, 0x3E, 0xF0, 0x7C, 0x1F, 0x07, 0xFE, 0x0F, 0x83,
  0xE0, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0x07,
  0xC1, 0xF0, 0x7D, 0xE0, 0xF8, 0x3E, 0x0F, 0xBC, 0x1F, 0x07, 0xC1, 0xE7,
  0xC3, 0xE1, 0xF8, 0x7C, 0xF8, 0x7E, 0x3F, 0x8F, 0x9F, 0x07, 0xFF, 0xFF,
  0xE3, 0xE0, 0xFF, 0xCF, 0xFC, 0x7C, 0x0F, 0xF1, 0xFF, 0x07, 0xC0, 0xFE,
  0x1F, 0xC0, 0xF8, 0x07, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0x01, 0xFE, 0x7E, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF,
  0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x03,
  0x8F, 0xF0, 0x02, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x87, 0xFF, 0x1E, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x10,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x03,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01,
  0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC0, 0x1C, 0x3F, 0xC0,
  0x02, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0xE0, 0x0F, 0xCF, 0xF8,
  0x07, 0xE3, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE8,
  0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xE0, 0x38, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xDF, 0xFE, 0xF8, 0x00, 0xFB, 0xFF,
  0xDF, 0x00, 0x3F, 0x7F, 0xFB, 0xF0, 0x07, 0xCF, 0xFF, 0x7E, 0x00, 0xF9,
  0xFF, 0xE7, 0xC0, 0x3F, 0x3F, 0xFC, 0xF8, 0x07, 0xE7, 0xFF, 0x9F, 0x80,
  0xF9, 0xFF, 0xF1, 0xF0, 0x1F, 0x3F, 0xFE, 0x3E, 0x07, 0xE7, 0xFF, 0xC7,
  0xE0, 0xFC, 0xFF, 0xF8, 0xFC, 0x1F, 0x1F, 0xFF, 0x0F, 0x83, 0xE3, 0xFF,
  0xE1, 0xF0, 0xFC, 0x7F, 0xFC, 0x3F, 0x1F, 0x0F, 0xFF, 0x87, 0xE3, 0xE1,
  0xFF, 0xF0, 0x7C, 0xFC, 0x3F, 0xFE, 0x0F, 0x9F, 0x87, 0xFF, 0xC1, 0xFB,
  0xE0, 0xFF, 0xF8, 0x3F, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xF0, 0x3F, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0x80, 0x7F, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xDF, 0x80, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0xE7, 0xE0,
  0x7F, 0xFC, 0x7E, 0x0F, 0xFF, 0x8F, 0xC1, 0xFF, 0xF1, 0xFC, 0x3F, 0xFE,
  0x1F, 0x87, 0xFF, 0xC3, 0xF0, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0x07, 0xE3,
  0xFF, 0xE0, 0xFE, 0x7F, 0xFC, 0x0F, 0xCF, 0xFF, 0x81, 0xFC, 0xFF, 0xF0,
  0x1F, 0x9F, 0xFE, 0x03, 0xF3, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x07, 0xEF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFE,
  0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xF0, 0x7F, 0xDF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFD, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE,
  0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xFD,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC,
  0x1F, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0x83, 0xC7, 0xF0, 0x04, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFE, 0xF0, 0x0F, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0xE3, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x14, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0x9F, 0x80, 0x1F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0x8F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xFF,
  0x00, 0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x7D, 0xF0, 0x1F,
  0xC1, 0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xCF, 0x81, 0xF8, 0x1F,
  0x81, 0xF3, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0x3E, 0x0F, 0xE0, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0x0F, 0xC3, 0xE1, 0xF0,
  0xFC, 0x03, 0xF0, 0xF8, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x1F, 0x1F, 0xC0,
  0x3F, 0x9F, 0x87, 0xC7, 0xF0, 0x07, 0xE7, 0xE1, 0xF9, 0xF8, 0x01, 0xF9,
  0xF0, 0x3E, 0x7E, 0x00, 0x7E, 0x7C, 0x0F, 0x9F, 0x80, 0x1F, 0x9F, 0x03,
  0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0xFB, 0xF8, 0x00, 0xFB, 0xF0, 0x3E, 0xFC,
  0x00, 0x3F, 0xF8, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x7F, 0x9F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1,
  0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F,
  0x80, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1C, 0x0F, 0xF0, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFE, 0x3F, 0x7F,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFD, 0xF7, 0xFF, 0x9F, 0x3F, 0xF1, 0xF1, 0xFE, 0x1F, 0x03, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x1F, 0xCF, 0xFC, 0x3F, 0xBF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF9, 0xFF, 0x8F, 0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x0F, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00,
  0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0x9F,
  0xF0, 0x7F, 0x3F, 0xFF, 0xFE, 0x7E, 0xFF, 0xF8, 0xFC, 0xFF, 0xE1, 0xF9,
  0xFF, 0xC3, 0xF0, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x7F,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFC, 0x18,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x13, 0xFC, 0x1C, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x10, 0x3F, 0x07, 0xF8, 0xFC, 0x3F,
  0xF3, 0xF1, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x1F,
  0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x03, 0xFC, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFE, 0x7C, 0x3F, 0xF1, 0xF0, 0x7F, 0x87, 0xC0, 0x10, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x11, 0xFE, 0x03, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x7F, 0x84, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x0F, 0xE1, 0xF0, 0xFF, 0xC7, 0xC7, 0xFF, 0x9F, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xF8, 0x7F, 0xDF, 0xC0, 0xFF, 0x7F, 0x01, 0xFD, 0xF8,
  0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xF3, 0xF8, 0x7F,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF0, 0xFF, 0xCF, 0xC1,
  0xFE, 0x3F, 0x00, 0x40, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF2, 0x00, 0x3F, 0x8E, 0x01, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x03, 0xA0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x08,
  0x0F, 0xE3, 0xF8, 0x7F, 0x7F, 0xF3, 0xFF, 0xFF, 0x9F, 0xBF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x7F, 0xEF,
  0xFD, 0xFF, 0x3F, 0xE7, 0xF8, 0x78, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F,
  0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x10,
  0x1F, 0x87, 0xF0, 0x3F, 0xC3, 0xF3, 0xFF, 0x0F, 0xFC, 0x7E, 0xFF, 0xF3,
  0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1,
  0xFF, 0xCF, 0xF7, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0x80, 0x7F, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0x80, 0x7F, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x04, 0x07, 0xE1, 0xFC, 0x3F, 0x3F, 0xF9,
  0xFB, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0xFE, 0x7F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x01, 0xF8, 0x7F, 0x03, 0xF1, 0xFF, 0x87,
  0xE7, 0xFF, 0x0F, 0xDF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F,
  0x81, 0xFC, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0,
  0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x80, 0xFE,
  0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xF3, 0xFF, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xDF, 0xFC, 0x3F, 0x9F, 0xF8, 0x7F, 0x1F, 0xC0, 0xFE,
  0x04, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xE1, 0xF0, 0xFF, 0xC7,
  0xC7, 0xFF, 0x9F, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8, 0x7F, 0xDF,
  0xC0, 0xFF, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x01,
  0xFD, 0xFC, 0x0F, 0xF3, 0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFB, 0xF0, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x00, 0x40, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x09, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB,
  0xF8, 0x19, 0xF8, 0x04, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC2,
  0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x30, 0x00,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7F, 0x7F, 0x07, 0xFB, 0xFC, 0x7F, 0xDF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xCF, 0x8F, 0xFC, 0x7C, 0x3F, 0xC3, 0xE0, 0x10, 0x00,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0,
  0x03, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFB, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x80, 0xFC, 0xFC,
  0x07, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0xE0, 0x3F, 0x1F, 0x81, 0xFF, 0x03,
  0xF8, 0xFC, 0x0F, 0x78, 0x1F, 0x87, 0xE0, 0x7B, 0xE0, 0xFC, 0x3F, 0x07,
  0xDF, 0x07, 0xE1, 0xFC, 0x3E, 0xF8, 0x3F, 0x07, 0xE1, 0xF7, 0xC3, 0xF0,
  0x3F, 0x0F, 0x9E, 0x1F, 0x81, 0xF8, 0x78, 0xF0, 0xFC, 0x0F, 0xC7, 0xC7,
  0xC7, 0xE0, 0x3F, 0x3E, 0x3E, 0x3F, 0x01, 0xF9, 0xF1, 0xF3, 0xF0, 0x0F,
  0xCF, 0x8F, 0x9F, 0x80, 0x7E, 0x78, 0x3C, 0xFC, 0x03, 0xF3, 0xC1, 0xE7,
  0xE0, 0x0F, 0x9E, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8,
  0x03, 0xFB, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x07, 0xE0,
  0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0xBF,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F,
  0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x02, 0x7F, 0xF0, 0x0D, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0x40, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 42, 14, 3, -41 },
  { 43, 18, 15, 24, 3, -41 },
  { 77, 26, 41, 28, 1, -41 },
  { 211, 21, 46, 26, 2, -43 },
  { 332, 38, 42, 42, 2, -41 },
  { 532, 29, 42, 30, 1, -41 },
  { 685, 7, 15, 13, 3, -41 },
  { 699, 13, 50, 17, 3, -41 },
  { 781, 14, 50, 17, 1, -41 },
  { 869, 21, 21, 24, 2, -43 },
  { 925, 22, 27, 26, 2, -34 },
  { 1000, 9, 14, 14, 2, -7 },
  { 1016, 13, 6, 17, 2, -18 },
  { 1026, 8, 9, 14, 3, -8 },
  { 1035, 21, 41, 22, 1, -41 },
  { 1143, 21, 42, 26, 2, -41 },
  { 1254, 16, 41, 26, 3, -41 },
  { 1336, 21, 41, 26, 2, -41 },
  { 1444, 21, 42, 26, 2, -41 },
  { 1555, 24, 41, 26, 1, -41 },
  { 1678, 20, 42, 26, 3, -41 },
  { 1783, 22, 42, 26, 2, -41 },
  { 1899, 23, 41, 26, 1, -41 },
  { 2017, 22, 42, 26, 2, -41 },
  { 2133, 21, 42, 26, 2, -41 },
  { 2244, 8, 32, 14, 3, -31 },
  { 2276, 9, 38, 14, 2, -31 },
  { 2319, 22, 27, 26, 2, -34 },
  { 2394, 22, 16, 26, 2, -28 },
  { 2438, 22, 27, 26, 2, -34 },
  { 2513, 19, 42, 20, 0, -41 },
  { 2613, 35, 46, 40, 2, -41 },
  { 2815, 28, 41, 28, 0, -41 },
  { 2959, 23, 41, 29, 4, -41 },
  { 3077, 22, 42, 27, 3, -41 },
  { 3193, 24, 41, 31, 4, -41 },
  { 3316, 17, 41, 24, 4, -41 },
  { 3404, 17, 41, 23, 4, -41 },
  { 3492, 25, 42, 32, 3, -41 },
  { 3624, 24, 41, 32, 4, -41 },
  { 3747, 14, 41, 17, 2, -41 },
  { 3819, 14, 53, 15, -3, -41 },
  { 3912, 24, 41, 28, 4, -41 },
  { 4035, 17, 41, 22, 4, -41 },
  { 4123, 35, 41, 43, 4, -41 },
  { 4303, 27, 41, 35, 4, -41 },
  { 4442, 27, 42, 33, 3, -41 },
  { 4584, 21, 41, 27, 4, -41 },
  { 4692, 27, 51, 33, 3, -41 },
  { 4865, 24, 41, 28, 4, -41 },
  { 4988, 20, 42, 24, 2, -41 },
  { 5093, 22, 41, 23, 1, -41 },
  { 5206, 24, 42, 32, 4, -41 },
  { 5332, 27, 41, 27, 0, -41 },
  { 5471, 42, 41, 42, 0, -41 },
  { 5687, 25, 41, 25, 0, -41 },
  { 5816, 25, 41, 25, 0, -41 },
  { 5945, 20, 41, 22, 1, -41 },
  { 6048, 12, 50, 18, 4, -41 },
  { 6123, 21, 41, 22, 1, -41 },
  { 6231, 12, 50, 18, 2, -41 },
  { 6306, 26, 24, 28, 1, -41 },
  { 6384, 24, 4, 24, 0, 5 },
  { 6396, 12, 9, 17, 2, -44 },
  { 6410, 20, 33, 25, 2, -32 },
  { 6493, 23, 44, 28, 3, -43 },
  { 6620, 18, 33, 22, 2, -32 },
  { 6695, 22, 44, 28, 2, -43 },
  { 6816, 21, 32, 25, 2, -31 },
  { 6900, 17, 44, 16, 1, -44 },
  { 6994, 22, 46, 28, 2, -32 },
  { 7121, 21, 43, 28, 3, -43 },
  { 7234, 7, 43, 13, 3, -43 },
  { 7272, 11, 57, 13, -1, -43 },
  { 7351, 22, 43, 26, 4, -43 },
  { 7470, 7, 43, 13, 3, -43 },
  { 7508, 35, 32, 41, 3, -32 },
  { 7648, 21, 32, 28, 3, -32 },
  { 7732, 23, 33, 27, 2, -32 },
  { 7827, 23, 46, 28, 3, -32 },
  { 7960, 22, 46, 28, 2, -32 },
  { 8087, 15, 32, 19, 3, -32 },
  { 8147, 17, 33, 21, 2, -32 },
  { 8218, 15, 39, 17, 1, -38 },
  { 8292, 21, 32, 28, 3, -31 },
  { 8376, 24, 31, 24, 0, -31 },
  { 8469, 37, 31, 37, 0, -31 },
  { 8613, 23, 31, 23, 0, -31 },
  { 8703, 24, 45, 24, 0, -31 },
  { 8838, 17, 31, 19, 1, -31 },
  { 8904, 17, 50, 20, 1, -41 },
  { 9011, 6, 57, 24, 9, -44 },
  { 9054, 17, 50, 20, 2, -41 },
  { 9161, 23, 8, 26, 1, -24 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD57PT7B_H_
