#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0xFF, 0x80, 0xF3, 0xF9, 0xDC,
  0xEC, 0x76, 0x3B, 0x1D, 0x8E, 0x1C, 0xC1, 0xCC, 0x18, 0xC1, 0x9C, 0x19,
  0xCF, 0xFF, 0xFF, 0xF1, 0x98, 0x39, 0x83, 0x98, 0x31, 0x8F, 0xFE, 0xFF,
  0xE3, 0x30, 0x33, 0x03, 0x30, 0x73, 0x06, 0x30, 0x67, 0x00, 0x04, 0x01,
  0x00, 0x40, 0xFF, 0x7F, 0xFD, 0x2E, 0x43, 0x90, 0xE4, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0x81, 0x70, 0x5C, 0x17, 0x85, 0xFF, 0xEF, 0xF0, 0x70, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x1F, 0x06, 0x07, 0xC1, 0x83, 0xB8, 0xE0,
  0xC6, 0x30, 0x31, 0x9C, 0x0C, 0x66, 0x03, 0x19, 0x80, 0xC6, 0xE7, 0x3B,
  0xB3, 0xE7, 0xCD, 0xD9, 0xF7, 0x67, 0x11, 0x99, 0xC0, 0xE6, 0x70, 0x31,
  0x9C, 0x0C, 0x67, 0x07, 0x19, 0xC1, 0x86, 0x60, 0x60, 0xF8, 0x38, 0x3C,
  0x04, 0x01, 0xF8, 0x0F, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x07,
  0xE0, 0x3F, 0x00, 0xF0, 0x1F, 0x9E, 0xFC, 0xEE, 0x77, 0x73, 0xFB, 0x8F,
  0xDC, 0x3C, 0xE1, 0xE7, 0xFF, 0x1F, 0xFC, 0x7C, 0xF0, 0xFF, 0x76, 0x66,
  0x60, 0x0E, 0x38, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x80, 0xE1, 0x87,
  0x0C, 0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE3,
  0x9C, 0x71, 0x8E, 0x00, 0x1C, 0x07, 0x00, 0xC3, 0x32, 0xFF, 0xFF, 0xF1,
  0xE0, 0xFC, 0x77, 0x9C, 0xC2, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x77,
  0x7E, 0xEE, 0xC0, 0xFF, 0xFF, 0xC0, 0x67, 0xF7, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x0C, 0x0F, 0xC7, 0xF9,
  0xCE, 0x73, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0, 0xFC, 0x07, 0x0F, 0x1F,
  0x3F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0C, 0x1F, 0xCF, 0xFB, 0x8E, 0x43, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xE0,
  0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x08, 0x1F, 0xCF, 0xF9, 0x8E, 0x03, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x0F, 0x83, 0xF0, 0x3E, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x83, 0xFB, 0xEF, 0xFB, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x39, 0xC3, 0x1C, 0x71, 0xC6, 0x1C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F,
  0x9F, 0xE7, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0xFC, 0xFF, 0x9F, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x0F, 0xFF, 0xBF, 0xC7, 0xE0, 0x03,
  0x07, 0xE3, 0xF8, 0xF0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEF,
  0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xE3, 0xF8, 0x7C,
  0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x80,
  0x04, 0x0F, 0xC7, 0xFB, 0xCF, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x8F,
  0xC3, 0xF1, 0xFE, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xF8,
  0xFC, 0x08, 0x0F, 0xC7, 0xFB, 0xCE, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xFF, 0xFD, 0xFF, 0x3D, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x97, 0xC7,
  0xF1, 0xF0, 0xDF, 0xF0, 0x00, 0x00, 0x6F, 0xF8, 0x67, 0x77, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x76, 0xEE, 0xC0, 0x00, 0x40, 0x30, 0x3C, 0x3E, 0x3E,
  0x3E, 0x0E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3C, 0x03, 0x00, 0x40, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x1C, 0x1F, 0x1F, 0x1F, 0x0F, 0x03, 0x00, 0x80,
  0x00, 0x08, 0x3F, 0xBF, 0xCC, 0xF0, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x07,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x1E, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x80, 0x63, 0x80,
  0x39, 0x8F, 0xCC, 0xC7, 0xE6, 0xE7, 0x33, 0xF3, 0x19, 0xF1, 0x8C, 0xF8,
  0xCE, 0x7C, 0x67, 0x36, 0x33, 0x9B, 0x99, 0xCD, 0xCF, 0xBC, 0x63, 0x9C,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x81, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x9C,
  0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0x7F, 0xE3, 0xFF, 0x3F, 0xF9, 0xC1, 0xCE,
  0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x0E, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE,
  0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0E, 0xFF, 0xDF, 0xF3, 0xFC, 0x00, 0x03, 0x01, 0xFC,
  0x7F, 0x9E, 0x27, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0xF8, 0x7F, 0x07,
  0xE0, 0xFF, 0x1F, 0xF3, 0xBF, 0x70, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x1E, 0xFF,
  0xDF, 0xF3, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xE3,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF0, 0x77, 0x07, 0x70, 0x77, 0x07, 0x78, 0x73, 0xFF, 0x1F, 0xF0, 0xFF,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0x80, 0xFF, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x7B, 0xFF, 0xC0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0xFF, 0xBE,
  0x40, 0xE1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x79, 0xCE, 0x3B, 0x87, 0x70,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7B, 0x8E, 0x71, 0xC7, 0x38, 0xE7, 0x1E, 0xE1,
  0xDC, 0x3F, 0x83, 0x80, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xEC, 0x37, 0xEE, 0x37, 0xEE, 0x77, 0xE6, 0x77, 0xE6, 0x67, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE3, 0xE7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1,
  0x87, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xB8,
  0xFD, 0xC7, 0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF1, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1E, 0x03, 0x00, 0xFE, 0x0F,
  0xF8, 0x79, 0xE7, 0x87, 0x38, 0x3D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F, 0x78, 0x71,
  0xFF, 0x87, 0xF8, 0x1F, 0x80, 0xFF, 0x3F, 0xEE, 0xFB, 0x8F, 0xE1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xE3, 0xBF, 0xEF, 0xF3, 0xF8, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xFE, 0x0F, 0xF8, 0x79, 0xE7,
  0x87, 0x38, 0x3D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F, 0x78, 0x71, 0xFF, 0x87, 0xF8,
  0x1F, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0xFF, 0x1F,
  0xF3, 0xBE, 0x71, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1E, 0xE7, 0x9F, 0xF3,
  0xF8, 0x73, 0x8E, 0x71, 0xCF, 0x38, 0xE7, 0x1E, 0xE1, 0xDC, 0x3B, 0x87,
  0x80, 0x08, 0x1F, 0xDF, 0xFF, 0x7E, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x3E,
  0x0F, 0xC1, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x83, 0xFF, 0xFF, 0xDF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x38, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x06, 0x70,
  0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x36, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xC0, 0xE0, 0xE0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0xE7, 0x0F, 0x0E, 0x70,
  0xF0, 0xE7, 0x1F, 0x0E, 0x71, 0xF8, 0xE7, 0x1F, 0x9E, 0x39, 0x99, 0xC3,
  0x99, 0x9C, 0x3B, 0x99, 0xC3, 0xB9, 0xDC, 0x3B, 0x9F, 0xC1, 0xB1, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0E, 0x0F,
  0x00, 0x70, 0xF7, 0x0E, 0x39, 0xE3, 0x9C, 0x39, 0xC1, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xDC, 0x39, 0xC3,
  0x9E, 0x70, 0xE7, 0x0E, 0xF0, 0xF0, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x9E,
  0x39, 0xC3, 0x9C, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F,
  0xDF, 0xF0, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x1C, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x0E,
  0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1B, 0x83, 0x98, 0x31, 0xC7, 0x1C, 0x60,
  0xEE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3, 0x86, 0x0C, 0x1E,
  0x3F, 0xDF, 0xE8, 0x70, 0x38, 0x1C, 0xFE, 0xFF, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7F, 0xED, 0xF6, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0xE3, 0xFE, 0xFF, 0xB8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xFF, 0x3B, 0x7E, 0xCF, 0x00, 0x1F, 0x1F, 0xDF, 0xCE, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x93, 0xF8, 0xFC,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0x3B, 0xF7, 0x7F,
  0xEE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE,
  0x3D, 0xEF, 0xBF, 0x73, 0xEE, 0x1E, 0x0F, 0xC7, 0xF9, 0xC7, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x8F, 0xE1, 0xF8,
  0x0E, 0x1F, 0x3F, 0x38, 0x38, 0x38, 0x3E, 0xFE, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0xE7, 0xDD,
  0xFF, 0xB8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF8, 0xF7, 0xBE, 0xFD, 0xCF, 0x78, 0x0F, 0x01, 0xC0, 0x39, 0x0F, 0x3F,
  0xC7, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xE3, 0xFE,
  0xFF, 0xB8, 0xEE, 0x3B, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xC0, 0x7F, 0x70, 0x07, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x1C, 0xF1, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0xFB, 0xE0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x1F, 0x8E, 0xE7, 0xB9, 0xCE,
  0xE3, 0xB8, 0xFC, 0x3F, 0x8F, 0xE3, 0x9C, 0xE7, 0x39, 0xEE, 0x3B, 0x8F,
  0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xCE, 0x1C,
  0xDF, 0xFE, 0xFF, 0xFF, 0xE3, 0xCF, 0xE3, 0xC7, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE3, 0x87, 0xCF, 0x37, 0xEF, 0xFB, 0x8E, 0xE3, 0xB8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3C, 0x1E,
  0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x1D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0x38, 0xE7, 0xBC, 0x7F, 0x07, 0xC0, 0xCF, 0x37, 0xEF, 0xFB,
  0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xF3,
  0xBF, 0xEE, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0xE7, 0xDD, 0xFF, 0xB8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF8, 0xF7, 0xBE, 0xFD, 0xCF, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0xCF, 0xBF, 0x77, 0x8E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x3E, 0x7F, 0xFE, 0xE2, 0xE0, 0xF0,
  0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x87, 0xEF, 0xFE, 0xFC, 0x18, 0x38, 0x38,
  0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3D, 0x3F, 0x1F, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x7F, 0xED, 0xF6, 0xE0, 0xFC, 0x1D, 0xC3,
  0xB8, 0xE7, 0x1C, 0xE3, 0x8E, 0x71, 0xDC, 0x3B, 0x83, 0x70, 0x6C, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0x80, 0xE1, 0xE3, 0xF0, 0xF1, 0xDC, 0x78, 0xEE,
  0x7C, 0x77, 0x3E, 0x3B, 0x9B, 0x38, 0xCD, 0xDC, 0x76, 0x6E, 0x3B, 0x37,
  0x1F, 0x9B, 0x0F, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x78,
  0x70, 0xF1, 0xEE, 0x39, 0xCF, 0x1D, 0xC3, 0xB8, 0x3E, 0x07, 0xC0, 0x70,
  0x1F, 0x03, 0xE0, 0xEE, 0x1D, 0xC7, 0x3C, 0xE3, 0xBC, 0x78, 0xE0, 0xFE,
  0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0x63, 0x8E, 0x71, 0xDC, 0x3B, 0x83, 0x70,
  0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x3E, 0x07, 0x80, 0xFE, 0xFE, 0xFE, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38,
  0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x3C, 0xF1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x73, 0xE7, 0x0F, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xC3, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C,
  0x1F, 0x07, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8,
  0xF0, 0x20, 0x3F, 0x8F, 0xFF, 0xC7, 0xE8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 9, 7, 11, 1, -19 },
  { 17, 12, 19, 13, 1, -19 },
  { 46, 10, 23, 12, 1, -21 },
  { 75, 18, 20, 20, 1, -20 },
  { 120, 13, 20, 14, 1, -20 },
  { 153, 4, 7, 6, 1, -19 },
  { 157, 7, 23, 8, 1, -19 },
  { 178, 6, 23, 8, 1, -19 },
  { 196, 10, 11, 12, 1, -21 },
  { 210, 10, 13, 12, 1, -16 },
  { 227, 4, 7, 6, 1, -3 },
  { 231, 6, 3, 8, 1, -9 },
  { 234, 4, 4, 7, 1, -4 },
  { 236, 10, 19, 11, 0, -19 },
  { 260, 10, 20, 12, 1, -20 },
  { 285, 8, 19, 12, 1, -19 },
  { 304, 10, 20, 12, 1, -20 },
  { 329, 10, 20, 12, 1, -20 },
  { 354, 12, 19, 12, 0, -19 },
  { 383, 10, 19, 12, 1, -19 },
  { 407, 10, 20, 12, 1, -20 },
  { 432, 10, 19, 12, 1, -19 },
  { 456, 10, 20, 12, 1, -20 },
  { 481, 10, 20, 12, 1, -20 },
  { 506, 3, 15, 7, 2, -15 },
  { 512, 4, 19, 7, 1, -15 },
  { 522, 10, 13, 12, 1, -16 },
  { 539, 10, 7, 12, 1, -13 },
  { 548, 10, 13, 12, 1, -16 },
  { 565, 9, 20, 9, 0, -20 },
  { 588, 17, 22, 19, 1, -20 },
  { 635, 13, 19, 13, 0, -19 },
  { 666, 11, 19, 14, 2, -19 },
  { 693, 11, 20, 13, 1, -20 },
  { 721, 11, 19, 15, 2, -19 },
  { 748, 8, 19, 11, 2, -19 },
  { 767, 8, 19, 11, 2, -19 },
  { 786, 12, 20, 15, 1, -20 },
  { 816, 11, 19, 15, 2, -19 },
  { 843, 6, 19, 8, 1, -19 },
  { 858, 6, 25, 7, -1, -19 },
  { 877, 11, 19, 13, 2, -19 },
  { 904, 8, 19, 11, 2, -19 },
  { 923, 16, 19, 20, 2, -19 },
  { 961, 13, 19, 16, 2, -19 },
  { 992, 13, 20, 16, 1, -20 },
  { 1025, 10, 19, 13, 2, -19 },
  { 1049, 13, 25, 16, 1, -20 },
  { 1090, 11, 19, 13, 2, -19 },
  { 1117, 9, 20, 11, 1, -20 },
  { 1140, 11, 19, 11, 0, -19 },
  { 1167, 11, 19, 15, 2, -19 },
  { 1194, 13, 19, 13, 0, -19 },
  { 1225, 20, 19, 20, 0, -19 },
  { 1273, 12, 19, 12, 0, -19 },
  { 1302, 12, 19, 12, 0, -19 },
  { 1331, 10, 19, 11, 0, -19 },
  { 1355, 6, 23, 8, 2, -19 },
  { 1373, 10, 19, 11, 0, -19 },
  { 1397, 6, 23, 8, 1, -19 },
  { 1415, 12, 11, 13, 1, -19 },
  { 1432, 11, 2, 11, 0, 2 },
  { 1435, 6, 5, 8, 1, -21 },
  { 1439, 9, 15, 12, 1, -15 },
  { 1456, 10, 21, 13, 2, -21 },
  { 1483, 9, 15, 10, 1, -15 },
  { 1500, 11, 21, 13, 1, -21 },
  { 1529, 10, 15, 12, 1, -15 },
  { 1548, 8, 21, 8, 0, -21 },
  { 1569, 11, 21, 13, 1, -15 },
  { 1598, 10, 21, 13, 2, -21 },
  { 1625, 4, 20, 6, 1, -20 },
  { 1635, 6, 26, 6, -1, -20 },
  { 1655, 10, 21, 12, 2, -21 },
  { 1682, 3, 21, 6, 2, -21 },
  { 1690, 16, 15, 20, 2, -15 },
  { 1720, 10, 15, 13, 2, -15 },
  { 1739, 11, 15, 13, 1, -15 },
  { 1760, 10, 21, 13, 2, -15 },
  { 1787, 11, 21, 13, 1, -15 },
  { 1816, 7, 15, 9, 2, -15 },
  { 1830, 8, 15, 10, 1, -15 },
  { 1845, 8, 18, 8, 0, -18 },
  { 1863, 9, 15, 13, 2, -15 },
  { 1880, 11, 15, 11, 0, -15 },
  { 1901, 17, 15, 18, 0, -15 },
  { 1933, 11, 15, 11, 0, -15 },
  { 1954, 11, 21, 11, 0, -15 },
  { 1983, 8, 15, 9, 1, -15 },
  { 1998, 7, 23, 10, 1, -19 },
  { 2019, 3, 27, 12, 4, -21 },
  { 2030, 8, 23, 10, 1, -19 },
  { 2053, 11, 5, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD27PT7B_H_
