#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x6C, 0x07, 0xF8, 0xEF, 0xDF, 0xBE, 0x7C, 0xC0,
  0x09, 0x86, 0x41, 0x90, 0x6C, 0x7F, 0xDF, 0xF1, 0x30, 0x4C, 0x33, 0x3F,
  0xEF, 0xF8, 0xD8, 0x36, 0x0D, 0x82, 0x60, 0x10, 0x10, 0x7E, 0xFE, 0xD0,
  0xD0, 0xF0, 0x70, 0x3C, 0x1E, 0x17, 0x17, 0x96, 0xFE, 0x7C, 0x10, 0x10,
  0x70, 0xC3, 0x63, 0x0D, 0x88, 0x36, 0x60, 0xD9, 0x83, 0x6C, 0x0D, 0xB7,
  0xB6, 0xDE, 0x76, 0xC8, 0x1B, 0x30, 0x4C, 0xC3, 0x33, 0x0C, 0xC8, 0x21,
  0xE1, 0x87, 0x80, 0x3C, 0x1F, 0x86, 0x61, 0x98, 0x6E, 0x1B, 0x03, 0x81,
  0xE7, 0xFD, 0xB3, 0x6C, 0xFB, 0x1C, 0xC7, 0x3F, 0xE7, 0xDC, 0xFF, 0xEC,
  0x19, 0x9C, 0xC6, 0x73, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x8E, 0x31, 0xC0,
  0xE3, 0x0C, 0x61, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xE6, 0x77, 0x00,
  0x38, 0x23, 0x5F, 0xF3, 0x8D, 0xBB, 0xA2, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x6C, 0xFF, 0xC0, 0xFF, 0x80, 0x03,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60,
  0x60, 0xE0, 0x3C, 0x7E, 0xE6, 0xC6, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC6, 0xC6, 0xE6, 0x7E, 0x3C, 0x1C, 0xF7, 0xFB, 0x4C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7C, 0xFE, 0xC6, 0x06, 0x06, 0x06, 0x0E,
  0x0C, 0x1C, 0x38, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0x86, 0x06,
  0x06, 0x0E, 0x7C, 0x7C, 0x0E, 0x06, 0x07, 0x07, 0x8E, 0xFE, 0xFC, 0x07,
  0x03, 0x83, 0xC1, 0xE1, 0xF0, 0xB8, 0xDC, 0x4E, 0x67, 0x23, 0xBF, 0xFF,
  0xF0, 0x70, 0x38, 0x1C, 0x7E, 0xFE, 0xE0, 0xE0, 0xC0, 0xC0, 0xFC, 0xFE,
  0x06, 0x07, 0x07, 0x06, 0x8E, 0xFE, 0xFC, 0x1E, 0x7E, 0x60, 0xE0, 0xC0,
  0xCC, 0xFE, 0xEE, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C, 0xFF, 0xFF,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x7C, 0xFE, 0xC6, 0xC6, 0xC6, 0x6E, 0x7C, 0x3C, 0x6E, 0xC6, 0xC7,
  0xC7, 0xC7, 0xFE, 0x7C, 0x7C, 0xFE, 0xE6, 0xC6, 0xC7, 0xC7, 0xC7, 0xEF,
  0x7F, 0x36, 0x06, 0x06, 0x0E, 0xFC, 0xF8, 0x5F, 0xA0, 0x00, 0x0F, 0xF0,
  0x5F, 0xA0, 0x00, 0x01, 0xFD, 0xB0, 0x03, 0x0F, 0x3C, 0xF0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x7D, 0xFD, 0x38, 0x30, 0x61, 0xC7,
  0x0C, 0x30, 0x60, 0x00, 0x03, 0x07, 0x0C, 0x00, 0x0F, 0x81, 0xE7, 0x0C,
  0x18, 0xC0, 0x64, 0x79, 0x66, 0xCF, 0x26, 0x7B, 0x33, 0xD9, 0x9E, 0xCC,
  0xF2, 0x65, 0x9F, 0xEC, 0x66, 0x30, 0x01, 0xC1, 0x07, 0xF8, 0x07, 0x00,
  0x0E, 0x07, 0x81, 0xE0, 0x7C, 0x1B, 0x0E, 0xC3, 0x30, 0xCE, 0x33, 0x9F,
  0xE7, 0xF9, 0x87, 0x61, 0xF8, 0x7E, 0x0C, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E,
  0x37, 0x1B, 0xFD, 0xFC, 0xE7, 0x71, 0xF8, 0xFC, 0x7E, 0x3F, 0xFB, 0xF8,
  0x1F, 0x3F, 0x71, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60,
  0x71, 0x3F, 0x1F, 0xFC, 0x7F, 0xB9, 0xDC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x77, 0xFB, 0xF0, 0xFF, 0xFF, 0x87, 0x0E,
  0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00,
  0x1F, 0x9F, 0xDC, 0x2C, 0x0E, 0x07, 0x03, 0x81, 0xCF, 0xE7, 0xF0, 0xF8,
  0x6C, 0x37, 0x19, 0xFC, 0x7E, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x86, 0xFF, 0x98,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7B, 0xE0, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xBC, 0xE3, 0xF1, 0xB9, 0xDC,
  0xCE, 0xE7, 0x63, 0xF1, 0xF8, 0xFC, 0x77, 0x39, 0x9C, 0xEE, 0x37, 0x1F,
  0x8E, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1F, 0xFF, 0x80, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x6F, 0xB3, 0x7D, 0x9B, 0xEC, 0xDF, 0x6C, 0xF9, 0xE7, 0xCF, 0x3E, 0x71,
  0xF3, 0x8F, 0x8C, 0x60, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFF, 0x3E,
  0xCF, 0xBB, 0xE6, 0xF9, 0xBE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7E, 0x1C, 0x3F,
  0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E,
  0x1F, 0x87, 0x73, 0x9F, 0xE1, 0xF0, 0xFC, 0xFE, 0xE7, 0xE3, 0xE3, 0xE3,
  0xE7, 0xFF, 0xFE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x1F, 0xE7,
  0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1D, 0x87,
  0x73, 0x9F, 0xE1, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0xFC, 0x7F, 0xB9,
  0xDC, 0x6E, 0x37, 0x1B, 0x9D, 0xFC, 0xFC, 0x77, 0x39, 0x9C, 0xEE, 0x77,
  0x1F, 0x8E, 0x7F, 0xFF, 0x8E, 0x0C, 0x1C, 0x1C, 0x1E, 0x1C, 0x1C, 0x18,
  0x38, 0xFF, 0xBE, 0x00, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x36, 0x3B, 0xF8, 0xFC,
  0xC0, 0xF8, 0x76, 0x1D, 0x86, 0x61, 0x9C, 0xE3, 0x38, 0xCC, 0x33, 0x0E,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0xC1, 0x87, 0xE3, 0x86, 0xE3,
  0x86, 0x63, 0x8E, 0x63, 0xCE, 0x62, 0xCC, 0x76, 0xCC, 0x76, 0xCC, 0x36,
  0xCC, 0x36, 0x7C, 0x36, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x1C, 0x78, 0x1C,
  0x38, 0xE3, 0xB1, 0x9C, 0xC6, 0xE3, 0xE0, 0xF0, 0x70, 0x38, 0x1E, 0x1F,
  0x0D, 0x86, 0xE7, 0x33, 0x1F, 0x8E, 0xE1, 0xB1, 0xD8, 0xCE, 0x63, 0x71,
  0xB0, 0xF8, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0xFF,
  0xFF, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60,
  0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xFF, 0x0C, 0x03, 0x81, 0xE0, 0x7C, 0x3B, 0x0C, 0xC7, 0x19, 0x86,
  0xE0, 0xC0, 0xFF, 0x80, 0xE6, 0x30, 0x19, 0xF9, 0x38, 0x30, 0x6F, 0xFF,
  0xE3, 0xC7, 0x9F, 0xFB, 0xB0, 0xE0, 0xE0, 0xE0, 0xE0, 0xEC, 0xFE, 0xF7,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xDE, 0x18, 0xFD, 0xD7,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC5, 0xF1, 0xE0, 0x03, 0x03, 0x03, 0x03,
  0x33, 0x7B, 0xEF, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xE7, 0x7F, 0x7B,
  0x18, 0x7C, 0x66, 0xC6, 0xC6, 0xFF, 0xFF, 0xC0, 0xC0, 0xE1, 0x7E, 0x3E,
  0x1E, 0x78, 0xC3, 0x87, 0x1F, 0xBF, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7B, 0xEF, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xE7,
  0x7F, 0x7B, 0x03, 0x07, 0x87, 0xFE, 0x7C, 0xE0, 0xE0, 0xE0, 0xE0, 0xEC,
  0xDE, 0xF7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x5F,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x27, 0x70, 0x07, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x7E, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3B, 0x99,
  0xD8, 0xFC, 0x7C, 0x3F, 0x1D, 0x8E, 0xE7, 0x33, 0x9D, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x66, 0xF7, 0xBF, 0xEF, 0xCE, 0x7E, 0x71,
  0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0x38, 0xF9, 0xC7, 0xCE, 0x30,
  0x0C, 0xDE, 0xF7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0x18, 0x7E, 0x66, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C,
  0x0C, 0xDE, 0xF7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x30, 0x7B, 0xEF, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0xE7, 0x7F, 0x7B, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x7F,
  0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x33, 0xFC, 0xB0, 0xC3, 0xC7,
  0x87, 0x0E, 0x3F, 0xFE, 0x30, 0xC3, 0x3F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x3C, 0xF0, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xE7,
  0x7F, 0x7B, 0xE3, 0xB1, 0x98, 0xCC, 0xE7, 0x61, 0xB0, 0xD8, 0x7C, 0x3C,
  0x0E, 0x07, 0x00, 0xE7, 0x1D, 0x9E, 0x66, 0x79, 0x99, 0xEE, 0x65, 0xB1,
  0xF2, 0xC3, 0xCB, 0x0F, 0x2C, 0x3C, 0xF0, 0xF3, 0x81, 0x8E, 0x00, 0xE7,
  0x76, 0x36, 0x3C, 0x1C, 0x1C, 0x3C, 0x3E, 0x76, 0x67, 0xE3, 0xE3, 0xB1,
  0x98, 0xCC, 0xE7, 0x61, 0xB0, 0xD8, 0x7C, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC1, 0xC0, 0xE0, 0x7E, 0xF8, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61,
  0xFF, 0xF8, 0x0E, 0x3C, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0xF1, 0xE0, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE3, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0x73, 0x0C, 0x30,
  0xC3, 0x1C, 0xF3, 0x80, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 7, 5, 9, 1, -15 },
  { 12, 10, 15, 10, 0, -15 },
  { 31, 8, 17, 9, 1, -16 },
  { 48, 14, 15, 15, 1, -15 },
  { 75, 10, 15, 11, 1, -15 },
  { 94, 3, 5, 5, 1, -15 },
  { 96, 5, 18, 6, 1, -15 },
  { 108, 5, 18, 6, 0, -15 },
  { 120, 7, 8, 9, 1, -16 },
  { 127, 8, 10, 9, 1, -12 },
  { 137, 3, 5, 5, 1, -2 },
  { 139, 5, 2, 6, 1, -7 },
  { 141, 3, 3, 5, 1, -3 },
  { 143, 8, 15, 8, 0, -15 },
  { 158, 8, 15, 9, 1, -15 },
  { 173, 6, 15, 9, 1, -15 },
  { 185, 8, 15, 9, 1, -15 },
  { 200, 8, 15, 9, 1, -15 },
  { 215, 9, 15, 9, 0, -15 },
  { 232, 8, 15, 9, 1, -15 },
  { 247, 8, 15, 9, 1, -15 },
  { 262, 8, 15, 9, 1, -15 },
  { 277, 8, 15, 9, 1, -15 },
  { 292, 8, 15, 9, 1, -15 },
  { 307, 3, 12, 5, 1, -12 },
  { 312, 3, 15, 5, 1, -12 },
  { 318, 8, 9, 9, 1, -12 },
  { 327, 8, 6, 9, 1, -10 },
  { 333, 8, 9, 9, 1, -12 },
  { 342, 7, 15, 7, 0, -15 },
  { 356, 13, 17, 15, 1, -15 },
  { 384, 10, 15, 10, 0, -15 },
  { 403, 9, 15, 11, 1, -15 },
  { 420, 8, 15, 10, 1, -15 },
  { 435, 9, 15, 11, 1, -15 },
  { 452, 7, 15, 9, 1, -15 },
  { 466, 7, 15, 9, 1, -15 },
  { 480, 9, 15, 12, 1, -15 },
  { 497, 9, 15, 12, 1, -15 },
  { 514, 5, 15, 6, 1, -15 },
  { 524, 5, 19, 5, -1, -15 },
  { 536, 9, 15, 10, 1, -15 },
  { 553, 7, 15, 8, 1, -15 },
  { 567, 13, 15, 16, 1, -15 },
  { 592, 10, 15, 13, 1, -15 },
  { 611, 10, 15, 12, 1, -15 },
  { 630, 8, 15, 10, 1, -15 },
  { 645, 10, 19, 12, 1, -15 },
  { 669, 9, 15, 10, 1, -15 },
  { 686, 7, 15, 9, 1, -15 },
  { 700, 8, 15, 9, 0, -15 },
  { 715, 9, 15, 12, 1, -15 },
  { 732, 10, 15, 10, 0, -15 },
  { 751, 16, 15, 15, 0, -15 },
  { 781, 9, 15, 9, 0, -15 },
  { 798, 9, 15, 9, 0, -15 },
  { 815, 8, 15, 8, 0, -15 },
  { 830, 5, 18, 7, 1, -15 },
  { 842, 8, 15, 8, 0, -15 },
  { 857, 4, 18, 7, 1, -15 },
  { 866, 10, 9, 10, 0, -15 },
  { 878, 9, 1, 9, 0, 2 },
  { 880, 4, 3, 6, 1, -16 },
  { 882, 7, 12, 9, 1, -12 },
  { 893, 8, 16, 10, 1, -16 },
  { 909, 7, 12, 8, 1, -12 },
  { 920, 8, 16, 10, 1, -16 },
  { 936, 8, 12, 9, 1, -12 },
  { 948, 7, 16, 6, 0, -16 },
  { 962, 8, 17, 10, 1, -12 },
  { 979, 8, 16, 10, 1, -16 },
  { 995, 3, 16, 5, 1, -16 },
  { 1001, 4, 21, 5, 0, -16 },
  { 1012, 9, 16, 9, 1, -16 },
  { 1030, 3, 16, 5, 1, -16 },
  { 1036, 13, 12, 15, 1, -12 },
  { 1056, 8, 12, 10, 1, -12 },
  { 1068, 8, 12, 10, 1, -12 },
  { 1080, 8, 17, 10, 1, -12 },
  { 1097, 8, 17, 10, 1, -12 },
  { 1114, 6, 12, 7, 1, -12 },
  { 1123, 6, 12, 8, 1, -12 },
  { 1132, 6, 14, 6, 0, -14 },
  { 1143, 8, 11, 10, 1, -11 },
  { 1154, 9, 11, 9, 0, -11 },
  { 1167, 14, 11, 14, 0, -11 },
  { 1187, 8, 11, 8, 0, -11 },
  { 1198, 9, 16, 9, 0, -11 },
  { 1216, 7, 11, 7, 0, -11 },
  { 1226, 7, 18, 7, 0, -15 },
  { 1242, 3, 21, 9, 3, -16 },
  { 1250, 6, 18, 7, 1, -15 },
  { 1264, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD21PT7B_H_
