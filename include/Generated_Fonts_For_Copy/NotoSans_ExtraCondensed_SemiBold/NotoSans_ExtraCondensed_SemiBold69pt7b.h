#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x0E, 0x00, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0xC7, 0xF9, 0xC0,
  0xE7, 0xF8, 0xE0, 0x13, 0xFC, 0x70, 0x01, 0xFC, 0x38, 0x00, 0xFE, 0x1C,
  0x00, 0x7F, 0x0E, 0x00, 0x3F, 0x87, 0x00, 0x1F, 0xE3, 0x80, 0x07, 0xF9,
  0xC0, 0x03, 0xFE, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3B, 0xFE,
  0x00, 0x1C, 0xFF, 0x80, 0x0E, 0x3F, 0xC0, 0x07, 0x0F, 0xE0, 0x03, 0x87,
  0xF0, 0x01, 0xC3, 0xF8, 0x00, 0xE1, 0xFC, 0x00, 0x70, 0xFF, 0x00, 0x38,
  0x7F, 0xE0, 0x1C, 0x7F, 0xFE, 0x0E, 0x7F, 0xBF, 0xF7, 0xFF, 0xDF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x0F, 0xC3, 0xFF, 0x07, 0xE0, 0xFC,
  0x7E, 0x1F, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0x1F, 0x8F,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x1F, 0xCF, 0xE1, 0xFF, 0xF0, 0xFC,
  0x7E, 0x1F, 0x87, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x0F, 0xFE, 0x1F, 0x8F,
  0xC1, 0xF8, 0x1F, 0xF0, 0x7E, 0x3F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xE1,
  0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0x81, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF,
  0x1F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF3, 0xFE, 0x1F, 0xE3,
  0xFC, 0xFF, 0x03, 0xFD, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F,
  0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0x80,
  0xFC, 0x0C, 0x7C, 0x3E, 0x0F, 0x1F, 0xEF, 0x9F, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x87, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xFD, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x7F, 0xBF, 0xCF, 0xFF,
  0xF1, 0xFE, 0xFC, 0x3F, 0xCF, 0x07, 0xF8, 0xC0, 0xFF, 0x08, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFE, 0x0F, 0xFC, 0x3E, 0x00, 0xFF, 0x07, 0x00, 0x3F,
  0xE0, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFC, 0x07,
  0xFC, 0x1C, 0x00, 0xFF, 0x86, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xEF, 0x00, 0x1F, 0xFB, 0xF8, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xDF,
  0xC0, 0x00, 0x3E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0x3F, 0x80,
  0x01, 0xFB, 0xFC, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x07,
  0xC7, 0xF8, 0x00, 0x7E, 0x3F, 0xC0, 0x03, 0xE1, 0xFE, 0x00, 0x3F, 0x0F,
  0xF0, 0x01, 0xF0, 0x7F, 0x80, 0x1F, 0x83, 0xFC, 0x00, 0xFC, 0x1F, 0xE0,
  0x0F, 0xC0, 0xFF, 0x00, 0x7E, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x3F,
  0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x81, 0xF8, 0x03,
  0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0C, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x80, 0x01, 0xFF, 0x78, 0x01, 0xFF, 0xBF, 0x87, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x08, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0x80,
  0x3F, 0x8F, 0xFC, 0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0xFF, 0xFC, 0x1F, 0xDF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF3,
  0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00,
  0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01,
  0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE1, 0xFF,
  0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F,
  0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0xFF, 0xDF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x1F,
  0xFF, 0xDF, 0xC3, 0xFF, 0xE7, 0xF0, 0x7F, 0xF1, 0xFC, 0x0F, 0xF8, 0xFF,
  0x00, 0x70, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xBF, 0x82, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x70, 0x07, 0x83,
  0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x1F, 0xE3, 0xF8,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFC, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x83, 0xFE, 0x18, 0x03,
  0xFE, 0x20, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xC1, 0xF8, 0xFC, 0x03, 0xFF,
  0xF0, 0x7E, 0x3F, 0x01, 0xFF, 0xFC, 0x1F, 0x8F, 0xC0, 0xFF, 0xFF, 0x03,
  0xE7, 0xE0, 0x7F, 0x8F, 0xC0, 0xFD, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xDF, 0x83, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xFF, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xC0, 0xFF,
  0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0x07,
  0xE0, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x07,
  0xF0, 0x3F, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xBF, 0x07, 0xE0, 0x7F, 0x07,
  0xEF, 0xC0, 0xFC, 0x1F, 0xC1, 0xFB, 0xF0, 0x3F, 0x0F, 0xF0, 0x7E, 0xFC,
  0x0F, 0xE3, 0xFE, 0x3F, 0x1F, 0x81, 0xFF, 0xEF, 0xFF, 0xC7, 0xE0, 0x7F,
  0xF9, 0xFF, 0xE1, 0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x7E, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0x1F, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF,
  0xE7, 0xF8, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0,
  0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xEF,
  0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7C, 0x0F, 0xFC, 0x01, 0xC1, 0xFF, 0x80, 0x04, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x02, 0x0F, 0xFC, 0x00, 0xC0, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xE0, 0x3F, 0xF8, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x07,
  0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x00, 0xFF, 0xC7, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x7E, 0x0F, 0xFE, 0x00,
  0x38, 0x1F, 0xF8, 0x00, 0x10, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xDF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0x07,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFD,
  0x87, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xBF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x01,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F,
  0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE,
  0x7F, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0x7F, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0xFF, 0xBF, 0x80, 0x07,
  0xF7, 0xFF, 0xEF, 0xE0, 0x01, 0xF9, 0xFF, 0xFB, 0xF8, 0x00, 0x7E, 0xFF,
  0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0xFF, 0x9F, 0xC0, 0x0F, 0xEF, 0xFF, 0xE7,
  0xF0, 0x03, 0xF3, 0xFF, 0xF8, 0xFC, 0x01, 0xFC, 0xFF, 0xFE, 0x3F, 0x80,
  0x7F, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F, 0x8F, 0xFF, 0xE3, 0xF8, 0x07, 0xE3,
  0xFF, 0xF8, 0x7E, 0x03, 0xF8, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xFF,
  0x87, 0xF0, 0x3F, 0x0F, 0xFF, 0xE1, 0xFC, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F,
  0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0x83, 0xF8, 0x7E,
  0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0, 0xFF,
  0xFE, 0x07, 0xF3, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xDF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0xFE,
  0x00, 0x7F, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0x00, 0x7F, 0xFE, 0x7F,
  0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x7F, 0xFE, 0x3F, 0x80, 0x7F, 0xFE, 0x3F,
  0xC0, 0x7F, 0xFE, 0x1F, 0xC0, 0x7F, 0xFE, 0x1F, 0xE0, 0x7F, 0xFE, 0x1F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x07,
  0xF0, 0x7F, 0xFE, 0x07, 0xF8, 0x7F, 0xFE, 0x03, 0xF8, 0x7F, 0xFE, 0x03,
  0xFC, 0x7F, 0xFE, 0x03, 0xFC, 0x7F, 0xFE, 0x01, 0xFE, 0x7F, 0xFE, 0x01,
  0xFE, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0xFE, 0x00,
  0x7F, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F,
  0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07,
  0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0,
  0x1F, 0xF3, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0x00, 0xFF, 0x87,
  0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x8F, 0xF0,
  0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x83, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x7F, 0x80,
  0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xE0, 0x1E, 0x3F, 0xE0, 0x02, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0xC0, 0x00, 0xFF, 0x78, 0x00, 0xFF,
  0xBF, 0x80, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFE, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xC0, 0xFE, 0x00,
  0xFD, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0x03, 0xFC,
  0x07, 0xF7, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0x9F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF1, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7E, 0x3F, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F,
  0x80, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x1F, 0xC3,
  0xFC, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x07, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F,
  0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F, 0xC0, 0x03, 0xF9,
  0xFC, 0x07, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0xFC, 0xFF, 0x00, 0x07,
  0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x01,
  0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0x07, 0xFC, 0x0C, 0x01, 0xFE, 0x04, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0x87,
  0xFB, 0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0x07, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xCF, 0xFF, 0xEF, 0xE7, 0xFF, 0xE7, 0xF1,
  0xFF, 0xE1, 0xF8, 0x7F, 0xE0, 0xFC, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xF8, 0x07,
  0xF8, 0xFF, 0xC0, 0xFF, 0x3F, 0xFC, 0x1F, 0xEF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xC1, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xFC, 0x07, 0xF9, 0xFF, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFE, 0x1F, 0xCF, 0xFF, 0xC3, 0xF8, 0xFF,
  0xF0, 0x7E, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xF8, 0x0C, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x8F, 0xFC, 0x1E,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xF8, 0x7F,
  0x0F, 0xFF, 0x9F, 0xC7, 0xFF, 0xF7, 0xF1, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF8,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0xC3,
  0xFF, 0xE3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xF8, 0x3F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0x7F,
  0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x0C, 0x7F, 0xC0, 0x1E, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x82, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF8, 0xFC, 0x7F, 0xFF, 0x7F, 0x1F, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x87, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFF, 0xFD, 0xFC, 0x3F, 0xFE,
  0x7F, 0x07, 0xFF, 0x1F, 0xC0, 0xFF, 0x87, 0xF0, 0x0F, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xD0, 0x00, 0x1F, 0xE7, 0x00, 0x0F,
  0xF9, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0x81, 0xFE, 0x3F, 0xF0, 0xFF, 0x7F, 0xFC, 0x7F, 0x3F, 0xFF, 0x3F,
  0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xFE, 0x3F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F,
  0xE0, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F,
  0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xF7, 0xF0, 0x0F, 0xFC, 0xFF, 0x01, 0xFF, 0x8F, 0xE0, 0x3F,
  0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xE7, 0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7E, 0x1F, 0xFC, 0x3F, 0x9F, 0xFF, 0x1F, 0xCF, 0xFF, 0xCF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFE, 0x07,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFB, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFC,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0x0F,
  0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0xE7, 0xFF, 0x07,
  0xFC, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x1F, 0xE7, 0xFF, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0x0F,
  0xF3, 0xFF, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF8, 0xFC, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x87, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFF, 0xFD, 0xFC, 0x3F, 0xFE,
  0x7F, 0x07, 0xFF, 0x1F, 0xC0, 0xFF, 0x87, 0xF0, 0x0F, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x0F, 0x9F,
  0xE0, 0x1C, 0xFF, 0x00, 0x27, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC3, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC,
  0x0F, 0xFD, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xCF, 0xC7, 0xFF, 0xC7, 0xE1, 0xFF, 0xE3, 0xF0, 0x7F, 0xC1, 0xF8,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFB,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0x87, 0xF8, 0x0F,
  0xBE, 0x03, 0xFC, 0x3F, 0xC0, 0xFD, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xEF,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0xC1, 0xFB, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0x8F, 0x83, 0xFC, 0x0F, 0xF0, 0x7C, 0x7C, 0x1F,
  0xC0, 0x3F, 0x87, 0xE3, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x1F, 0x87, 0xF0,
  0x0F, 0xF1, 0xF8, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0x87, 0xE3, 0xFC, 0x01,
  0xFC, 0x7C, 0x1F, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0xF8, 0xFE, 0x00, 0x7F,
  0x3F, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0x3F, 0x3F, 0x80, 0x1F, 0xCF,
  0xC1, 0xFB, 0xF8, 0x00, 0x7F, 0x7C, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xE0,
  0x3E, 0xFE, 0x00, 0x1F, 0xDF, 0x01, 0xF7, 0xF0, 0x00, 0xFE, 0xF8, 0x0F,
  0xBF, 0x80, 0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x8F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x23, 0xFE, 0x00,
  0x05, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xD0, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 50, 17, 4, -49 },
  { 58, 21, 18, 29, 4, -49 },
  { 106, 31, 49, 34, 1, -49 },
  { 296, 25, 56, 31, 3, -52 },
  { 471, 46, 51, 50, 2, -50 },
  { 765, 34, 51, 36, 2, -50 },
  { 982, 8, 18, 16, 4, -49 },
  { 1000, 17, 61, 21, 3, -50 },
  { 1130, 17, 61, 21, 1, -50 },
  { 1260, 26, 26, 29, 2, -53 },
  { 1345, 27, 33, 31, 2, -41 },
  { 1457, 11, 17, 16, 2, -8 },
  { 1481, 16, 7, 20, 2, -22 },
  { 1495, 9, 11, 17, 4, -10 },
  { 1508, 25, 50, 27, 1, -50 },
  { 1665, 26, 51, 31, 2, -50 },
  { 1831, 19, 49, 31, 4, -49 },
  { 1948, 26, 50, 31, 2, -50 },
  { 2111, 26, 51, 31, 2, -50 },
  { 2277, 29, 49, 31, 1, -49 },
  { 2455, 25, 50, 31, 3, -49 },
  { 2612, 27, 51, 31, 2, -50 },
  { 2785, 27, 49, 31, 2, -49 },
  { 2951, 27, 51, 31, 2, -50 },
  { 3124, 26, 51, 31, 2, -50 },
  { 3290, 9, 39, 17, 4, -38 },
  { 3334, 11, 47, 17, 2, -38 },
  { 3399, 27, 32, 31, 2, -41 },
  { 3507, 27, 20, 31, 2, -34 },
  { 3575, 27, 32, 31, 2, -41 },
  { 3683, 23, 51, 24, 0, -50 },
  { 3830, 42, 56, 48, 3, -50 },
  { 4124, 34, 49, 34, 0, -49 },
  { 4333, 27, 49, 35, 5, -49 },
  { 4499, 28, 51, 32, 3, -50 },
  { 4678, 29, 49, 37, 5, -49 },
  { 4856, 21, 49, 29, 5, -49 },
  { 4985, 21, 49, 28, 5, -49 },
  { 5114, 31, 51, 38, 3, -50 },
  { 5312, 29, 49, 39, 5, -49 },
  { 5490, 17, 49, 21, 2, -49 },
  { 5595, 17, 63, 18, -4, -49 },
  { 5729, 29, 49, 34, 5, -49 },
  { 5907, 21, 49, 27, 5, -49 },
  { 6036, 42, 49, 52, 5, -49 },
  { 6294, 32, 49, 42, 5, -49 },
  { 6490, 34, 51, 40, 3, -50 },
  { 6707, 26, 49, 33, 5, -49 },
  { 6867, 34, 62, 40, 3, -50 },
  { 7131, 29, 49, 34, 5, -49 },
  { 7309, 25, 51, 29, 2, -50 },
  { 7469, 26, 49, 28, 1, -49 },
  { 7629, 29, 50, 38, 5, -49 },
  { 7811, 33, 49, 33, 0, -49 },
  { 8014, 51, 49, 51, 0, -49 },
  { 8327, 31, 49, 31, 0, -49 },
  { 8517, 31, 49, 31, 0, -49 },
  { 8707, 25, 49, 27, 1, -49 },
  { 8861, 16, 61, 22, 4, -50 },
  { 8983, 25, 50, 27, 1, -50 },
  { 9140, 15, 61, 22, 2, -50 },
  { 9255, 32, 28, 34, 1, -49 },
  { 9367, 29, 4, 29, 0, 6 },
  { 9382, 15, 11, 20, 3, -53 },
  { 9403, 25, 39, 31, 2, -38 },
  { 9525, 27, 53, 34, 4, -52 },
  { 9704, 22, 39, 26, 3, -38 },
  { 9812, 26, 53, 34, 3, -52 },
  { 9985, 25, 39, 31, 3, -38 },
  { 10107, 20, 53, 19, 1, -53 },
  { 10240, 26, 55, 34, 3, -38 },
  { 10419, 25, 52, 33, 4, -52 },
  { 10582, 8, 52, 16, 4, -52 },
  { 10634, 14, 69, 16, -2, -52 },
  { 10755, 27, 52, 31, 4, -52 },
  { 10931, 8, 52, 16, 4, -52 },
  { 10983, 42, 38, 50, 4, -38 },
  { 11183, 25, 38, 33, 4, -38 },
  { 11302, 27, 39, 33, 3, -38 },
  { 11434, 27, 55, 34, 4, -38 },
  { 11620, 26, 55, 34, 3, -38 },
  { 11799, 18, 38, 23, 4, -38 },
  { 11885, 21, 39, 25, 2, -38 },
  { 11988, 19, 47, 21, 1, -46 },
  { 12100, 25, 38, 33, 4, -37 },
  { 12219, 29, 37, 29, 0, -37 },
  { 12354, 45, 37, 45, 0, -37 },
  { 12563, 27, 37, 28, 0, -37 },
  { 12688, 29, 54, 29, 0, -37 },
  { 12884, 20, 37, 23, 2, -37 },
  { 12977, 20, 60, 24, 2, -49 },
  { 13127, 7, 69, 29, 11, -53 },
  { 13188, 20, 60, 24, 3, -49 },
  { 13338, 27, 11, 31, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD69PT7B_H_
