#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0x9E, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x70, 0xF7,
  0x0F, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xE3, 0xC0, 0x71, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE1, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1E,
  0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1E,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x1F, 0xF9, 0xFF, 0xF7,
  0xFF, 0xBE, 0xCE, 0xF3, 0x03, 0xCC, 0x0F, 0x30, 0x3C, 0xC0, 0xFB, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xDF,
  0x03, 0x3C, 0x0C, 0xF8, 0x33, 0xF0, 0xDF, 0xF3, 0xFB, 0xFF, 0xCF, 0xFE,
  0x0F, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0x00, 0x70,
  0x0F, 0xE0, 0x3C, 0x07, 0xFC, 0x0E, 0x01, 0xEF, 0x07, 0x80, 0x71, 0xC1,
  0xC0, 0x3C, 0x70, 0x70, 0x0F, 0x1E, 0x3C, 0x03, 0xC7, 0x8E, 0x00, 0xF1,
  0xE3, 0x80, 0x3C, 0x79, 0xE0, 0x0F, 0x1E, 0x70, 0x01, 0xC7, 0x3C, 0x78,
  0x71, 0xCE, 0x3F, 0x1E, 0xF3, 0x9F, 0xE7, 0xFD, 0xE7, 0x38, 0xFE, 0x73,
  0xCF, 0x1F, 0x1C, 0xE3, 0xC0, 0x0F, 0x38, 0x70, 0x03, 0x8E, 0x1C, 0x01,
  0xE3, 0x87, 0x00, 0x78, 0xE1, 0xC0, 0x1C, 0x38, 0x70, 0x0F, 0x0E, 0x1C,
  0x03, 0x83, 0xCF, 0x00, 0xE0, 0x73, 0xC0, 0x78, 0x1F, 0xE0, 0x1C, 0x03,
  0xF8, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xEF, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC3, 0xE7, 0xFE, 0x3E, 0x7D, 0xF3, 0xCF, 0x8F,
  0x3C, 0xF8, 0xFF, 0xCF, 0x87, 0xF8, 0xF8, 0x7F, 0x8F, 0x83, 0xF0, 0xF8,
  0x1F, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF3, 0xE1,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xCE, 0x73, 0x80, 0x07, 0x87, 0x83,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x06, 0x38,
  0xCF, 0x7F, 0xBF, 0xFF, 0x7F, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0x81,
  0xF7, 0x87, 0xC7, 0x83, 0x8E, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E,
  0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF7, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC3, 0xC7, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1F, 0x78, 0x3E, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7D, 0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0x9F, 0x0F,
  0x1E, 0x3E, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x01, 0xE0,
  0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0x7F, 0xCF, 0x73, 0xE4, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0x07, 0xC4, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE3,
  0xFF, 0xE3, 0x07, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xC1, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xE0, 0x3E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0x78, 0x07, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1C, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x20, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE6, 0x3F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xA0,
  0x3E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE3, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE7, 0x83, 0xDF, 0xCF, 0xFF, 0xDF, 0xFF, 0xBF, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x07, 0xDF, 0x0F, 0x9E, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xF7, 0xE7, 0xC3, 0xCF, 0x07, 0xDE, 0x0F, 0xBC, 0x1F, 0x78, 0x3C, 0xF8,
  0x78, 0xF9, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xFC,
  0x7C, 0x7C, 0xF0, 0x7D, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0x7C, 0x7E, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0x0F,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F,
  0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF,
  0x8F, 0xDF, 0xFF, 0x9F, 0xEF, 0x3F, 0xDE, 0x3F, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x77, 0xF0, 0xFF, 0xE1,
  0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0x80, 0x3C, 0xF9, 0xF3, 0xE3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF1, 0xE7,
  0xCF, 0x9E, 0x3C, 0x71, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC, 0xFF, 0xE6, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0xF0,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x1E, 0x1C,
  0x70, 0x7F, 0x9E, 0x70, 0xFF, 0x8E, 0xF1, 0xE7, 0x8E, 0xE1, 0xC7, 0x8E,
  0xE3, 0xC7, 0x8E, 0xE3, 0xC7, 0x8F, 0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x8E,
  0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x8E, 0xE3, 0xC7, 0x8E, 0xE3, 0xCF, 0x9E,
  0xE1, 0xED, 0x9C, 0xF1, 0xFD, 0xFC, 0xF0, 0xF9, 0xF8, 0x70, 0x20, 0x60,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xF0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x07, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1,
  0xF7, 0x8F, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x7E, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xF0, 0x4F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x01, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0xFC,
  0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7E,
  0xF0, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0, 0x11, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0x7C,
  0x0F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0xFF, 0x7F, 0xBF, 0x9F, 0x80, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF8,
  0xF1, 0xF0, 0xF3, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0xC0, 0xF7, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF1, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E,
  0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xF7, 0x81, 0xDF, 0xF7, 0x83, 0xDF, 0xF7, 0x83, 0xDF,
  0xF3, 0x83, 0xDF, 0xF3, 0xC3, 0x9F, 0xF3, 0xC7, 0x9F, 0xF3, 0xC7, 0x9F,
  0xF1, 0xC7, 0x1F, 0xF1, 0xE7, 0x1F, 0xF1, 0xEF, 0x1F, 0xF1, 0xEF, 0x1F,
  0xF0, 0xEE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F,
  0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x38, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFD, 0xE0, 0xFF, 0x7C,
  0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0xCF,
  0xF0, 0xF3, 0xFC, 0x3E, 0xFF, 0x07, 0xBF, 0xC1, 0xEF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0x7C, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE1, 0xF0, 0x7C,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC7, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFC, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xE1, 0xF8, 0xF8,
  0x1F, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80,
  0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE1, 0xF0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF1,
  0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF,
  0xDF, 0xFE, 0x7C, 0x19, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF8,
  0x3F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0,
  0xF0, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C,
  0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xC0,
  0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3D, 0xF0, 0x1F, 0x01, 0xE7, 0x80, 0xF8,
  0x0F, 0x3C, 0x0F, 0xC0, 0xF9, 0xE0, 0x7F, 0x07, 0xCF, 0x83, 0xF8, 0x3E,
  0x7C, 0x1D, 0xC1, 0xE1, 0xE0, 0xEE, 0x0F, 0x0F, 0x0F, 0x70, 0xF8, 0x78,
  0x7B, 0xC7, 0xC3, 0xE3, 0xDE, 0x3E, 0x1F, 0x1C, 0xF1, 0xE0, 0x79, 0xE7,
  0x8F, 0x03, 0xCF, 0x1C, 0xF8, 0x1E, 0x78, 0xF7, 0xC0, 0xF3, 0xC7, 0xBE,
  0x07, 0xDC, 0x3D, 0xE0, 0x1E, 0xE1, 0xEF, 0x00, 0xFF, 0x07, 0x78, 0x07,
  0xF8, 0x3B, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7C, 0x0F, 0xBE, 0x0F, 0x8F, 0x07, 0xC7, 0xC3, 0xC3, 0xE3, 0xE0,
  0xF1, 0xF0, 0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x81, 0xF3, 0xC0, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x3C, 0x3C, 0x1F, 0x3E, 0x0F, 0x9E, 0x03, 0xFF, 0x01,
  0xF0, 0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xF1,
  0xF0, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0xBE, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0E, 0x3C, 0x07, 0x8F, 0x01,
  0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x7B, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x00, 0x80, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x18, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xF7, 0xCF, 0xDF, 0xFF,
  0x7F, 0x9C, 0xFC, 0x70, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x41, 0xF7, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xE7, 0xDF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xF7, 0xFF, 0xEF, 0x7F, 0x9E, 0x7E,
  0x00, 0x01, 0x81, 0xFF, 0x3F, 0xF7, 0xFE, 0x7C, 0x6F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x81, 0x7E, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x02, 0x1F, 0x0F, 0xDF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x7F,
  0x7C, 0x3F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1F,
  0x7C, 0x3F, 0x3E, 0x7F, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x03, 0x00,
  0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x78, 0xFB, 0xE1, 0xEF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x27, 0xE3, 0x9F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xC0, 0x03, 0xE0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x02, 0x00,
  0x0F, 0xCF, 0x1F, 0xEF, 0x3F, 0xEF, 0x3E, 0x7F, 0x7C, 0x3F, 0x7C, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x40, 0x3E, 0x7D, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0xC1, 0xF7, 0xE3, 0xFF, 0xE7, 0xBF, 0xEF, 0xE7,
  0xDF, 0x87, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0xBE, 0xFE, 0xFE, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0xF9, 0xF0,
  0xF9, 0xE0, 0xFB, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFD, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x3C, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x20, 0xF3, 0xF0, 0xFC, 0xF7, 0xF9, 0xFE, 0xF7, 0xFF,
  0xFE, 0xFE, 0xFF, 0xBF, 0xFC, 0x7E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0x00, 0xC1, 0xE7, 0xE3, 0xDF,
  0xE7, 0xBF, 0xEF, 0xE7, 0xDF, 0x87, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xC0, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C,
  0x3E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7C,
  0x3E, 0x3E, 0x7E, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0xC1, 0xE7,
  0xE3, 0xDF, 0xE7, 0xBF, 0xEF, 0xE7, 0xDF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xF7, 0xFF, 0xEF, 0xBF,
  0x9F, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xCF,
  0x1F, 0xEF, 0x3F, 0xEF, 0x3E, 0x7F, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x3F, 0x7F, 0x3F, 0xFF,
  0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xDE,
  0x7F, 0xDF, 0x7B, 0xEF, 0xFD, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0x03, 0xFE, 0x7F, 0xF7, 0xFE, 0xF8,
  0x6F, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0xFB, 0xFF, 0xFE, 0xFF,
  0xC7, 0xF8, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xEC, 0xFF, 0x3F, 0xC7, 0xF0, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7E, 0xFF, 0xFD, 0xFF, 0x79, 0xFE,
  0xF1, 0xF9, 0xE0, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C,
  0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x3E, 0x07,
  0xBC, 0x1F, 0x03, 0xDE, 0x0F, 0xC3, 0xEF, 0x07, 0xE1, 0xE7, 0xC7, 0xF0,
  0xF3, 0xE3, 0xB8, 0x78, 0xF1, 0xDC, 0x7C, 0x78, 0xEF, 0x3C, 0x3C, 0x73,
  0x9E, 0x1F, 0x79, 0xCF, 0x07, 0xB8, 0xE7, 0x83, 0xDC, 0x77, 0xC1, 0xEE,
  0x3B, 0xC0, 0xF7, 0x1D, 0xE0, 0x7B, 0x87, 0xF0, 0x1D, 0xC3, 0xF8, 0x0F,
  0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x80, 0x78, 0x3E, 0xF8, 0x7C, 0xF0, 0xF1, 0xF3, 0xE1, 0xE7,
  0x83, 0xDF, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xBE, 0x0F, 0x3C, 0x3E, 0x78, 0x78,
  0xF9, 0xF0, 0xF3, 0xC1, 0xFF, 0x81, 0xE0, 0xF8, 0x1F, 0x78, 0x1F, 0x78,
  0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC7, 0xF0, 0xFC, 0x1F,
  0x03, 0xF8, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFF, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0x80, 0x18, 0x01,
  0x7F, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0xC3, 0xFE, 0x80, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 12, 10, 16, 2, -28 },
  { 37, 17, 28, 19, 1, -28 },
  { 97, 14, 32, 18, 2, -30 },
  { 153, 26, 28, 29, 1, -28 },
  { 244, 20, 28, 21, 1, -28 },
  { 314, 5, 10, 9, 2, -28 },
  { 321, 9, 34, 12, 2, -28 },
  { 360, 9, 34, 12, 1, -28 },
  { 399, 15, 15, 17, 1, -30 },
  { 428, 15, 18, 18, 1, -23 },
  { 462, 7, 9, 9, 1, -4 },
  { 470, 9, 5, 11, 1, -13 },
  { 476, 5, 5, 10, 2, -5 },
  { 480, 15, 28, 15, 0, -28 },
  { 533, 15, 28, 18, 1, -28 },
  { 586, 11, 28, 18, 2, -28 },
  { 625, 15, 28, 18, 1, -28 },
  { 678, 15, 28, 18, 1, -28 },
  { 731, 16, 28, 18, 1, -28 },
  { 787, 14, 28, 18, 2, -28 },
  { 836, 15, 28, 18, 1, -28 },
  { 889, 15, 28, 18, 1, -28 },
  { 942, 15, 28, 18, 1, -28 },
  { 995, 15, 28, 18, 1, -28 },
  { 1048, 5, 21, 10, 2, -21 },
  { 1062, 7, 26, 10, 1, -21 },
  { 1085, 16, 18, 18, 1, -23 },
  { 1121, 15, 11, 18, 1, -19 },
  { 1142, 16, 18, 18, 1, -23 },
  { 1178, 13, 28, 14, 0, -28 },
  { 1224, 24, 31, 27, 2, -28 },
  { 1317, 19, 28, 19, 0, -28 },
  { 1384, 15, 28, 20, 3, -28 },
  { 1437, 15, 28, 18, 2, -28 },
  { 1490, 16, 28, 21, 3, -28 },
  { 1546, 12, 28, 17, 3, -28 },
  { 1588, 12, 28, 16, 3, -28 },
  { 1630, 17, 28, 22, 2, -28 },
  { 1690, 16, 28, 22, 3, -28 },
  { 1746, 10, 28, 12, 1, -28 },
  { 1781, 9, 36, 10, -2, -28 },
  { 1822, 16, 28, 19, 3, -28 },
  { 1878, 12, 28, 15, 3, -28 },
  { 1920, 24, 28, 29, 3, -28 },
  { 2004, 18, 28, 24, 3, -28 },
  { 2067, 19, 28, 23, 2, -28 },
  { 2134, 14, 28, 18, 3, -28 },
  { 2183, 19, 35, 23, 2, -28 },
  { 2267, 16, 28, 19, 3, -28 },
  { 2323, 14, 28, 16, 1, -28 },
  { 2372, 16, 28, 16, 0, -28 },
  { 2428, 16, 28, 22, 3, -28 },
  { 2484, 19, 28, 19, 0, -28 },
  { 2551, 29, 28, 29, 0, -28 },
  { 2653, 17, 28, 17, 0, -28 },
  { 2713, 17, 28, 17, 0, -28 },
  { 2773, 14, 28, 15, 1, -28 },
  { 2822, 9, 34, 12, 2, -28 },
  { 2861, 15, 28, 15, 0, -28 },
  { 2914, 9, 34, 12, 1, -28 },
  { 2953, 18, 16, 19, 1, -28 },
  { 2989, 16, 3, 16, 0, 3 },
  { 2995, 8, 6, 11, 2, -30 },
  { 3001, 14, 22, 17, 1, -22 },
  { 3040, 15, 30, 19, 2, -30 },
  { 3097, 12, 22, 15, 2, -22 },
  { 3130, 16, 30, 19, 1, -30 },
  { 3190, 14, 22, 17, 2, -22 },
  { 3229, 12, 30, 11, 0, -30 },
  { 3274, 16, 31, 19, 1, -22 },
  { 3336, 15, 30, 19, 2, -30 },
  { 3393, 5, 29, 9, 2, -29 },
  { 3412, 8, 38, 9, -1, -29 },
  { 3450, 16, 30, 18, 2, -30 },
  { 3510, 5, 30, 9, 2, -30 },
  { 3529, 24, 22, 28, 2, -22 },
  { 3595, 15, 22, 19, 2, -22 },
  { 3637, 16, 22, 18, 1, -22 },
  { 3681, 15, 31, 19, 2, -22 },
  { 3740, 16, 31, 19, 1, -22 },
  { 3802, 11, 22, 13, 2, -22 },
  { 3833, 12, 22, 14, 1, -22 },
  { 3866, 10, 26, 12, 1, -26 },
  { 3899, 15, 21, 19, 2, -21 },
  { 3939, 16, 21, 16, 0, -21 },
  { 3981, 25, 21, 25, 0, -21 },
  { 4047, 15, 21, 16, 0, -21 },
  { 4087, 16, 30, 16, 0, -21 },
  { 4147, 11, 21, 13, 1, -21 },
  { 4176, 11, 34, 14, 1, -28 },
  { 4223, 4, 39, 17, 6, -30 },
  { 4243, 12, 34, 14, 1, -28 },
  { 4294, 16, 6, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD39PT7B_H_
