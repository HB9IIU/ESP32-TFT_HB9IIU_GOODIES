#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x77, 0x76, 0x66, 0x66, 0x60, 0x27, 0xF7, 0xE7, 0xE7,
  0xE7, 0x67, 0x67, 0x67, 0x63, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x99,
  0xFF, 0xFF, 0xF9, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x7F, 0xEF, 0xFC, 0xEE,
  0x19, 0x83, 0x30, 0x66, 0x0C, 0xC0, 0x08, 0x04, 0x0F, 0xCF, 0xFF, 0x97,
  0x43, 0xA1, 0xD0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0xB8, 0x4E, 0x2F, 0xFF,
  0xFF, 0x1E, 0x02, 0x01, 0x00, 0x78, 0x38, 0x7C, 0x30, 0xCC, 0x70, 0xCC,
  0x60, 0xCC, 0x60, 0xCC, 0xE0, 0xCC, 0xC0, 0xCC, 0xCE, 0xCD, 0x9F, 0x7D,
  0xB3, 0x7B, 0xB3, 0x03, 0x33, 0x03, 0x33, 0x07, 0x33, 0x06, 0x33, 0x06,
  0x33, 0x0C, 0x1F, 0x0C, 0x1E, 0x1E, 0x03, 0xF0, 0x77, 0x07, 0x30, 0x73,
  0x07, 0x70, 0x77, 0x03, 0xE0, 0x3C, 0x07, 0xC7, 0xEE, 0xEE, 0x7E, 0xE7,
  0xEE, 0x3C, 0xE1, 0xCF, 0x7C, 0xFF, 0xE7, 0xE7, 0xFF, 0xB6, 0xD8, 0x1C,
  0x63, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71,
  0xC3, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x18, 0x71, 0xC7, 0x0C, 0x30,
  0xC3, 0x0C, 0x31, 0xC7, 0x1C, 0x63, 0x8C, 0x73, 0x80, 0x1C, 0x0E, 0x26,
  0x3F, 0xFF, 0xF8, 0xE0, 0xF8, 0xEE, 0x66, 0x00, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x77,
  0x6E, 0xEC, 0xFF, 0xFF, 0xC0, 0x2F, 0xF6, 0x01, 0xC0, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x3E, 0x3F, 0x9D, 0xCC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xEE,
  0x7F, 0x1F, 0x00, 0x06, 0x1C, 0x79, 0xFF, 0xED, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3E, 0x7F, 0xBF, 0xC8, 0x70,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x83, 0x83, 0xC1, 0xC1,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x7F, 0xB9, 0xE8, 0x70, 0x38, 0x1C, 0x0C,
  0x3E, 0x3C, 0x1F, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x8F, 0xFF, 0x7F,
  0x00, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x06, 0xE0, 0xDC,
  0x33, 0x86, 0x71, 0x8E, 0x31, 0xCF, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x7F, 0x3F, 0x9F, 0xCC, 0x06, 0x03, 0x03, 0x81, 0xFC, 0xFF,
  0x23, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x9F, 0xFF, 0x7F, 0x00, 0x0F,
  0x1F, 0x9F, 0x2E, 0x06, 0x07, 0x03, 0x91, 0xFE, 0xFF, 0xF1, 0xF8, 0xFC,
  0x3E, 0x1F, 0x1F, 0x8E, 0xEF, 0x7F, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x38, 0x00, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1D,
  0xDE, 0xFE, 0x3E, 0x3F, 0x9D, 0xDC, 0x7E, 0x1F, 0x0F, 0x87, 0xC7, 0x7F,
  0x1F, 0x00, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFF, 0xDF, 0x67, 0x70, 0x38, 0x1C, 0x1C, 0x1E, 0x7E, 0x3E, 0x00, 0x2F,
  0xF6, 0x00, 0x00, 0x00, 0x27, 0xF7, 0x2F, 0xF6, 0x00, 0x00, 0x00, 0x07,
  0x76, 0xEE, 0xC0, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3C,
  0x7C, 0x7C, 0x3C, 0x0C, 0x02, 0x00, 0x7E, 0xFF, 0x6F, 0x07, 0x03, 0x07,
  0x07, 0x0E, 0x1E, 0x1C, 0x18, 0x18, 0x18, 0x00, 0x10, 0x38, 0x38, 0x38,
  0x07, 0xE0, 0x1F, 0xE0, 0x60, 0x61, 0x80, 0x67, 0x00, 0xEC, 0x7C, 0xD9,
  0xD9, 0xE3, 0x33, 0xCE, 0x67, 0x98, 0xCF, 0x31, 0x9E, 0x63, 0x3C, 0xEE,
  0x78, 0xF7, 0x99, 0xEF, 0x30, 0x00, 0x70, 0x00, 0x70, 0x20, 0x7F, 0xC0,
  0x3F, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xD8, 0x1D,
  0xC1, 0x9C, 0x39, 0xC3, 0x8C, 0x38, 0xE3, 0xFE, 0x7F, 0xE7, 0x0E, 0x70,
  0x77, 0x07, 0xE0, 0x7E, 0x07, 0xFE, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8,
  0xEE, 0x3B, 0xBC, 0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x3F,
  0x9E, 0xFF, 0x3F, 0x80, 0x0F, 0x87, 0xF3, 0xDD, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xF3,
  0x3F, 0xC7, 0xF0, 0xFC, 0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0xFF,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFF, 0x87,
  0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38,
  0x70, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x0F, 0xC3,
  0xFC, 0xFB, 0xBC, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF0, 0x3F, 0x06, 0xE0, 0xDC, 0x19, 0xE7, 0x3F, 0xE1, 0xFC, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x30, 0xFF, 0xF7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xF0,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xCE, 0xFB, 0xEF, 0x00, 0xE1, 0xF8, 0xFE, 0x3B, 0x9C, 0xE7,
  0x3B, 0x8E, 0xE3, 0xF0, 0xFC, 0x3F, 0x8F, 0xE3, 0xB8, 0xE7, 0x39, 0xCE,
  0x3B, 0x8E, 0xE1, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0xC1, 0xFD, 0x83, 0xFB, 0x07, 0xF6, 0x1F, 0xEE, 0x37,
  0xEC, 0x6F, 0xD9, 0xDF, 0xBB, 0xBF, 0x76, 0x7E, 0x6C, 0xFC, 0xF9, 0xF9,
  0xE3, 0xF3, 0xC7, 0xE3, 0x8F, 0xC7, 0x1C, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x3F, 0x87, 0xB0, 0xF7, 0x1E, 0x63, 0xCE, 0x7D, 0xCF, 0x9D, 0xF3, 0xBE,
  0x37, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1C, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x0E, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0xFC,
  0x7F, 0xBF, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xFF, 0xBF, 0x9C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x0E, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8,
  0xEE, 0x3B, 0x8E, 0xFF, 0x3F, 0x8F, 0xE3, 0xB8, 0xE7, 0x39, 0xCE, 0x7B,
  0x8E, 0xE3, 0xB8, 0x70, 0x3F, 0x3F, 0xFF, 0xDC, 0x2E, 0x07, 0x03, 0x80,
  0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x1D, 0xDE, 0xFF, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0x7F, 0x8F, 0xC0, 0xE0,
  0x7E, 0x07, 0x60, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x0C, 0x39,
  0xC3, 0x9C, 0x19, 0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0xE0, 0xE0, 0xFC, 0x1C, 0x3B, 0x87, 0x87, 0x30, 0xF0, 0xE7,
  0x1E, 0x1C, 0xE3, 0xE3, 0x9C, 0x7C, 0xE3, 0x9D, 0x9C, 0x33, 0xB3, 0x86,
  0x66, 0x70, 0xEC, 0xCE, 0x1D, 0x9F, 0x83, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0xC1, 0xC0, 0xF0, 0xEE, 0x39,
  0xC7, 0x1C, 0xC3, 0xB8, 0x37, 0x07, 0xC0, 0xF8, 0x0E, 0x01, 0xE0, 0x7C,
  0x0F, 0x83, 0xB8, 0x77, 0x0E, 0x73, 0x8E, 0x71, 0xDC, 0x1C, 0xE0, 0xFC,
  0x1D, 0xC7, 0x38, 0xE3, 0x18, 0x77, 0x0E, 0xE0, 0xD8, 0x1F, 0x03, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x7F,
  0xBF, 0xDF, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x06,
  0x00, 0x70, 0x0F, 0x00, 0xF8, 0x1D, 0x81, 0x9C, 0x39, 0xC3, 0x8C, 0x70,
  0xE7, 0x06, 0xE0, 0x70, 0xFF, 0xFF, 0xFC, 0xF3, 0x8E, 0x30, 0x1E, 0x3F,
  0x9D, 0xC0, 0x70, 0x38, 0x1D, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0xFF,
  0xFB, 0xDC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x39, 0x8E, 0xFB, 0xFE,
  0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xF3, 0xFF,
  0xEE, 0xF0, 0x1E, 0x3F, 0x7E, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x71, 0x7F, 0x3E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC6, 0x77,
  0xDD, 0xFF, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F,
  0x73, 0xDF, 0xF3, 0xDC, 0x1C, 0x1F, 0x9D, 0xDC, 0x7E, 0x3F, 0x0F, 0xFF,
  0xFF, 0xE0, 0x70, 0x38, 0x0E, 0x17, 0xF9, 0xF8, 0x1F, 0x3E, 0x3A, 0x38,
  0x38, 0x3E, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x19, 0xDF, 0x77, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x3D, 0xCF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x03,
  0x99, 0xE7, 0xF1, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x39, 0xCE,
  0xFB, 0xFE, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1C, 0x7F, 0xA1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x19, 0xCE, 0x20, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xFF, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F, 0x1D,
  0x8E, 0xCE, 0x66, 0x37, 0x1F, 0x8F, 0xC7, 0x73, 0x39, 0x8E, 0xC7, 0x61,
  0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7, 0x1C,
  0xEF, 0xBE, 0xFF, 0xFE, 0xF3, 0xCF, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0x87,
  0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87,
  0xE1, 0x87, 0xE7, 0x3B, 0xEF, 0xFB, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x1E, 0x0F, 0xC7, 0xFB,
  0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x19, 0xCE, 0x7F,
  0x0F, 0x80, 0xE6, 0x3B, 0xEF, 0xFB, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7F, 0x1F, 0xEF, 0xFF, 0xBB, 0xCE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x19, 0xDF, 0x77, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x3D, 0xCF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0xE7, 0xDF, 0xFF, 0xCF, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x3D, 0xFF, 0xFE, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x7F, 0xFF, 0x80, 0x10, 0x60, 0xC1, 0xFF, 0xFF, 0xCC,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x9F, 0x1E, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x3D, 0xDF,
  0x7F, 0xCF, 0x70, 0xE1, 0xF8, 0x76, 0x1D, 0xC7, 0x73, 0x9C, 0xE3, 0x38,
  0xEC, 0x3B, 0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x03, 0x80, 0xE1, 0xC7, 0xE3,
  0xC7, 0x63, 0xC7, 0x73, 0xC6, 0x73, 0xC6, 0x73, 0x6E, 0x77, 0x6E, 0x36,
  0x6E, 0x36, 0x6C, 0x3E, 0x6C, 0x3E, 0x7C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C,
  0x38, 0xE1, 0xDC, 0xE7, 0x38, 0xEC, 0x3F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0xC3, 0xF1, 0xCE, 0x73, 0xB8, 0x70, 0xE1, 0xF8, 0x76, 0x1D, 0xC7,
  0x73, 0x8C, 0xE3, 0x38, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x1F, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xF8, 0xE1,
  0xC7, 0x0E, 0x1C, 0x70, 0xE3, 0x87, 0x0F, 0xFF, 0xC0, 0x0E, 0x3C, 0xF1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF3, 0xC7, 0x87, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xE1, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE1, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0x78, 0xF3, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xCF, 0x1C, 0x00, 0x60,
  0x7F, 0x3F, 0xFE, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 18, 6, 1, -18 },
  { 10, 8, 7, 10, 1, -18 },
  { 17, 11, 18, 12, 1, -18 },
  { 42, 9, 20, 11, 1, -19 },
  { 65, 16, 18, 18, 1, -18 },
  { 101, 12, 18, 13, 1, -18 },
  { 128, 3, 7, 6, 1, -18 },
  { 131, 6, 22, 8, 1, -18 },
  { 148, 6, 22, 8, 0, -18 },
  { 165, 9, 9, 11, 1, -19 },
  { 176, 10, 12, 11, 1, -15 },
  { 191, 4, 6, 6, 1, -3 },
  { 194, 6, 3, 7, 1, -8 },
  { 197, 4, 4, 6, 1, -4 },
  { 199, 10, 18, 10, 0, -18 },
  { 222, 9, 18, 11, 1, -18 },
  { 243, 7, 18, 11, 1, -18 },
  { 259, 9, 18, 11, 1, -18 },
  { 280, 9, 18, 11, 1, -18 },
  { 301, 11, 18, 11, 0, -18 },
  { 326, 9, 18, 11, 1, -18 },
  { 347, 9, 18, 11, 1, -18 },
  { 368, 9, 18, 11, 1, -18 },
  { 389, 9, 18, 11, 1, -18 },
  { 410, 9, 18, 11, 1, -18 },
  { 431, 4, 14, 6, 1, -14 },
  { 438, 4, 17, 6, 1, -14 },
  { 447, 10, 12, 11, 1, -15 },
  { 462, 10, 7, 11, 1, -12 },
  { 471, 10, 12, 11, 1, -15 },
  { 486, 8, 18, 9, 0, -18 },
  { 504, 15, 20, 17, 1, -18 },
  { 542, 12, 18, 12, 0, -18 },
  { 569, 10, 18, 13, 2, -18 },
  { 592, 10, 18, 12, 1, -18 },
  { 615, 10, 18, 14, 2, -18 },
  { 638, 7, 18, 11, 2, -18 },
  { 654, 7, 18, 10, 2, -18 },
  { 670, 11, 18, 14, 1, -18 },
  { 695, 10, 18, 14, 2, -18 },
  { 718, 6, 18, 8, 1, -18 },
  { 732, 6, 23, 6, -1, -18 },
  { 750, 10, 18, 12, 2, -18 },
  { 773, 7, 18, 10, 2, -18 },
  { 789, 15, 18, 19, 2, -18 },
  { 823, 11, 18, 15, 2, -18 },
  { 848, 12, 18, 14, 1, -18 },
  { 875, 9, 18, 12, 2, -18 },
  { 896, 12, 22, 14, 1, -18 },
  { 929, 10, 18, 12, 2, -18 },
  { 952, 9, 18, 10, 1, -18 },
  { 973, 10, 18, 10, 0, -18 },
  { 996, 10, 18, 14, 2, -18 },
  { 1019, 12, 18, 12, 0, -18 },
  { 1046, 19, 18, 18, 0, -18 },
  { 1089, 11, 18, 11, 0, -18 },
  { 1114, 11, 18, 11, 0, -18 },
  { 1139, 9, 18, 10, 0, -18 },
  { 1160, 5, 22, 8, 2, -18 },
  { 1174, 10, 18, 10, 0, -18 },
  { 1197, 5, 22, 8, 1, -18 },
  { 1211, 12, 11, 12, 0, -18 },
  { 1228, 11, 2, 10, 0, 2 },
  { 1231, 5, 4, 7, 1, -19 },
  { 1234, 9, 14, 11, 1, -14 },
  { 1250, 10, 19, 12, 1, -19 },
  { 1274, 8, 14, 10, 1, -14 },
  { 1288, 10, 19, 12, 1, -19 },
  { 1312, 9, 14, 11, 1, -14 },
  { 1328, 8, 19, 7, 0, -19 },
  { 1347, 10, 20, 12, 1, -14 },
  { 1372, 10, 19, 12, 1, -19 },
  { 1396, 3, 19, 6, 1, -19 },
  { 1404, 5, 25, 6, -1, -19 },
  { 1420, 9, 19, 11, 2, -19 },
  { 1442, 3, 19, 6, 1, -19 },
  { 1450, 16, 14, 18, 1, -14 },
  { 1478, 10, 14, 12, 1, -14 },
  { 1496, 10, 14, 12, 1, -14 },
  { 1514, 10, 20, 12, 1, -14 },
  { 1539, 10, 20, 12, 1, -14 },
  { 1564, 7, 14, 8, 1, -14 },
  { 1577, 7, 14, 9, 1, -14 },
  { 1590, 7, 17, 8, 0, -17 },
  { 1605, 10, 14, 12, 1, -14 },
  { 1623, 10, 14, 10, 0, -14 },
  { 1641, 16, 14, 16, 0, -14 },
  { 1669, 10, 14, 10, 0, -14 },
  { 1687, 10, 20, 10, 0, -14 },
  { 1712, 7, 14, 8, 1, -14 },
  { 1725, 7, 22, 9, 1, -18 },
  { 1745, 3, 25, 11, 4, -19 },
  { 1755, 7, 22, 9, 1, -18 },
  { 1775, 10, 4, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD25PT7B_H_
