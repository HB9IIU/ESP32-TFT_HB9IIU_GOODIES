#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73,
  0x80, 0x00, 0x3B, 0xFF, 0xFB, 0xC0, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xF0, 0xEF, 0x0E, 0xF0, 0xE0, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x3C, 0x0E, 0x38, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x70,
  0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0xC3, 0xFF, 0xBF, 0xFB, 0xE9, 0xDE,
  0x42, 0xE2, 0x07, 0x10, 0x3C, 0x81, 0xF4, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x17, 0xC0, 0x9E, 0x04, 0xF0, 0x27, 0xC1, 0x3F,
  0x8B, 0xFF, 0xFE, 0xFF, 0xE1, 0xFC, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x1F, 0xE0, 0x70, 0x0E, 0x70,
  0x38, 0x07, 0x3C, 0x3C, 0x07, 0x8E, 0x1C, 0x03, 0xC7, 0x0E, 0x01, 0xE3,
  0x8E, 0x00, 0xF1, 0xC7, 0x00, 0x78, 0xE7, 0x80, 0x3C, 0x73, 0x80, 0x1E,
  0x39, 0xCF, 0x87, 0x3D, 0xEF, 0xE3, 0x9C, 0xE7, 0xF9, 0xFE, 0x73, 0x9C,
  0x7E, 0x73, 0xCE, 0x0E, 0x39, 0xC7, 0x80, 0x3C, 0xE3, 0xC0, 0x1C, 0x71,
  0xE0, 0x0E, 0x38, 0xF0, 0x0F, 0x1C, 0x78, 0x07, 0x0E, 0x3C, 0x03, 0x87,
  0x9C, 0x03, 0x81, 0xCE, 0x01, 0xC0, 0xFF, 0x01, 0xE0, 0x3F, 0x00, 0xE0,
  0x1F, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xF1, 0xF3, 0xFF, 0x3C, 0x79, 0xE7, 0x9F, 0x3E, 0xF3, 0xC3, 0xFE, 0x78,
  0x3F, 0x8F, 0x07, 0xF1, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFE, 0xF0, 0x7F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xC1,
  0xE0, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x11, 0xC2, 0x77,
  0x7B, 0xFF, 0xEF, 0xFF, 0xC3, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xCF, 0x1F,
  0x3E, 0x18, 0x60, 0x21, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x3F, 0x81, 0xFF,
  0x0F, 0xFC, 0x3C, 0xF9, 0xE1, 0xE7, 0x87, 0xDE, 0x0F, 0x78, 0x3D, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x7D, 0xE1, 0xE7, 0xC7, 0x8F,
  0xBE, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x7F,
  0x3F, 0xDF, 0xFF, 0xBD, 0xCF, 0x23, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0x70,
  0xF8, 0x81, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x70,
  0xF8, 0x81, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFC, 0x7E, 0xFF, 0xFB,
  0xFF, 0xC7, 0xFC, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0E, 0xF0, 0x1D, 0xE0, 0x73,
  0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xF1,
  0xC1, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xB8, 0x3F,
  0xF1, 0xFF, 0xCF, 0xFF, 0x20, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x7B, 0xCF, 0xDF, 0xFC, 0xFF, 0xC7,
  0xFC, 0x00, 0x00, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x3E, 0x3D, 0xFC, 0xF7,
  0xFB, 0xFF, 0xEF, 0xC7, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xDE,
  0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xC7, 0xCF, 0xBE, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7D, 0xE0, 0xF7, 0x83,
  0xDE, 0x0F, 0x78, 0x3D, 0xF1, 0xE3, 0xEF, 0x87, 0xFC, 0x1F, 0xE0, 0x3F,
  0x01, 0xFF, 0x0F, 0xFE, 0x7C, 0x79, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x83, 0xDF, 0x1F, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x7C, 0xF9, 0xE1, 0xEF, 0x87,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7D, 0xF3,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xBC, 0x18, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x10, 0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFE,
  0xF0, 0x3D, 0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9C, 0xF0, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x0F, 0x07, 0xFC, 0xFF, 0xE7,
  0xFF, 0x61, 0xF4, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0xF8, 0x1E,
  0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x9E, 0x0F, 0x0E, 0x70, 0xFF,
  0x3F, 0xC7, 0xFC, 0x7E, 0x1C, 0x71, 0xF8, 0xF1, 0xC7, 0xE3, 0x87, 0x1F,
  0x8E, 0x3C, 0x7E, 0x38, 0xF1, 0xF8, 0xE3, 0xC7, 0xE3, 0x8F, 0x1F, 0x8E,
  0x3C, 0x7E, 0x38, 0xF1, 0xF8, 0xF7, 0xCE, 0xE3, 0xFB, 0xFB, 0x87, 0xEF,
  0xCF, 0x0E, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x18, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x3E, 0x7C, 0x07, 0x9F, 0x01,
  0xE7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xF0, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7B, 0xC1, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xEF, 0x0F,
  0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x01, 0xF0, 0x3F, 0xF1,
  0xFF, 0xCF, 0xFF, 0x3E, 0x09, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0,
  0x4F, 0xEF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xE7, 0x9F, 0xCF, 0x07, 0xDE, 0x0F, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x07, 0xDE,
  0x1F, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x06, 0x7E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x7E, 0x0F, 0x3F, 0x9F, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFE, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3C, 0xFF, 0xFF, 0xDF, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xFC, 0xFB, 0xFD, 0xFC, 0xFC, 0x10,
  0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xF7, 0x87, 0xCF, 0x0F, 0x1E, 0x3E,
  0x3C, 0x78, 0x79, 0xF0, 0xF7, 0xC1, 0xEF, 0x83, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7D, 0xF0, 0xF3, 0xE1, 0xE3, 0xC3, 0xC7,
  0xC7, 0x87, 0x8F, 0x0F, 0x9E, 0x0F, 0x3C, 0x1F, 0x78, 0x3E, 0xF0, 0x3F,
  0xE0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xB8, 0x07, 0xFE, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xBF, 0xDC, 0x0E, 0xFF, 0x70, 0x7B, 0xFD, 0xE1, 0xCF, 0xF7,
  0x87, 0x3F, 0xCE, 0x3C, 0xFF, 0x3C, 0xF3, 0xFC, 0xF3, 0x8F, 0xF3, 0xCE,
  0x3F, 0xC7, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFC, 0x3F,
  0xC3, 0xF0, 0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xF0, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xBC, 0x1F, 0xDE, 0x0F, 0xFF, 0x87, 0xFB, 0xC3, 0xFD,
  0xE1, 0xFE, 0x78, 0xFF, 0x3C, 0x7F, 0x8F, 0x3F, 0xC7, 0x9F, 0xE3, 0xEF,
  0xF0, 0xF7, 0xF8, 0x7B, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F, 0x07, 0xC7,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x03, 0xE7,
  0xC1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0xC7, 0xFF, 0x3F, 0xFD, 0xE7, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x3F, 0x7F, 0xFB, 0xFF, 0x9F,
  0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F, 0x07, 0xC7, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x80,
  0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0xC7, 0x9F, 0xCF, 0x0F, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0x8F, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F,
  0xF0, 0x79, 0xE0, 0xF3, 0xE1, 0xE3, 0xC3, 0xC7, 0xC7, 0x8F, 0x8F, 0x0F,
  0x1E, 0x1F, 0x3C, 0x1E, 0x78, 0x3E, 0xF0, 0x3D, 0xE0, 0x7C, 0x07, 0x80,
  0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xC7, 0x3C, 0x0B, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xFF,
  0xFE, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x1F, 0x7C, 0x1F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF0,
  0x07, 0xFE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCE, 0x00, 0x77, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xBC, 0x0F, 0x81, 0xF7,
  0x81, 0xF0, 0x3C, 0xF0, 0x3F, 0x07, 0x9E, 0x0F, 0xE0, 0xF3, 0xE1, 0xDC,
  0x1E, 0x3C, 0x3B, 0x87, 0xC7, 0x87, 0x70, 0xF0, 0xF0, 0xEF, 0x1E, 0x1E,
  0x3D, 0xE3, 0xC3, 0xC7, 0x9C, 0x78, 0x3C, 0xE3, 0x9F, 0x07, 0x9C, 0x73,
  0xC0, 0xF3, 0x8F, 0x78, 0x1E, 0xF1, 0xEF, 0x03, 0xDE, 0x1D, 0xE0, 0x3B,
  0x83, 0xBC, 0x07, 0xF0, 0x77, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x1F, 0x7C, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x3E,
  0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x78, 0x1E,
  0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E,
  0x1E, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE7, 0x80, 0x7B, 0xC0, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x3E, 0x1E, 0x0F, 0x07,
  0x1F, 0xE1, 0xFF, 0x8F, 0xFE, 0x21, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x1F, 0xF9, 0xFF, 0xDF, 0xDE, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF8, 0xFB, 0xFD, 0xDF, 0xEE, 0x7E, 0x70, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF3, 0xF1, 0xEF, 0xF3, 0xFF, 0xE7, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xBE,
  0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x3E, 0xFC, 0x7D, 0xFF, 0xF3, 0xDF, 0xC7,
  0x9F, 0x80, 0x0F, 0xF1, 0xFF, 0x3F, 0xF3, 0xE2, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7E, 0x33, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x1F,
  0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xE3, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF,
  0x07, 0xDE, 0x0F, 0xBC, 0x1F, 0x7C, 0x7E, 0x7F, 0xFC, 0xFF, 0x78, 0xFC,
  0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x1E, 0x78, 0x3D, 0xE0, 0xF7,
  0x83, 0xDE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x18, 0xFF, 0xE1, 0xFF, 0x83, 0xFC,
  0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xF2, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x7F, 0xCF, 0xFC, 0xFF, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB,
  0xE3, 0xF7, 0xC3, 0xEF, 0x07, 0xDE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDE, 0x0F, 0xBE, 0x1F,
  0x7E, 0x7E, 0x7F, 0xFC, 0xFF, 0x78, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x60, 0x7C, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x81, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0x3E, 0xF8, 0x7F,
  0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x77, 0xBF, 0xF7, 0x00, 0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x0E, 0x1E, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x3D, 0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C,
  0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xEF, 0x0F, 0x9E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x7C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF7,
  0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF1, 0xF9, 0xEF, 0xE7, 0xFB, 0xFF, 0xFF,
  0xF7, 0xE7, 0xF3, 0xEF, 0x87, 0xC3, 0xDF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F,
  0xF8, 0x3E, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0, 0xFF,
  0x83, 0xC1, 0xFF, 0x07, 0x83, 0xFE, 0x0F, 0x07, 0xFC, 0x1E, 0x0F, 0xF8,
  0x3C, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0, 0xFF, 0x83,
  0xC1, 0xF0, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0x3E, 0xF8, 0x7F, 0xE1,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC3, 0xCF, 0x07,
  0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3E, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7F, 0x00, 0xF3, 0xF1, 0xEF, 0xF3, 0xFF, 0xE7, 0xE3, 0xEF, 0x83,
  0xDF, 0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x3E, 0xFC, 0x7D, 0xFF,
  0xF3, 0xDF, 0xC7, 0x9F, 0x8F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1F, 0x9E,
  0x7F, 0xBC, 0xFF, 0xFB, 0xE3, 0xF7, 0xC3, 0xEF, 0x07, 0xDE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x07,
  0xDE, 0x0F, 0xBE, 0x1F, 0x7E, 0x7E, 0x7F, 0xFC, 0xFF, 0x78, 0xFC, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF3, 0xFD, 0xFF, 0x7F, 0xFF, 0xFC, 0x3E,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x3F, 0xCF, 0xFD, 0xFF, 0xFC, 0x2F,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x7F, 0xBF, 0xEF, 0xF9, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C,
  0x4F, 0xF3, 0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0x7C, 0xFD, 0xFF, 0xF7,
  0xFB, 0xCF, 0xCF, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83,
  0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0x38, 0xF0, 0x79, 0xC0,
  0xF7, 0x81, 0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x3E, 0x0F, 0x78, 0x7E, 0x1F, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x3C,
  0xF7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x1C,
  0xE7, 0x3C, 0x1E, 0xE7, 0x78, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3,
  0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x7C, 0x3C,
  0x78, 0xF8, 0xF9, 0xE0, 0xF7, 0xC1, 0xF0, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0,
  0xFB, 0xC1, 0xE7, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xC0, 0xF7, 0x80, 0xEF, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE1, 0xFC, 0x3F, 0x87, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x7C, 0x3F, 0x87, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFC, 0x1F, 0xC1,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x07,
  0xE1, 0xFC, 0x3F, 0x07, 0x80, 0x3C, 0x02, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 12, 9, 16, 2, -26 },
  { 32, 16, 26, 18, 1, -26 },
  { 84, 13, 30, 17, 2, -28 },
  { 133, 25, 27, 27, 1, -27 },
  { 218, 19, 27, 19, 1, -27 },
  { 283, 4, 9, 8, 2, -26 },
  { 288, 9, 33, 11, 2, -27 },
  { 326, 9, 33, 11, 1, -27 },
  { 364, 14, 14, 16, 1, -28 },
  { 389, 15, 18, 17, 1, -22 },
  { 423, 6, 9, 9, 1, -4 },
  { 430, 9, 4, 11, 1, -12 },
  { 435, 5, 5, 9, 2, -5 },
  { 439, 14, 27, 15, 0, -27 },
  { 487, 14, 27, 17, 1, -27 },
  { 535, 10, 26, 17, 2, -26 },
  { 568, 14, 27, 17, 1, -27 },
  { 616, 14, 27, 17, 1, -27 },
  { 664, 15, 27, 17, 1, -27 },
  { 715, 13, 26, 17, 2, -26 },
  { 758, 14, 27, 17, 1, -27 },
  { 806, 14, 26, 17, 1, -26 },
  { 852, 14, 27, 17, 1, -27 },
  { 900, 14, 27, 17, 1, -27 },
  { 948, 5, 20, 9, 2, -20 },
  { 961, 6, 25, 9, 1, -20 },
  { 980, 15, 17, 17, 1, -22 },
  { 1012, 15, 10, 17, 1, -18 },
  { 1031, 15, 17, 17, 1, -22 },
  { 1063, 12, 27, 13, 0, -27 },
  { 1104, 22, 30, 26, 2, -27 },
  { 1187, 18, 26, 18, 0, -26 },
  { 1246, 14, 26, 19, 3, -26 },
  { 1292, 14, 27, 17, 2, -27 },
  { 1340, 15, 26, 20, 3, -26 },
  { 1389, 11, 26, 16, 3, -26 },
  { 1425, 11, 26, 15, 3, -26 },
  { 1461, 16, 27, 21, 2, -27 },
  { 1515, 15, 26, 21, 3, -26 },
  { 1564, 9, 26, 11, 1, -26 },
  { 1594, 9, 34, 9, -2, -26 },
  { 1633, 15, 26, 18, 3, -26 },
  { 1682, 11, 26, 15, 3, -26 },
  { 1718, 22, 26, 28, 3, -26 },
  { 1790, 17, 26, 22, 3, -26 },
  { 1846, 18, 27, 21, 2, -27 },
  { 1907, 13, 26, 17, 3, -26 },
  { 1950, 18, 33, 21, 2, -27 },
  { 2025, 15, 26, 18, 3, -26 },
  { 2074, 13, 27, 16, 1, -27 },
  { 2118, 15, 26, 15, 0, -26 },
  { 2167, 16, 26, 20, 2, -26 },
  { 2219, 18, 26, 18, 0, -26 },
  { 2278, 27, 26, 27, 0, -26 },
  { 2366, 16, 26, 17, 0, -26 },
  { 2418, 16, 26, 16, 0, -26 },
  { 2470, 13, 26, 15, 1, -26 },
  { 2513, 9, 33, 12, 2, -27 },
  { 2551, 14, 27, 15, 0, -27 },
  { 2599, 8, 33, 12, 1, -27 },
  { 2632, 17, 15, 18, 1, -26 },
  { 2664, 16, 3, 16, 0, 3 },
  { 2670, 8, 6, 11, 1, -28 },
  { 2676, 13, 20, 17, 1, -20 },
  { 2709, 15, 28, 18, 2, -28 },
  { 2762, 12, 20, 14, 1, -20 },
  { 2792, 15, 28, 18, 1, -28 },
  { 2845, 14, 20, 16, 1, -20 },
  { 2880, 12, 28, 10, 0, -28 },
  { 2922, 15, 29, 18, 1, -20 },
  { 2977, 14, 28, 18, 2, -28 },
  { 3026, 5, 28, 9, 2, -28 },
  { 3044, 8, 37, 9, -1, -28 },
  { 3081, 15, 28, 17, 2, -28 },
  { 3134, 4, 28, 9, 2, -28 },
  { 3148, 23, 20, 27, 2, -20 },
  { 3206, 14, 20, 18, 2, -20 },
  { 3241, 15, 20, 17, 1, -20 },
  { 3279, 15, 29, 18, 2, -20 },
  { 3334, 15, 29, 18, 1, -20 },
  { 3389, 10, 20, 12, 2, -20 },
  { 3414, 11, 20, 13, 1, -20 },
  { 3442, 10, 24, 11, 1, -24 },
  { 3472, 14, 20, 18, 2, -20 },
  { 3507, 15, 20, 15, 0, -20 },
  { 3545, 24, 20, 24, 0, -20 },
  { 3605, 15, 20, 15, 0, -20 },
  { 3643, 15, 29, 15, 0, -20 },
  { 3698, 11, 20, 13, 1, -20 },
  { 3726, 11, 32, 13, 1, -26 },
  { 3770, 4, 37, 16, 6, -28 },
  { 3789, 11, 32, 13, 1, -26 },
  { 3833, 15, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD37PT7B_H_
