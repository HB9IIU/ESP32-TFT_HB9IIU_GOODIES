#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0xD0, 0x28, 0xA2, 0x9F, 0x51, 0x4F, 0x94, 0x50,
  0x23, 0xD8, 0xC7, 0x1C, 0xBF, 0x21, 0x00, 0x64, 0x64, 0x94, 0x98, 0x6B,
  0x6D, 0x15, 0x15, 0x23, 0x31, 0x45, 0x14, 0x61, 0xDD, 0xF6, 0x7C, 0xF0,
  0x5A, 0xAA, 0xB4, 0x89, 0x92, 0x49, 0x6B, 0x00, 0x27, 0xC8, 0xA0, 0x21,
  0x3E, 0x42, 0x10, 0x58, 0xE0, 0xC0, 0x18, 0x84, 0x42, 0x31, 0x08, 0xC0,
  0x33, 0x97, 0x9C, 0xE5, 0x6B, 0x70, 0x2E, 0x92, 0x49, 0x20, 0x37, 0xC6,
  0x31, 0x19, 0x88, 0xF8, 0x77, 0xC6, 0x26, 0x0C, 0x73, 0xF0, 0x11, 0x8C,
  0xA5, 0x2B, 0xE2, 0x10, 0xEE, 0x88, 0xE3, 0x3B, 0xE0, 0x3B, 0xD0, 0xAF,
  0xE7, 0x2B, 0x70, 0xFF, 0xC6, 0x21, 0x18, 0x84, 0x60, 0x32, 0xD2, 0xB3,
  0x2F, 0x39, 0x70, 0x23, 0xB7, 0x95, 0xB4, 0x62, 0x70, 0xC6, 0x50, 0x05,
  0xC0, 0x09, 0xB0, 0xC1, 0x84, 0xF8, 0x3F, 0xF0, 0x83, 0x06, 0x6C, 0x40,
  0x6F, 0x13, 0x24, 0x04, 0x60, 0x30, 0x9A, 0x15, 0xDA, 0xBD, 0x6E, 0xD2,
  0xC0, 0xF0, 0x30, 0xC3, 0x1E, 0x49, 0xE7, 0xB3, 0xCC, 0xE7, 0xA5, 0x2E,
  0x4A, 0x72, 0xF0, 0x3F, 0x88, 0x88, 0x8D, 0x70, 0xE7, 0xA7, 0x38, 0xCE,
  0x72, 0xE0, 0xFF, 0x88, 0xE8, 0x88, 0xF0, 0xFE, 0x4F, 0x24, 0x80, 0x37,
  0xE1, 0x0B, 0xDE, 0x39, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xED,
  0xB6, 0xDB, 0xE0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x9C, 0xAD, 0x4E, 0x72,
  0xD2, 0x98, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC7, 0x8F, 0x1F, 0x7A, 0xB5,
  0x6A, 0xD9, 0x92, 0xCE, 0x73, 0xDA, 0xDE, 0x73, 0x88, 0x77, 0xE3, 0x18,
  0xC6, 0x3B, 0x70, 0xCF, 0x99, 0xBE, 0x88, 0x80, 0x77, 0xE3, 0x18, 0xC6,
  0x3B, 0x70, 0x86, 0xC7, 0xA5, 0x2F, 0x72, 0xD2, 0x98, 0x3B, 0xB0, 0x87,
  0x08, 0x73, 0xF0, 0xFF, 0xC8, 0x42, 0x10, 0x84, 0x20, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x70, 0x8F, 0x34, 0x92, 0x59, 0x67, 0x0C, 0x30, 0x88, 0xE4,
  0xF6, 0x4A, 0xA5, 0x52, 0xA9, 0x5C, 0xEE, 0x26, 0x00, 0xCA, 0xD4, 0xE3,
  0x19, 0x4B, 0xC8, 0x8E, 0x56, 0xA3, 0x10, 0x84, 0x20, 0xF7, 0x84, 0x62,
  0x31, 0x18, 0xF8, 0xEA, 0xAA, 0xAC, 0x82, 0x10, 0xC2, 0x10, 0xC2, 0x18,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x20, 0xC3, 0x12, 0xCC, 0xF8, 0xC4, 0x32,
  0x86, 0xFD, 0xED, 0xA0, 0x88, 0xAF, 0x99, 0x99, 0xF0, 0x37, 0x4C, 0xC4,
  0x70, 0x08, 0x4A, 0xF4, 0xE7, 0x29, 0x78, 0x22, 0xD3, 0xF4, 0x21, 0xE0,
  0x74, 0x6E, 0x44, 0x44, 0x40, 0x2B, 0xD3, 0x9C, 0xA5, 0xE1, 0x5B, 0x80,
  0x88, 0xAF, 0x99, 0x99, 0x90, 0xFF, 0x80, 0x55, 0x55, 0x57, 0x88, 0x9B,
  0xAE, 0xAB, 0x90, 0xFF, 0x80, 0xA5, 0xFE, 0x4C, 0x99, 0x32, 0x64, 0x80,
  0xAF, 0x99, 0x99, 0x90, 0x33, 0xD3, 0x9C, 0xA5, 0xC0, 0xAF, 0x99, 0x99,
  0xF8, 0x88, 0x2B, 0xD3, 0x9C, 0xA5, 0xE1, 0x08, 0x40, 0xBE, 0x49, 0x20,
  0x6D, 0xC6, 0x39, 0xF0, 0x4F, 0xA4, 0x93, 0x99, 0x99, 0x9B, 0xF0, 0x8E,
  0xD4, 0xA5, 0x28, 0x80, 0x9B, 0xDB, 0x5A, 0x5A, 0x6A, 0x66, 0x64, 0xDA,
  0x9C, 0x47, 0x2B, 0x60, 0x8E, 0xD4, 0xA5, 0x38, 0x84, 0x66, 0x00, 0xFF,
  0x26, 0x44, 0xF0, 0x12, 0x66, 0x6C, 0x66, 0x62, 0x30, 0xFF, 0xF0, 0x86,
  0x66, 0x63, 0x26, 0x66, 0xC0, 0xFC, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 5, 10, 5, 0, -9 },
  { 19, 8, 9, 9, 0, -9 },
  { 28, 6, 9, 6, 0, -9 },
  { 35, 1, 4, 3, 1, -9 },
  { 36, 2, 11, 4, 1, -9 },
  { 39, 3, 11, 4, 0, -9 },
  { 44, 5, 4, 5, 0, -9 },
  { 47, 5, 6, 5, 0, -7 },
  { 51, 2, 3, 3, 0, -1 },
  { 52, 3, 1, 4, 0, -4 },
  { 53, 1, 2, 3, 1, -2 },
  { 54, 5, 9, 5, 0, -9 },
  { 60, 5, 9, 5, 0, -9 },
  { 66, 3, 9, 5, 1, -9 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 5, 9, 5, 0, -9 },
  { 82, 5, 9, 5, 0, -9 },
  { 88, 4, 9, 5, 1, -9 },
  { 93, 5, 9, 5, 0, -9 },
  { 99, 5, 9, 5, 0, -9 },
  { 105, 5, 9, 5, 0, -9 },
  { 111, 5, 9, 5, 0, -9 },
  { 117, 1, 7, 3, 1, -7 },
  { 118, 2, 9, 3, 0, -7 },
  { 121, 5, 6, 5, 0, -7 },
  { 125, 5, 4, 5, 0, -6 },
  { 128, 5, 6, 5, 0, -7 },
  { 132, 4, 9, 4, 0, -9 },
  { 137, 7, 10, 8, 1, -9 },
  { 146, 6, 9, 6, 0, -9 },
  { 153, 5, 9, 6, 1, -9 },
  { 159, 4, 9, 6, 1, -9 },
  { 164, 5, 9, 7, 1, -9 },
  { 170, 4, 9, 5, 1, -9 },
  { 175, 3, 9, 5, 1, -9 },
  { 179, 5, 9, 7, 1, -9 },
  { 185, 5, 9, 7, 1, -9 },
  { 191, 3, 9, 4, 0, -9 },
  { 195, 3, 11, 3, -1, -9 },
  { 200, 5, 9, 6, 1, -9 },
  { 206, 4, 9, 5, 1, -9 },
  { 211, 7, 9, 9, 1, -9 },
  { 219, 5, 9, 7, 1, -9 },
  { 225, 5, 9, 7, 1, -9 },
  { 231, 4, 9, 6, 1, -9 },
  { 236, 5, 11, 7, 1, -9 },
  { 243, 5, 9, 6, 1, -9 },
  { 249, 5, 9, 5, 0, -9 },
  { 255, 5, 9, 5, 0, -9 },
  { 261, 5, 9, 7, 1, -9 },
  { 267, 6, 9, 6, 0, -9 },
  { 274, 9, 9, 9, 0, -9 },
  { 285, 5, 9, 5, 0, -9 },
  { 291, 5, 9, 5, 0, -9 },
  { 297, 5, 9, 5, 0, -9 },
  { 303, 2, 11, 4, 1, -9 },
  { 306, 5, 9, 5, 0, -9 },
  { 312, 3, 11, 4, 0, -9 },
  { 317, 6, 5, 6, 0, -9 },
  { 321, 5, 1, 5, 0, 1 },
  { 322, 3, 2, 4, 0, -9 },
  { 323, 5, 7, 5, 0, -7 },
  { 328, 4, 9, 6, 1, -9 },
  { 333, 4, 7, 5, 0, -7 },
  { 337, 5, 9, 6, 0, -9 },
  { 343, 5, 7, 5, 0, -7 },
  { 348, 4, 9, 3, 0, -9 },
  { 353, 5, 10, 6, 0, -7 },
  { 360, 4, 9, 6, 1, -9 },
  { 365, 1, 9, 3, 1, -9 },
  { 367, 2, 12, 3, 0, -9 },
  { 370, 4, 9, 5, 1, -9 },
  { 375, 1, 9, 3, 1, -9 },
  { 377, 7, 7, 9, 1, -7 },
  { 384, 4, 7, 6, 1, -7 },
  { 388, 5, 7, 6, 0, -7 },
  { 393, 4, 10, 6, 1, -7 },
  { 398, 5, 10, 6, 0, -7 },
  { 405, 3, 7, 4, 1, -7 },
  { 408, 4, 7, 4, 0, -7 },
  { 412, 3, 8, 4, 0, -8 },
  { 415, 4, 7, 6, 1, -7 },
  { 419, 5, 7, 5, 0, -7 },
  { 424, 8, 7, 8, 0, -7 },
  { 431, 5, 7, 5, 0, -7 },
  { 436, 5, 10, 5, 0, -7 },
  { 443, 4, 7, 4, 0, -7 },
  { 447, 4, 11, 4, 0, -9 },
  { 453, 1, 12, 5, 2, -9 },
  { 455, 4, 11, 4, 0, -9 },
  { 461, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD12PT7B_H_
