#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x07, 0x7F, 0xFF, 0xF0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x77, 0x8E, 0xF1, 0xC0, 0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0,
  0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFC, 0x31, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xC1,
  0xFF, 0x9F, 0xFD, 0xFF, 0xCF, 0x62, 0x73, 0x03, 0x98, 0x1E, 0xC0, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x1B, 0xC0, 0xCE,
  0x06, 0x78, 0x33, 0xF1, 0xBF, 0xFF, 0xDF, 0xFC, 0x3F, 0xC0, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x3E, 0x01, 0xC0, 0xFE, 0x07, 0x01, 0xFE,
  0x0E, 0x03, 0x9C, 0x1C, 0x0E, 0x38, 0x70, 0x1C, 0x70, 0xE0, 0x38, 0xE3,
  0xC0, 0x71, 0xC7, 0x00, 0xE3, 0x8E, 0x01, 0xC7, 0x38, 0x03, 0x8E, 0x73,
  0xE3, 0x9C, 0xEF, 0xE7, 0xFB, 0x9F, 0xE7, 0xE7, 0x39, 0xCF, 0x9E, 0xE3,
  0x80, 0x39, 0xC7, 0x00, 0x73, 0x8E, 0x01, 0xC7, 0x1C, 0x03, 0x8E, 0x38,
  0x07, 0x1C, 0x70, 0x1C, 0x38, 0xE0, 0x38, 0x39, 0xC0, 0xF0, 0x7F, 0x81,
  0xC0, 0x7E, 0x03, 0x80, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0x9E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x7B, 0xFE, 0x7D, 0xEF,
  0x3D, 0xE3, 0xDE, 0xF1, 0xEF, 0x78, 0x7F, 0x3C, 0x1F, 0x9E, 0x0F, 0x8F,
  0x87, 0xC7, 0xE7, 0xF1, 0xFF, 0xFC, 0xFF, 0xDE, 0x1F, 0xC7, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x0E, 0x1C, 0x3C, 0x3C, 0x38, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x06, 0x73, 0x7F, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0x80, 0xEE, 0x0F, 0x78,
  0xF1, 0xE1, 0x8C, 0x04, 0x40, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3D,
  0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xE0, 0xFF, 0xFF, 0xFF, 0x77, 0xBF, 0xFF,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0x79,
  0xE7, 0x8F, 0x3C, 0x3D, 0xE1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC3, 0xDE,
  0x1E, 0xF0, 0xF7, 0x8F, 0x1E, 0x78, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x03,
  0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDE, 0xFF, 0x3D, 0x8F, 0x23, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC,
  0xF3, 0xE2, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFF, 0x3F, 0xFC, 0xE1, 0xE2, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x87, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xF8, 0x07,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x6F, 0x03, 0xBC, 0x0C, 0xF0, 0x73, 0xC1, 0xCF,
  0x0E, 0x3C, 0x38, 0xF1, 0xC3, 0xC7, 0x0F, 0x38, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xF0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xFC, 0x3E, 0xFF, 0xEF,
  0xFC, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x87, 0xFC, 0x7E, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x9F, 0x3D, 0xFD, 0xFF, 0xEF, 0xCF,
  0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xDC, 0x1E, 0xF0, 0xF7,
  0x87, 0xBE, 0x7C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x3E, 0x78,
  0x79, 0xC1, 0xE7, 0x07, 0x9E, 0x1E, 0x78, 0xF0, 0xF7, 0xC3, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x87, 0xDF, 0x1E, 0x1E, 0xF0, 0x7B, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF9, 0xE7, 0x8F, 0x78, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7, 0xCF, 0xBF, 0xDC, 0xFE,
  0xE3, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1F, 0x01, 0xF1,
  0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xDF, 0xFF, 0xFC, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x7D, 0xE7, 0x9E, 0x79, 0xCF, 0x38, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x80, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x0F,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x3F, 0x8F, 0xFC, 0x7F, 0xE7, 0x1E, 0x41,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x7C, 0x7C, 0x03, 0xC0, 0x38, 0x1E, 0x00, 0x70, 0xF0, 0x01, 0xC3,
  0x81, 0xC3, 0x8E, 0x1F, 0xCE, 0x70, 0xFF, 0x19, 0xC7, 0x1C, 0x77, 0x1C,
  0x71, 0xDC, 0xF1, 0xC7, 0x73, 0x87, 0x1D, 0x8E, 0x1C, 0x7E, 0x38, 0x71,
  0xFC, 0xE3, 0xC7, 0x73, 0x8F, 0x19, 0xC7, 0x3C, 0xE7, 0x1F, 0xBF, 0x9C,
  0x7E, 0xFC, 0x70, 0xF1, 0xE0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x38, 0x07, 0x9E, 0x03, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC,
  0x7E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xEF,
  0xFF, 0xBF, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0x8F, 0x8E, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xFC, 0xE3, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF,
  0x07, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF9, 0xF8, 0x77, 0xC0, 0x2F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0xC1, 0xE7, 0xC3,
  0xCF, 0xFF, 0x8F, 0xFF, 0x07, 0xFC, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xFF, 0xFF, 0xDF, 0xC7, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFE, 0xFC, 0xF8, 0x1F, 0xF0, 0x7B, 0xE1, 0xF7,
  0xC3, 0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xC1, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7C, 0xF0,
  0xF9, 0xE1, 0xF1, 0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x87, 0x9F, 0x0F, 0xBE,
  0x0F, 0x7C, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFD,
  0xC0, 0xFF, 0xF7, 0x03, 0xBF, 0xDE, 0x0E, 0xFF, 0x38, 0x7B, 0xFC, 0xE1,
  0xCF, 0xF3, 0x87, 0x3F, 0xCF, 0x3C, 0xFF, 0x1C, 0xF3, 0xFC, 0x73, 0x8F,
  0xF1, 0xCE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0,
  0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78,
  0x3C, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xEE, 0x0F, 0xF7, 0x87, 0xFB, 0xC3, 0xFC, 0xF1,
  0xFE, 0x78, 0xFF, 0x1E, 0x7F, 0x8F, 0x3F, 0xC3, 0x9F, 0xE1, 0xEF, 0xF0,
  0xF7, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x0F, 0xCF, 0xC7, 0xC1, 0xE7, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBE, 0x03, 0xCF,
  0x03, 0xE7, 0xC1, 0xE3, 0xF3, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0x7F, 0xFB,
  0xFF, 0x9F, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xCF, 0xC7, 0xC1, 0xE7, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBE, 0x03, 0xCF, 0x03,
  0xE7, 0xC1, 0xE3, 0xF3, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0x9E, 0x0F, 0x3C,
  0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x8F, 0xCF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0xC7,
  0x87, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1F, 0x78, 0x1E, 0xF0, 0x3E, 0x1F,
  0xE3, 0xFF, 0x7F, 0xF7, 0xFF, 0x78, 0x2F, 0x80, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0xBF, 0xFF, 0xEF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x83,
  0xEF, 0x8F, 0x8F, 0xFF, 0x1F, 0xFC, 0x0F, 0xF0, 0xF0, 0x07, 0xF8, 0x03,
  0xDC, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x78, 0xE0, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x0F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x79,
  0xC0, 0xF8, 0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF0,
  0x79, 0xE0, 0xFC, 0x3C, 0x38, 0x7F, 0x0F, 0x0F, 0x1D, 0xE3, 0xC3, 0xC7,
  0x78, 0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x9F, 0x07, 0x3C, 0xE7, 0x81,
  0xEF, 0x3D, 0xE0, 0x7B, 0x8F, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xB8, 0x77,
  0x80, 0xEE, 0x1D, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0,
  0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E,
  0xF8, 0x1F, 0xF0, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x38, 0x38, 0x3C, 0x78,
  0x1C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x7C, 0x3C, 0x1E, 0x0E, 0x07, 0x1F, 0xC3, 0xFF, 0x0F, 0xFC, 0x61, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0xFF, 0x3F, 0xFB, 0xFF, 0xDE, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0x1F, 0x7F, 0xFB, 0xFB, 0xCF, 0x8E,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0x3E, 0x3E, 0xF8, 0x7B, 0xC1,
  0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC1, 0xEF, 0x87, 0xBE, 0x3E, 0xFF, 0xF3, 0xFF, 0xCE, 0x7E, 0x00,
  0x0F, 0xF1, 0xFE, 0x3F, 0xE7, 0xC2, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC2,
  0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1F, 0x3C, 0xFE, 0xF3, 0xFF,
  0xDF, 0x3F, 0x78, 0x7D, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xE0, 0xF7, 0x87, 0xDF, 0x1F, 0x3F,
  0xFC, 0xFF, 0xF1, 0xF9, 0xC0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7,
  0x87, 0xB8, 0x3D, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x82, 0x3F, 0xF0, 0xFF, 0x83, 0xFC,
  0x03, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x7F,
  0xDF, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x1F, 0x9C, 0xFE, 0xF3, 0xFF, 0xDF, 0x3F, 0x78, 0x7D, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3D, 0xE0, 0xF7, 0x87, 0xDF, 0x3F, 0x3F, 0xFC, 0xFE, 0xF1, 0xF3, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x98, 0x3E, 0x7F, 0xF9, 0xFF, 0xC3,
  0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF7, 0xE7, 0xFF, 0xBF, 0xFD, 0xF9, 0xFF, 0x87, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x3C, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0xFF, 0xFD, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F,
  0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xFC, 0x3E, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xE3, 0xE7, 0x7F, 0xBF,
  0xBF, 0xFF, 0xFF, 0xF1, 0xF9, 0xFF, 0x8F, 0x87, 0xF8, 0x3C, 0x3F, 0xC1,
  0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x1E, 0x1F,
  0xE0, 0xF0, 0xFF, 0x07, 0x87, 0xF8, 0x3C, 0x3F, 0xC1, 0xE1, 0xFE, 0x0F,
  0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x1E, 0x1E, 0xE7, 0xE7, 0x7F,
  0xBF, 0xFD, 0xF9, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1E, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78,
  0x79, 0xE0, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x87, 0x9F, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0xE3, 0xE3, 0xDF, 0xCF, 0xFF, 0x3E, 0x3E, 0xF8, 0x7B, 0xC1,
  0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC1, 0xEF, 0x87, 0xBF, 0x3E, 0xFF, 0xF3, 0xDF, 0xCF, 0x3E, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x1F, 0x9C, 0xFE, 0xF3, 0xFF, 0xDF, 0x3F, 0x78, 0x7D, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3D, 0xE0, 0xF7, 0x87, 0xDF, 0x3F, 0x3F, 0xFC, 0xFE, 0xF1, 0xF3, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0xE3, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x3F, 0x8F, 0xFB, 0xFF, 0x78, 0x6F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x1E, 0xFF, 0xDF,
  0xF1, 0xFC, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0xFF, 0xFF, 0xFC,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF9, 0x1F, 0xC7, 0xF0, 0xFC, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0x3F, 0x7F, 0xFB,
  0xFF, 0xCF, 0xCE, 0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x78,
  0xE1, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0x73, 0xC1, 0xCF, 0x07, 0xB8,
  0x1E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x7C, 0x1E, 0xE0, 0xF8, 0x79, 0xE1, 0xF0, 0xF3, 0xC3, 0xE1,
  0xE7, 0x8E, 0xC3, 0xCF, 0x1D, 0xC7, 0x0E, 0x3B, 0x9E, 0x1E, 0x77, 0x3C,
  0x3C, 0xCE, 0x78, 0x7B, 0x9C, 0xE0, 0x77, 0x19, 0xC0, 0xEE, 0x3F, 0x81,
  0xDC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x7D, 0xE1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x1C, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xCF, 0x0F, 0x3C,
  0x78, 0x79, 0xE1, 0xEF, 0x83, 0xC0, 0xF0, 0x3D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x1C, 0xF0, 0x73, 0xC1,
  0xEF, 0x07, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC3, 0xF0, 0xFC, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x1F, 0x8F,
  0xC3, 0xC0, 0xFC, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x3F, 0x0F, 0xC1, 0xF0, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0x0F, 0xE3, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x7F, 0x0F, 0xC1, 0xF0, 0x30, 0x00, 0x3C, 0x07, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 11, 9, 15, 2, -25 },
  { 30, 15, 25, 17, 1, -25 },
  { 77, 13, 29, 16, 1, -27 },
  { 125, 23, 25, 26, 1, -25 },
  { 197, 17, 25, 18, 1, -25 },
  { 251, 4, 9, 8, 2, -25 },
  { 256, 8, 31, 11, 2, -25 },
  { 287, 8, 31, 11, 1, -25 },
  { 318, 13, 14, 15, 1, -27 },
  { 341, 14, 17, 16, 1, -21 },
  { 371, 6, 9, 8, 1, -4 },
  { 378, 8, 3, 10, 1, -11 },
  { 381, 5, 5, 9, 2, -5 },
  { 385, 13, 25, 14, 0, -25 },
  { 426, 13, 25, 16, 1, -25 },
  { 467, 10, 25, 16, 2, -25 },
  { 499, 13, 25, 16, 1, -25 },
  { 540, 13, 25, 16, 1, -25 },
  { 581, 14, 25, 16, 1, -25 },
  { 625, 12, 25, 16, 2, -25 },
  { 663, 13, 25, 16, 1, -25 },
  { 704, 14, 25, 16, 1, -25 },
  { 748, 14, 25, 16, 1, -25 },
  { 792, 13, 25, 16, 1, -25 },
  { 833, 5, 19, 9, 2, -19 },
  { 845, 6, 24, 9, 1, -19 },
  { 863, 14, 17, 16, 1, -21 },
  { 893, 14, 10, 16, 1, -17 },
  { 911, 14, 17, 16, 1, -21 },
  { 941, 12, 25, 12, 0, -25 },
  { 979, 22, 28, 24, 1, -25 },
  { 1056, 17, 25, 17, 0, -25 },
  { 1110, 14, 25, 18, 2, -25 },
  { 1154, 14, 25, 16, 2, -25 },
  { 1198, 15, 25, 19, 2, -25 },
  { 1245, 11, 25, 15, 2, -25 },
  { 1280, 11, 25, 14, 2, -25 },
  { 1315, 15, 25, 19, 2, -25 },
  { 1362, 15, 25, 20, 2, -25 },
  { 1409, 9, 25, 11, 1, -25 },
  { 1438, 8, 32, 9, -2, -25 },
  { 1470, 15, 25, 17, 2, -25 },
  { 1517, 11, 25, 14, 2, -25 },
  { 1552, 22, 25, 26, 2, -25 },
  { 1621, 17, 25, 21, 2, -25 },
  { 1675, 17, 25, 20, 2, -25 },
  { 1729, 13, 25, 17, 2, -25 },
  { 1770, 17, 31, 20, 2, -25 },
  { 1836, 15, 25, 17, 2, -25 },
  { 1883, 12, 25, 15, 1, -25 },
  { 1921, 14, 25, 14, 0, -25 },
  { 1965, 15, 25, 19, 2, -25 },
  { 2012, 17, 25, 17, 0, -25 },
  { 2066, 26, 25, 26, 0, -25 },
  { 2148, 16, 25, 16, 0, -25 },
  { 2198, 16, 25, 16, 0, -25 },
  { 2248, 12, 25, 14, 1, -25 },
  { 2286, 8, 31, 11, 2, -25 },
  { 2317, 13, 25, 14, 0, -25 },
  { 2358, 8, 31, 11, 1, -25 },
  { 2389, 16, 15, 17, 1, -25 },
  { 2419, 15, 2, 15, 0, 3 },
  { 2423, 8, 6, 10, 1, -27 },
  { 2429, 13, 19, 16, 1, -19 },
  { 2460, 14, 27, 17, 2, -27 },
  { 2508, 12, 19, 13, 1, -19 },
  { 2537, 14, 27, 17, 1, -27 },
  { 2585, 13, 19, 15, 1, -19 },
  { 2616, 11, 27, 10, 0, -27 },
  { 2654, 14, 27, 17, 1, -19 },
  { 2702, 13, 27, 17, 2, -27 },
  { 2746, 4, 26, 8, 2, -26 },
  { 2759, 7, 34, 8, -1, -26 },
  { 2789, 14, 27, 16, 2, -27 },
  { 2837, 4, 27, 8, 2, -27 },
  { 2851, 21, 19, 25, 2, -19 },
  { 2901, 13, 19, 17, 2, -19 },
  { 2932, 14, 19, 17, 1, -19 },
  { 2966, 14, 27, 17, 2, -19 },
  { 3014, 14, 27, 17, 1, -19 },
  { 3062, 9, 19, 12, 2, -19 },
  { 3084, 11, 19, 13, 1, -19 },
  { 3111, 10, 23, 11, 0, -23 },
  { 3140, 13, 19, 17, 2, -19 },
  { 3171, 14, 19, 15, 0, -19 },
  { 3205, 23, 19, 23, 0, -19 },
  { 3260, 14, 19, 14, 0, -19 },
  { 3294, 14, 27, 15, 0, -19 },
  { 3342, 10, 19, 12, 1, -19 },
  { 3366, 10, 31, 12, 1, -25 },
  { 3405, 3, 35, 15, 6, -27 },
  { 3419, 11, 31, 12, 1, -25 },
  { 3462, 14, 5, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD35PT7B_H_
