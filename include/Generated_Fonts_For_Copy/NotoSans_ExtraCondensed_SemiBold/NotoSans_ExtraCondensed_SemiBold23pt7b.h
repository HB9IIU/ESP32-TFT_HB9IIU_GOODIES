#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x6D, 0x81, 0xFF, 0xE7, 0xCF, 0x9F, 0x36, 0x6C,
  0xC0, 0x0C, 0xC1, 0xB0, 0x26, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xC8,
  0x1B, 0x1F, 0xFB, 0xFF, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0xB0, 0x08,
  0x1C, 0x7F, 0xFF, 0xE8, 0xC8, 0xE8, 0x78, 0x3C, 0x0F, 0x0F, 0x0B, 0x0B,
  0xCF, 0xFE, 0x7C, 0x08, 0x08, 0x30, 0x00, 0xF0, 0xC3, 0x61, 0x86, 0x66,
  0x0C, 0xCC, 0x19, 0x98, 0x33, 0x60, 0x66, 0xDE, 0xDB, 0x3C, 0xF6, 0xCC,
  0xCD, 0x98, 0x33, 0x30, 0x66, 0x60, 0xCC, 0xC3, 0x19, 0x86, 0x1E, 0x18,
  0x3C, 0x18, 0x07, 0xC1, 0xF8, 0x33, 0x86, 0x60, 0xCC, 0x1F, 0x81, 0xE0,
  0x78, 0x0F, 0x9F, 0xBB, 0x67, 0xEC, 0x7D, 0x87, 0x39, 0xE7, 0xFE, 0x7C,
  0xE0, 0xFF, 0xF6, 0xC0, 0x1C, 0x63, 0x0C, 0x71, 0x86, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x86, 0x18, 0x70, 0xC3, 0x06, 0x1C, 0xE1, 0x83, 0x0C, 0x38,
  0x61, 0x87, 0x1C, 0x70, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x18, 0xE0,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x38, 0x7C, 0xE6, 0x64, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x87, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x6F, 0xFD,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0,
  0x00, 0x18, 0x3E, 0x7E, 0xE7, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3,
  0xE3, 0xE3, 0xE7, 0x67, 0x7E, 0x3C, 0x1E, 0x3C, 0xFF, 0x74, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x18, 0x7E, 0xFF, 0x47,
  0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xFF,
  0xFF, 0x38, 0xFE, 0xFF, 0x87, 0x07, 0x07, 0x07, 0x3E, 0x3C, 0x3E, 0x07,
  0x03, 0x03, 0x07, 0x87, 0xFE, 0xFC, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x1B,
  0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x30, 0x0C, 0x7F, 0x7F, 0x60, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0x07, 0x03,
  0x03, 0x03, 0x07, 0x87, 0xFE, 0xFC, 0x0E, 0x1F, 0x9F, 0xCE, 0x06, 0x07,
  0x03, 0x31, 0xBC, 0xFF, 0x71, 0xB8, 0xD8, 0x7E, 0x37, 0x19, 0x9C, 0xFE,
  0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x18, 0x3F, 0x3F, 0xDC,
  0x6E, 0x37, 0x19, 0x9C, 0xFC, 0x3C, 0x3F, 0x39, 0xD8, 0x6C, 0x3E, 0x1F,
  0x8D, 0xFE, 0x7E, 0x00, 0x18, 0x7E, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE7, 0xFF, 0x7B, 0x03, 0x07, 0x07, 0x0E, 0xFC, 0xF8, 0x7F, 0xB0, 0x00,
  0x03, 0xFE, 0x7F, 0xB0, 0x00, 0x01, 0xBF, 0xF6, 0x00, 0x80, 0xC1, 0xE3,
  0xC7, 0x87, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x20, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x60, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x3E,
  0x7C, 0xF8, 0x70, 0x20, 0x00, 0x38, 0xFE, 0x7E, 0x47, 0x07, 0x07, 0x0E,
  0x0E, 0x1C, 0x18, 0x38, 0x30, 0x00, 0x00, 0x38, 0x38, 0x38, 0x03, 0x00,
  0x3F, 0x81, 0x87, 0x0C, 0x06, 0x60, 0x19, 0x9F, 0x3C, 0x6C, 0xF3, 0x33,
  0xCC, 0xCF, 0x33, 0x3C, 0xCC, 0xF3, 0x33, 0xCD, 0xDB, 0x1D, 0xE6, 0x00,
  0x18, 0x00, 0x30, 0x20, 0x7F, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x7C,
  0x0D, 0x81, 0xB8, 0x37, 0x0E, 0x61, 0xCC, 0x31, 0xC7, 0xF9, 0xFF, 0x3F,
  0xE7, 0x0E, 0xC1, 0xF8, 0x3F, 0x07, 0xFE, 0x7F, 0xB1, 0xD8, 0x6C, 0x36,
  0x3B, 0xFD, 0xFC, 0xFF, 0x61, 0xF0, 0xF8, 0x7C, 0x3E, 0x3B, 0xFD, 0xF8,
  0x0E, 0x0F, 0xCF, 0xEE, 0x17, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x81, 0xE2, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0xB1, 0xD8,
  0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x7B,
  0xF9, 0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0x7E, 0xFD, 0x83, 0x06,
  0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xFD,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x07, 0x07, 0xF3, 0xFD, 0xE1, 0x70,
  0x38, 0x0E, 0x03, 0x80, 0xE3, 0xF8, 0xFE, 0x0F, 0x83, 0x60, 0xDC, 0x37,
  0x8C, 0xFF, 0x1F, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFB, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xFF, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xFF, 0xEE, 0x00, 0xC3, 0xE3,
  0xB1, 0xD9, 0xCC, 0xE6, 0xE3, 0x61, 0xF8, 0xFC, 0x76, 0x33, 0x99, 0xCC,
  0x76, 0x3B, 0x0F, 0x87, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0x63, 0xFD, 0x8D, 0xF6, 0x37, 0xDC, 0xDF, 0x36, 0x7C,
  0xD9, 0xF3, 0x67, 0xC7, 0x9F, 0x1C, 0x7C, 0x71, 0xF1, 0xC7, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF8, 0xF6, 0x3D, 0xCF, 0x33, 0xCE, 0xF3, 0xBC, 0x6F,
  0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0x0E, 0x07, 0xF1, 0xFF, 0x38, 0xE6,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E,
  0xE1, 0xDE, 0x71, 0xFC, 0x1F, 0x00, 0xFE, 0xFE, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xCF, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0E, 0x07,
  0xF1, 0xFF, 0x38, 0xE6, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDE, 0x71, 0xFC, 0x1F, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0xFE, 0x7F, 0xB1, 0xD8, 0xEC, 0x76, 0x3B, 0x1D, 0xFC,
  0xFC, 0x6E, 0x33, 0x99, 0xCC, 0x76, 0x3B, 0x0F, 0x87, 0x1C, 0x7F, 0xFE,
  0xE2, 0xE0, 0xE0, 0xE0, 0x70, 0x7C, 0x1E, 0x0F, 0x07, 0x07, 0x07, 0xCE,
  0xFE, 0xFC, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3F, 0x1F,
  0xFC, 0xFC, 0xE0, 0xFC, 0x1D, 0x83, 0x30, 0x67, 0x1C, 0xE3, 0x8C, 0x61,
  0x8C, 0x3B, 0x87, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x3E, 0x03, 0x80, 0x70,
  0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xCC, 0x38, 0x66, 0x36, 0x73, 0x9B,
  0x39, 0xCD, 0x9C, 0xE6, 0xCC, 0x33, 0x66, 0x1B, 0x3B, 0x0D, 0x8F, 0x87,
  0xC7, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x38, 0xF1, 0xDC,
  0xE3, 0x38, 0xEC, 0x3F, 0x07, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x83, 0xF0,
  0xEC, 0x33, 0x9C, 0xE6, 0x1F, 0x87, 0xE1, 0xD8, 0x67, 0x39, 0xCE, 0x33,
  0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x7F, 0xBF, 0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFC,
  0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xFE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0x80, 0x06, 0x01,
  0xC0, 0x3C, 0x0D, 0x81, 0xB8, 0x73, 0x0C, 0x73, 0x86, 0xE0, 0xE0, 0xFF,
  0xFF, 0xF0, 0xE3, 0x0C, 0x70, 0x1C, 0x7E, 0x67, 0x07, 0x07, 0x1F, 0x7F,
  0xE7, 0xC7, 0xC7, 0xE7, 0xFB, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x67,
  0xFB, 0xFF, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0xCF, 0xFE,
  0xEF, 0x00, 0x1C, 0xFD, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8B,
  0xF3, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xBB, 0xFD, 0xFF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xFF, 0x3D, 0x80, 0x1C, 0x7E,
  0x77, 0xE3, 0xE3, 0xC3, 0xFF, 0xC0, 0xC0, 0xE0, 0xE1, 0x7F, 0x3F, 0x0C,
  0x7C, 0xF9, 0x83, 0x06, 0x3F, 0x7E, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x38, 0x3F, 0xDF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF9, 0xEF, 0xF3, 0xB8, 0x1C, 0x0F, 0x06, 0xFF, 0x7F, 0x04,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0xFD, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xC6, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xF9, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x1F, 0x9D, 0xCC, 0xEE, 0x7E, 0x3F, 0x1F, 0xCE, 0x67, 0x3B, 0x8D,
  0xC7, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x33,
  0xFD, 0xFF, 0xFF, 0xF8, 0xE7, 0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3,
  0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xE3, 0x8C, 0x0E, 0x7F, 0xBF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38,
  0x1C, 0x3F, 0x1D, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xD8,
  0xCF, 0xE3, 0xE0, 0x0E, 0x7F, 0xBF, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF1, 0xFC, 0xFF, 0xEE, 0xF7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x00, 0x38, 0x3F, 0xDF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF9, 0xEF, 0xF3, 0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x0F,
  0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x39, 0xFF, 0xB6,
  0x0C, 0x1E, 0x1E, 0x1E, 0x0E, 0x1E, 0x3F, 0xEF, 0x80, 0x30, 0x60, 0xC7,
  0xEF, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xCF, 0x80, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xB3, 0xDF, 0xE7,
  0xB0, 0xE1, 0xD8, 0xE6, 0x39, 0xCC, 0x73, 0x0D, 0xC3, 0x70, 0xD8, 0x3E,
  0x07, 0x81, 0xE0, 0x70, 0xE3, 0x8E, 0xC7, 0x19, 0x9B, 0x33, 0xB6, 0xE7,
  0x6D, 0xCE, 0xDB, 0x0D, 0xB6, 0x1A, 0x6C, 0x34, 0x58, 0x78, 0xF0, 0x71,
  0xC0, 0xE3, 0x80, 0xE3, 0xBB, 0x8D, 0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x7C,
  0x37, 0x3B, 0x98, 0xDC, 0x70, 0xE1, 0xD8, 0xE6, 0x39, 0xCC, 0x73, 0x0D,
  0xC3, 0x70, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x81,
  0xE0, 0x70, 0x08, 0x00, 0x7E, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70,
  0xE3, 0xFF, 0xF0, 0x0E, 0x3C, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x39, 0xE3,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x78, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3C, 0x1C,
  0xF9, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xE3, 0xC6, 0x00, 0x70, 0xFF, 0xE7,
  0xF0, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 7, 6, 10, 1, -16 },
  { 13, 11, 16, 11, 0, -16 },
  { 35, 8, 18, 10, 1, -17 },
  { 53, 15, 17, 17, 1, -17 },
  { 85, 11, 17, 12, 1, -17 },
  { 109, 3, 6, 5, 1, -16 },
  { 112, 6, 21, 7, 1, -17 },
  { 128, 6, 21, 7, 0, -17 },
  { 144, 8, 9, 10, 1, -18 },
  { 153, 9, 11, 10, 1, -14 },
  { 166, 3, 6, 6, 1, -3 },
  { 169, 5, 2, 7, 1, -7 },
  { 171, 3, 3, 6, 1, -3 },
  { 173, 9, 17, 9, 0, -17 },
  { 193, 8, 17, 10, 1, -17 },
  { 210, 7, 16, 10, 1, -16 },
  { 224, 8, 17, 10, 1, -17 },
  { 241, 8, 17, 10, 1, -17 },
  { 258, 10, 16, 10, 0, -16 },
  { 278, 8, 16, 10, 1, -16 },
  { 294, 9, 17, 10, 1, -17 },
  { 314, 9, 16, 10, 1, -16 },
  { 332, 9, 17, 10, 1, -17 },
  { 352, 8, 17, 10, 1, -17 },
  { 369, 3, 13, 6, 1, -13 },
  { 374, 3, 16, 6, 1, -13 },
  { 380, 9, 11, 10, 1, -14 },
  { 393, 9, 6, 10, 1, -11 },
  { 400, 9, 11, 10, 1, -14 },
  { 413, 8, 17, 8, 0, -17 },
  { 430, 14, 19, 16, 1, -17 },
  { 464, 11, 16, 11, 0, -16 },
  { 486, 9, 16, 12, 2, -16 },
  { 504, 9, 17, 11, 1, -17 },
  { 524, 9, 16, 12, 2, -16 },
  { 542, 7, 16, 10, 2, -16 },
  { 556, 7, 16, 9, 2, -16 },
  { 570, 10, 17, 13, 1, -17 },
  { 592, 9, 16, 13, 2, -16 },
  { 610, 5, 16, 7, 1, -16 },
  { 620, 5, 21, 6, -1, -16 },
  { 634, 9, 16, 11, 2, -16 },
  { 652, 7, 16, 9, 2, -16 },
  { 666, 14, 16, 17, 2, -16 },
  { 694, 10, 16, 14, 2, -16 },
  { 714, 11, 17, 13, 1, -17 },
  { 738, 8, 16, 11, 2, -16 },
  { 754, 11, 21, 13, 1, -17 },
  { 783, 9, 16, 11, 2, -16 },
  { 801, 8, 17, 10, 1, -17 },
  { 818, 9, 16, 9, 0, -16 },
  { 836, 9, 16, 13, 2, -16 },
  { 854, 11, 16, 11, 0, -16 },
  { 876, 17, 16, 17, 0, -16 },
  { 910, 10, 16, 10, 0, -16 },
  { 930, 10, 16, 10, 0, -16 },
  { 950, 9, 16, 9, 0, -16 },
  { 968, 6, 21, 7, 1, -17 },
  { 984, 9, 17, 9, 0, -17 },
  { 1004, 5, 21, 7, 1, -17 },
  { 1018, 11, 9, 11, 0, -16 },
  { 1031, 10, 2, 10, 0, 2 },
  { 1034, 5, 4, 7, 1, -18 },
  { 1037, 8, 13, 10, 1, -13 },
  { 1050, 9, 17, 11, 1, -17 },
  { 1070, 7, 13, 9, 1, -13 },
  { 1082, 9, 17, 11, 1, -17 },
  { 1102, 8, 13, 10, 1, -13 },
  { 1115, 7, 18, 6, 0, -18 },
  { 1131, 9, 19, 11, 1, -13 },
  { 1153, 9, 17, 11, 1, -17 },
  { 1173, 3, 17, 5, 1, -17 },
  { 1180, 5, 23, 5, -1, -17 },
  { 1195, 9, 17, 10, 1, -17 },
  { 1215, 3, 17, 5, 1, -17 },
  { 1222, 14, 13, 17, 1, -13 },
  { 1245, 9, 13, 11, 1, -13 },
  { 1260, 9, 13, 11, 1, -13 },
  { 1275, 9, 19, 11, 1, -13 },
  { 1297, 9, 19, 11, 1, -13 },
  { 1319, 6, 13, 8, 1, -13 },
  { 1329, 7, 13, 8, 1, -13 },
  { 1341, 7, 15, 7, 0, -15 },
  { 1355, 9, 12, 11, 1, -12 },
  { 1369, 10, 12, 10, 0, -12 },
  { 1384, 15, 12, 15, 0, -12 },
  { 1407, 9, 12, 9, 0, -12 },
  { 1421, 10, 18, 10, 0, -12 },
  { 1444, 7, 12, 8, 0, -12 },
  { 1455, 7, 20, 8, 0, -16 },
  { 1473, 2, 23, 10, 4, -18 },
  { 1479, 7, 20, 8, 1, -16 },
  { 1497, 9, 4, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD23PT7B_H_
