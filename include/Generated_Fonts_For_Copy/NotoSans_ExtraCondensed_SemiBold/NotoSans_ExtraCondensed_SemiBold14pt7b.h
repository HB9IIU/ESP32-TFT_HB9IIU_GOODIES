#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA8, 0xF0, 0xB9, 0x99, 0x34, 0x58, 0xA3, 0xF2, 0x85, 0x3F,
  0x34, 0x48, 0xB0, 0x21, 0x3F, 0x4A, 0x70, 0xC7, 0xBF, 0x88, 0x40, 0x73,
  0x14, 0x8D, 0x63, 0x50, 0x55, 0x9F, 0xB0, 0xAC, 0x2B, 0x12, 0xC4, 0x60,
  0x38, 0xD1, 0xA3, 0xC3, 0x0E, 0xF7, 0xE6, 0x4C, 0xFC, 0xF0, 0x6B, 0x49,
  0x24, 0x99, 0x30, 0xC6, 0x22, 0x23, 0x33, 0x22, 0x6C, 0x30, 0xCF, 0xCC,
  0x78, 0xC0, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x69, 0x60, 0xFF, 0xF0, 0x08,
  0xC4, 0x23, 0x10, 0x8C, 0x46, 0x00, 0x39, 0xA4, 0xD3, 0x4F, 0x34, 0xD3,
  0x68, 0xE0, 0x37, 0xF3, 0x33, 0x33, 0x33, 0x7B, 0x20, 0xC2, 0x18, 0x63,
  0x18, 0x43, 0xF0, 0xF9, 0x20, 0xC2, 0x30, 0xE0, 0xC3, 0x9B, 0xE0, 0x18,
  0x62, 0x8A, 0x49, 0x2C, 0xBF, 0x08, 0x20, 0xF4, 0x21, 0x0F, 0x0C, 0x63,
  0xB7, 0x80, 0x39, 0x84, 0x10, 0x7B, 0x34, 0xD3, 0x68, 0xE0, 0xFC, 0x30,
  0x86, 0x18, 0x43, 0x0C, 0x21, 0x80, 0x79, 0x34, 0xDA, 0x39, 0xE4, 0xF3,
  0x4D, 0xE0, 0x79, 0x2C, 0xF3, 0x4D, 0xF0, 0xC2, 0x19, 0xC0, 0xB0, 0x0F,
  0x4C, 0x00, 0x1B, 0x58, 0x0C, 0xEE, 0x18, 0x38, 0x30, 0xFC, 0x00, 0x3F,
  0xC1, 0xC1, 0xC7, 0x73, 0x00, 0xF4, 0xC6, 0x23, 0x11, 0x80, 0x63, 0x00,
  0x3C, 0x42, 0xC1, 0xBD, 0xAD, 0xAD, 0xAD, 0xBF, 0x80, 0x40, 0x3C, 0x38,
  0x70, 0xA1, 0x46, 0xCD, 0x9F, 0x22, 0xC7, 0x8C, 0xF3, 0x6C, 0xB2, 0xF3,
  0x6C, 0xF3, 0xDB, 0xC0, 0x7F, 0x71, 0x08, 0x42, 0x18, 0xEB, 0xC0, 0xF3,
  0x6C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDB, 0xC0, 0xFC, 0xCC, 0xFF, 0xCC, 0xCF,
  0xFC, 0xCC, 0xFF, 0xCC, 0xCC, 0x7D, 0x9C, 0x20, 0x82, 0x78, 0xF3, 0xCD,
  0xF0, 0xCF, 0x3C, 0xF3, 0xFF, 0xFC, 0xF3, 0xCF, 0x30, 0xF6, 0x66, 0x66,
  0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xE0, 0xCF, 0x6D, 0x3C,
  0xE3, 0xCD, 0x36, 0xDB, 0x30, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xC3, 0xF1,
  0xE8, 0xF4, 0xFE, 0x5F, 0xAF, 0x77, 0xBB, 0xD9, 0xEC, 0xC0, 0xC7, 0xCF,
  0x9D, 0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x9C, 0x7B, 0x3C, 0xE1, 0x86, 0x18,
  0x73, 0xCD, 0xE0, 0xF6, 0xF7, 0x9D, 0xFB, 0x18, 0xC6, 0x00, 0x7B, 0x3C,
  0xE1, 0x86, 0x18, 0x73, 0xCD, 0xE1, 0x83, 0xF3, 0x6C, 0xB2, 0xDB, 0xCD,
  0x36, 0xDB, 0x30, 0x7B, 0x50, 0x87, 0x1C, 0x21, 0xDF, 0x80, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCD, 0xE0, 0xC7, 0x89, 0x12, 0x66, 0xCD, 0x0A, 0x1C, 0x38, 0x60, 0xCC,
  0x73, 0x3C, 0xCD, 0x3B, 0x4E, 0x9E, 0xA7, 0x29, 0xCE, 0x33, 0x8C, 0xE0,
  0xCD, 0x27, 0x8E, 0x30, 0xC3, 0x9A, 0x4F, 0x30, 0xCD, 0x36, 0x9E, 0x38,
  0xC3, 0x0C, 0x30, 0xC0, 0xF8, 0xC6, 0x23, 0x11, 0x88, 0xC7, 0xC0, 0xF2,
  0x49, 0x24, 0x92, 0x70, 0xC2, 0x18, 0xC2, 0x18, 0x42, 0x18, 0x40, 0xE4,
  0x92, 0x49, 0x24, 0xF0, 0x10, 0x70, 0xA3, 0x64, 0x58, 0xC0, 0xFC, 0x99,
  0x80, 0x33, 0xC2, 0x76, 0xE7, 0x2F, 0x84, 0x21, 0x6F, 0xEE, 0x31, 0x8E,
  0xEC, 0x7F, 0x88, 0x88, 0xDF, 0x18, 0xC6, 0xFF, 0xCE, 0x73, 0x9E, 0xFA,
  0x67, 0xA7, 0xFF, 0xC3, 0x2E, 0x37, 0x67, 0xF6, 0x66, 0x66, 0x60, 0x6F,
  0xE7, 0x39, 0xCF, 0x7F, 0x1C, 0xFC, 0x84, 0x21, 0x6F, 0xEE, 0x73, 0x9C,
  0xE6, 0xDF, 0xE0, 0x51, 0x55, 0x55, 0x70, 0x84, 0x21, 0x19, 0xDA, 0x9E,
  0x94, 0xE6, 0xFF, 0xE0, 0xB6, 0xFF, 0xD9, 0x99, 0x99, 0x99, 0x99, 0x99,
  0xB7, 0xF7, 0x39, 0xCE, 0x73, 0x67, 0xA7, 0x39, 0xCF, 0x6E, 0xB7, 0xF7,
  0x18, 0xC7, 0x76, 0x84, 0x20, 0x6F, 0xE7, 0x39, 0xCF, 0x7F, 0x18, 0xC6,
  0xBE, 0xC8, 0x88, 0x88, 0x3B, 0xB0, 0xC3, 0x0E, 0x7E, 0x47, 0xF4, 0x44,
  0x46, 0x70, 0x9C, 0xE7, 0x39, 0xCF, 0x7D, 0xCF, 0x24, 0x96, 0x79, 0xC3,
  0x0C, 0xC9, 0xEE, 0xD5, 0x6A, 0xA5, 0x53, 0xA9, 0xDC, 0x6C, 0xC9, 0x67,
  0x8C, 0x31, 0xC5, 0xB3, 0xCF, 0x24, 0x96, 0x79, 0xC3, 0x0C, 0x30, 0x8E,
  0x00, 0xFF, 0x32, 0x66, 0x4F, 0x32, 0x22, 0x2E, 0xE2, 0x22, 0x23, 0xFF,
  0xFF, 0xFF, 0xF0, 0xCC, 0x44, 0x47, 0x74, 0x44, 0x4C, 0x66, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 3, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 7, 10, 7, 0, -10 },
  { 15, 5, 12, 6, 1, -11 },
  { 23, 10, 10, 10, 0, -10 },
  { 36, 7, 10, 7, 0, -10 },
  { 45, 1, 4, 3, 1, -10 },
  { 46, 3, 12, 4, 1, -10 },
  { 51, 4, 12, 4, 0, -10 },
  { 57, 6, 6, 6, 0, -11 },
  { 62, 6, 6, 6, 0, -8 },
  { 67, 3, 4, 3, 0, -2 },
  { 69, 4, 2, 4, 0, -5 },
  { 70, 2, 2, 3, 1, -2 },
  { 71, 5, 10, 5, 0, -10 },
  { 78, 6, 10, 6, 0, -10 },
  { 86, 4, 10, 6, 1, -10 },
  { 91, 6, 10, 6, 0, -10 },
  { 99, 6, 10, 6, 0, -10 },
  { 107, 6, 10, 6, 0, -10 },
  { 115, 5, 10, 6, 1, -10 },
  { 122, 6, 10, 6, 0, -10 },
  { 130, 6, 10, 6, 0, -10 },
  { 138, 6, 10, 6, 0, -10 },
  { 146, 6, 10, 6, 0, -10 },
  { 154, 2, 8, 3, 1, -8 },
  { 156, 3, 10, 3, 0, -8 },
  { 160, 6, 6, 6, 0, -8 },
  { 165, 6, 4, 6, 0, -7 },
  { 168, 6, 6, 6, 0, -8 },
  { 173, 5, 10, 5, 0, -10 },
  { 180, 8, 11, 10, 1, -10 },
  { 191, 7, 10, 7, 0, -10 },
  { 200, 6, 10, 7, 1, -10 },
  { 208, 5, 10, 7, 1, -10 },
  { 215, 6, 10, 8, 1, -10 },
  { 223, 4, 10, 6, 1, -10 },
  { 228, 4, 10, 6, 1, -10 },
  { 233, 6, 10, 8, 1, -10 },
  { 241, 6, 10, 8, 1, -10 },
  { 249, 4, 10, 4, 0, -10 },
  { 254, 4, 13, 4, -1, -10 },
  { 261, 6, 10, 7, 1, -10 },
  { 269, 4, 10, 6, 1, -10 },
  { 274, 9, 10, 11, 1, -10 },
  { 286, 7, 10, 9, 1, -10 },
  { 295, 6, 10, 8, 1, -10 },
  { 303, 5, 10, 7, 1, -10 },
  { 310, 6, 12, 8, 1, -10 },
  { 319, 6, 10, 7, 1, -10 },
  { 327, 5, 10, 6, 0, -10 },
  { 334, 6, 10, 6, 0, -10 },
  { 342, 6, 10, 8, 1, -10 },
  { 350, 7, 10, 7, 0, -10 },
  { 359, 10, 10, 10, 0, -10 },
  { 372, 6, 10, 6, 0, -10 },
  { 380, 6, 10, 6, 0, -10 },
  { 388, 5, 10, 5, 0, -10 },
  { 395, 3, 12, 4, 1, -10 },
  { 400, 5, 10, 5, 0, -10 },
  { 407, 3, 12, 4, 0, -10 },
  { 412, 7, 6, 7, 0, -10 },
  { 418, 6, 1, 6, 0, 1 },
  { 419, 3, 3, 4, 1, -11 },
  { 421, 5, 8, 6, 0, -8 },
  { 426, 5, 11, 7, 1, -11 },
  { 433, 4, 8, 5, 1, -8 },
  { 437, 5, 11, 7, 1, -11 },
  { 444, 5, 8, 6, 1, -8 },
  { 449, 4, 11, 4, 0, -11 },
  { 455, 5, 11, 7, 1, -8 },
  { 462, 5, 11, 7, 1, -11 },
  { 469, 1, 11, 3, 1, -11 },
  { 471, 2, 14, 3, 0, -11 },
  { 475, 5, 11, 6, 1, -11 },
  { 482, 1, 11, 3, 1, -11 },
  { 484, 8, 8, 10, 1, -8 },
  { 492, 5, 8, 7, 1, -8 },
  { 497, 5, 8, 7, 1, -8 },
  { 502, 5, 11, 7, 1, -8 },
  { 509, 5, 11, 7, 1, -8 },
  { 516, 4, 8, 5, 1, -8 },
  { 520, 5, 8, 5, 0, -8 },
  { 525, 4, 9, 4, 0, -9 },
  { 530, 5, 8, 7, 1, -8 },
  { 535, 6, 8, 6, 0, -8 },
  { 541, 9, 8, 9, 0, -8 },
  { 550, 6, 8, 6, 0, -8 },
  { 556, 6, 11, 6, 0, -8 },
  { 565, 4, 8, 5, 0, -8 },
  { 569, 4, 12, 5, 0, -10 },
  { 575, 2, 14, 6, 2, -11 },
  { 579, 4, 12, 5, 1, -10 },
  { 585, 6, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD14PT7B_H_
