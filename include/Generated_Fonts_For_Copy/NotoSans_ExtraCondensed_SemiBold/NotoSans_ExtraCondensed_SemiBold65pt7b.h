#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xFD, 0xFE, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xF3, 0xF0, 0x70, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF,
  0xC1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F,
  0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFE,
  0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0,
  0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xB8, 0x7C, 0xFF, 0x38, 0x08, 0xFE, 0x38, 0x00, 0xFE,
  0x38, 0x00, 0xFE, 0x38, 0x00, 0xFE, 0x38, 0x00, 0xFE, 0x38, 0x00, 0xFE,
  0x38, 0x00, 0xFF, 0x38, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x39, 0xFE, 0x00, 0x38, 0xFE, 0x00, 0x38, 0xFE, 0x00, 0x38, 0x7F, 0x00,
  0x38, 0x7F, 0x00, 0x38, 0x7F, 0x80, 0x38, 0x7E, 0x80, 0x38, 0xFE, 0xF0,
  0x38, 0xFE, 0xFC, 0x3B, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x1F,
  0x00, 0x80, 0x3E, 0x0F, 0xC7, 0xE0, 0xFE, 0x07, 0xC1, 0xF8, 0xFC, 0x3F,
  0xF0, 0xFC, 0x3F, 0x1F, 0x0F, 0xFE, 0x1F, 0x87, 0xC7, 0xE3, 0xFF, 0xE1,
  0xF9, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0x1F, 0x8F, 0xC3, 0xFF,
  0xC7, 0xE3, 0xF0, 0xF8, 0x7F, 0xF0, 0xF8, 0x7C, 0x1F, 0x87, 0xFC, 0x3F,
  0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xC0, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x07,
  0xC1, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x87,
  0xC0, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x01, 0xFE, 0x1F, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0x81, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFC, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFC, 0xFF, 0x07, 0xFB, 0xF8, 0xFE, 0x03, 0xFB, 0xF8, 0xFE, 0x03,
  0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x00,
  0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF,
  0xF3, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x70, 0x7E, 0x0E, 0x7E, 0x7C, 0x7E, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC,
  0x0F, 0x81, 0xF0, 0x07, 0x01, 0xC0, 0x01, 0x00, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x8F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xCF,
  0xF7, 0xF1, 0xFE, 0x7C, 0x3F, 0xC7, 0x07, 0xF8, 0x40, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3E, 0x03, 0xFE, 0x3C, 0x01,
  0xFE, 0x18, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0x7F, 0xF8, 0x78, 0x03, 0xFC, 0x18, 0x01, 0xFE, 0x08,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFA, 0x00, 0x07, 0xFD, 0x80, 0x03, 0xFE,
  0xF8, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFB, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xF9, 0xFC,
  0x00, 0x3F, 0x7F, 0x80, 0x07, 0xCF, 0xF0, 0x01, 0xF9, 0xFE, 0x00, 0x3E,
  0x3F, 0xC0, 0x07, 0xC7, 0xF8, 0x01, 0xF0, 0xFF, 0x00, 0x3E, 0x1F, 0xE0,
  0x0F, 0xC3, 0xFC, 0x01, 0xF0, 0x7F, 0x80, 0x7E, 0x0F, 0xF0, 0x0F, 0x81,
  0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x1F, 0x80, 0xFF, 0x03,
  0xE0, 0x1F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3C, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x80, 0x03, 0xFE, 0xC0, 0x07,
  0xFC, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0x38, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xCF, 0xFC,
  0x0F, 0xCF, 0xFF, 0x07, 0xEF, 0xFF, 0xC7, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xE7, 0xFE, 0xFF, 0xC0, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF,
  0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF1, 0xFF, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFC,
  0x1F, 0xE3, 0xFC, 0x07, 0xF9, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0xFF, 0x3F, 0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0x87, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xF8, 0x07, 0xFD, 0xFE, 0x07,
  0xFE, 0xFF, 0x87, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xDF, 0x87, 0xFF,
  0xEF, 0xC3, 0xFF, 0xE7, 0xE0, 0xFF, 0xE7, 0xF0, 0x3F, 0xE3, 0xF8, 0x01,
  0x81, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1C, 0x06, 0x03, 0xF0, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0x01, 0xFE,
  0x10, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x04, 0x00, 0xFC, 0x3F, 0x00, 0xFF, 0xF0, 0xFC,
  0x3F, 0x01, 0xFF, 0xF8, 0x7C, 0x3E, 0x03, 0xFF, 0xF0, 0x7E, 0x7E, 0x07,
  0xFF, 0xF0, 0x7E, 0x7E, 0x0F, 0xE1, 0xF0, 0x3E, 0x7C, 0x0F, 0xC1, 0xF0,
  0x3E, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0xFC,
  0x1F, 0x83, 0xF0, 0x3E, 0xFC, 0x1F, 0x03, 0xF0, 0x3E, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0xF8, 0x3F, 0x03, 0xF0, 0x3E,
  0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0xF8, 0x3F,
  0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x03, 0xF0,
  0x7E, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0xFC, 0x1F, 0x87, 0xF0, 0x7C, 0xFC,
  0x1F, 0x87, 0xF0, 0xFC, 0xFC, 0x1F, 0xCF, 0x79, 0xF8, 0xFC, 0x0F, 0xFF,
  0x7F, 0xF8, 0x7C, 0x0F, 0xFE, 0x7F, 0xF0, 0x7E, 0x07, 0xFC, 0x3F, 0xE0,
  0x7E, 0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0x60, 0x07, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xEF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F,
  0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF,
  0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F,
  0xCF, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC0, 0x7F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFC, 0x1F, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x1C, 0x1F, 0xF0,
  0x01, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x06, 0x0F, 0xFE, 0x0F, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0x01, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x1E, 0x1F, 0xF8,
  0x00, 0x20, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE,
  0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xCF,
  0xE0, 0x0F, 0xF1, 0xFC, 0x03, 0xFE, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x1F,
  0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x07, 0xF8, 0x0F, 0xE1, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x8F, 0xF8,
  0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x7F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFF, 0x7F,
  0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF7, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xC0, 0x01, 0xFF, 0xFF, 0xDF, 0x80,
  0x07, 0xEF, 0xFF, 0xBF, 0x80, 0x0F, 0xDF, 0xFF, 0x3F, 0x00, 0x1F, 0xBF,
  0xFF, 0x7E, 0x00, 0x7F, 0x7F, 0xFE, 0xFE, 0x00, 0xFC, 0xFF, 0xFC, 0xFC,
  0x01, 0xF9, 0xFF, 0xF9, 0xF8, 0x03, 0xF3, 0xFF, 0xF3, 0xF0, 0x0F, 0xE7,
  0xFF, 0xE7, 0xF0, 0x1F, 0x8F, 0xFF, 0xC7, 0xE0, 0x3F, 0x1F, 0xFF, 0x8F,
  0xC0, 0x7E, 0x3F, 0xFF, 0x1F, 0x81, 0xF8, 0x7F, 0xFE, 0x3F, 0x83, 0xF0,
  0xFF, 0xFC, 0x3F, 0x07, 0xE1, 0xFF, 0xF8, 0x7E, 0x1F, 0xC3, 0xFF, 0xF0,
  0xFC, 0x3F, 0x07, 0xFF, 0xE1, 0xFC, 0x7E, 0x0F, 0xFF, 0xC1, 0xF8, 0xFC,
  0x1F, 0xFF, 0x83, 0xF3, 0xF0, 0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0x7F, 0xFE,
  0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x7F, 0x00, 0x7F, 0xFD, 0xFC, 0x01, 0xFF, 0xF7, 0xF0, 0x07,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0x01, 0xFF,
  0xF9, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0x8F, 0xE0, 0x7F, 0xFE,
  0x3F, 0x81, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x83,
  0xF8, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0xC7, 0xFF, 0xE0, 0x7F,
  0x1F, 0xFF, 0x81, 0xFC, 0x7F, 0xFE, 0x03, 0xF9, 0xFF, 0xF8, 0x0F, 0xE7,
  0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0x80, 0x7F, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xF9, 0xFE,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xF0, 0x7C, 0x7F, 0x80, 0x18,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x7C, 0x01, 0xFE, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x07, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8,
  0x1F, 0xC0, 0x3E, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x7C, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x7E, 0x07, 0xF8,
  0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x7E, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x7F, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFC, 0x3F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFC, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFC, 0x3F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x3F, 0x0F, 0xE0,
  0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x1F, 0x9F, 0xE0,
  0x07, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0x03, 0xF9, 0xF8, 0x1F, 0x9F, 0xC0,
  0x03, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0xC0,
  0x03, 0xFB, 0xF0, 0x0F, 0x9F, 0xC0, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFC, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xE0, 0xFF, 0x06,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x81, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xC7,
  0xF7, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF, 0xF3, 0xFF, 0xBF, 0xFF, 0xBF, 0x7F,
  0xFF, 0x7E, 0x7F, 0xFC, 0xFC, 0x7F, 0xF1, 0xF8, 0x7F, 0xC1, 0xF0, 0x1C,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7C, 0x03, 0xF8, 0xFF,
  0xC1, 0xFC, 0xFF, 0xF0, 0xFE, 0xFF, 0xFC, 0x7F, 0x7F, 0xFE, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFE, 0x7F, 0xCF, 0xFC, 0x1F, 0xF7, 0xFC, 0x07, 0xFB, 0xFC,
  0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0xC0,
  0x7F, 0xBF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xF7,
  0xFF, 0xE3, 0xF3, 0xFF, 0xE1, 0xF8, 0xFF, 0xE0, 0xFC, 0x3F, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xF3, 0xE7, 0xFC, 0x04, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x17, 0xFC, 0x07, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3E, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFC, 0x1F, 0xFC, 0x7F, 0x0F, 0xFF, 0x9F, 0xC7, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFF, 0xCF, 0xFF, 0x3F, 0xC0, 0xFF, 0xCF, 0xF0, 0x1F, 0xF7,
  0xF8, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F,
  0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F,
  0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x7F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xF0, 0xFF, 0xF9, 0xFC, 0x1F, 0xFC, 0x3F,
  0x03, 0xFE, 0x0F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x4F, 0xF8, 0x03, 0x8F, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xF0,
  0x7F, 0xF9, 0xFC, 0x3F, 0xFE, 0x7F, 0x1F, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0x3F, 0xFC, 0xFF, 0x03, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0,
  0x1F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFF,
  0x3F, 0xC0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x7F, 0x1F, 0xFF, 0xDF, 0xC3, 0xFF, 0xE7, 0xF0, 0x7F, 0xF3, 0xFC, 0x0F,
  0xF8, 0xFF, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0xC0, 0x01, 0xFC, 0x3C, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xD0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7C, 0xFE, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x01, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xF8, 0x1F, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC,
  0x3F, 0xE0, 0x18, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xEF, 0xE0, 0x3F, 0xF7, 0xF8, 0x1F, 0xF1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xF1, 0xFF, 0xE3, 0xFF, 0xE7,
  0xE7, 0xFF, 0xC7, 0xFF, 0xCF, 0xDF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0xF0, 0xFC,
  0x7F, 0xF8, 0xFC, 0xFF, 0xFC, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF7, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xE0,
  0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0xF8,
  0x3F, 0x1F, 0xFE, 0x1F, 0x9F, 0xFF, 0x8F, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0x8F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x80,
  0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8, 0x0F,
  0xF7, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFE, 0xFF,
  0xFC, 0x7F, 0x3F, 0xFC, 0x3F, 0x9F, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0,
  0x78, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xF0, 0x7F, 0xF9, 0xFC, 0x3F,
  0xFE, 0x7F, 0x1F, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0x3F, 0xFC,
  0xFF, 0x03, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x03,
  0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0,
  0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF,
  0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0x1F, 0xFF, 0xDF,
  0xC3, 0xFF, 0xE7, 0xF0, 0x7F, 0xF1, 0xFC, 0x0F, 0xF8, 0xFF, 0x00, 0x70,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFB, 0xF7, 0xFD, 0xFF, 0xFE, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0x83,
  0xCF, 0xE0, 0x08, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xEF, 0x01, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x43, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xE0, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x3F, 0xFE, 0x7F, 0x1F, 0xFE,
  0x3F, 0x0F, 0xF8, 0x3F, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xEF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xDF,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF7, 0xF0, 0x07, 0xFC, 0x03, 0xF9, 0xFC, 0x03,
  0xFF, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xFF, 0x81, 0xFC,
  0x3F, 0x81, 0xFB, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0xF8, 0x1F, 0xC1, 0xFC,
  0x1F, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xCF, 0x83, 0xF8, 0x1F, 0xC1, 0xF3,
  0xF0, 0xFE, 0x07, 0xF0, 0xFC, 0x7C, 0x3F, 0x80, 0xFE, 0x3F, 0x1F, 0x0F,
  0xE0, 0x3F, 0x8F, 0x87, 0xC3, 0xF0, 0x0F, 0xE3, 0xE1, 0xF1, 0xFC, 0x03,
  0xF8, 0xF8, 0x7E, 0x7F, 0x00, 0x7E, 0x3E, 0x1F, 0x9F, 0xC0, 0x1F, 0xDF,
  0x83, 0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0xF9, 0xF8, 0x01, 0xFD, 0xF0, 0x3E,
  0xFE, 0x00, 0x7F, 0x7C, 0x0F, 0xBF, 0x80, 0x0F, 0xDF, 0x03, 0xEF, 0xE0,
  0x03, 0xF7, 0xC0, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0x3F,
  0x7C, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F,
  0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0,
  0x07, 0xF3, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F,
  0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x4F, 0xFC, 0x00, 0x37, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x80, 0x07, 0xFF, 0x20, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 47, 16, 4, -46 },
  { 54, 21, 16, 27, 3, -46 },
  { 96, 30, 46, 32, 1, -46 },
  { 269, 24, 53, 29, 3, -49 },
  { 428, 43, 48, 48, 2, -47 },
  { 686, 32, 48, 34, 2, -47 },
  { 878, 8, 16, 15, 3, -46 },
  { 894, 16, 57, 20, 3, -47 },
  { 1008, 16, 57, 20, 1, -47 },
  { 1122, 24, 25, 28, 2, -50 },
  { 1197, 25, 30, 29, 2, -38 },
  { 1291, 11, 16, 16, 2, -7 },
  { 1313, 15, 7, 19, 2, -21 },
  { 1327, 8, 10, 16, 4, -9 },
  { 1337, 24, 47, 25, 1, -47 },
  { 1478, 25, 48, 29, 2, -47 },
  { 1628, 19, 46, 29, 3, -46 },
  { 1738, 24, 47, 29, 2, -47 },
  { 1879, 25, 48, 29, 2, -47 },
  { 2029, 27, 47, 29, 1, -47 },
  { 2188, 24, 47, 29, 3, -46 },
  { 2329, 25, 48, 29, 2, -47 },
  { 2479, 25, 46, 29, 2, -46 },
  { 2623, 25, 48, 29, 2, -47 },
  { 2773, 25, 48, 29, 2, -47 },
  { 2923, 8, 37, 16, 4, -36 },
  { 2960, 11, 45, 16, 2, -36 },
  { 3022, 26, 30, 29, 2, -38 },
  { 3120, 25, 19, 29, 2, -32 },
  { 3180, 26, 30, 29, 2, -38 },
  { 3278, 22, 48, 23, 0, -47 },
  { 3410, 40, 52, 45, 3, -47 },
  { 3670, 32, 46, 32, 0, -46 },
  { 3854, 26, 46, 33, 4, -46 },
  { 4004, 26, 48, 30, 3, -47 },
  { 4160, 28, 46, 35, 4, -46 },
  { 4321, 19, 46, 28, 5, -46 },
  { 4431, 19, 46, 27, 5, -46 },
  { 4541, 29, 48, 36, 3, -47 },
  { 4715, 27, 46, 37, 5, -46 },
  { 4871, 16, 46, 20, 2, -46 },
  { 4963, 15, 59, 17, -3, -46 },
  { 5074, 27, 46, 32, 5, -46 },
  { 5230, 21, 46, 26, 4, -46 },
  { 5351, 39, 46, 49, 5, -46 },
  { 5576, 30, 46, 39, 5, -46 },
  { 5749, 32, 48, 38, 3, -47 },
  { 5941, 25, 46, 31, 4, -46 },
  { 6085, 32, 58, 38, 3, -47 },
  { 6317, 28, 46, 32, 4, -46 },
  { 6478, 23, 48, 27, 2, -47 },
  { 6616, 25, 46, 27, 1, -46 },
  { 6760, 28, 47, 36, 4, -46 },
  { 6925, 31, 46, 31, 0, -46 },
  { 7104, 48, 46, 48, 0, -46 },
  { 7380, 29, 46, 29, 0, -46 },
  { 7547, 29, 46, 29, 0, -46 },
  { 7714, 23, 46, 25, 1, -46 },
  { 7847, 15, 57, 20, 4, -47 },
  { 7954, 24, 47, 25, 1, -47 },
  { 8095, 14, 57, 20, 2, -47 },
  { 8195, 30, 27, 32, 1, -46 },
  { 8297, 27, 4, 27, 0, 6 },
  { 8311, 14, 11, 19, 3, -50 },
  { 8331, 23, 37, 29, 2, -36 },
  { 8438, 25, 50, 32, 4, -49 },
  { 8595, 20, 37, 25, 3, -36 },
  { 8688, 26, 50, 32, 2, -49 },
  { 8851, 23, 37, 29, 3, -36 },
  { 8958, 19, 50, 18, 1, -50 },
  { 9077, 26, 52, 32, 2, -36 },
  { 9246, 24, 49, 31, 4, -49 },
  { 9393, 8, 49, 15, 4, -49 },
  { 9442, 14, 65, 15, -2, -49 },
  { 9556, 25, 49, 29, 4, -49 },
  { 9710, 7, 49, 15, 4, -49 },
  { 9753, 39, 36, 47, 4, -36 },
  { 9929, 24, 36, 31, 4, -36 },
  { 10037, 26, 37, 31, 2, -36 },
  { 10158, 25, 52, 32, 4, -36 },
  { 10321, 26, 52, 32, 2, -36 },
  { 10490, 17, 36, 22, 4, -36 },
  { 10567, 20, 37, 23, 2, -36 },
  { 10660, 18, 44, 20, 1, -43 },
  { 10759, 24, 36, 31, 4, -35 },
  { 10867, 27, 35, 27, 0, -35 },
  { 10986, 42, 35, 42, 0, -35 },
  { 11170, 26, 35, 26, 0, -35 },
  { 11284, 27, 51, 27, 0, -35 },
  { 11457, 20, 35, 22, 1, -35 },
  { 11545, 19, 57, 23, 1, -47 },
  { 11681, 6, 65, 28, 11, -50 },
  { 11730, 19, 57, 23, 2, -47 },
  { 11866, 26, 10, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD65PT7B_H_
