#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x00, 0xEF, 0x60, 0xE7, 0xE7,
  0xE7, 0xE7, 0x67, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0xC1, 0x98, 0xFF,
  0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x33, 0xFF, 0xFF, 0xF3, 0x30, 0x66, 0x0C,
  0xC1, 0x98, 0x33, 0x00, 0x08, 0x04, 0x0F, 0xEF, 0xEE, 0x97, 0x43, 0xA1,
  0xF0, 0x7C, 0x0F, 0x03, 0xC1, 0x70, 0xBC, 0x5F, 0xBD, 0xFE, 0x3C, 0x04,
  0x02, 0x00, 0x78, 0x30, 0xFC, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0xCC, 0xC0,
  0xCC, 0xC0, 0xCD, 0xC8, 0xCD, 0xBE, 0xFD, 0xB6, 0x7B, 0x36, 0x03, 0x73,
  0x03, 0x73, 0x06, 0x73, 0x06, 0x77, 0x0E, 0x36, 0x0C, 0x3E, 0x0C, 0x1C,
  0x3E, 0x07, 0xF0, 0x77, 0x06, 0x70, 0x67, 0x07, 0x60, 0x3E, 0x03, 0xC0,
  0x7C, 0xEE, 0xCE, 0xEE, 0xEC, 0x7C, 0xC3, 0xCE, 0x38, 0xE7, 0xCF, 0xFE,
  0x7E, 0xF0, 0xFF, 0xF6, 0xC0, 0x1C, 0xE3, 0x1C, 0x71, 0x86, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x86, 0x18, 0x70, 0xC3, 0x86, 0x1C, 0xE1, 0xC3, 0x0E,
  0x18, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x1C,
  0xE0, 0x18, 0x0C, 0x36, 0x5F, 0xEF, 0xF9, 0xE1, 0xF9, 0xCE, 0x24, 0x00,
  0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x76, 0xEE, 0xEC, 0xFF, 0xFE, 0xEF, 0x60, 0x03, 0x81, 0xC0, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0xE0, 0x00, 0x3E, 0x3F, 0x9D, 0xDC, 0x6E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x19, 0xDC, 0xFE, 0x3E, 0x00,
  0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x7E, 0x7F, 0xB1, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E,
  0x0E, 0x07, 0x07, 0x07, 0x03, 0x03, 0x83, 0x81, 0xFF, 0xFF, 0x80, 0x7E,
  0x7F, 0x91, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x7C, 0x3E, 0x07, 0x80, 0xE0,
  0x70, 0x38, 0x1E, 0x1D, 0xFE, 0xFE, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x3E,
  0x0F, 0x86, 0xE1, 0xB8, 0xCE, 0x33, 0x98, 0xE6, 0x3B, 0xFF, 0xFF, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x07, 0x03,
  0xF1, 0xFE, 0x7F, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0x3D, 0xFE, 0xFC,
  0x00, 0x1F, 0x1F, 0x9C, 0x0C, 0x0E, 0x07, 0x03, 0xB9, 0xBE, 0xF7, 0x71,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0xDC, 0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x60, 0x70, 0x00, 0x3E, 0x3F, 0xB8, 0xDC, 0x7E, 0x3F, 0x19,
  0xDC, 0x7C, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x3E, 0x1F, 0x8E, 0xFE, 0x3E,
  0x00, 0x3E, 0x3F, 0xB9, 0xDC, 0x6C, 0x3E, 0x1F, 0x8F, 0xC7, 0xFF, 0xBF,
  0xCE, 0xE0, 0x60, 0x30, 0x38, 0x38, 0xFC, 0x7C, 0x00, 0x6F, 0xE0, 0x00,
  0x00, 0x00, 0xEF, 0x60, 0x6F, 0xE0, 0x00, 0x00, 0x00, 0x76, 0x6E, 0xEC,
  0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xC0,
  0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70, 0x3E,
  0x07, 0xC0, 0xF8, 0x1C, 0x3E, 0x7C, 0xF8, 0x70, 0x20, 0x00, 0x7E, 0xFE,
  0x47, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x38, 0x38, 0x0F, 0xE0, 0x3D, 0xE0, 0xE0, 0x63, 0x80, 0xE6, 0x1C,
  0xCC, 0xFD, 0xB3, 0xB9, 0xE6, 0x73, 0xCC, 0xE7, 0x99, 0x8F, 0x33, 0x1E,
  0x66, 0x6C, 0xFF, 0xDC, 0xE7, 0x18, 0x00, 0x38, 0x00, 0x38, 0x20, 0x3F,
  0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0x98,
  0x19, 0x83, 0x9C, 0x39, 0xC3, 0x9C, 0x3F, 0xC7, 0xFE, 0x70, 0xE7, 0x0E,
  0x70, 0xEE, 0x07, 0xE0, 0x70, 0xFE, 0x7F, 0xB1, 0xF8, 0x7C, 0x3E, 0x1F,
  0x1D, 0xFC, 0xFF, 0x63, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0xFE, 0xFE,
  0x00, 0x1F, 0xCF, 0xE7, 0x89, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x88, 0xFE, 0x1F, 0x80, 0xFE,
  0x3F, 0xCC, 0x7B, 0x0E, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC3, 0xB0, 0xEC, 0xF3, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFE,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0x0F, 0xE7, 0xFC, 0xE1, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x83, 0xF0, 0x77, 0x0E, 0xE1, 0xDE, 0x39,
  0xFF, 0x1F, 0xE0, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xC0, 0xFF, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x3F, 0xFC, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xCF, 0xFF, 0xF0, 0xC3, 0xF0, 0xEC, 0x73, 0x1C, 0xCE, 0x33, 0x8D,
  0xC3, 0x70, 0xFC, 0x3F, 0x0E, 0xE3, 0x38, 0xC7, 0x31, 0xCC, 0x3B, 0x0E,
  0xC1, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F,
  0xF8, 0x7F, 0x61, 0xBD, 0x86, 0xF7, 0x3B, 0xCC, 0xCF, 0x33, 0x3C, 0xCC,
  0xF3, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC3, 0x0C, 0xE0,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xB1, 0xF7, 0x3E, 0x67, 0xCE, 0xF9,
  0xDF, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xE0, 0x1F,
  0x83, 0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F,
  0x80, 0xFC, 0x7F, 0xB3, 0xD8, 0xEC, 0x3E, 0x1F, 0x0F, 0x8E, 0xFF, 0x7F,
  0x3E, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0x83, 0xFC,
  0x79, 0xE7, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0xFC, 0x3F, 0xCC, 0xF3, 0x0E, 0xC3, 0xB0,
  0xEC, 0x73, 0x1C, 0xFE, 0x3F, 0x0C, 0xE3, 0x38, 0xC7, 0x31, 0xCC, 0x3B,
  0x0E, 0xC3, 0xC0, 0x3F, 0x7F, 0xF3, 0xE0, 0xE0, 0xE0, 0xF0, 0x78, 0x3E,
  0x1E, 0x07, 0x07, 0x07, 0x87, 0xEF, 0xFE, 0xFC, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7F,
  0x39, 0xFE, 0x3F, 0x00, 0xE0, 0x7E, 0x0E, 0x60, 0xE7, 0x0E, 0x70, 0xC7,
  0x0C, 0x31, 0xC3, 0x1C, 0x39, 0x83, 0x98, 0x1B, 0x81, 0xB8, 0x1B, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0xC1, 0xF8, 0x70, 0x7E, 0x1E,
  0x19, 0x87, 0x8E, 0x61, 0xE3, 0x9C, 0xF8, 0xE7, 0x3E, 0x39, 0xCD, 0xCC,
  0x33, 0x37, 0x0C, 0xCD, 0xC3, 0xF3, 0x70, 0xFC, 0xDC, 0x3E, 0x36, 0x07,
  0x8F, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x00, 0xF1, 0xCE, 0x38,
  0xCE, 0x1D, 0xC3, 0xB0, 0x3E, 0x07, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x7C,
  0x1D, 0x83, 0xB8, 0x67, 0x1C, 0x73, 0x8E, 0xE1, 0xE0, 0xE0, 0xEC, 0x39,
  0xC7, 0x38, 0xC3, 0x38, 0x77, 0x0E, 0xC0, 0xF8, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xBF, 0xC0,
  0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03,
  0x81, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C,
  0x07, 0x03, 0x80, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCF, 0xFF, 0x80, 0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xB8,
  0x33, 0x0E, 0x71, 0x86, 0x70, 0xFC, 0x0C, 0xFF, 0xFF, 0xF0, 0xF3, 0x8E,
  0x7E, 0x7F, 0x47, 0x03, 0x03, 0x3F, 0x7F, 0xE3, 0xE3, 0xC7, 0xE7, 0xFF,
  0x7B, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xCE, 0xE1,
  0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1B, 0xCE, 0xFF, 0xBB, 0xC0,
  0x3F, 0x7E, 0x72, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7E,
  0x3E, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x19, 0xED, 0xF7, 0xE7, 0xE3, 0xF1,
  0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0xE7, 0x7F, 0x9E, 0xC0, 0x3E, 0x3F,
  0x98, 0xDC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x1C, 0x4F, 0xE3,
  0xF0, 0x1E, 0x7C, 0xE1, 0x83, 0x0F, 0xFF, 0x98, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x3D, 0xBE, 0xFC, 0xFC, 0x7E, 0x3F, 0x0F,
  0x87, 0xC3, 0xE3, 0xF1, 0xFC, 0xEF, 0xB3, 0xD8, 0x0C, 0x0F, 0x07, 0x7F,
  0x3F, 0x8F, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x7B, 0xFF, 0xE7,
  0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xC0,
  0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x19, 0xCE, 0x00, 0x1C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xDC, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x3B, 0x9C, 0xE6, 0x3B, 0x8F, 0xC3,
  0xF8, 0xF6, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0x3D, 0xFF, 0xFB, 0xCF, 0x3F, 0x1C, 0x7E,
  0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E,
  0x3F, 0x1C, 0x7E, 0x38, 0xE0, 0xEF, 0x7F, 0xFC, 0xFC, 0x7E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x18, 0x3E, 0x3F, 0x9C, 0xFC,
  0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xDC, 0xEF, 0xE3, 0xE0, 0xEF,
  0x3F, 0xEF, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6F,
  0x3B, 0xFE, 0xEF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3D,
  0xBE, 0xFC, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xFC, 0xEF,
  0xB3, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xEF, 0xFF, 0xF7,
  0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x7F, 0xFF, 0x96,
  0x0E, 0x1F, 0x1F, 0x0F, 0x0E, 0x1E, 0x3F, 0xEF, 0xC0, 0x30, 0x60, 0xC3,
  0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x9F, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xDD, 0xEF,
  0xF3, 0xD8, 0xE1, 0xF8, 0x76, 0x19, 0xCE, 0x73, 0x8C, 0xC3, 0x30, 0xDC,
  0x3F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0xE3, 0x87, 0xC7, 0x8D, 0x8F,
  0x3B, 0x9E, 0x77, 0x6C, 0xCE, 0xD9, 0x8D, 0x9F, 0x1B, 0x3E, 0x36, 0x7C,
  0x7C, 0xF0, 0xF1, 0xE0, 0xE3, 0xC1, 0xC7, 0x80, 0xE3, 0x9C, 0xE7, 0x30,
  0xFC, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0D, 0xC7, 0x31, 0xCE, 0xE3,
  0xC0, 0xE1, 0xD8, 0x76, 0x19, 0xCE, 0x73, 0x8C, 0xC3, 0x30, 0xFC, 0x3F,
  0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x78, 0x1E, 0x06,
  0x00, 0xFD, 0xF8, 0x70, 0xE3, 0x87, 0x0C, 0x38, 0x71, 0xC3, 0x87, 0xFF,
  0xE0, 0x1E, 0x7C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x31, 0xE3, 0x87, 0x83,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x7C, 0x39,
  0xE3, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xC7, 0x8C, 0x00, 0xF8, 0xFF, 0xE3,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 8, 6, 10, 1, -17 },
  { 16, 11, 17, 12, 0, -17 },
  { 40, 9, 19, 11, 1, -18 },
  { 62, 16, 17, 18, 1, -17 },
  { 96, 12, 17, 13, 1, -17 },
  { 122, 3, 6, 5, 1, -17 },
  { 125, 6, 21, 7, 1, -17 },
  { 141, 6, 21, 7, 0, -17 },
  { 157, 9, 9, 10, 1, -18 },
  { 168, 9, 11, 11, 1, -14 },
  { 181, 4, 6, 6, 1, -3 },
  { 184, 5, 3, 7, 1, -8 },
  { 186, 4, 3, 6, 1, -3 },
  { 188, 9, 17, 9, 0, -17 },
  { 208, 9, 17, 11, 1, -17 },
  { 228, 7, 17, 11, 1, -17 },
  { 243, 9, 17, 11, 1, -17 },
  { 263, 9, 17, 11, 1, -17 },
  { 283, 10, 17, 11, 0, -17 },
  { 305, 9, 17, 11, 1, -17 },
  { 325, 9, 17, 11, 1, -17 },
  { 345, 9, 17, 11, 1, -17 },
  { 365, 9, 17, 11, 1, -17 },
  { 385, 9, 17, 11, 1, -17 },
  { 405, 4, 13, 6, 1, -13 },
  { 412, 4, 16, 6, 1, -13 },
  { 420, 9, 11, 11, 1, -14 },
  { 433, 9, 7, 11, 1, -12 },
  { 441, 9, 11, 11, 1, -14 },
  { 454, 8, 17, 8, 0, -17 },
  { 471, 15, 19, 17, 1, -17 },
  { 507, 12, 17, 12, 0, -17 },
  { 533, 9, 17, 12, 2, -17 },
  { 553, 10, 17, 11, 1, -17 },
  { 575, 10, 17, 13, 2, -17 },
  { 597, 7, 17, 10, 2, -17 },
  { 612, 7, 17, 10, 2, -17 },
  { 627, 11, 17, 13, 1, -17 },
  { 651, 10, 17, 14, 2, -17 },
  { 673, 6, 17, 7, 1, -17 },
  { 686, 5, 22, 6, -1, -17 },
  { 700, 10, 17, 12, 2, -17 },
  { 722, 7, 17, 9, 2, -17 },
  { 737, 14, 17, 18, 2, -17 },
  { 767, 11, 17, 15, 2, -17 },
  { 791, 12, 17, 14, 1, -17 },
  { 817, 9, 17, 11, 2, -17 },
  { 837, 12, 21, 14, 1, -17 },
  { 869, 10, 17, 12, 2, -17 },
  { 891, 8, 17, 10, 1, -17 },
  { 908, 10, 17, 10, 0, -17 },
  { 930, 10, 17, 13, 2, -17 },
  { 952, 12, 17, 12, 0, -17 },
  { 978, 18, 17, 18, 0, -17 },
  { 1017, 11, 17, 11, 0, -17 },
  { 1041, 11, 17, 11, 0, -17 },
  { 1065, 9, 17, 9, 0, -17 },
  { 1085, 5, 21, 7, 2, -17 },
  { 1099, 9, 17, 9, 0, -17 },
  { 1119, 5, 21, 7, 1, -17 },
  { 1133, 11, 10, 12, 0, -17 },
  { 1147, 10, 2, 10, 0, 2 },
  { 1150, 5, 3, 7, 1, -18 },
  { 1152, 8, 13, 11, 1, -13 },
  { 1165, 10, 18, 12, 1, -18 },
  { 1188, 8, 13, 9, 1, -13 },
  { 1201, 9, 18, 12, 1, -18 },
  { 1222, 9, 13, 11, 1, -13 },
  { 1237, 7, 18, 7, 0, -18 },
  { 1253, 9, 19, 12, 1, -13 },
  { 1275, 9, 18, 12, 1, -18 },
  { 1296, 3, 18, 6, 1, -18 },
  { 1303, 5, 24, 6, -1, -18 },
  { 1318, 10, 18, 11, 1, -18 },
  { 1341, 3, 18, 6, 1, -18 },
  { 1348, 15, 13, 17, 1, -13 },
  { 1373, 9, 13, 12, 1, -13 },
  { 1388, 9, 13, 11, 1, -13 },
  { 1403, 10, 19, 12, 1, -13 },
  { 1427, 9, 19, 12, 1, -13 },
  { 1449, 7, 13, 8, 1, -13 },
  { 1461, 7, 13, 9, 1, -13 },
  { 1473, 7, 16, 7, 0, -16 },
  { 1487, 9, 13, 12, 1, -13 },
  { 1502, 10, 13, 10, 0, -13 },
  { 1519, 15, 13, 16, 0, -13 },
  { 1544, 10, 13, 10, 0, -13 },
  { 1561, 10, 19, 10, 0, -13 },
  { 1585, 7, 13, 8, 1, -13 },
  { 1597, 7, 21, 8, 1, -17 },
  { 1616, 2, 24, 10, 4, -18 },
  { 1622, 7, 21, 8, 1, -17 },
  { 1641, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD24PT7B_H_
