#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFF, 0xE0,
  0x73, 0xDC, 0xF7, 0x3D, 0xCE, 0x73, 0x9C, 0xE7, 0x19, 0xC6, 0x0C, 0x60,
  0x67, 0x03, 0x38, 0x19, 0xC1, 0xCC, 0x0E, 0x63, 0xFF, 0xFF, 0xFF, 0x18,
  0xC0, 0xCE, 0x06, 0x70, 0x73, 0x83, 0x98, 0x7F, 0xFB, 0xFF, 0xC6, 0x30,
  0x33, 0x81, 0x9C, 0x0C, 0xE0, 0xE6, 0x07, 0x30, 0x00, 0x04, 0x00, 0x80,
  0x3E, 0x1F, 0xF7, 0xFD, 0xE8, 0xB9, 0x07, 0x20, 0xF4, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x0B, 0x81, 0x38, 0x27, 0x84, 0xF8, 0xBB, 0xFF, 0x7F,
  0xC0, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x3C, 0x0E, 0x0F, 0x81, 0x81, 0xB8,
  0x70, 0x73, 0x0E, 0x0E, 0x71, 0x81, 0xCE, 0x70, 0x39, 0xCC, 0x07, 0x3B,
  0x80, 0xE7, 0x73, 0x1C, 0xCC, 0xF9, 0xBB, 0xBF, 0x3F, 0x76, 0x73, 0xCC,
  0xCE, 0x03, 0x98, 0xC0, 0x63, 0x18, 0x1C, 0x63, 0x03, 0x8C, 0x60, 0x61,
  0x9C, 0x1C, 0x3B, 0x83, 0x83, 0xE0, 0xE0, 0x78, 0x1F, 0x00, 0xFE, 0x03,
  0xF8, 0x1E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0xB8, 0x0E, 0xE0, 0x3F, 0x00,
  0x7C, 0x03, 0xE3, 0xDF, 0xCF, 0xF7, 0x3B, 0x8E, 0xEE, 0x3F, 0xB8, 0x7C,
  0xE0, 0xF3, 0xC7, 0xCF, 0xFF, 0x9F, 0xEE, 0x3F, 0x3C, 0x77, 0x77, 0x77,
  0x77, 0x0E, 0x18, 0x70, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0E,
  0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C,
  0xE3, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xCF, 0x38, 0xE7, 0x1C, 0xE3, 0x00, 0x0E, 0x01, 0xC0, 0x30,
  0x76, 0xEF, 0xFD, 0xFF, 0xC7, 0x81, 0xF8, 0x7B, 0x8E, 0x78, 0x44, 0x00,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7B, 0x9C, 0xEE, 0x73,
  0x80, 0xFF, 0xFF, 0xF8, 0xEE, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x1F,
  0x07, 0xF1, 0xFE, 0x39, 0xE7, 0x1D, 0xE3, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x7F, 0x8F, 0x71, 0xCE, 0x39,
  0xFF, 0x1F, 0xC1, 0xF0, 0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xEF, 0xCF, 0x4F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x0F, 0xF3, 0xFF, 0x31, 0xE4, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0xF3, 0xFF, 0x31, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x87, 0xE0, 0xFC, 0x1F, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3B, 0xFF, 0x7F, 0xCF, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xBC,
  0x1D, 0xE0, 0xCF, 0x0E, 0x78, 0x63, 0xC7, 0x1E, 0x30, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xCF,
  0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0x0F, 0xF1,
  0xFF, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x7B, 0xFF,
  0x7F, 0xC7, 0xF0, 0x07, 0xC3, 0xF8, 0xFF, 0x1E, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xEF, 0x9F, 0xFB, 0xFF, 0x78, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F,
  0x87, 0xF1, 0xEE, 0x3D, 0xFF, 0x1F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xEF, 0x1F, 0xE3, 0xDC, 0x73, 0x8E,
  0x3F, 0xC7, 0xF0, 0x7C, 0x1F, 0xC7, 0x3D, 0xE3, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0xEF, 0x3F, 0xE3, 0xF8, 0x1E, 0x07, 0xF1, 0xFE, 0x79, 0xEE,
  0x1D, 0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xFE, 0x3F, 0xCF, 0xBF, 0xF3, 0xEE,
  0x31, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x71, 0xFE, 0x3F, 0x87, 0xE0, 0xEE,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xEE, 0xFE, 0x73, 0x9E, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3D, 0xCE, 0x77, 0x39, 0xC0, 0x00, 0x20, 0x1C, 0x0F,
  0x87, 0xE3, 0xF1, 0xF8, 0x3C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x78, 0x1F,
  0x0F, 0x87, 0xC3, 0xF0, 0x78, 0x0C, 0x00, 0x3E, 0x3F, 0xE7, 0xF9, 0x0E,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x1C, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x8C, 0x00, 0x67,
  0x1F, 0x99, 0x8F, 0xE7, 0x63, 0x39, 0xF9, 0xCE, 0x7E, 0x73, 0x8F, 0x9C,
  0xE7, 0xE6, 0x39, 0xF9, 0xCE, 0x7E, 0x73, 0x9B, 0x9F, 0xFE, 0x63, 0xEF,
  0x1C, 0x21, 0x87, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x04, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3B,
  0x80, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0xC1, 0xC7, 0x0F, 0x1C, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0x9E, 0x0E, 0x78, 0x39, 0xC0, 0xF7, 0x03, 0xFC,
  0x0F, 0xF0, 0x1C, 0xFE, 0x0F, 0xFC, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x1E, 0xE1, 0xCF, 0xF8, 0xFF, 0x8F, 0xFE, 0xE1, 0xEE, 0x0E,
  0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0x07,
  0xC1, 0xFF, 0x1F, 0xE3, 0xC2, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x03, 0xC1, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xF8, 0xFF, 0xCE,
  0x3E, 0xE1, 0xEE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF,
  0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x7C, 0x33, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x7F, 0xE3, 0xFF, 0x1F,
  0xB8, 0x1D, 0xC0, 0xEF, 0x07, 0x78, 0x39, 0xE1, 0xCF, 0xFE, 0x3F, 0xF0,
  0xFF, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFD,
  0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x71, 0xF7, 0xFF, 0xE0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFF,
  0xEF, 0x00, 0xE0, 0xFE, 0x0F, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7,
  0x8E, 0xF0, 0xEF, 0x0E, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8E, 0x78, 0xE3,
  0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xF0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xF8, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x7E,
  0xC1, 0xDF, 0xB8, 0x77, 0xEE, 0x1D, 0xFB, 0x86, 0x7E, 0x63, 0x9F, 0x9C,
  0xE7, 0xE7, 0x31, 0xF9, 0xDC, 0x7E, 0x37, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1,
  0xF8, 0xF8, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xC1, 0xC0, 0xF0, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFE, 0xE3, 0xFB, 0x8F,
  0xEF, 0x3F, 0x9C, 0xFE, 0x73, 0xF8, 0xEF, 0xE3, 0xBF, 0x8F, 0x7E, 0x1D,
  0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7C, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x0F, 0x1E, 0x78, 0x39, 0xE0, 0xF7, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77,
  0x01, 0xDC, 0x0F, 0x78, 0x3C, 0xF1, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3B, 0xFF, 0x7F, 0xCF, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x0F, 0x1E,
  0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x78, 0x3C, 0xF1,
  0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE1, 0xEE, 0x1E,
  0xE1, 0xEE, 0x1E, 0xE1, 0xEE, 0x3C, 0xFF, 0xCF, 0xF0, 0xFF, 0x0E, 0x78,
  0xE3, 0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0, 0x1F,
  0x0F, 0xF7, 0xFF, 0xE6, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xF0, 0xFF, 0xFB, 0xFE,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF,
  0x0F, 0x7F, 0xE7, 0xFE, 0x1F, 0x80, 0xE0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C,
  0x0E, 0x70, 0x39, 0xC1, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x70, 0x3F, 0x81, 0xC0,
  0xEF, 0x07, 0x83, 0xBC, 0x1E, 0x0E, 0x70, 0xF8, 0x79, 0xC3, 0xE1, 0xC7,
  0x0D, 0x87, 0x1C, 0x37, 0x1C, 0x78, 0xDC, 0x70, 0xE7, 0x73, 0xC3, 0x9D,
  0xCE, 0x0E, 0x73, 0x38, 0x39, 0xCE, 0xE0, 0xF6, 0x3B, 0x81, 0xF8, 0xFE,
  0x07, 0xE3, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x00, 0xF0, 0x7C, 0x03,
  0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x70, 0x73, 0x87, 0x9E, 0x3C, 0x71, 0xC3,
  0xDE, 0x0E, 0xE0, 0x77, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x1F,
  0x00, 0xF8, 0x0F, 0xE0, 0x77, 0x07, 0xBC, 0x38, 0xE1, 0xC7, 0x1E, 0x3C,
  0xE0, 0xEF, 0x07, 0x80, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xF1, 0xE3, 0x8E,
  0x1C, 0x70, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F,
  0xFF, 0xF0, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x0E,
  0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x1D, 0xC0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF1, 0xE3, 0x87, 0x1F, 0x1F, 0xE3, 0xFC, 0x87, 0x01, 0xC0,
  0x70, 0xFC, 0xFF, 0x7F, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xFD, 0xF7, 0xFD,
  0xF3, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xC7, 0xFC,
  0xFF, 0xDE, 0x3B, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0xC7, 0x7D, 0xEF, 0xFD, 0x9F, 0x00, 0x1F, 0x9F, 0xDF, 0xEF,
  0x17, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x0B, 0xFC,
  0xFE, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xB9,
  0xFF, 0x7F, 0xEE, 0x3F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x1D, 0xC7, 0xBD, 0xF7, 0xFE, 0x7C, 0xC0, 0x1F, 0x07, 0xF1,
  0xFF, 0x38, 0xEF, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x78, 0x07, 0x02, 0xFB, 0x8F, 0xF0, 0xFE, 0x0F, 0x8F, 0xCF, 0xC7, 0x83,
  0x81, 0xC0, 0xFD, 0xFE, 0xFF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1E, 0x67, 0xFD, 0xFF,
  0xB8, 0xFF, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8,
  0x77, 0x1E, 0xFF, 0xDF, 0xF9, 0xF7, 0x00, 0xE0, 0x1C, 0x03, 0xA0, 0xF7,
  0xFC, 0xFF, 0x0F, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0xF3, 0xFE, 0xFF, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xDF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x71, 0xC7, 0x00, 0x01, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xFF, 0xFE, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x7F, 0x0E, 0xE3, 0x9C, 0xF3, 0x9C, 0x77, 0x0E, 0xE1, 0xFC, 0x3F, 0xC7,
  0xB8, 0xE7, 0x9C, 0x73, 0x8E, 0x70, 0xEE, 0x1D, 0xC3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCF, 0x1E, 0x7F, 0xDF, 0xBF,
  0xFF, 0xFE, 0x7C, 0xFE, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87,
  0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E,
  0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xCF, 0x3F, 0xEF, 0xFF, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x1E, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xEF, 0x0E, 0x70, 0xE7, 0xFC, 0x3F, 0xC1,
  0xF8, 0xCF, 0x1F, 0xF3, 0xFF, 0x78, 0xEE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0x1D, 0xFF, 0xBF, 0xF7, 0x7C, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x67, 0xFD,
  0xFF, 0xB8, 0xFF, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x77, 0x1E, 0xFF, 0xDF, 0xF9, 0xF7, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0xC7, 0x9F, 0xFF, 0xDF, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x3E, 0x3F, 0xFF, 0xDC, 0x2E,
  0x07, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0xF8, 0x7F, 0xFB, 0xFD,
  0xFC, 0x18, 0x18, 0x38, 0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3,
  0xFF, 0xFF, 0xFD, 0xF3, 0xF0, 0x7F, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE7,
  0x9E, 0x39, 0xC3, 0x9C, 0x39, 0xC1, 0x9C, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0xE0, 0xE1, 0xFE, 0x3E, 0x39, 0xC7, 0xC7, 0x38,
  0xF8, 0xE7, 0x1B, 0x1C, 0xE3, 0x67, 0x8E, 0xEC, 0xE1, 0xDD, 0xDC, 0x3B,
  0x3B, 0x87, 0x63, 0x70, 0xEC, 0x7C, 0x0D, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0x70, 0xF0, 0xF0, 0xE7, 0x1E, 0x79, 0xC3, 0x9C,
  0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xB8,
  0x39, 0xC7, 0x9C, 0x71, 0xEF, 0x0F, 0xF0, 0x7F, 0x0F, 0x70, 0xE7, 0x0E,
  0x78, 0xE3, 0x9E, 0x39, 0xC3, 0x9C, 0x39, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x7C, 0x07, 0xC0, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0x0E, 0x1E, 0x1C,
  0x3C, 0x38, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0x0F, 0x1F,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x78, 0xF0, 0xF0, 0x78,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x7C,
  0x3E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC0,
  0xF8, 0x7C, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE1,
  0xF0, 0xF8, 0x40, 0x00, 0xFC, 0x3F, 0xFF, 0x3F, 0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 21, 7, 2, -21 },
  { 12, 10, 8, 12, 1, -21 },
  { 22, 13, 21, 14, 1, -21 },
  { 57, 11, 24, 13, 1, -22 },
  { 90, 19, 21, 21, 1, -21 },
  { 140, 14, 21, 15, 1, -21 },
  { 177, 4, 8, 7, 1, -21 },
  { 181, 7, 26, 9, 1, -21 },
  { 204, 6, 26, 9, 1, -21 },
  { 224, 11, 11, 12, 1, -22 },
  { 240, 11, 14, 13, 1, -17 },
  { 260, 5, 7, 7, 1, -3 },
  { 265, 7, 3, 9, 1, -9 },
  { 268, 4, 4, 7, 2, -4 },
  { 270, 11, 21, 11, 0, -21 },
  { 299, 11, 21, 13, 1, -21 },
  { 328, 8, 21, 13, 2, -21 },
  { 349, 11, 21, 13, 1, -21 },
  { 378, 11, 21, 13, 1, -21 },
  { 407, 13, 21, 13, 0, -21 },
  { 442, 11, 21, 13, 1, -21 },
  { 471, 11, 21, 13, 1, -21 },
  { 500, 11, 21, 13, 1, -21 },
  { 529, 11, 21, 13, 1, -21 },
  { 558, 11, 21, 13, 1, -21 },
  { 587, 4, 16, 7, 2, -16 },
  { 595, 5, 20, 7, 1, -16 },
  { 608, 11, 13, 13, 1, -17 },
  { 626, 11, 8, 13, 1, -14 },
  { 637, 11, 13, 13, 1, -17 },
  { 655, 10, 21, 10, 0, -21 },
  { 682, 18, 23, 20, 1, -21 },
  { 734, 14, 21, 14, 0, -21 },
  { 771, 12, 21, 15, 2, -21 },
  { 803, 12, 21, 14, 1, -21 },
  { 835, 12, 21, 16, 2, -21 },
  { 867, 9, 21, 12, 2, -21 },
  { 891, 9, 21, 12, 2, -21 },
  { 915, 13, 21, 16, 1, -21 },
  { 950, 12, 21, 16, 2, -21 },
  { 982, 7, 21, 9, 1, -21 },
  { 1001, 6, 27, 7, -1, -21 },
  { 1022, 12, 21, 14, 2, -21 },
  { 1054, 9, 21, 11, 2, -21 },
  { 1078, 18, 21, 22, 2, -21 },
  { 1126, 14, 21, 18, 2, -21 },
  { 1163, 14, 21, 17, 1, -21 },
  { 1200, 11, 21, 14, 2, -21 },
  { 1229, 14, 26, 17, 1, -21 },
  { 1275, 12, 21, 14, 2, -21 },
  { 1307, 10, 21, 12, 1, -21 },
  { 1334, 12, 21, 12, 0, -21 },
  { 1366, 12, 21, 16, 2, -21 },
  { 1398, 14, 21, 14, 0, -21 },
  { 1435, 22, 21, 21, 0, -21 },
  { 1493, 13, 21, 13, 0, -21 },
  { 1528, 13, 21, 13, 0, -21 },
  { 1563, 10, 21, 11, 1, -21 },
  { 1590, 6, 26, 9, 2, -21 },
  { 1610, 11, 21, 11, 0, -21 },
  { 1639, 6, 26, 9, 1, -21 },
  { 1659, 13, 12, 14, 1, -21 },
  { 1679, 12, 2, 12, 0, 2 },
  { 1682, 6, 4, 9, 1, -22 },
  { 1685, 10, 16, 13, 1, -16 },
  { 1705, 11, 22, 14, 2, -22 },
  { 1736, 9, 16, 11, 1, -16 },
  { 1754, 11, 22, 14, 1, -22 },
  { 1785, 11, 16, 13, 1, -16 },
  { 1807, 9, 22, 8, 0, -22 },
  { 1832, 11, 23, 14, 1, -16 },
  { 1864, 10, 22, 14, 2, -22 },
  { 1892, 3, 22, 7, 2, -22 },
  { 1901, 6, 29, 7, -1, -22 },
  { 1923, 11, 22, 13, 2, -22 },
  { 1954, 3, 22, 7, 2, -22 },
  { 1963, 17, 16, 21, 2, -16 },
  { 1997, 10, 16, 14, 2, -16 },
  { 2017, 12, 16, 14, 1, -16 },
  { 2041, 11, 23, 14, 2, -16 },
  { 2073, 11, 23, 14, 1, -16 },
  { 2105, 7, 16, 10, 2, -16 },
  { 2119, 9, 16, 10, 1, -16 },
  { 2137, 8, 19, 9, 0, -19 },
  { 2156, 10, 16, 14, 2, -16 },
  { 2176, 12, 16, 12, 0, -16 },
  { 2200, 19, 16, 19, 0, -16 },
  { 2238, 12, 16, 12, 0, -16 },
  { 2262, 12, 23, 12, 0, -16 },
  { 2297, 8, 16, 10, 1, -16 },
  { 2313, 8, 26, 10, 1, -21 },
  { 2339, 3, 29, 12, 5, -22 },
  { 2350, 9, 26, 10, 1, -21 },
  { 2380, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD29PT7B_H_
