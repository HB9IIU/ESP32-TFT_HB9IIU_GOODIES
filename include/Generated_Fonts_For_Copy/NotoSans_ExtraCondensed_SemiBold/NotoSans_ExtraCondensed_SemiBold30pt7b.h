#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x0E, 0xFF, 0xE0,
  0xE7, 0xF3, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x0E, 0x60, 0x63, 0x03,
  0x18, 0x19, 0xC1, 0xCE, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6,
  0x06, 0x70, 0x33, 0x8F, 0xFF, 0x7F, 0xFB, 0xFF, 0xC6, 0x30, 0x31, 0x81,
  0x8C, 0x0C, 0xE0, 0x67, 0x07, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x1F,
  0xF7, 0xFE, 0xFF, 0xBD, 0x87, 0x30, 0xF6, 0x0E, 0xC1, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x37, 0x06, 0xF0, 0xDF, 0x9F, 0xFF, 0xE7, 0xF8,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x18, 0x00, 0x07, 0xE0, 0xE0, 0x7E,
  0x0E, 0x0E, 0x70, 0xC0, 0xE7, 0x1C, 0x0E, 0x71, 0x80, 0xE7, 0x38, 0x0E,
  0x73, 0x80, 0xE7, 0x30, 0x0E, 0x77, 0x3C, 0xE7, 0x77, 0xE7, 0xE6, 0x66,
  0x7E, 0xEE, 0x71, 0x8C, 0xE7, 0x01, 0xCE, 0x70, 0x1C, 0xE7, 0x01, 0x8E,
  0x70, 0x38, 0xE7, 0x03, 0x8E, 0x70, 0x30, 0x66, 0x07, 0x07, 0xE0, 0x60,
  0x3C, 0x0E, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xCE, 0x07, 0x9C, 0x0E, 0x38,
  0x1E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0xE7,
  0xF3, 0xDE, 0xF7, 0xB8, 0xFE, 0x70, 0xFC, 0xE1, 0xF9, 0xC1, 0xE3, 0xC7,
  0xC7, 0xFF, 0xC7, 0xFF, 0xC7, 0xE3, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0xC1, 0xC1, 0xC3, 0x83, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70, 0xF0,
  0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC3,
  0x80, 0x0E, 0x01, 0xC0, 0x38, 0x67, 0x2F, 0xFF, 0xFF, 0xC7, 0x80, 0xF8,
  0x3B, 0x8E, 0x78, 0xC6, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x7B, 0x9C, 0xEF, 0x73, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0xEF, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0xF0, 0xFF, 0x3D, 0xE7, 0x1E, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xEE, 0x3D, 0xE7,
  0x3F, 0xE3, 0xF8, 0x3E, 0x00, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0xE7, 0x47,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0F, 0xF3, 0xFF, 0x79, 0xE4, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x3C, 0x0F, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x0F, 0xF3,
  0xFF, 0x39, 0xE4, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC1, 0xF0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x3E, 0x07, 0xFF,
  0xEF, 0xFD, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0x70, 0x1B, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x06, 0x38, 0x71, 0xC3,
  0x0E, 0x38, 0x71, 0x83, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x90, 0x7F, 0x8F, 0xF9, 0xDF, 0x80, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xF0, 0x3F, 0xFF, 0x7F, 0xC7, 0xF0, 0x03, 0xC1, 0xF8,
  0x7F, 0x1F, 0x17, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE7, 0x1D, 0xFB, 0xFF,
  0x7C, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xEE, 0x1D, 0xC7, 0xBF,
  0xE3, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0xF8, 0x7F, 0xC7, 0x1E, 0xF0, 0xEF, 0x0E, 0xF0, 0xE7, 0x1E,
  0x7B, 0xC3, 0xFC, 0x1F, 0x03, 0xF8, 0x7B, 0xC7, 0x1E, 0xF0, 0xEE, 0x0E,
  0xE0, 0xFE, 0x0E, 0xF0, 0xEF, 0xFE, 0x7F, 0xC3, 0xF8, 0x0E, 0x07, 0xF1,
  0xFF, 0x3D, 0xEF, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7,
  0xBF, 0xF7, 0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x3F,
  0xC7, 0xF0, 0xFC, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE,
  0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEE, 0x73, 0xB9,
  0xC0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x0C, 0x1F, 0xEF,
  0xF9, 0xDF, 0x43, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0x03, 0x83, 0x80,
  0x38, 0x70, 0x03, 0x9C, 0x3E, 0x73, 0x8F, 0xE6, 0x63, 0x98, 0xCC, 0x63,
  0x1F, 0x9C, 0x63, 0xF3, 0x8C, 0x7E, 0x71, 0x8F, 0xCE, 0x31, 0xB9, 0xCE,
  0x37, 0x39, 0xCE, 0x63, 0xEF, 0xCC, 0x7D, 0xF1, 0xC3, 0x08, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x08, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xB8, 0x0F,
  0x78, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE3, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0x77, 0x80, 0xFF,
  0x01, 0xE0, 0xFF, 0x8F, 0xFE, 0xF7, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xEF, 0x1E, 0xFF, 0xEF, 0xF8, 0xFF, 0xCF, 0x3E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x03, 0xC0,
  0xFF, 0x1F, 0xF3, 0xE7, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x13, 0xFF, 0x1F, 0xF0, 0x7E, 0xFF, 0x87, 0xFE, 0x3F, 0xF9,
  0xE3, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0x9F,
  0x3F, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF,
  0xCE, 0x3C, 0x09, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFD, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x78, 0x3D,
  0xE0, 0xF3, 0xC3, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x80, 0xFF, 0xFC, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71,
  0xF7, 0xFF, 0xE0, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0E, 0x1E, 0xFE, 0xFC, 0xF8, 0xF0, 0xFF, 0x87, 0xBC, 0x79, 0xE3,
  0xCF, 0x3C, 0x79, 0xC3, 0xDE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFF, 0x0F, 0x78, 0x79, 0xC3, 0xCF, 0x1E, 0x38, 0xF1, 0xE7, 0x8F, 0x3C,
  0x3D, 0xE1, 0xEF, 0x07, 0x80, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFB, 0x83, 0xFE, 0xE0, 0xFF, 0xB8, 0x77, 0xEE,
  0x1D, 0xF9, 0xC7, 0x7E, 0x71, 0x9F, 0x9C, 0xE7, 0xE7, 0x39, 0xF8, 0xEE,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7E, 0x1E, 0x1F,
  0x87, 0x87, 0xE0, 0xE1, 0xC0, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07,
  0xFC, 0x1F, 0xB8, 0x7E, 0xE1, 0xFB, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x39,
  0xF8, 0xE7, 0xE3, 0xDF, 0x87, 0x7E, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3C, 0x03, 0x80, 0x1F, 0xE0, 0x7F, 0xE1,
  0xF3, 0xC7, 0x83, 0xCF, 0x07, 0x9E, 0x07, 0x38, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xB8, 0x0F,
  0x78, 0x1C, 0xF0, 0x78, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0xFF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFE, 0x3F, 0xFF, 0x7F, 0xCF, 0xF1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xF3,
  0xC7, 0x83, 0xCF, 0x07, 0x9E, 0x07, 0x38, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x78,
  0x1C, 0xF0, 0x78, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0x87, 0xFE, 0x3F,
  0xF9, 0xE3, 0xCF, 0x0E, 0x78, 0x73, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0xBE,
  0x3F, 0xF1, 0xFE, 0x0F, 0x78, 0x79, 0xC3, 0xCF, 0x1E, 0x78, 0xF1, 0xE7,
  0x8F, 0x3C, 0x39, 0xE1, 0xEF, 0x07, 0x80, 0x0E, 0x07, 0xFD, 0xFF, 0x3F,
  0xEF, 0x05, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3B, 0x0F, 0x7F, 0xEF, 0xF8,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x77, 0x87, 0x9F, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xF0, 0x1F, 0xC0,
  0x77, 0x03, 0xDC, 0x0E, 0x70, 0x39, 0xE0, 0xE3, 0x87, 0x8E, 0x1E, 0x38,
  0x70, 0xF1, 0xC1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0xE0, 0x78,
  0x1F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xDC, 0x1E, 0x0E, 0x70, 0x7C, 0x39,
  0xC3, 0xF0, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x38, 0xEC, 0x78, 0xE3,
  0x39, 0xC3, 0x9C, 0xE7, 0x0E, 0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0x77, 0x3B,
  0xC1, 0xD8, 0x6E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80,
  0xF8, 0x7E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x7B, 0xC3, 0x8E,
  0x3C, 0x79, 0xC1, 0xDE, 0x0E, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xE0, 0x77, 0x87, 0x9C, 0x3C, 0xE1,
  0xC7, 0x9E, 0x1C, 0xE0, 0xFF, 0x07, 0x80, 0xF0, 0x7B, 0x83, 0xDE, 0x1C,
  0xF1, 0xE3, 0x8E, 0x1E, 0x70, 0x77, 0x83, 0xB8, 0x1F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0xF0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xF8, 0xE0, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x0E, 0xE0, 0xE3,
  0x87, 0x1C, 0x70, 0x73, 0x83, 0xB8, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x06, 0x0F, 0xF1, 0xFF, 0x19, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0xFF, 0x7F, 0xEF, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F,
  0xC3, 0xFF, 0xFB, 0xF7, 0x7C, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x87, 0x7C, 0xFF, 0xDF, 0x7F, 0xC7, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xFF, 0xFD, 0xFF,
  0xBB, 0xE0, 0x06, 0x07, 0xF3, 0xF9, 0xE6, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x17, 0xF8, 0xFE, 0x1F, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xF3, 0xEF,
  0x7F, 0x77, 0x9F, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x7F, 0xF3, 0xF7, 0x3E, 0x70, 0x04,
  0x03, 0xF0, 0xFF, 0x3C, 0xE7, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x5F, 0xF9, 0xFF, 0x1F, 0xC0, 0x0F,
  0x8F, 0xC7, 0xE7, 0x83, 0xC1, 0xC0, 0xE0, 0xFE, 0xFF, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x0C, 0x03, 0xF7, 0x7F, 0x77, 0x9F, 0x70, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x7F, 0xF3,
  0xFF, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x41, 0xE7, 0xFE, 0x7F, 0xC3,
  0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0xC7, 0x7C,
  0xFF, 0xDF, 0x7B, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x78, 0x5F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x08, 0x71, 0xC7, 0x00, 0x00, 0x07,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xFF, 0xFB, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x1E, 0xE1, 0xCE, 0x3C, 0xE7, 0x8E, 0x70, 0xEF,
  0x0E, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE3, 0x8E, 0x3C, 0xE1,
  0xCE, 0x1E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x02, 0x04, 0x3B, 0xE7, 0xEF, 0xFF, 0xFB, 0xEF, 0xDF, 0xF1, 0xE3,
  0xF8, 0x78, 0xFE, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E,
  0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87,
  0x87, 0xE1, 0xE1, 0xC0, 0x02, 0x1D, 0xF3, 0xFF, 0x7D, 0xEF, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xE0, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0x9E, 0x70, 0xEF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x70, 0xF7,
  0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x03, 0x1D, 0xF3, 0xFF, 0x7D, 0xFF,
  0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F,
  0xE3, 0xFF, 0xF7, 0x7E, 0xEF, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x0C, 0x03, 0xF7, 0x7F, 0x77, 0x9F, 0x70, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F,
  0x7F, 0xF3, 0xF7, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x02, 0xEF, 0xFE, 0xFE, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x08, 0x3F, 0xFF, 0xDE,
  0x6E, 0x07, 0x03, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x3F,
  0xFF, 0xFE, 0xFE, 0x00, 0x18, 0x0C, 0x06, 0x07, 0x07, 0xF7, 0xF8, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0xC7, 0xE3, 0xF0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xFF, 0xDF, 0xBB,
  0xE7, 0xF0, 0x77, 0x0F, 0x70, 0xF7, 0x0E, 0x78, 0xE3, 0x8E, 0x39, 0xE3,
  0x9C, 0x39, 0xC1, 0xDC, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0xF0, 0xF0, 0xEE, 0x1E, 0x1D, 0xC7, 0xC7, 0xB8, 0xF8, 0xF7, 0x9B,
  0x9C, 0xF3, 0x73, 0x8E, 0x6E, 0x71, 0xDC, 0xDE, 0x3B, 0x9B, 0x87, 0x73,
  0x70, 0x7C, 0x6E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3E, 0x1E, 0x07, 0xC3,
  0xC0, 0x78, 0x78, 0xF0, 0xF7, 0x9E, 0x39, 0xE3, 0xDC, 0x1F, 0xC1, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xFC, 0x39, 0xC7, 0x9E,
  0x70, 0xEF, 0x0F, 0xF0, 0x77, 0x0F, 0x70, 0xF7, 0x8E, 0x78, 0xE3, 0x8E,
  0x39, 0xE3, 0x9C, 0x1D, 0xC1, 0xDC, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x7E, 0x07, 0xC0,
  0x78, 0x00, 0xFF, 0x7F, 0xBF, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C,
  0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0x1F, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF0, 0xF8, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF0,
  0x78, 0x7C, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF1,
  0xF0, 0xF8, 0x60, 0x00, 0x38, 0x1F, 0xE3, 0xFF, 0xF8, 0x7E, 0x80, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 21, 7, 2, -21 },
  { 12, 9, 7, 13, 2, -21 },
  { 20, 13, 21, 15, 1, -21 },
  { 55, 11, 25, 14, 1, -23 },
  { 90, 20, 22, 22, 1, -22 },
  { 145, 15, 22, 16, 1, -22 },
  { 187, 3, 7, 7, 2, -21 },
  { 190, 8, 27, 9, 1, -22 },
  { 217, 7, 27, 9, 1, -22 },
  { 241, 11, 11, 13, 1, -23 },
  { 257, 12, 15, 14, 1, -18 },
  { 280, 5, 7, 7, 1, -3 },
  { 285, 7, 4, 9, 1, -10 },
  { 289, 4, 4, 7, 2, -4 },
  { 291, 11, 22, 12, 0, -22 },
  { 322, 11, 22, 13, 1, -22 },
  { 353, 8, 21, 13, 2, -21 },
  { 374, 11, 22, 13, 1, -22 },
  { 405, 11, 22, 13, 1, -22 },
  { 436, 13, 22, 13, 0, -22 },
  { 472, 11, 21, 13, 1, -21 },
  { 501, 11, 22, 13, 1, -22 },
  { 532, 12, 21, 13, 1, -21 },
  { 564, 12, 22, 13, 1, -22 },
  { 597, 11, 22, 13, 1, -22 },
  { 628, 4, 16, 7, 2, -16 },
  { 636, 5, 20, 7, 1, -16 },
  { 649, 12, 14, 14, 1, -18 },
  { 670, 12, 9, 14, 1, -15 },
  { 684, 12, 14, 14, 1, -18 },
  { 705, 10, 22, 11, 0, -22 },
  { 733, 19, 24, 21, 1, -22 },
  { 790, 15, 21, 15, 0, -21 },
  { 830, 12, 21, 15, 2, -21 },
  { 862, 12, 22, 14, 1, -22 },
  { 895, 13, 21, 16, 2, -21 },
  { 930, 9, 21, 13, 2, -21 },
  { 954, 9, 21, 12, 2, -21 },
  { 978, 14, 22, 17, 1, -22 },
  { 1017, 13, 21, 17, 2, -21 },
  { 1052, 7, 21, 9, 1, -21 },
  { 1071, 8, 27, 8, -2, -21 },
  { 1098, 13, 21, 15, 2, -21 },
  { 1133, 9, 21, 12, 2, -21 },
  { 1157, 18, 21, 23, 2, -21 },
  { 1205, 14, 21, 18, 2, -21 },
  { 1242, 15, 22, 17, 1, -22 },
  { 1284, 11, 21, 14, 2, -21 },
  { 1313, 15, 27, 17, 1, -22 },
  { 1364, 13, 21, 15, 2, -21 },
  { 1399, 11, 22, 13, 1, -22 },
  { 1430, 12, 21, 12, 0, -21 },
  { 1462, 13, 21, 17, 2, -21 },
  { 1497, 14, 21, 14, 0, -21 },
  { 1534, 22, 21, 22, 0, -21 },
  { 1592, 13, 21, 13, 0, -21 },
  { 1627, 13, 21, 13, 0, -21 },
  { 1662, 10, 21, 12, 1, -21 },
  { 1689, 7, 27, 9, 2, -22 },
  { 1713, 11, 22, 12, 0, -22 },
  { 1744, 6, 27, 9, 1, -22 },
  { 1765, 13, 12, 15, 1, -21 },
  { 1785, 13, 2, 13, 0, 3 },
  { 1789, 7, 5, 9, 1, -23 },
  { 1794, 11, 17, 13, 1, -17 },
  { 1818, 11, 23, 15, 2, -23 },
  { 1850, 10, 17, 11, 1, -17 },
  { 1872, 12, 23, 15, 1, -23 },
  { 1907, 11, 17, 13, 1, -17 },
  { 1931, 9, 23, 8, 0, -23 },
  { 1957, 12, 24, 15, 1, -17 },
  { 1993, 11, 23, 15, 2, -23 },
  { 2025, 3, 23, 7, 2, -23 },
  { 2034, 6, 30, 7, -1, -23 },
  { 2057, 12, 23, 14, 2, -23 },
  { 2092, 3, 23, 7, 2, -23 },
  { 2101, 18, 17, 22, 2, -17 },
  { 2140, 11, 17, 15, 2, -17 },
  { 2164, 12, 17, 14, 1, -17 },
  { 2190, 11, 24, 15, 2, -17 },
  { 2223, 12, 24, 15, 1, -17 },
  { 2259, 8, 17, 10, 2, -17 },
  { 2276, 9, 17, 11, 1, -17 },
  { 2296, 9, 20, 9, 0, -20 },
  { 2319, 11, 16, 15, 2, -16 },
  { 2341, 12, 16, 12, 0, -16 },
  { 2365, 19, 16, 20, 0, -16 },
  { 2403, 12, 16, 12, 0, -16 },
  { 2427, 12, 23, 12, 0, -16 },
  { 2462, 9, 16, 10, 1, -16 },
  { 2480, 8, 26, 11, 1, -21 },
  { 2506, 3, 30, 13, 5, -23 },
  { 2518, 9, 26, 11, 1, -21 },
  { 2548, 12, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD30PT7B_H_
