#ifndef _ROBOTOMONO_REGULAR34PT7B_H_
#define _ROBOTOMONO_REGULAR34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x00, 0x0F,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x01, 0xC3, 0x80,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0C, 0x00,
  0xC1, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xE1, 0xC0, 0x1C, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0x81, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x00, 0x38,
  0x60, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xFF, 0x07, 0xFF, 0x0F, 0x1F, 0x3C, 0x0E, 0x70, 0x1E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x1E, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x61, 0x80, 0x0C, 0x38, 0x61, 0x87, 0x1C, 0x30, 0xE3, 0x06, 0x1C, 0xC0,
  0xE3, 0x18, 0x0F, 0xE6, 0x00, 0xF9, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x7C, 0x03, 0x9F, 0xC0, 0x67, 0x18,
  0x18, 0xC3, 0x87, 0x18, 0x70, 0xC3, 0x0E, 0x08, 0x61, 0xC0, 0x0E, 0x30,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00,
  0xF1, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x3C,
  0x70, 0x07, 0x78, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x07, 0xBC, 0x39, 0xC7, 0x8E, 0xF0, 0xE3, 0xB8, 0x3C, 0xEE, 0x07, 0xF3,
  0x80, 0xFC, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x87, 0xF0, 0xFF, 0xDE, 0x1F,
  0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x07,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x40, 0x40, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x10,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x83, 0x82, 0xE1,
  0x8E, 0xFD, 0xBE, 0x7F, 0xFF, 0x07, 0xE0, 0x07, 0xC0, 0x06, 0xC0, 0x0E,
  0xE0, 0x1C, 0x70, 0x38, 0x38, 0x38, 0x3C, 0x10, 0x10, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x7B, 0xDE, 0xF7, 0xB9, 0xDC, 0xE2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFE, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x80,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3C, 0x3C, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x07,
  0x70, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xF7, 0xF1, 0xE7,
  0xF3, 0xC7, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x0E, 0x38, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xF0,
  0x00, 0xC1, 0xF1, 0xFF, 0xFF, 0xF9, 0xF0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x07, 0xF8, 0x07, 0xFF,
  0x07, 0x87, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x3D, 0xE0, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80,
  0x01, 0x00, 0x3F, 0xC0, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0xC0, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0x9E, 0x1F, 0x1F, 0xFC, 0x1F, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xC0,
  0x30, 0x70, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x73, 0xC0, 0xFF, 0xE1,
  0xFF, 0xE3, 0xC1, 0xE1, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xCF, 0x8F, 0x8F, 0xFE,
  0x07, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x71, 0xE0, 0x77, 0xF8, 0x6F, 0xFC,
  0xFC, 0x1C, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1E, 0x3E, 0x3C, 0x1F, 0xF8,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x01, 0x00, 0x1F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x01, 0xCE,
  0x03, 0xDC, 0x03, 0xF8, 0x07, 0x70, 0x1E, 0xE0, 0x38, 0xE0, 0xF1, 0xFF,
  0xC0, 0xFE, 0x07, 0xFF, 0x1E, 0x0F, 0x38, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x03, 0xDF, 0x0F, 0x1F, 0xFC, 0x0F,
  0xF0, 0x01, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1C, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70,
  0x0F, 0x78, 0x0F, 0x38, 0x1F, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xCE, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xFF, 0xDC, 0x79, 0xF7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x38, 0xE3, 0x9E, 0x79, 0xC7, 0x38, 0x40, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0x80, 0x3C, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x7F, 0xC3, 0xFF, 0x9E, 0x1F, 0x70, 0x1F, 0x80, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0xE0, 0x70, 0x70, 0x0E, 0x38, 0x01, 0x8C, 0x3E, 0x36, 0x1F,
  0x8D, 0x8E, 0x63, 0x63, 0x18, 0xF1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0x63,
  0xC6, 0x18, 0xF1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0xE2, 0xC7, 0xF9, 0x98,
  0xF7, 0xC6, 0x18, 0x61, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x02, 0x00, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x18, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x38, 0x30, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0x80, 0x38, 0xE0, 0x0E,
  0x78, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0xE1, 0xFC, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D,
  0xC0, 0x0E, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x70, 0xF8, 0xF8, 0x3F, 0xF8,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xE3, 0xF8, 0xE0, 0x78, 0xE0,
  0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0x9C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xCF, 0xFF,
  0x9C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x87, 0xC7, 0x80, 0xE3, 0x80, 0x3B, 0xC0, 0x1D,
  0xC0, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xEE, 0x00, 0x77, 0x80, 0x39, 0xC0, 0x3C, 0xFC, 0x7C, 0x3F, 0xFC,
  0x07, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xF7, 0x01, 0xCF, 0x8F, 0x8F, 0xFE, 0x07, 0xF0, 0xE0, 0x0F, 0x70,
  0x0F, 0x38, 0x0F, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x07, 0x83, 0x87, 0x81,
  0xC7, 0x80, 0xE7, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xDE, 0x03, 0xC7, 0x01, 0xC3, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38,
  0x1E, 0x1C, 0x07, 0x8E, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x3D, 0xC0, 0x0F,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1B, 0xFC, 0x3F, 0xEC, 0x3F, 0xEE,
  0x37, 0xEE, 0x77, 0xE6, 0x77, 0xE7, 0x67, 0xE7, 0xE7, 0xE3, 0xE7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE1, 0xC7, 0xE1, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xF7, 0x07, 0xF7, 0x87, 0xF3, 0x87, 0xF3, 0xC7, 0xF1, 0xC7, 0xF1,
  0xE7, 0xF0, 0xE7, 0xF0, 0xF7, 0xF0, 0x77, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0x00, 0x80, 0x07,
  0xF8, 0x07, 0xFE, 0x07, 0xCF, 0x87, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE1, 0xC0, 0xF0, 0xFD, 0xF0, 0x3F, 0xF0,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1E, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xC7, 0x87,
  0x81, 0xE3, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3,
  0xC0, 0xF0, 0xFD, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x10, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0xFC, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1E, 0xE0, 0x1C, 0xE0, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7B, 0xC0, 0x78, 0xF8, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3E,
  0x7C, 0x1F, 0xF8, 0x07, 0xF0, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x39,
  0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x1C, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0xC7,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0xE0,
  0xE0, 0xFC, 0x1C, 0x19, 0x83, 0x87, 0x38, 0xF0, 0xE7, 0x1F, 0x1C, 0xE3,
  0xE3, 0x9C, 0x6C, 0x73, 0x8D, 0x8E, 0x71, 0xB1, 0xCE, 0x76, 0x31, 0xCE,
  0xE6, 0x19, 0x9D, 0xC3, 0x31, 0xB8, 0x76, 0x37, 0x0F, 0xC6, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x78, 0x03, 0xCE, 0x00,
  0xE3, 0xC0, 0x78, 0x70, 0x1C, 0x1E, 0x0E, 0x03, 0x87, 0x80, 0x71, 0xC0,
  0x1C, 0xF0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x1C, 0x03, 0xC7,
  0x80, 0xE0, 0xE0, 0x78, 0x3C, 0x1C, 0x07, 0x0E, 0x01, 0xE7, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x78, 0xE0, 0x1C, 0x3C,
  0x0F, 0x07, 0x03, 0x81, 0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F,
  0xFE, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFC, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x0E, 0xE0, 0xE7, 0x07, 0x18, 0x30, 0xE3,
  0x87, 0x1C, 0x1D, 0xC0, 0xEE, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0xE0, 0x7F, 0xF1, 0xE1, 0xE7,
  0x81, 0xEE, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFE, 0x3F, 0xFC, 0xF8,
  0x3B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x0F, 0x7C, 0xFE,
  0x7F, 0xFE, 0x7F, 0x3C, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE7, 0xE1, 0xFF, 0xF3, 0xF1,
  0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xBC, 0x0F, 0x7E,
  0x3C, 0xFF, 0xF9, 0xCF, 0xC0, 0x07, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x38,
  0x0E, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x07, 0x70, 0x07, 0x38, 0x0E, 0x3E,
  0x3E, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0xEE, 0x3F, 0xFC,
  0xF8, 0xFB, 0xC0, 0xF7, 0x00, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDE, 0x07,
  0x9F, 0x1F, 0x1F, 0xF6, 0x1F, 0xCC, 0x07, 0xF0, 0x1F, 0xFC, 0x3E, 0x3C,
  0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x02, 0x38, 0x07,
  0x3E, 0x1E, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xE6,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE6,
  0x3F, 0xEC, 0xF8, 0xFB, 0xC0, 0xF7, 0x00, 0xEE, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x01,
  0xDE, 0x07, 0x9F, 0x1F, 0x1F, 0xFE, 0x1F, 0xDC, 0x00, 0x38, 0x00, 0x72,
  0x00, 0xEE, 0x03, 0xCF, 0xBF, 0x0F, 0xFC, 0x07, 0xE0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE7, 0xF1, 0xDF, 0xF3, 0xF1, 0xF7, 0x80, 0xEE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE8, 0x7C, 0xFF,
  0x3F, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x3E, 0xE0, 0x78, 0xE0, 0xF0,
  0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xF3, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x78,
  0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xDF, 0x3E, 0x6F, 0xFF, 0xBC,
  0xF9, 0xFC, 0x38, 0x7C, 0x1C, 0x3E, 0x0E, 0x1F, 0x07, 0x0F, 0x83, 0x87,
  0xC1, 0xC3, 0xE0, 0xE1, 0xF0, 0x70, 0xF8, 0x38, 0x7C, 0x1C, 0x3E, 0x0E,
  0x1F, 0x07, 0x0F, 0x83, 0x87, 0xC1, 0xC3, 0xE0, 0xE1, 0xC0, 0xE7, 0xF1,
  0xDF, 0xF3, 0xF1, 0xF7, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x07, 0xF0, 0x1F, 0xF8,
  0x3E, 0x3C, 0x78, 0x1E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F,
  0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0xE7, 0xE1, 0xFF, 0xF3,
  0xF3, 0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xBC, 0x0F,
  0x7C, 0x3C, 0xFF, 0xF9, 0xDF, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xE6, 0x3F, 0xEC, 0xF8,
  0xFB, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDE, 0x03, 0x9F,
  0x1F, 0x1F, 0xFE, 0x1F, 0xDC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0xE3, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0xE0, 0x7F, 0xF1, 0xF1, 0xF3, 0x80, 0xE7, 0x01, 0xEE, 0x00, 0x1C,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x07, 0xBC, 0x1E, 0x3F, 0xF8, 0x1F, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC2, 0x03, 0xFF, 0x01, 0xFE, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xDC, 0x0F, 0xBC, 0x7F,
  0x3F, 0xEE, 0x3F, 0x1C, 0xE0, 0x07, 0xF0, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xC7, 0x00, 0xE1, 0xC0, 0x60, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E,
  0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x3B, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0xC0, 0xFC, 0x1C, 0x1B,
  0x83, 0x83, 0x30, 0xF0, 0xE6, 0x1E, 0x1C, 0xE3, 0xE3, 0x9C, 0x6C, 0x63,
  0x9D, 0x8C, 0x33, 0x31, 0x86, 0x67, 0x70, 0xCC, 0x6E, 0x1F, 0x8D, 0x83,
  0xE1, 0xB0, 0x3C, 0x36, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xF0, 0x07, 0xBC, 0x07, 0x8E, 0x07, 0x83, 0x83, 0x81, 0xE3,
  0x80, 0x73, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0xEE, 0x00, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0x70, 0x70, 0x1C,
  0x78, 0x0F, 0x78, 0x03, 0xC0, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x38,
  0xE0, 0x1E, 0x38, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x78, 0x38, 0x0E,
  0x1C, 0x03, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x02, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x10, 0x0E, 0x01, 0xF0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x07, 0xC0,
  0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1F,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x07,
  0x00, 0xF8, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x01, 0xF0,
  0x3F, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x80, 0x60, 0x00,
  0x3F, 0x00, 0x8F, 0xF0, 0x1F, 0xCF, 0x83, 0x70, 0x7D, 0xEC, 0x07, 0xF8,
  0x00, 0x7E, 0x00,
};

const GFXglyph RobotoMono_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 24, 20, 8, -24 },
  { 13, 8, 8, 20, 6, -26 },
  { 21, 19, 24, 20, 1, -24 },
  { 78, 15, 31, 20, 3, -28 },
  { 137, 19, 25, 20, 1, -25 },
  { 197, 18, 25, 20, 2, -25 },
  { 254, 3, 8, 20, 8, -26 },
  { 257, 9, 35, 20, 6, -27 },
  { 297, 9, 35, 20, 5, -27 },
  { 337, 16, 16, 20, 3, -24 },
  { 369, 17, 18, 20, 2, -20 },
  { 408, 5, 10, 20, 6, -4 },
  { 415, 12, 3, 20, 4, -12 },
  { 420, 5, 4, 20, 8, -4 },
  { 423, 13, 26, 20, 4, -24 },
  { 466, 16, 25, 20, 2, -25 },
  { 516, 10, 24, 20, 3, -24 },
  { 546, 17, 25, 20, 1, -25 },
  { 600, 15, 25, 20, 2, -25 },
  { 647, 18, 24, 20, 1, -24 },
  { 701, 15, 24, 20, 3, -24 },
  { 746, 16, 24, 20, 2, -24 },
  { 794, 16, 24, 20, 2, -24 },
  { 842, 15, 25, 20, 3, -25 },
  { 889, 16, 25, 20, 2, -25 },
  { 939, 5, 19, 20, 9, -19 },
  { 951, 6, 25, 20, 8, -19 },
  { 970, 14, 15, 20, 3, -18 },
  { 997, 15, 10, 20, 3, -16 },
  { 1016, 15, 15, 20, 3, -18 },
  { 1045, 14, 25, 20, 3, -25 },
  { 1089, 18, 24, 20, 1, -24 },
  { 1143, 18, 24, 20, 1, -24 },
  { 1197, 16, 24, 20, 3, -24 },
  { 1245, 17, 25, 20, 2, -25 },
  { 1299, 16, 24, 20, 3, -24 },
  { 1347, 15, 24, 20, 3, -24 },
  { 1392, 15, 24, 20, 3, -24 },
  { 1437, 17, 25, 20, 2, -25 },
  { 1491, 16, 24, 20, 2, -24 },
  { 1539, 15, 24, 20, 3, -24 },
  { 1584, 15, 24, 20, 2, -24 },
  { 1629, 17, 24, 20, 3, -24 },
  { 1680, 15, 24, 20, 3, -24 },
  { 1725, 16, 24, 20, 2, -24 },
  { 1773, 16, 24, 20, 2, -24 },
  { 1821, 17, 25, 20, 2, -25 },
  { 1875, 16, 24, 20, 3, -24 },
  { 1923, 17, 29, 20, 2, -25 },
  { 1985, 16, 24, 20, 3, -24 },
  { 2033, 17, 25, 20, 2, -25 },
  { 2087, 18, 24, 20, 1, -24 },
  { 2141, 16, 24, 20, 2, -24 },
  { 2189, 18, 24, 20, 1, -24 },
  { 2243, 19, 24, 20, 1, -24 },
  { 2300, 18, 24, 20, 1, -24 },
  { 2354, 18, 24, 20, 1, -24 },
  { 2408, 16, 24, 20, 2, -24 },
  { 2456, 7, 33, 20, 7, -28 },
  { 2485, 13, 26, 20, 4, -24 },
  { 2528, 6, 33, 20, 7, -28 },
  { 2553, 13, 13, 20, 4, -24 },
  { 2575, 15, 3, 20, 3, 0 },
  { 2581, 7, 5, 20, 7, -25 },
  { 2586, 15, 18, 20, 3, -18 },
  { 2620, 15, 26, 20, 3, -26 },
  { 2669, 16, 18, 20, 2, -18 },
  { 2705, 15, 26, 20, 2, -26 },
  { 2754, 16, 18, 20, 2, -18 },
  { 2790, 16, 26, 20, 3, -26 },
  { 2842, 15, 25, 20, 2, -18 },
  { 2889, 15, 26, 20, 3, -26 },
  { 2938, 15, 24, 20, 3, -24 },
  { 2983, 11, 31, 20, 3, -24 },
  { 3026, 16, 26, 20, 3, -26 },
  { 3078, 15, 26, 20, 3, -26 },
  { 3127, 17, 18, 20, 2, -18 },
  { 3166, 15, 18, 20, 3, -18 },
  { 3200, 16, 18, 20, 2, -18 },
  { 3236, 15, 25, 20, 3, -18 },
  { 3283, 15, 25, 20, 2, -18 },
  { 3330, 13, 18, 20, 5, -18 },
  { 3360, 15, 18, 20, 3, -18 },
  { 3394, 16, 22, 20, 2, -22 },
  { 3438, 15, 18, 20, 3, -18 },
  { 3472, 17, 18, 20, 2, -18 },
  { 3511, 19, 18, 20, 1, -18 },
  { 3554, 17, 18, 20, 2, -18 },
  { 3593, 18, 25, 20, 1, -18 },
  { 3650, 15, 18, 20, 3, -18 },
  { 3684, 12, 33, 20, 5, -27 },
  { 3734, 2, 31, 20, 9, -24 },
  { 3742, 12, 33, 20, 5, -27 },
  { 3792, 19, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_Regular34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular34pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_REGULAR34PT7B_H_
