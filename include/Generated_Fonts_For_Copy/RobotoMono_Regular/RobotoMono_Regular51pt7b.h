#ifndef _ROBOTOMONO_REGULAR51PT7B_H_
#define _ROBOTOMONO_REGULAR51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xDE, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x07, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x0E,
  0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x81, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF0, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC7, 0xF0, 0xFC, 0x03, 0xF1, 0xF0, 0x03, 0xE3, 0xC0,
  0x07, 0xC7, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xE0,
  0x1F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x03, 0x80,
  0x80, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x3C, 0x0F,
  0x03, 0x83, 0x80, 0xF0, 0x38, 0x78, 0x0F, 0x07, 0x87, 0x00, 0x78, 0x78,
  0xF0, 0x07, 0xFF, 0x0E, 0x00, 0x3F, 0xE1, 0xE0, 0x00, 0xFC, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x3F,
  0x80, 0x03, 0xC7, 0xFE, 0x00, 0x38, 0xFF, 0xE0, 0x07, 0x8F, 0x0F, 0x00,
  0xF1, 0xE0, 0x70, 0x0F, 0x1E, 0x07, 0x01, 0xE1, 0xE0, 0x70, 0x1C, 0x1E,
  0x07, 0x03, 0xC1, 0xE0, 0x70, 0x18, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x03,
  0xC0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x1F, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x3C, 0x7E, 0x7C, 0x07, 0x9F, 0x8F, 0xC1, 0xF3, 0xE0,
  0xF8, 0x3E, 0xF8, 0x0F, 0x87, 0x9F, 0x00, 0xF8, 0xF3, 0xC0, 0x1F, 0xBE,
  0x78, 0x01, 0xF7, 0x8F, 0x00, 0x1F, 0xF1, 0xE0, 0x01, 0xFC, 0x3E, 0x00,
  0x3F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC7, 0xE0, 0x7F, 0xF0, 0x7E, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0xC0,
  0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x60, 0x01, 0x00, 0x40,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x00, 0x70,
  0x3C, 0x0E, 0x7C, 0x3C, 0x3E, 0xFF, 0xBC, 0xFE, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0xC0, 0x07, 0xC3, 0xC0, 0x0F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x0E, 0x00, 0xE0, 0x02,
  0x00, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE7, 0x87, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x7E,
  0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xC0, 0x1F,
  0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7E, 0x7F, 0xC1,
  0xF8, 0xFF, 0x87, 0xE1, 0xFF, 0x3F, 0x03, 0xFE, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7F, 0x8F, 0xE0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x03, 0xF8, 0x3F, 0x81, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0,
  0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x81, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x7C, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF1, 0xF0, 0x0F, 0xE0, 0x80, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3F,
  0xC7, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x3E,
  0x03, 0xE7, 0xFE, 0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xFF, 0x83, 0xF3,
  0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC7, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x1F,
  0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x0F, 0x80, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x3F, 0x87, 0xE0, 0x1F, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x0F,
  0xBE, 0x00, 0x3F, 0x3F, 0x00, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFD, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xEF, 0x03, 0xFF, 0x1E, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x11, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x7E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x0C, 0x1F,
  0x8F, 0xCF, 0xF7, 0xF9, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1E, 0x1F, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFF, 0x3E, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x3C,
  0x1E, 0x38, 0x1F, 0xE1, 0xC7, 0x07, 0xFE, 0x39, 0xC1, 0xF1, 0xC3, 0x38,
  0x38, 0x38, 0x77, 0x0F, 0x06, 0x0F, 0xC1, 0xC0, 0xC1, 0xF8, 0x78, 0x38,
  0x3F, 0x0E, 0x07, 0x07, 0xE1, 0xC0, 0xE0, 0xFC, 0x38, 0x1C, 0x1F, 0x87,
  0x03, 0x83, 0xF0, 0xE0, 0x70, 0x7E, 0x1C, 0x0E, 0x0D, 0xC3, 0x81, 0xC1,
  0xB8, 0x70, 0x78, 0x77, 0x0E, 0x0F, 0x0C, 0xE1, 0xFF, 0xE3, 0x9C, 0x3F,
  0xFF, 0xE3, 0xC3, 0xF9, 0xFC, 0x38, 0x3C, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0x00, 0x0F, 0xC0,
  0x60, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8,
  0x01, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x07, 0xF0, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xF8, 0x07, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x07,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xE0, 0xFE, 0x03,
  0xE0, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0x80, 0x3F, 0xFD, 0xE0, 0x00,
  0x1F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0xC1, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0xE7,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0,
  0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F,
  0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0x87, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xEF, 0x07, 0xBF, 0xDE, 0x0F, 0x7F, 0xBC, 0x1E, 0xFF,
  0x3C, 0x79, 0xFE, 0x78, 0xF3, 0xFC, 0xF3, 0xE7, 0xF8, 0xF7, 0x8F, 0xF1,
  0xEF, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F,
  0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x78,
  0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xEF,
  0x00, 0x7F, 0xDF, 0x00, 0xFF, 0x9E, 0x01, 0xFF, 0x3E, 0x03, 0xFE, 0x3C,
  0x07, 0xFC, 0x7C, 0x0F, 0xF8, 0x78, 0x1F, 0xF0, 0xF8, 0x3F, 0xE0, 0xF8,
  0x7F, 0xC1, 0xF0, 0xFF, 0x81, 0xF1, 0xFF, 0x03, 0xE3, 0xFE, 0x03, 0xE7,
  0xFC, 0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xF0, 0x0F, 0xBF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xF8, 0x07, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0, 0x07, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C,
  0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x08, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE1, 0xF8, 0x03,
  0xF0, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x7F, 0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F,
  0x80, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x03, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E,
  0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xFC, 0x0F,
  0x80, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x3F, 0x07, 0xDE, 0x0F, 0xE0, 0xFB,
  0xC1, 0xFC, 0x1E, 0x78, 0x3F, 0x83, 0xCF, 0x07, 0xF0, 0x79, 0xE0, 0xEF,
  0x0F, 0x3C, 0x1D, 0xE1, 0xE7, 0xC7, 0xBC, 0x3C, 0xF8, 0xF7, 0x87, 0x8F,
  0x1E, 0x70, 0xF1, 0xE3, 0x8E, 0x3E, 0x3C, 0x71, 0xE7, 0x87, 0x9E, 0x3C,
  0xF0, 0xF3, 0xC7, 0x9E, 0x1E, 0x78, 0xF3, 0xC3, 0xCF, 0x0E, 0x78, 0x79,
  0xC1, 0xCF, 0x07, 0xB8, 0x3D, 0xE0, 0xFF, 0x07, 0xBC, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF0,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3,
  0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1F, 0x0F, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xE0, 0x1F, 0x8F, 0x80,
  0x1F, 0x1E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xC0, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBF,
  0x00, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFE, 0x78, 0x3F,
  0xF0, 0xF8, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC7, 0xFC, 0x0F, 0xBF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFB, 0xFC,
  0x7F, 0x80, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0xFD, 0xFE, 0x03, 0xF3, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xBF, 0xFE, 0x1F, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x3F, 0xC3, 0xF0, 0x0F,
  0x8F, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80,
  0x0F, 0x8F, 0xC0, 0x3E, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0xF8, 0xF0, 0x7F, 0xF9, 0xE1, 0xFF, 0xFB, 0xC7,
  0xFD, 0xFF, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x3F, 0x01, 0xFC, 0x7F, 0x9F, 0xF8,
  0x7F, 0xFE, 0xF0, 0x7F, 0xF9, 0xE0, 0x3F, 0xE3, 0xC0, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xE3, 0xF8,
  0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x04, 0x3F, 0x00, 0x0E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0xFE,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x1E,
  0x0F, 0xFF, 0x3C, 0x3F, 0xFF, 0x78, 0xFF, 0xBF, 0xF1, 0xF8, 0x0F, 0xE7,
  0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x8F, 0xF3, 0xFF, 0x0F, 0xFF, 0xDE, 0x0F, 0xFF, 0x3C,
  0x07, 0xFC, 0x78, 0x00, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC2,
  0x00, 0x0F, 0x8C, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xFE, 0x0F, 0x9F, 0xFE,
  0x1F, 0x7F, 0xFE, 0x3F, 0xFD, 0xFE, 0x7F, 0x80, 0x7E, 0xFE, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0,
  0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00,
  0xF9, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xF8, 0x7F, 0x3F,
  0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x07,
  0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F,
  0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8,
  0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F,
  0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C,
  0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0,
  0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3C,
  0xF8, 0x7F, 0xC1, 0xF3, 0xFF, 0xC3, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xF0, 0x0F, 0xDF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x03,
  0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE1,
  0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xF8, 0xFF,
  0x81, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F,
  0x9F, 0x80, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x80,
  0x1F, 0xBF, 0x80, 0x7E, 0x7F, 0xC3, 0xF8, 0xFF, 0xFF, 0xF1, 0xF7, 0xFF,
  0x83, 0xE3, 0xFE, 0x07, 0xC0, 0x40, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x1E,
  0x0F, 0xFF, 0x3C, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xF1, 0xF8, 0x0F, 0xE7,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0xF1, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBC,
  0x07, 0xFC, 0x78, 0x00, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFC, 0x05, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x3F,
  0xC3, 0xE0, 0x0F, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0x80,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x80, 0x1F, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE7,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x02, 0x00,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x7D, 0xF0, 0x03,
  0xF3, 0xE0, 0x1F, 0xCF, 0xF7, 0xFF, 0x1F, 0xFF, 0xBC, 0x3F, 0xFC, 0xF0,
  0x7F, 0xC3, 0xC0, 0x10, 0x00, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x00,
  0xFF, 0xC0, 0x38, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x01, 0xE7,
  0x80, 0xF8, 0x0F, 0x3C, 0x07, 0xC0, 0x78, 0xE0, 0x7F, 0x07, 0x87, 0x83,
  0xB8, 0x3C, 0x3C, 0x1D, 0xC1, 0xE1, 0xE0, 0xEE, 0x0F, 0x0F, 0x0F, 0x78,
  0x70, 0x38, 0x73, 0xC3, 0x81, 0xE3, 0x8E, 0x3C, 0x0F, 0x1C, 0x71, 0xE0,
  0x79, 0xE3, 0xCF, 0x03, 0xCE, 0x1E, 0x70, 0x0E, 0x70, 0x73, 0x80, 0x73,
  0x83, 0x9C, 0x03, 0xFC, 0x1D, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0,
  0x07, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0xFC,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0x3F, 0xFC, 0x00, 0x73, 0xFF, 0xF0, 0x0F, 0x7C, 0x3F,
  0x80, 0xF7, 0x80, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xEF, 0x00, 0x3F, 0xFC,
  0x30, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 6, 36, 31, 12, -36 },
  { 28, 12, 12, 31, 9, -38 },
  { 46, 27, 36, 31, 2, -36 },
  { 168, 23, 47, 31, 4, -42 },
  { 304, 28, 38, 31, 1, -37 },
  { 437, 27, 38, 31, 3, -37 },
  { 566, 4, 12, 31, 12, -38 },
  { 572, 13, 53, 31, 9, -41 },
  { 659, 13, 53, 31, 8, -41 },
  { 746, 24, 24, 31, 4, -36 },
  { 818, 25, 26, 31, 3, -30 },
  { 900, 7, 13, 31, 9, -5 },
  { 912, 19, 4, 31, 5, -18 },
  { 922, 8, 7, 31, 12, -7 },
  { 929, 20, 39, 31, 6, -36 },
  { 1027, 23, 38, 31, 4, -37 },
  { 1137, 14, 36, 31, 5, -36 },
  { 1200, 25, 37, 31, 2, -37 },
  { 1316, 23, 38, 31, 2, -37 },
  { 1426, 26, 36, 31, 2, -36 },
  { 1543, 22, 37, 31, 5, -36 },
  { 1645, 22, 37, 31, 4, -36 },
  { 1747, 24, 36, 31, 3, -36 },
  { 1855, 23, 38, 31, 4, -37 },
  { 1965, 23, 37, 31, 4, -37 },
  { 2072, 7, 29, 31, 14, -29 },
  { 2098, 9, 37, 31, 12, -29 },
  { 2140, 21, 22, 31, 4, -27 },
  { 2198, 23, 14, 31, 4, -23 },
  { 2239, 22, 22, 31, 4, -27 },
  { 2300, 21, 37, 31, 5, -37 },
  { 2398, 27, 36, 31, 2, -36 },
  { 2520, 27, 36, 31, 2, -36 },
  { 2642, 24, 36, 31, 4, -36 },
  { 2750, 25, 38, 31, 3, -37 },
  { 2869, 24, 36, 31, 4, -36 },
  { 2977, 22, 36, 31, 5, -36 },
  { 3076, 22, 36, 31, 5, -36 },
  { 3175, 26, 38, 31, 2, -37 },
  { 3299, 23, 36, 31, 4, -36 },
  { 3403, 22, 36, 31, 4, -36 },
  { 3502, 24, 37, 31, 2, -36 },
  { 3613, 26, 36, 31, 4, -36 },
  { 3730, 22, 36, 31, 5, -36 },
  { 3829, 23, 36, 31, 4, -36 },
  { 3933, 23, 36, 31, 4, -36 },
  { 4037, 25, 38, 31, 3, -37 },
  { 4156, 24, 36, 31, 5, -36 },
  { 4264, 27, 43, 31, 2, -37 },
  { 4410, 24, 36, 31, 4, -36 },
  { 4518, 25, 38, 31, 3, -37 },
  { 4637, 27, 36, 31, 2, -36 },
  { 4759, 24, 37, 31, 3, -36 },
  { 4870, 27, 36, 31, 2, -36 },
  { 4992, 27, 36, 31, 2, -36 },
  { 5114, 27, 36, 31, 2, -36 },
  { 5236, 27, 36, 31, 2, -36 },
  { 5358, 24, 36, 31, 3, -36 },
  { 5466, 9, 49, 31, 11, -41 },
  { 5522, 19, 39, 31, 6, -36 },
  { 5615, 10, 49, 31, 10, -41 },
  { 5677, 19, 19, 31, 6, -36 },
  { 5723, 23, 4, 31, 4, 0 },
  { 5735, 10, 7, 31, 10, -37 },
  { 5744, 23, 28, 31, 4, -27 },
  { 5825, 23, 39, 31, 4, -38 },
  { 5938, 23, 28, 31, 4, -27 },
  { 6019, 23, 39, 31, 3, -38 },
  { 6132, 24, 28, 31, 3, -27 },
  { 6216, 24, 39, 31, 4, -39 },
  { 6333, 23, 38, 31, 3, -27 },
  { 6443, 23, 38, 31, 4, -38 },
  { 6553, 23, 37, 31, 5, -37 },
  { 6660, 16, 48, 31, 5, -37 },
  { 6756, 24, 38, 31, 4, -38 },
  { 6870, 23, 38, 31, 5, -38 },
  { 6980, 26, 27, 31, 2, -27 },
  { 7068, 23, 27, 31, 4, -27 },
  { 7146, 25, 28, 31, 3, -27 },
  { 7234, 23, 37, 31, 4, -27 },
  { 7341, 23, 37, 31, 3, -27 },
  { 7448, 19, 27, 31, 8, -27 },
  { 7513, 23, 28, 31, 4, -27 },
  { 7594, 23, 34, 31, 4, -33 },
  { 7692, 22, 28, 31, 4, -27 },
  { 7769, 26, 27, 31, 2, -27 },
  { 7857, 29, 27, 31, 1, -27 },
  { 7955, 25, 27, 31, 3, -27 },
  { 8040, 27, 38, 31, 2, -27 },
  { 8169, 23, 27, 31, 4, -27 },
  { 8247, 17, 49, 31, 8, -40 },
  { 8352, 4, 46, 31, 13, -36 },
  { 8375, 17, 49, 31, 8, -40 },
  { 8480, 28, 10, 31, 1, -20 },
};

const GFXfont RobotoMono_Regular51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular51pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_REGULAR51PT7B_H_
