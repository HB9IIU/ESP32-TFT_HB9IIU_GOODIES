#ifndef _ROBOTOMONO_REGULAR41PT7B_H_
#define _ROBOTOMONO_REGULAR41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x60, 0x70, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x0E, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x3E, 0x07, 0x87, 0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x1E,
  0xF0, 0x03, 0xCF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x07, 0x9F, 0x81, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x8E, 0x00, 0x0E,
  0x0C, 0x08, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x71, 0xC0, 0xE0,
  0xE3, 0x81, 0xC3, 0x8E, 0x01, 0xC7, 0x1C, 0x03, 0xFC, 0x70, 0x03, 0xF0,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x8F, 0xC0, 0x07, 0x3F, 0xC0, 0x1C, 0xF1,
  0xC0, 0x39, 0xC1, 0x80, 0xE3, 0x83, 0x81, 0x87, 0x07, 0x07, 0x0E, 0x0E,
  0x04, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x78, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0x70, 0x07, 0x01,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE3, 0xE0, 0x03, 0xDF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0xFB, 0xC0, 0xE7, 0xC7, 0x83, 0x9E, 0x0F, 0x1E, 0xF0, 0x3E,
  0x7B, 0xC0, 0x79, 0xCF, 0x00, 0xFF, 0x3C, 0x01, 0xF8, 0xF0, 0x07, 0xE1,
  0xE0, 0x0F, 0x07, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFE, 0xF8, 0x3F,
  0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x18, 0x07, 0x81, 0xE0,
  0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x08, 0x40, 0x0C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x81, 0xC0, 0x5C, 0x38, 0x3B, 0xF3, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x01,
  0xC7, 0x80, 0x78, 0x70, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7,
  0x9E, 0x73, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF,
  0xFF, 0x78, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F,
  0xF8, 0x1F, 0xFF, 0x83, 0xC0, 0x78, 0xF0, 0x07, 0x9C, 0x00, 0xF7, 0x80,
  0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7B, 0xFC, 0x3E, 0x7F, 0x8F, 0x8F, 0xF3, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x77, 0x80, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x70, 0xF0, 0x1E, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x1F, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x40, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xC0, 0xF8, 0xF0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x40, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C,
  0x07, 0x9E, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xF7, 0xC0, 0x78, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1C, 0x0F,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x07,
  0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xBF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0x8F, 0xC7, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0x78, 0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x1F,
  0x83, 0xDF, 0xF8, 0xFF, 0xFF, 0x3F, 0x83, 0xEF, 0x80, 0x7B, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x8F, 0x83, 0xE1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x1E, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x1E, 0x7C, 0x0F,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0x1E, 0x03, 0xCF,
  0x00, 0x7B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xE7, 0x80, 0xF9, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7C, 0x0F, 0x1E, 0x01, 0xE7, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x1F, 0x3C, 0x0F, 0xCF, 0xFF, 0x71, 0xFF, 0xBC, 0x1F, 0xCF,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x7B,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xBF, 0xFF, 0xF7, 0x80, 0x3C, 0xF9, 0xFB, 0xE7, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xCF,
  0x9F, 0x3C, 0x78, 0xF1, 0xC7, 0x8E, 0x08, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x7E, 0x3E, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x70, 0x70,
  0x00, 0xE1, 0x83, 0xE1, 0x8E, 0x1F, 0xC7, 0x30, 0xF3, 0x0D, 0xC7, 0x0C,
  0x36, 0x1C, 0x30, 0xD8, 0x60, 0xC3, 0x63, 0x83, 0x0F, 0x8E, 0x0C, 0x3E,
  0x38, 0x30, 0xF8, 0xC0, 0xC3, 0xE3, 0x07, 0x0F, 0x8C, 0x1C, 0x7E, 0x38,
  0x71, 0x98, 0xE3, 0xCE, 0x61, 0xFB, 0xF1, 0xC7, 0xCF, 0x87, 0x04, 0x08,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x04, 0x00, 0xFC, 0x70, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0xC0, 0x03, 0xDE, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x70, 0x0E,
  0x03, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0x80,
  0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x78, 0x07, 0xCF, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0x80, 0xFC,
  0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFD, 0xFC, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x38, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x07, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0xC0, 0x1E,
  0x1E, 0x03, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F,
  0x8F, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1E, 0x03, 0xE3,
  0xC0, 0x1E, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x3C,
  0x00, 0x73, 0xE0, 0x0F, 0x1F, 0x01, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x1F, 0xF0, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B,
  0xC0, 0x1E, 0x78, 0x03, 0xC7, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0,
  0x78, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0x7C, 0x00,
  0x7B, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFE, 0xF8, 0x07, 0xE3,
  0xC0, 0x3E, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x83,
  0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFB, 0x83, 0xBF, 0x70, 0x77, 0xEE, 0x1E, 0xFC, 0xE3,
  0x9F, 0x9C, 0x73, 0xF3, 0x9E, 0x7E, 0x7B, 0x8F, 0xC7, 0x71, 0xFC, 0xFE,
  0x7F, 0x9F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0x70,
  0xFF, 0x0C, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0xF0, 0x3F, 0xDE, 0x07,
  0xF9, 0xE0, 0xFF, 0x3C, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x87, 0x8F,
  0xF0, 0xF1, 0xFE, 0x0F, 0x3F, 0xC0, 0xE7, 0xF8, 0x1E, 0xFF, 0x01, 0xDF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x01,
  0xE7, 0x80, 0x0E, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xF7,
  0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C,
  0x1F, 0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x07, 0xCF, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x1F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xE0, 0x7C, 0x1E, 0x01, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x1E, 0x70, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1D,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xEF,
  0x00, 0x07, 0x78, 0x00, 0x79, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x38, 0x01,
  0xE1, 0xE0, 0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x08, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x0F,
  0xCE, 0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03,
  0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x03, 0xEE, 0x00, 0x79, 0xC0, 0x3E,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1C, 0x0F, 0x03, 0x80, 0xF0,
  0x70, 0x1E, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x00, 0x78,
  0xE0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x1E,
  0x00, 0x30, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0,
  0x3E, 0x1E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x73,
  0xC0, 0x00, 0x4F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x73, 0x80, 0x1E, 0x78, 0x07, 0xC7,
  0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x1C, 0x0F, 0x00,
  0x78, 0x38, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0F, 0x1C, 0x00, 0x3C,
  0x70, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x38, 0x1E, 0xE0, 0x70, 0x39, 0xC1,
  0xF0, 0x73, 0x83, 0xE0, 0xE7, 0x07, 0xC1, 0xCF, 0x0F, 0x83, 0x9E, 0x1F,
  0x0F, 0x3C, 0x3F, 0x1E, 0x38, 0xEE, 0x3C, 0x71, 0xDC, 0x70, 0xE3, 0xB8,
  0xE1, 0xC7, 0x71, 0xC3, 0x8E, 0x63, 0x87, 0x18, 0xE7, 0x0F, 0x71, 0xCE,
  0x1E, 0xE3, 0x9C, 0x3D, 0xC7, 0x78, 0x3B, 0x8E, 0xF0, 0x77, 0x0D, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x8F, 0x00,
  0x7C, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x07, 0x83, 0xC0, 0x3C, 0x1F, 0x03, 0xC0, 0x78, 0x3E, 0x01, 0xE1, 0xE0,
  0x0F, 0x1F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x7D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xB8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0xB8, 0x0E, 0x78,
  0x3C, 0x70, 0x70, 0xF0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0xDE, 0x03, 0xB8,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3E, 0x07,
  0xC7, 0x80, 0x78, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xF1, 0xE7, 0xC0, 0x3C, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF9, 0xE0, 0x7F,
  0x3F, 0xFF, 0xE3, 0xFF, 0xBC, 0x1F, 0xE7, 0xC0, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3F, 0x03, 0xDF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xE0, 0xF9, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F,
  0x7F, 0x07, 0xCF, 0xFF, 0xF1, 0xEF, 0xFE, 0x3C, 0xFF, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x3C, 0xF0, 0x07,
  0x9C, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F,
  0x78, 0x01, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1,
  0xFC, 0xF0, 0xFF, 0xBC, 0x7F, 0xFF, 0x3E, 0x0F, 0xDF, 0x01, 0xF7, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x7C, 0xF8, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0x70, 0x7F,
  0x1C, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0,
  0x7C, 0xF0, 0x07, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x8F, 0x80, 0x38, 0xF8, 0x0F, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xF1, 0xC3, 0xFE, 0x71, 0xFF, 0xDC, 0xF8, 0x3F, 0x7C,
  0x07, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF3, 0xE0, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCC, 0x01,
  0xE7, 0x80, 0xF9, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x08, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x3F, 0x0F, 0x3F,
  0xF3, 0xDF, 0xFE, 0xFF, 0x0F, 0xBF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x40,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3D, 0x8F, 0xEF, 0xFE, 0x7F, 0xC1, 0xF8, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF3, 0x80, 0x3C,
  0x70, 0x0F, 0x0E, 0x03, 0xC1, 0xC0, 0xF0, 0x38, 0x3C, 0x07, 0x0F, 0x00,
  0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0xBE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xF7, 0xC0, 0x3C, 0x7C, 0x07, 0x07, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x83,
  0x80, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0xF9, 0xC0, 0x0F, 0x38, 0x00, 0xF8,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0xC7,
  0xC7, 0x7F, 0x7F, 0xBF, 0xFF, 0xFD, 0xE1, 0xF1, 0xFE, 0x0F, 0x07, 0xF0,
  0x38, 0x3F, 0x81, 0xC1, 0xFC, 0x0E, 0x0F, 0xE0, 0x70, 0x7F, 0x03, 0x83,
  0xF8, 0x1C, 0x1F, 0xC0, 0xE0, 0xFE, 0x07, 0x07, 0xF0, 0x38, 0x3F, 0x81,
  0xC1, 0xFC, 0x0E, 0x0F, 0xE0, 0x70, 0x7F, 0x03, 0x83, 0xF8, 0x1C, 0x1F,
  0xC0, 0xE0, 0xFE, 0x07, 0x07, 0xF0, 0x38, 0x3C, 0xF0, 0xFC, 0x3C, 0xFF,
  0xCF, 0x7F, 0xFB, 0xFC, 0x3E, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x70, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x03, 0xE3, 0xC0,
  0x1E, 0x78, 0x00, 0xE7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x3E, 0x07, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xF1, 0xF8, 0x1E, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0x0F, 0xCF, 0x80, 0x79, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0xDF, 0x00, 0xFB,
  0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0x7F, 0xE1, 0xE7, 0xF8, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF1, 0xC3, 0xFE, 0x71, 0xFF, 0xFC,
  0xF8, 0x3F, 0x7C, 0x07, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x7C,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0xE1, 0xFF, 0x8F, 0xFE, 0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0x07, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x73, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x39, 0xF0,
  0x0F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xDE, 0x07, 0xEF, 0xFF, 0x73, 0xFF, 0x38, 0xFF, 0x1C, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1E, 0x1E, 0x00,
  0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x3C, 0x03,
  0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x00, 0x0E, 0x78,
  0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70,
  0x3F, 0xC0, 0xE0, 0x73, 0x83, 0xC0, 0xE7, 0x07, 0xC1, 0xCE, 0x0F, 0x83,
  0x9C, 0x1B, 0x0F, 0x3C, 0x76, 0x1C, 0x38, 0xEE, 0x38, 0x71, 0xDC, 0x70,
  0xE3, 0x38, 0xE1, 0xCE, 0x31, 0x81, 0x9C, 0x77, 0x03, 0xB8, 0xEE, 0x07,
  0x61, 0xDC, 0x0E, 0xC1, 0xB8, 0x1F, 0x83, 0x60, 0x1F, 0x07, 0xC0, 0x3C,
  0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x38, 0x00, 0xF8,
  0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x78,
  0x07, 0x87, 0xC0, 0x1E, 0x3C, 0x00, 0x7B, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3C, 0x07, 0x80,
  0xF0, 0x78, 0x03, 0xC7, 0xC0, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x78,
  0x03, 0xC1, 0xE0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x0F,
  0xE0, 0x3F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x60, 0x01, 0xE0, 0x0B, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0xC0, 0x1F, 0x00, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xF0, 0x07, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x1D, 0xFF, 0xC0, 0x3B, 0xC7, 0xC0, 0xEE,
  0x07, 0xE7, 0xDC, 0x03, 0xFF, 0x38, 0x03, 0xFC, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoMono_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 4, 29, 25, 10, -29 },
  { 16, 10, 10, 25, 7, -31 },
  { 29, 23, 29, 25, 1, -29 },
  { 113, 19, 38, 25, 3, -34 },
  { 204, 23, 30, 25, 1, -30 },
  { 291, 22, 30, 25, 2, -30 },
  { 374, 3, 10, 25, 10, -31 },
  { 378, 11, 42, 25, 7, -33 },
  { 436, 11, 42, 25, 6, -33 },
  { 494, 19, 20, 25, 3, -29 },
  { 542, 20, 21, 25, 2, -24 },
  { 595, 6, 11, 25, 7, -4 },
  { 604, 16, 3, 25, 4, -14 },
  { 610, 6, 5, 25, 10, -5 },
  { 614, 16, 32, 25, 5, -29 },
  { 678, 19, 30, 25, 3, -30 },
  { 750, 12, 29, 25, 4, -29 },
  { 794, 19, 30, 25, 2, -30 },
  { 866, 18, 30, 25, 2, -30 },
  { 934, 22, 29, 25, 1, -29 },
  { 1014, 18, 29, 25, 4, -29 },
  { 1080, 18, 29, 25, 3, -29 },
  { 1146, 20, 29, 25, 2, -29 },
  { 1219, 18, 30, 25, 4, -30 },
  { 1287, 18, 30, 25, 3, -30 },
  { 1355, 6, 23, 25, 11, -23 },
  { 1373, 7, 30, 25, 10, -23 },
  { 1400, 17, 18, 25, 3, -22 },
  { 1439, 18, 12, 25, 3, -19 },
  { 1466, 17, 18, 25, 4, -22 },
  { 1505, 17, 30, 25, 4, -30 },
  { 1569, 22, 29, 25, 1, -29 },
  { 1649, 21, 29, 25, 2, -29 },
  { 1726, 19, 29, 25, 3, -29 },
  { 1795, 20, 30, 25, 2, -30 },
  { 1870, 20, 29, 25, 3, -29 },
  { 1943, 18, 29, 25, 4, -29 },
  { 2009, 18, 29, 25, 4, -29 },
  { 2075, 20, 30, 25, 2, -30 },
  { 2150, 19, 29, 25, 3, -29 },
  { 2219, 18, 29, 25, 3, -29 },
  { 2285, 19, 29, 25, 2, -29 },
  { 2354, 21, 29, 25, 3, -29 },
  { 2431, 18, 29, 25, 4, -29 },
  { 2497, 19, 29, 25, 3, -29 },
  { 2566, 19, 29, 25, 3, -29 },
  { 2635, 20, 30, 25, 2, -30 },
  { 2710, 19, 29, 25, 4, -29 },
  { 2779, 21, 35, 25, 2, -30 },
  { 2871, 19, 29, 25, 4, -29 },
  { 2940, 21, 30, 25, 2, -30 },
  { 3019, 21, 29, 25, 2, -29 },
  { 3096, 19, 29, 25, 3, -29 },
  { 3165, 22, 29, 25, 1, -29 },
  { 3245, 23, 29, 25, 1, -29 },
  { 3329, 21, 29, 25, 2, -29 },
  { 3406, 22, 29, 25, 1, -29 },
  { 3486, 20, 29, 25, 2, -29 },
  { 3559, 7, 39, 25, 9, -33 },
  { 3594, 15, 32, 25, 5, -29 },
  { 3654, 8, 39, 25, 8, -33 },
  { 3693, 15, 15, 25, 5, -29 },
  { 3722, 18, 3, 25, 3, 0 },
  { 3729, 8, 6, 25, 8, -30 },
  { 3735, 19, 22, 25, 3, -22 },
  { 3788, 19, 31, 25, 3, -31 },
  { 3862, 19, 22, 25, 3, -22 },
  { 3915, 18, 31, 25, 3, -31 },
  { 3985, 19, 22, 25, 3, -22 },
  { 4038, 20, 32, 25, 3, -32 },
  { 4118, 18, 31, 25, 3, -22 },
  { 4188, 18, 31, 25, 3, -31 },
  { 4258, 18, 30, 25, 4, -30 },
  { 4326, 13, 39, 25, 4, -30 },
  { 4390, 19, 31, 25, 4, -31 },
  { 4464, 18, 31, 25, 4, -31 },
  { 4534, 21, 22, 25, 2, -22 },
  { 4592, 18, 22, 25, 3, -22 },
  { 4642, 20, 22, 25, 2, -22 },
  { 4697, 19, 30, 25, 3, -22 },
  { 4769, 18, 30, 25, 3, -22 },
  { 4837, 14, 22, 25, 7, -22 },
  { 4876, 19, 22, 25, 3, -22 },
  { 4929, 18, 27, 25, 3, -27 },
  { 4990, 17, 22, 25, 4, -22 },
  { 5037, 21, 22, 25, 2, -22 },
  { 5095, 23, 22, 25, 1, -22 },
  { 5159, 21, 22, 25, 2, -22 },
  { 5217, 22, 31, 25, 1, -22 },
  { 5303, 19, 22, 25, 3, -22 },
  { 5356, 14, 39, 25, 6, -32 },
  { 5425, 3, 37, 25, 11, -29 },
  { 5439, 14, 39, 25, 6, -32 },
  { 5508, 23, 8, 25, 1, -16 },
};

const GFXfont RobotoMono_Regular41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular41pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_REGULAR41PT7B_H_
