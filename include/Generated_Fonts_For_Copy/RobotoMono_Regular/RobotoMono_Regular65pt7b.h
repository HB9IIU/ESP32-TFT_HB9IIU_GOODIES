#ifndef _ROBOTOMONO_REGULAR65PT7B_H_
#define _ROBOTOMONO_REGULAR65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x80,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x0F,
  0x80, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3E, 0x0F,
  0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0x3F, 0x7F, 0x0F, 0x80, 0x01, 0xFF,
  0xF0, 0x7C, 0x00, 0x07, 0xFF, 0x87, 0xC0, 0x00, 0x0F, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x00,
  0x1E, 0x1F, 0xFF, 0x80, 0x01, 0xF0, 0xF8, 0xFC, 0x00, 0x0F, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x78, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0x7C,
  0x3E, 0x01, 0xE0, 0x03, 0xC1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x1E, 0x00, 0x10, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x0F, 0xE3, 0xF8, 0x07,
  0xE3, 0xF8, 0x3F, 0x80, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0x1F, 0xC0, 0x7F,
  0x03, 0xE3, 0xF0, 0x07, 0xF0, 0x7C, 0x7E, 0x00, 0x7F, 0x1F, 0x9F, 0x80,
  0x07, 0xF3, 0xE3, 0xF0, 0x00, 0xFE, 0xFC, 0x7E, 0x00, 0x0F, 0xFF, 0x8F,
  0xC0, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x01, 0xFF,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xFC, 0x07, 0xF8,
  0x00, 0x74, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF,
  0x7B, 0xC0, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x00,
  0x40, 0x40, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40, 0x07, 0xC0, 0x00, 0xF0,
  0x0F, 0x80, 0x31, 0xF8, 0x1F, 0x03, 0xE3, 0xFC, 0x3C, 0x1F, 0xE7, 0xFF,
  0x79, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF3,
  0xF1, 0xF9, 0xF8, 0x38, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xFB, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0xFE, 0xFF, 0xF0, 0x0F, 0xF3, 0xFF, 0xC0, 0x7F, 0x0F, 0xFF,
  0x03, 0xF8, 0x3F, 0xFC, 0x3F, 0xC0, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xCF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xBF, 0xE0, 0x00, 0x3E, 0xFE, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0xFE, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0x81, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xF8,
  0x01, 0xF8, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0xFC, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x7F, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0xC7, 0xFC, 0x7F,
  0xFC, 0x1F, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0x9F, 0x01, 0xFF, 0xF8, 0xF8,
  0x03, 0xFF, 0x0F, 0xC0, 0x01, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x0C,
  0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFE,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC0, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x7F, 0xE1, 0xFF, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x0F, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x7C, 0x03, 0xFC, 0x0E, 0x0F,
  0x01, 0xFF, 0xC1, 0xE1, 0xE0, 0x7F, 0xFC, 0x3C, 0x78, 0x1F, 0x87, 0x83,
  0x8F, 0x03, 0xE0, 0xE0, 0x71, 0xC0, 0xF8, 0x1C, 0x0F, 0x78, 0x1E, 0x03,
  0x81, 0xEF, 0x07, 0x80, 0x70, 0x3D, 0xE0, 0xF0, 0x0E, 0x07, 0xB8, 0x1E,
  0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x78, 0x1F, 0xE0, 0xF0, 0x0F, 0x03, 0xFC,
  0x1E, 0x01, 0xE0, 0x7F, 0x83, 0xC0, 0x3C, 0x0F, 0xF0, 0x78, 0x07, 0x81,
  0xDE, 0x0F, 0x00, 0xE0, 0x3B, 0xC1, 0xE0, 0x1C, 0x07, 0x78, 0x3C, 0x03,
  0x80, 0xEF, 0x07, 0x80, 0xF0, 0x3D, 0xE0, 0xF0, 0x1E, 0x07, 0x3C, 0x1F,
  0x07, 0xC1, 0xE3, 0xC1, 0xFF, 0xFC, 0x78, 0x78, 0x3F, 0xFF, 0xFF, 0x0F,
  0x03, 0xFE, 0x7F, 0xC1, 0xE0, 0x7F, 0x8F, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x00, 0xFF,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x03, 0xFC,
  0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x7F, 0xE1, 0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0xF0, 0x3F,
  0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x1F, 0xE0, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x1F, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0,
  0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF7, 0xF0, 0x00, 0x3F, 0xF1, 0xFC, 0x00, 0x1F, 0xF0, 0x7E, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7D, 0xFF, 0xFC, 0x01, 0xF7, 0xFE, 0xF8, 0x0F, 0xDF, 0xFB,
  0xE0, 0x3E, 0x7F, 0xEF, 0x80, 0xF9, 0xFF, 0x9F, 0x07, 0xE7, 0xFE, 0x7C,
  0x1F, 0x1F, 0xF9, 0xF0, 0x7C, 0xFF, 0xE3, 0xE3, 0xF3, 0xFF, 0x8F, 0x8F,
  0x8F, 0xFE, 0x3E, 0x3E, 0x3F, 0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xF7, 0xC3,
  0xFF, 0x87, 0xDF, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xE0, 0xFF, 0x83, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8,
  0x1F, 0xC0, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03,
  0xE0, 0x3F, 0xF8, 0x07, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFC, 0x00, 0xFF, 0xF7, 0xE0,
  0x07, 0xFF, 0x9F, 0x80, 0x3F, 0xFC, 0xFC, 0x01, 0xFF, 0xE3, 0xF0, 0x0F,
  0xFF, 0x1F, 0x80, 0x7F, 0xF8, 0x7E, 0x03, 0xFF, 0xC3, 0xF0, 0x1F, 0xFE,
  0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F,
  0xC1, 0xFF, 0xE0, 0x3F, 0x0F, 0xFF, 0x01, 0xF8, 0x7F, 0xF8, 0x07, 0xE3,
  0xFF, 0xC0, 0x3F, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xF0, 0x07, 0xF7, 0xFF,
  0x80, 0x1F, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xCF, 0xC0,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x3F, 0xCF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x9F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0x8F, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0x3E,
  0x7C, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8,
  0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0xC0, 0x7C,
  0x3E, 0x07, 0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0xE0, 0x7C, 0x3E, 0x07, 0xFE,
  0x07, 0xC3, 0xE0, 0x7F, 0xE0, 0x7C, 0x3E, 0x07, 0xBE, 0x0F, 0xC3, 0xF0,
  0x79, 0xE0, 0xFC, 0x3F, 0x0F, 0x9E, 0x0F, 0x83, 0xF0, 0xF9, 0xF0, 0xF8,
  0x1F, 0x0F, 0x9F, 0x0F, 0x81, 0xF0, 0xF9, 0xF0, 0xF8, 0x1F, 0x0F, 0x0F,
  0x0F, 0x81, 0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0xF9, 0xF8, 0x1F, 0x9F, 0x0F, 0x9F, 0x81, 0xF9, 0xE0, 0xF9, 0xF0,
  0x0F, 0x9E, 0x07, 0x9F, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x0F, 0xBE, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x7D, 0xF0, 0x0F, 0xBE, 0x07, 0xDF, 0x00, 0xFB,
  0xC0, 0x7D, 0xF0, 0x0F, 0xBC, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x3E,
  0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0x0F,
  0xC0, 0xFF, 0xF0, 0x7E, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x80, 0x1F, 0x0F, 0xFF, 0x00, 0xF9, 0xFF, 0xFE, 0x07, 0xDF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x8F,
  0xFF, 0x9F, 0xF8, 0x7D, 0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0xFC, 0x1F, 0x1F,
  0xFF, 0x80, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0x03, 0xE0, 0x1F, 0xFE, 0x1F, 0x01, 0xFF, 0xFC, 0xF8, 0x3F,
  0xFF, 0xF7, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xF1, 0xFE, 0x00,
  0x7F, 0x8F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x1F, 0x3F, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF0, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFB, 0xE0,
  0x3F, 0xFF, 0x9F, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x81, 0xFC, 0x00, 0x03, 0x81,
  0xFC, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFF, 0x03, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0x3E, 0x0F, 0xFF, 0xFD, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0x3F, 0xF1,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0xE7,
  0xC0, 0x1F, 0xFC, 0x3E, 0x00, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x80, 0x00, 0x7F, 0x0E, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x0F,
  0x83, 0xFF, 0xC0, 0xF8, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xF8, 0xFB, 0xFF,
  0xFF, 0xCF, 0xBE, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC8, 0x07, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x3E, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00,
  0x3F, 0x80, 0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x7F,
  0x00, 0x3E, 0x03, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x03, 0xE0, 0xFE, 0x00,
  0x0F, 0x87, 0xF0, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0xF9, 0xFC, 0x00, 0x03,
  0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F,
  0x80, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x01, 0xFC,
  0x0F, 0x80, 0x07, 0xF8, 0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0xC3,
  0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0xFF, 0x3E, 0x00, 0x01, 0xFE, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x7C, 0xFF, 0xC3, 0xFE, 0x3E, 0xFF, 0xF7,
  0xFF, 0x9F, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF0, 0x7F,
  0xC1, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x7C, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xF0,
  0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xFE,
  0x01, 0xF0, 0x07, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x01, 0xFF,
  0xC0, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x3F,
  0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x07,
  0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xC0, 0x3E, 0x00,
  0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xC0,
  0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0x83, 0xFF, 0xC0, 0xF8, 0xFF, 0xFF,
  0x0F, 0x9F, 0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0xCF, 0xFE, 0x03, 0xFC, 0xFF,
  0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xF0,
  0x3F, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0x00,
  0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFD, 0xFF, 0xFF, 0x03, 0xF3, 0xFF, 0xF8, 0x0F, 0xC3, 0xFF, 0x80,
  0x3F, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC7, 0xC0, 0xFF, 0xFF, 0x3E,
  0x0F, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xFC, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xDF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0xF8, 0x0F, 0xFF, 0xE7, 0xC0, 0x1F, 0xFC, 0x3E, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0xFC, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x8F,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xF7, 0xF0, 0x03, 0xFE, 0x7F, 0xC7, 0xFF,
  0xCF, 0xFF, 0xFE, 0xF8, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF, 0xE3, 0xE0, 0x7F,
  0xF0, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0xF8, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8,
  0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x3E, 0x7C, 0x03, 0xF8, 0x07, 0xC7, 0xC0,
  0x3F, 0xC0, 0x7C, 0x7C, 0x03, 0xBC, 0x07, 0xC3, 0xE0, 0x7B, 0xC0, 0x7C,
  0x3E, 0x07, 0xBC, 0x07, 0x83, 0xE0, 0x7B, 0xE0, 0x78, 0x3E, 0x07, 0xBE,
  0x0F, 0x83, 0xE0, 0xF9, 0xE0, 0xF8, 0x1E, 0x0F, 0x1E, 0x0F, 0x81, 0xF0,
  0xF1, 0xF0, 0xF0, 0x1F, 0x0F, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0xF1, 0xF0,
  0x0F, 0x1E, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0xF9, 0xF0, 0x0F, 0x9E, 0x0F,
  0x9E, 0x00, 0xFB, 0xE0, 0x79, 0xE0, 0x0F, 0xBC, 0x07, 0x9E, 0x00, 0x7B,
  0xC0, 0x7B, 0xE0, 0x07, 0xBC, 0x07, 0xFE, 0x00, 0x7B, 0xC0, 0x3F, 0xC0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3C, 0xFF, 0xFE, 0x00, 0x07, 0xBF, 0xFF, 0xF0,
  0x00, 0xF7, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0x83, 0xF7, 0xC0, 0x0F, 0xFF, 0xFE, 0xF0, 0x00, 0x7F, 0xFF, 0x9E,
  0x00, 0x07, 0xFF, 0xE0, 0x40, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00,
};

const GFXglyph RobotoMono_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 8, 46, 39, 15, -46 },
  { 47, 16, 15, 39, 11, -49 },
  { 77, 35, 46, 39, 2, -46 },
  { 279, 30, 61, 39, 5, -54 },
  { 508, 37, 48, 39, 1, -47 },
  { 730, 35, 48, 39, 3, -47 },
  { 940, 5, 15, 39, 16, -49 },
  { 950, 17, 67, 39, 11, -52 },
  { 1093, 17, 67, 39, 10, -52 },
  { 1236, 31, 31, 39, 5, -46 },
  { 1357, 31, 33, 39, 4, -38 },
  { 1485, 9, 18, 39, 11, -7 },
  { 1506, 24, 5, 39, 7, -23 },
  { 1521, 9, 9, 39, 16, -8 },
  { 1532, 25, 50, 39, 8, -46 },
  { 1689, 30, 48, 39, 5, -47 },
  { 1869, 18, 46, 39, 7, -46 },
  { 1973, 31, 47, 39, 3, -47 },
  { 2156, 29, 48, 39, 3, -47 },
  { 2330, 34, 46, 39, 2, -46 },
  { 2526, 29, 47, 39, 6, -46 },
  { 2697, 30, 47, 39, 4, -46 },
  { 2874, 31, 46, 39, 4, -46 },
  { 3053, 29, 48, 39, 6, -47 },
  { 3227, 29, 47, 39, 5, -47 },
  { 3398, 10, 37, 39, 17, -36 },
  { 3445, 11, 47, 39, 15, -36 },
  { 3510, 27, 29, 39, 5, -35 },
  { 3608, 29, 18, 39, 5, -30 },
  { 3674, 28, 29, 39, 6, -35 },
  { 3776, 27, 47, 39, 6, -47 },
  { 3935, 35, 46, 39, 2, -46 },
  { 4137, 34, 46, 39, 3, -46 },
  { 4333, 31, 46, 39, 5, -46 },
  { 4512, 32, 48, 39, 3, -47 },
  { 4704, 31, 46, 39, 5, -46 },
  { 4883, 28, 46, 39, 6, -46 },
  { 5044, 28, 46, 39, 6, -46 },
  { 5205, 32, 48, 39, 3, -47 },
  { 5397, 31, 46, 39, 4, -46 },
  { 5576, 27, 46, 39, 6, -46 },
  { 5732, 30, 47, 39, 3, -46 },
  { 5909, 33, 46, 39, 5, -46 },
  { 6099, 29, 46, 39, 6, -46 },
  { 6266, 30, 46, 39, 5, -46 },
  { 6439, 29, 46, 39, 5, -46 },
  { 6606, 33, 48, 39, 3, -47 },
  { 6804, 30, 46, 39, 6, -46 },
  { 6977, 34, 55, 39, 3, -47 },
  { 7211, 30, 46, 39, 6, -46 },
  { 7384, 32, 48, 39, 4, -47 },
  { 7576, 35, 46, 39, 2, -46 },
  { 7778, 31, 47, 39, 4, -46 },
  { 7961, 35, 46, 39, 2, -46 },
  { 8163, 36, 46, 39, 2, -46 },
  { 8370, 34, 46, 39, 3, -46 },
  { 8566, 34, 46, 39, 2, -46 },
  { 8762, 30, 46, 39, 4, -46 },
  { 8935, 12, 63, 39, 14, -53 },
  { 9030, 25, 50, 39, 7, -46 },
  { 9187, 12, 63, 39, 13, -53 },
  { 9282, 25, 25, 39, 7, -46 },
  { 9361, 29, 5, 39, 5, 0 },
  { 9380, 13, 8, 39, 13, -47 },
  { 9393, 29, 36, 39, 5, -35 },
  { 9524, 29, 50, 39, 6, -49 },
  { 9706, 29, 36, 39, 5, -35 },
  { 9837, 29, 50, 39, 4, -49 },
  { 10019, 31, 36, 39, 4, -35 },
  { 10159, 31, 50, 39, 5, -50 },
  { 10353, 29, 49, 39, 4, -35 },
  { 10531, 28, 49, 39, 6, -49 },
  { 10703, 29, 47, 39, 6, -47 },
  { 10874, 20, 61, 39, 7, -47 },
  { 11027, 30, 49, 39, 6, -49 },
  { 11211, 29, 49, 39, 6, -49 },
  { 11389, 33, 35, 39, 3, -35 },
  { 11534, 28, 35, 39, 6, -35 },
  { 11657, 31, 36, 39, 4, -35 },
  { 11797, 30, 48, 39, 5, -35 },
  { 11977, 29, 48, 39, 4, -35 },
  { 12151, 24, 35, 39, 10, -35 },
  { 12256, 28, 36, 39, 6, -35 },
  { 12382, 30, 44, 39, 4, -43 },
  { 12547, 27, 35, 39, 6, -34 },
  { 12666, 33, 34, 39, 3, -34 },
  { 12807, 36, 34, 39, 2, -34 },
  { 12960, 33, 34, 39, 3, -34 },
  { 13101, 35, 48, 39, 2, -34 },
  { 13311, 29, 34, 39, 5, -34 },
  { 13435, 22, 63, 39, 10, -51 },
  { 13609, 5, 59, 39, 17, -46 },
  { 13646, 22, 63, 39, 10, -51 },
  { 13820, 35, 12, 39, 2, -25 },
};

const GFXfont RobotoMono_Regular65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular65pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_REGULAR65PT7B_H_
