#ifndef _ROBOTOMONO_REGULAR66PT7B_H_
#define _ROBOTOMONO_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x06, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x81,
  0xE0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0x1E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x78, 0x00, 0x7E, 0x1F, 0x87, 0xC0,
  0x01, 0xFF, 0xF8, 0x3C, 0x00, 0x07, 0xFF, 0x83, 0xE0, 0x00, 0x1F, 0xF8,
  0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0xFF,
  0xC0, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0xFF, 0xFC, 0x00, 0x0F,
  0x87, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x3E,
  0x00, 0x3C, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x78, 0x00, 0x80, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0x07, 0xF3, 0xF8, 0x03, 0xE1, 0xFC, 0x3F, 0x80, 0x7C,
  0x7F, 0x07, 0xF0, 0x0F, 0x8F, 0xE0, 0x7F, 0x03, 0xF3, 0xF8, 0x07, 0xF0,
  0x7E, 0x7E, 0x00, 0x7F, 0x0F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF1, 0xF8, 0x00,
  0xFE, 0x7E, 0x7E, 0x00, 0x0F, 0xEF, 0x8F, 0xC0, 0x00, 0xFF, 0xF0, 0xFC,
  0x00, 0x1F, 0xFE, 0x1F, 0x80, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDE, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x40,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x60,
  0x0F, 0x80, 0x19, 0xF0, 0x1F, 0x00, 0xF3, 0xF8, 0x1E, 0x0F, 0xE7, 0xFE,
  0x3C, 0x7F, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC7, 0xE3, 0xF0, 0x38, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFB,
  0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0x01, 0xFC, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF,
  0xF0, 0xFF, 0x03, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x7F, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xC3,
  0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x07,
  0x80, 0x00, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x03, 0xFE,
  0x0F, 0xC0, 0x03, 0xFC, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x81,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xE1, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x81, 0xFB, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x01,
  0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0x00, 0xFF,
  0x07, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0xFC,
  0x0F, 0xFF, 0xC7, 0xE0, 0x1F, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0xC0, 0x1F,
  0x87, 0xF8, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0xCF, 0xF0, 0xFC, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC0, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x7E,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x01, 0xFC, 0x0F, 0x0F, 0x00, 0xFF, 0xC1, 0xE1,
  0xE0, 0x3F, 0xFC, 0x1C, 0x78, 0x0F, 0xFF, 0x83, 0xCF, 0x03, 0xF0, 0xF0,
  0x79, 0xE0, 0x78, 0x1E, 0x0F, 0x78, 0x1F, 0x03, 0xC0, 0xEF, 0x03, 0xC0,
  0x78, 0x1D, 0xE0, 0xF8, 0x0F, 0x03, 0xBC, 0x1E, 0x01, 0xC0, 0x77, 0x83,
  0xC0, 0x38, 0x0F, 0xE0, 0x78, 0x07, 0x01, 0xFC, 0x0F, 0x00, 0xE0, 0x3F,
  0x83, 0xC0, 0x1C, 0x07, 0xF0, 0x78, 0x07, 0x80, 0xFE, 0x0F, 0x00, 0xF0,
  0x1F, 0xC1, 0xE0, 0x1E, 0x07, 0xF8, 0x3C, 0x03, 0xC0, 0xFF, 0x07, 0x80,
  0x78, 0x1D, 0xE0, 0xF0, 0x0F, 0x03, 0xBC, 0x1F, 0x03, 0xE0, 0xF3, 0xC1,
  0xE0, 0xFC, 0x1C, 0x78, 0x3F, 0xFF, 0x87, 0x8F, 0x07, 0xFF, 0x7F, 0xE1,
  0xE0, 0x7F, 0xCF, 0xF8, 0x3E, 0x07, 0xF0, 0xFE, 0x03, 0xC0, 0x70, 0x07,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x1F,
  0xE0, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xF8, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xFF, 0x8F, 0xC0, 0x01,
  0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFE, 0x3F, 0x00,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xFF,
  0x8F, 0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0xBF, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF8,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF3, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0xFF, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0x8F, 0xE0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0xF8, 0x07, 0xDF, 0xFB, 0xE0, 0x1F, 0x7F, 0xEF, 0xC0, 0xF9, 0xFF,
  0x9F, 0x03, 0xE7, 0xFE, 0x7C, 0x0F, 0x9F, 0xF9, 0xF8, 0x7C, 0x7F, 0xE3,
  0xE1, 0xF1, 0xFF, 0x8F, 0x87, 0xC7, 0xFE, 0x3E, 0x3E, 0x1F, 0xF8, 0x7C,
  0xF8, 0x7F, 0xE1, 0xF3, 0xE1, 0xFF, 0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0x81, 0xFF, 0xC1, 0xFE, 0x07,
  0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF,
  0xC0, 0xFC, 0x07, 0xFF, 0x03, 0xE0, 0x1F, 0xFC, 0x07, 0x80, 0x7F, 0xF0,
  0x1E, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xDF, 0x80, 0x0F,
  0xFF, 0x3F, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0xF1, 0xF8, 0x03, 0xFF,
  0xC7, 0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0x3F, 0x00, 0xFF, 0xF0,
  0x7E, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF, 0x00, 0xFC,
  0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xF0, 0x07, 0xE3, 0xFF, 0xC0, 0x1F, 0xCF,
  0xFF, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0xFE, 0xFF, 0xF0, 0x01, 0xFB, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x03, 0xFE, 0x3F,
  0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFF, 0x3F, 0x00, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE3,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0x3F, 0x7C, 0x01,
  0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xC0, 0x3E, 0x7E, 0x03, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0xC0,
  0x3E, 0x7E, 0x03, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0xC0, 0x7E, 0x3E, 0x03,
  0xFE, 0x07, 0xE3, 0xE0, 0x3F, 0xE0, 0x7E, 0x3E, 0x07, 0xFE, 0x07, 0xE3,
  0xE0, 0x7D, 0xE0, 0x7C, 0x3F, 0x07, 0xDE, 0x07, 0xC3, 0xF0, 0x7D, 0xF0,
  0x7C, 0x3F, 0x07, 0x9F, 0x07, 0xC3, 0xF0, 0x79, 0xF0, 0x7C, 0x1F, 0x0F,
  0x9F, 0x07, 0xC1, 0xF0, 0xF8, 0xF0, 0xFC, 0x1F, 0x0F, 0x8F, 0x0F, 0xC1,
  0xF0, 0xF8, 0xF8, 0xF8, 0x1F, 0x0F, 0x0F, 0x8F, 0x81, 0xF0, 0xF0, 0xF8,
  0xF8, 0x1F, 0x9F, 0x0F, 0x8F, 0x81, 0xF9, 0xF0, 0x78, 0xF8, 0x0F, 0x9F,
  0x07, 0x8F, 0x80, 0xF9, 0xF0, 0x7C, 0xF8, 0x0F, 0x9E, 0x07, 0xDF, 0x80,
  0xFB, 0xE0, 0x7D, 0xF8, 0x0F, 0xBE, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3D,
  0xF0, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x83, 0xF8, 0x01, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xF8, 0x00,
  0x7F, 0xE7, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD,
  0xF8, 0x7F, 0xFF, 0xE7, 0xE0, 0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0xF0, 0x7F,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x1F, 0x87,
  0xFF, 0x00, 0xFC, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x01, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xFC, 0x03, 0xFC, 0x7F,
  0xFC, 0xFF, 0xE3, 0xEF, 0xFF, 0xFE, 0x1F, 0x3F, 0xFF, 0xE0, 0xF8, 0xFF,
  0xFE, 0x07, 0xC1, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x0F,
  0xC0, 0x1F, 0xFC, 0x3F, 0x01, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x7F,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xFC, 0x3F, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xBF, 0x01, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xC3, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xCF, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x83, 0xFC, 0x00, 0x03, 0x83, 0xFC, 0x00, 0x0F,
  0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0xFB,
  0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xE7,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0xE3, 0xFF, 0xBF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xEF, 0xC0, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0xE0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x08,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x80, 0x0F, 0xC1, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0x0F,
  0xCF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x1F, 0xEF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x8F, 0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x40, 0x3E, 0x3F,
  0xE0, 0xFF, 0x0F, 0x9F, 0xFC, 0xFF, 0xE3, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0x81, 0xFB,
  0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x80, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x7F,
  0xFF, 0x0F, 0x8F, 0xFF, 0xF8, 0xF9, 0xFF, 0xFF, 0xCF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x1F, 0xEF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x07, 0xC1, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0x01,
  0xF3, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0x81, 0xF8, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x7F, 0xFC, 0xFF, 0x80, 0x7F,
  0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xEF, 0xC0, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x40,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFE, 0xF8, 0x7F, 0xFE, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x3E, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFE, 0x00,
  0x3F, 0xC7, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE7, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF7, 0xF8, 0x03,
  0xFF, 0x3F, 0xF3, 0xFF, 0xF1, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xF3, 0xF0,
  0x7F, 0xFE, 0x3F, 0x03, 0xFF, 0x81, 0xF0, 0x03, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x80, 0x3E, 0x7C, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x3E, 0x7C,
  0x03, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x07, 0xFC, 0x07,
  0xC3, 0xE0, 0x7B, 0xE0, 0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xC3, 0xE0, 0x79,
  0xE0, 0x7C, 0x1E, 0x0F, 0x9E, 0x07, 0x81, 0xF0, 0xF9, 0xF0, 0xF8, 0x1F,
  0x0F, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x0F,
  0x00, 0xF1, 0xF0, 0xF8, 0xF0, 0x0F, 0x9E, 0x07, 0x8F, 0x00, 0xF9, 0xE0,
  0x79, 0xF0, 0x0F, 0xBE, 0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x7D, 0xE0, 0x07,
  0xBC, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x07, 0xBC, 0x03, 0xDE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x2F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xF3, 0xFF, 0xFC, 0x00, 0x1F, 0x7F, 0xFF, 0xE0,
  0x01, 0xF7, 0xFB, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFC, 0x03, 0xEF, 0x80,
  0x1F, 0xF0, 0xFE, 0xF0, 0x00, 0xFF, 0xFF, 0xCF, 0x00, 0x07, 0xFF, 0xFC,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00,
};

const GFXglyph RobotoMono_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 7, 47, 40, 16, -47 },
  { 43, 17, 16, 40, 11, -50 },
  { 77, 36, 47, 40, 2, -47 },
  { 289, 30, 62, 40, 5, -55 },
  { 522, 37, 49, 40, 1, -48 },
  { 749, 35, 49, 40, 3, -48 },
  { 964, 5, 16, 40, 16, -50 },
  { 974, 18, 68, 40, 11, -53 },
  { 1127, 17, 68, 40, 10, -53 },
  { 1272, 31, 32, 40, 5, -47 },
  { 1396, 32, 34, 40, 4, -39 },
  { 1532, 10, 18, 40, 11, -7 },
  { 1555, 25, 5, 40, 7, -23 },
  { 1571, 9, 9, 40, 16, -8 },
  { 1582, 25, 51, 40, 8, -47 },
  { 1742, 30, 49, 40, 5, -48 },
  { 1926, 18, 47, 40, 7, -47 },
  { 2032, 31, 48, 40, 3, -48 },
  { 2218, 30, 49, 40, 3, -48 },
  { 2402, 34, 47, 40, 2, -47 },
  { 2602, 30, 48, 40, 6, -47 },
  { 2782, 29, 48, 40, 5, -47 },
  { 2956, 31, 47, 40, 4, -47 },
  { 3139, 30, 49, 40, 6, -48 },
  { 3323, 29, 48, 40, 5, -48 },
  { 3497, 9, 37, 40, 18, -36 },
  { 3539, 11, 47, 40, 16, -36 },
  { 3604, 28, 29, 40, 5, -35 },
  { 3706, 28, 18, 40, 6, -30 },
  { 3769, 28, 29, 40, 6, -35 },
  { 3871, 28, 48, 40, 6, -48 },
  { 4039, 35, 47, 40, 2, -47 },
  { 4245, 35, 47, 40, 3, -47 },
  { 4451, 30, 47, 40, 6, -47 },
  { 4628, 33, 49, 40, 3, -48 },
  { 4831, 32, 47, 40, 5, -47 },
  { 5019, 29, 47, 40, 6, -47 },
  { 5190, 29, 47, 40, 6, -47 },
  { 5361, 33, 49, 40, 3, -48 },
  { 5564, 30, 47, 40, 5, -47 },
  { 5741, 28, 47, 40, 6, -47 },
  { 5906, 31, 48, 40, 3, -47 },
  { 6092, 32, 47, 40, 6, -47 },
  { 6280, 29, 47, 40, 6, -47 },
  { 6451, 30, 47, 40, 5, -47 },
  { 6628, 30, 47, 40, 5, -47 },
  { 6805, 33, 49, 40, 3, -48 },
  { 7008, 31, 47, 40, 6, -47 },
  { 7191, 35, 56, 40, 3, -48 },
  { 7436, 31, 47, 40, 6, -47 },
  { 7619, 32, 49, 40, 4, -48 },
  { 7815, 35, 47, 40, 2, -47 },
  { 8021, 31, 48, 40, 4, -47 },
  { 8207, 35, 47, 40, 2, -47 },
  { 8413, 36, 47, 40, 2, -47 },
  { 8625, 35, 47, 40, 3, -47 },
  { 8831, 35, 47, 40, 2, -47 },
  { 9037, 31, 47, 40, 4, -47 },
  { 9220, 12, 64, 40, 14, -54 },
  { 9316, 25, 51, 40, 7, -47 },
  { 9476, 13, 64, 40, 13, -54 },
  { 9580, 25, 25, 40, 7, -47 },
  { 9659, 30, 5, 40, 5, 0 },
  { 9678, 13, 9, 40, 13, -48 },
  { 9693, 30, 37, 40, 5, -36 },
  { 9832, 29, 51, 40, 6, -50 },
  { 10017, 30, 37, 40, 5, -36 },
  { 10156, 30, 51, 40, 4, -50 },
  { 10348, 31, 37, 40, 4, -36 },
  { 10492, 31, 51, 40, 5, -51 },
  { 10690, 29, 50, 40, 5, -36 },
  { 10872, 28, 50, 40, 6, -50 },
  { 11047, 29, 48, 40, 7, -48 },
  { 11221, 21, 62, 40, 7, -48 },
  { 11384, 30, 50, 40, 6, -50 },
  { 11572, 29, 50, 40, 7, -50 },
  { 11754, 34, 36, 40, 3, -36 },
  { 11907, 28, 36, 40, 6, -36 },
  { 12033, 32, 37, 40, 4, -36 },
  { 12181, 29, 49, 40, 6, -36 },
  { 12359, 29, 49, 40, 5, -36 },
  { 12537, 24, 36, 40, 11, -36 },
  { 12645, 29, 37, 40, 6, -36 },
  { 12780, 29, 44, 40, 5, -43 },
  { 12940, 28, 36, 40, 6, -35 },
  { 13066, 33, 35, 40, 3, -35 },
  { 13211, 36, 35, 40, 2, -35 },
  { 13369, 33, 35, 40, 4, -35 },
  { 13514, 35, 49, 40, 2, -35 },
  { 13729, 30, 35, 40, 5, -35 },
  { 13861, 22, 63, 40, 10, -51 },
  { 14035, 5, 60, 40, 17, -47 },
  { 14073, 22, 63, 40, 10, -51 },
  { 14247, 36, 13, 40, 2, -26 },
};

const GFXfont RobotoMono_Regular66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular66pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_REGULAR66PT7B_H_
