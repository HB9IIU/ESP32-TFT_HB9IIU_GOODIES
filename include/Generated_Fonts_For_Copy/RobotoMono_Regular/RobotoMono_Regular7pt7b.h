#ifndef _ROBOTOMONO_REGULAR7PT7B_H_
#define _ROBOTOMONO_REGULAR7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xC0, 0x5F, 0x6F, 0x60, 0x5A, 0xE3, 0xD0, 0xCE, 0x27, 0x30,
  0x66, 0x4B, 0x70, 0x80, 0x5A, 0xA5, 0xA5, 0x5A, 0x5F, 0x00, 0x2F, 0x22,
  0xC0, 0xC0, 0x80, 0x29, 0x48, 0x69, 0xF9, 0x60, 0xD5, 0x40, 0x69, 0x24,
  0xF0, 0x75, 0x9E, 0x26, 0x6F, 0x20, 0xF3, 0x9C, 0x68, 0xF9, 0x60, 0xF2,
  0x22, 0x40, 0xD7, 0x5C, 0xD7, 0x9C, 0x90, 0x98, 0x64, 0xFC, 0x8F, 0x00,
  0xC5, 0x24, 0x7F, 0xFF, 0x60, 0x26, 0x67, 0x90, 0xD7, 0x5C, 0x69, 0x89,
  0x60, 0xD6, 0xDC, 0xF3, 0x4E, 0xF3, 0x48, 0x69, 0xA9, 0x70, 0x99, 0xF9,
  0x90, 0xE9, 0x2E, 0x11, 0x19, 0x60, 0xBA, 0x6A, 0x92, 0x4E, 0x9F, 0xBB,
  0x90, 0x9D, 0xBB, 0x90, 0x69, 0x99, 0x60, 0xF7, 0xC8, 0x69, 0x99, 0x61,
  0xD7, 0x6A, 0x69, 0x69, 0x70, 0xF2, 0x22, 0x20, 0x99, 0x99, 0x60, 0x95,
  0x66, 0x20, 0xBB, 0x75, 0x50, 0x96, 0x26, 0x90, 0x96, 0x62, 0x20, 0xF2,
  0x44, 0xF0, 0xEA, 0xAC, 0xA5, 0x40, 0xD5, 0x5C, 0x7C, 0xE0, 0xC0, 0xCE,
  0xF0, 0x9A, 0xDC, 0x69, 0x87, 0x17, 0x99, 0x70, 0x69, 0xE7, 0xFE, 0x48,
  0x79, 0x97, 0xF0, 0x9A, 0xDA, 0x59, 0x2E, 0x75, 0x58, 0x97, 0x6A, 0xC9,
  0x2E, 0xFB, 0xBB, 0xD6, 0xD0, 0x69, 0x96, 0xD6, 0xE8, 0x79, 0x97, 0x10,
  0xF2, 0x40, 0xD5, 0xF0, 0x4F, 0x44, 0x30, 0xB6, 0xF0, 0x95, 0x62, 0xBB,
  0x75, 0x96, 0x2D, 0x95, 0x62, 0x48, 0xEA, 0x70, 0x5D, 0x50, 0xFC, 0xD5,
  0x60, 0xD2,
};

const GFXglyph RobotoMono_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 1, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 1, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 1, 4, 1, -5 },
  { 16, 2, 8, 4, 1, -6 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 3, 3, 4, 1, -5 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 1, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -3 },
  { 26, 1, 1, 4, 2, -1 },
  { 27, 3, 5, 4, 1, -5 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 2, 5, 4, 1, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 1, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 3, 5, 4, 1, -5 },
  { 54, 1, 4, 4, 2, -4 },
  { 55, 1, 5, 4, 2, -4 },
  { 56, 2, 3, 4, 1, -4 },
  { 57, 3, 2, 4, 1, -3 },
  { 58, 3, 3, 4, 1, -4 },
  { 60, 3, 5, 4, 1, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 3, 5, 4, 1, -5 },
  { 75, 3, 5, 4, 1, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 3, 5, 4, 1, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 4, 6, 4, 0, -5 },
  { 108, 3, 5, 4, 1, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 2, 7, 4, 1, -6 },
  { 136, 2, 5, 4, 1, -5 },
  { 138, 2, 7, 4, 1, -6 },
  { 140, 2, 3, 4, 1, -5 },
  { 141, 3, 1, 4, 1, 0 },
  { 142, 2, 1, 4, 1, -5 },
  { 143, 3, 4, 4, 1, -4 },
  { 145, 3, 5, 4, 1, -5 },
  { 147, 4, 4, 4, 0, -4 },
  { 149, 4, 5, 4, 0, -5 },
  { 152, 4, 4, 4, 0, -4 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 4, 5, 4, 0, -4 },
  { 159, 3, 5, 4, 1, -5 },
  { 161, 3, 5, 4, 1, -5 },
  { 163, 2, 7, 4, 1, -5 },
  { 165, 3, 5, 4, 1, -5 },
  { 167, 3, 5, 4, 1, -5 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 3, 4, 4, 1, -4 },
  { 173, 4, 4, 4, 0, -4 },
  { 175, 3, 5, 4, 1, -4 },
  { 177, 4, 5, 4, 0, -4 },
  { 180, 3, 4, 4, 1, -4 },
  { 182, 3, 4, 4, 1, -4 },
  { 184, 4, 5, 4, 0, -5 },
  { 187, 3, 4, 4, 1, -4 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 6, 4, 0, -4 },
  { 198, 3, 4, 4, 1, -4 },
  { 200, 2, 6, 4, 1, -5 },
  { 202, 1, 6, 4, 2, -5 },
  { 203, 2, 6, 4, 1, -5 },
  { 205, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_Regular7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular7pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_REGULAR7PT7B_H_
