#ifndef _ROBOTOMONO_REGULAR28PT7B_H_
#define _ROBOTOMONO_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x1B, 0xF0, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x03, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x61, 0x80, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x30, 0x18, 0x60, 0x31,
  0x80, 0x63, 0x01, 0x86, 0x1F, 0xFF, 0x86, 0x18, 0x0C, 0x60, 0x18, 0xC0,
  0x21, 0x80, 0xC3, 0x01, 0x86, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F,
  0x83, 0xFE, 0x1C, 0x39, 0xC0, 0xCE, 0x07, 0x70, 0x3B, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x3F, 0x01, 0xF8,
  0x0E, 0xC0, 0x77, 0x07, 0x1F, 0xF8, 0x7F, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0x18, 0x84, 0x31, 0x88, 0x62, 0x18, 0xCC,
  0x33, 0xB0, 0x3E, 0x60, 0x31, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x67, 0xC0, 0xD9, 0xC3, 0x31, 0x84, 0x63, 0x18, 0xC6, 0x01, 0x8C, 0x03,
  0xB8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x73, 0x81, 0xC3, 0x03, 0x86,
  0x07, 0x0C, 0x06, 0x38, 0x0F, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x7C, 0x01,
  0xDC, 0x77, 0x1C, 0xEC, 0x39, 0xB8, 0x3B, 0x70, 0x3E, 0x60, 0x38, 0xE0,
  0xF0, 0xFF, 0xF0, 0xFE, 0x70, 0xFF, 0xFC, 0x06, 0x1C, 0x70, 0xC3, 0x06,
  0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC3, 0x83,
  0x06, 0x0E, 0x0C, 0x18, 0x18, 0x38, 0x38, 0x30, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x06, 0x31, 0xFD, 0xBD, 0xFF, 0xE0,
  0xF0, 0x07, 0x80, 0x6E, 0x07, 0x30, 0x71, 0xC1, 0x07, 0x00, 0x20, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x77, 0x77,
  0x6E, 0xC4, 0xFF, 0xFF, 0xF0, 0x4F, 0xFE, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x00, 0x1F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x03, 0x70, 0x1F,
  0x80, 0xFC, 0x1F, 0xE1, 0xFF, 0x1D, 0xFB, 0xCF, 0xF8, 0x7F, 0x83, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0x60, 0x33, 0x83, 0x8F, 0xF8, 0x3F, 0x80, 0x03,
  0x0F, 0x7F, 0xFF, 0xC7, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0xC0, 0xFF, 0x87, 0x07,
  0x18, 0x0C, 0xE0, 0x3B, 0x80, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0xFF, 0xDF, 0xFF, 0x0F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0,
  0x6E, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x7E, 0x03, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x07, 0x60, 0x3B, 0x83, 0x8F,
  0xF8, 0x3F, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x1D, 0xC0, 0x67, 0x03, 0x9C, 0x1C, 0x70, 0x61, 0xC3, 0x87, 0x0C, 0x1C,
  0x60, 0x73, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x7F, 0xF7, 0xFF, 0x7F, 0xF6, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0xF8, 0xFF, 0xCF, 0x1E, 0x20, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x7C, 0x07, 0xE0, 0x7E, 0x0E, 0x7F, 0xC3, 0xF8, 0x03, 0xC0, 0x7E, 0x07,
  0xC0, 0x70, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1D, 0xF0, 0xFF, 0xE7, 0xC7,
  0x38, 0x1D, 0xC0, 0x6C, 0x03, 0x70, 0x1F, 0x80, 0xDC, 0x06, 0x60, 0x73,
  0x87, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x00, 0x0F, 0xC1, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x1D,
  0xC0, 0xCE, 0x0E, 0x3C, 0xE0, 0xFE, 0x0F, 0xF8, 0xE0, 0xE6, 0x03, 0xB0,
  0x1F, 0x80, 0x7C, 0x07, 0x60, 0x3B, 0x83, 0x8F, 0xFC, 0x3F, 0x80, 0x1F,
  0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xDC, 0x07,
  0xE0, 0x3F, 0x03, 0xDC, 0x3C, 0x7F, 0xE1, 0xFB, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0x27, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x27, 0xF7, 0x27, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x77,
  0x66, 0xEC, 0x40, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFC, 0x3E, 0x0F, 0x80,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x7E, 0x0F,
  0x83, 0xF0, 0x3E, 0x01, 0x80, 0x00, 0x3F, 0x8F, 0xFB, 0xC3, 0xE0, 0x7C,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x38, 0x07, 0x00, 0x03, 0xC0,
  0x1F, 0xE0, 0x60, 0x61, 0x80, 0x66, 0x1C, 0xCC, 0x7C, 0x91, 0x99, 0xE6,
  0x33, 0xCC, 0x67, 0x98, 0xCF, 0x21, 0x1E, 0x42, 0x3C, 0xC4, 0x59, 0x99,
  0xB3, 0xFE, 0x21, 0x18, 0x60, 0x00, 0x60, 0x40, 0x7F, 0x80, 0x7E, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0xD8, 0x03,
  0xB8, 0x07, 0x30, 0x0C, 0x60, 0x18, 0xE0, 0x70, 0xC0, 0xC1, 0x81, 0x83,
  0x87, 0xFF, 0x0F, 0xFE, 0x18, 0x0E, 0x70, 0x1C, 0xC0, 0x19, 0x80, 0x3F,
  0x00, 0x70, 0xFF, 0x87, 0xFF, 0x38, 0x3D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0E, 0xE1, 0xE7, 0xFE, 0x3F, 0xFD, 0xC0, 0xEE, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xBF, 0xF9, 0xFF, 0x80, 0x07,
  0xE0, 0x7F, 0xC3, 0x83, 0x8C, 0x07, 0x70, 0x1D, 0x80, 0x36, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0xDC, 0x07, 0x30, 0x1C, 0xE0, 0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0x03,
  0xFF, 0x0E, 0x1E, 0x38, 0x1C, 0xE0, 0x33, 0x80, 0xEE, 0x01, 0xB8, 0x06,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0x6E, 0x03,
  0xB8, 0x0E, 0xE0, 0x73, 0x87, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0xFF, 0x3F, 0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0xFF, 0xCC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x07, 0xE0, 0x7F, 0xC3, 0xC3, 0x8C, 0x07, 0x70, 0x1D, 0x80, 0x36, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xF8, 0x3F, 0xE0, 0x0D, 0x80,
  0x36, 0x00, 0xDC, 0x03, 0x38, 0x0C, 0xF0, 0x71, 0xFF, 0x81, 0xFC, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0x80, 0x6C, 0x07, 0x70, 0x3B, 0xC3, 0x8F, 0xF8, 0x3F, 0x80, 0xE0,
  0x3F, 0x80, 0xEE, 0x07, 0x38, 0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x39,
  0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xF0, 0x3E, 0xE0, 0xF3, 0x83, 0x87, 0x0E,
  0x0E, 0x38, 0x38, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xB8, 0x07, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F,
  0xEC, 0x6F, 0x63, 0x7B, 0xBB, 0xCD, 0x9E, 0x6C, 0xF3, 0xC7, 0x8E, 0x3C,
  0x71, 0xE3, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x30, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0,
  0xFD, 0x87, 0xEE, 0x3F, 0x31, 0xF9, 0xCF, 0xC6, 0x7E, 0x3B, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x70, 0x07, 0xC0,
  0x7F, 0xC3, 0xC7, 0x8C, 0x0E, 0x70, 0x1D, 0x80, 0x76, 0x00, 0xD8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x36, 0x01,
  0xDC, 0x07, 0x30, 0x38, 0xE1, 0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0x87, 0xFE,
  0x30, 0x3D, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x76,
  0x07, 0xBF, 0xF9, 0xFF, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xF1, 0xE1,
  0x81, 0xC7, 0x01, 0xCC, 0x03, 0x98, 0x03, 0x70, 0x06, 0xE0, 0x0D, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x6E, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x38, 0x0E,
  0x30, 0x18, 0x70, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0x00, 0xFF, 0x83, 0xFF, 0x8E, 0x0F, 0x38, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x83, 0xCF, 0xFE, 0x3F, 0xE0, 0xE1,
  0xC3, 0x83, 0x0E, 0x0E, 0x38, 0x18, 0xE0, 0x73, 0x80, 0xCE, 0x03, 0xB8,
  0x07, 0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x3B, 0x83, 0xCF, 0xFC, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0x60, 0x33, 0x87, 0x8F, 0xF8, 0x3F, 0x80, 0xE0, 0x0F, 0xC0,
  0x19, 0x80, 0x73, 0x80, 0xE7, 0x01, 0x86, 0x07, 0x0E, 0x0E, 0x1C, 0x18,
  0x18, 0x30, 0x30, 0xE0, 0x71, 0x80, 0x63, 0x00, 0xCE, 0x01, 0xDC, 0x01,
  0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xC3,
  0x87, 0xC7, 0x0F, 0x8E, 0x1F, 0x1C, 0x76, 0x38, 0xEC, 0x79, 0xD9, 0xB3,
  0x33, 0x66, 0x66, 0xCC, 0xCD, 0x99, 0xD9, 0xB3, 0xE3, 0x67, 0xC7, 0xC7,
  0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xC1,
  0xC0, 0xF0, 0x0E, 0xE0, 0x38, 0xE0, 0x61, 0xC1, 0xC1, 0xC7, 0x03, 0x8E,
  0x03, 0xB8, 0x03, 0x60, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0x6E, 0x01, 0xDC, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x38, 0x70, 0x31, 0xC0,
  0x77, 0x00, 0x70, 0xE0, 0x0E, 0xC0, 0x39, 0xC0, 0x61, 0x81, 0xC3, 0x83,
  0x07, 0x0E, 0x07, 0x18, 0x0E, 0x70, 0x0E, 0xC0, 0x1D, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xFE, 0x0C, 0x01, 0xC0, 0x38, 0x0F,
  0x81, 0xB0, 0x76, 0x0C, 0x63, 0x8C, 0x61, 0xCC, 0x1B, 0x83, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x1F, 0x81, 0xFF, 0x1C, 0x3C, 0xC0, 0xE8,
  0x03, 0x00, 0x18, 0x7F, 0xC7, 0xFE, 0x70, 0x37, 0x01, 0xB8, 0x0D, 0xC0,
  0xEF, 0x0F, 0x3F, 0xF8, 0xFC, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xBF, 0x1F, 0xFC, 0xF8, 0xF7, 0x03, 0xB8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xBC,
  0x1D, 0xFF, 0xCE, 0xFC, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x1C, 0xE0, 0x6E,
  0x03, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x0E, 0xC0,
  0x77, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x1F, 0x33, 0xFF, 0x78, 0xF7, 0x07, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x73, 0xFF,
  0x1F, 0xB0, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0x6E, 0x03, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x27, 0x83, 0x9F,
  0xF8, 0x7F, 0x00, 0x00, 0x60, 0x1F, 0xC1, 0xFE, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x1F, 0xFE, 0xFF, 0xF0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1F, 0x33, 0xFF, 0x78, 0xF7, 0x07, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x73, 0xFF,
  0x1F, 0xB0, 0x03, 0x00, 0x36, 0x07, 0x70, 0xE3, 0xFC, 0x0F, 0x80, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x1D, 0xFC,
  0xF8, 0x77, 0x81, 0xB8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0x06, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x03, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0xFD, 0xFE,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1E, 0xFE, 0x7C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xFC, 0x1C, 0xE1,
  0xC7, 0x1C, 0x39, 0xC1, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xDC, 0x1C, 0x70,
  0xE1, 0xC7, 0x0F, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0x80, 0xFE, 0x0F, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0xEF, 0x79, 0xFF, 0xFB, 0x8E, 0x37, 0x1C,
  0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F,
  0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0x80, 0xE7, 0xC7,
  0x7F, 0x3E, 0x1D, 0xE0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x0F,
  0x81, 0xFF, 0x1E, 0x3C, 0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x67, 0x07, 0x1F, 0xF0, 0x7F, 0x00,
  0xEF, 0xC7, 0xFF, 0x3E, 0x3D, 0xC0, 0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xEF, 0x0F, 0x7F, 0xF3, 0xBF,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1F,
  0x33, 0xFF, 0x78, 0xF7, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x73, 0xFF, 0x1F, 0xB0, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xE7, 0xFD, 0xFB, 0xFB, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xE0, 0x66, 0x03,
  0xB8, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xB8, 0x0E, 0xC0, 0x77,
  0x07, 0x1F, 0xF8, 0x7F, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xFF, 0xEF,
  0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0x60, 0x36, 0x07, 0x70, 0xF3, 0xFF, 0x1F, 0x30, 0xE0, 0x0D,
  0x80, 0x77, 0x01, 0x8C, 0x06, 0x38, 0x38, 0x60, 0xC1, 0x87, 0x07, 0x18,
  0x0C, 0x60, 0x33, 0x80, 0x6C, 0x01, 0xB0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC1, 0x07, 0x87, 0x0F, 0x0E, 0x1F, 0x1C, 0x76, 0x28, 0xCC, 0xD9,
  0x99, 0xB3, 0x33, 0x66, 0x64, 0xCC, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0x87, 0x87, 0x06, 0x06, 0x0C, 0x00, 0x70, 0x1C, 0x70, 0x70, 0xE0, 0xE0,
  0xE3, 0x80, 0xEE, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x0D,
  0x80, 0x3B, 0x80, 0xE3, 0x83, 0x83, 0x87, 0x03, 0x3C, 0x07, 0x80, 0xE0,
  0x0E, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0xC3, 0x83, 0x87, 0x06, 0x06, 0x1C,
  0x0E, 0x38, 0x0C, 0x60, 0x1D, 0xC0, 0x1B, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x03, 0xE0,
  0x07, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0xF0, 0x70, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x78, 0x3C, 0x0F, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00,
  0xF0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x3C, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x7C, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x3C, 0x06, 0x00, 0x3C, 0x00, 0xFE, 0x0F, 0x9E,
  0x1E, 0x0F, 0xE8, 0x0F, 0xC0, 0x02, 0x00,
};

const GFXglyph RobotoMono_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 20, 17, 7, -20 },
  { 9, 7, 7, 17, 5, -21 },
  { 16, 15, 20, 17, 1, -20 },
  { 54, 13, 26, 17, 2, -23 },
  { 97, 15, 20, 17, 1, -20 },
  { 135, 15, 20, 17, 1, -20 },
  { 173, 2, 7, 17, 7, -21 },
  { 175, 7, 28, 17, 5, -22 },
  { 200, 8, 28, 17, 4, -22 },
  { 228, 13, 14, 17, 2, -20 },
  { 251, 13, 14, 17, 2, -16 },
  { 274, 4, 8, 17, 5, -3 },
  { 278, 10, 2, 17, 3, -10 },
  { 281, 4, 4, 17, 7, -4 },
  { 283, 11, 22, 17, 3, -20 },
  { 314, 13, 20, 17, 2, -20 },
  { 347, 8, 20, 17, 3, -20 },
  { 367, 14, 20, 17, 1, -20 },
  { 402, 13, 20, 17, 1, -20 },
  { 435, 14, 20, 17, 1, -20 },
  { 470, 12, 20, 17, 3, -20 },
  { 500, 13, 20, 17, 2, -20 },
  { 533, 13, 20, 17, 2, -20 },
  { 566, 13, 20, 17, 2, -20 },
  { 599, 13, 20, 17, 2, -20 },
  { 632, 4, 16, 17, 7, -16 },
  { 640, 4, 21, 17, 7, -16 },
  { 651, 12, 12, 17, 2, -15 },
  { 669, 13, 8, 17, 2, -13 },
  { 682, 13, 12, 17, 2, -15 },
  { 702, 11, 20, 17, 3, -20 },
  { 730, 15, 20, 17, 1, -20 },
  { 768, 15, 20, 17, 1, -20 },
  { 806, 13, 20, 17, 2, -20 },
  { 839, 14, 20, 17, 1, -20 },
  { 874, 14, 20, 17, 2, -20 },
  { 909, 13, 20, 17, 2, -20 },
  { 942, 12, 20, 17, 3, -20 },
  { 972, 14, 20, 17, 1, -20 },
  { 1007, 13, 20, 17, 2, -20 },
  { 1040, 12, 20, 17, 2, -20 },
  { 1070, 13, 20, 17, 1, -20 },
  { 1103, 14, 20, 17, 2, -20 },
  { 1138, 12, 20, 17, 3, -20 },
  { 1168, 13, 20, 17, 2, -20 },
  { 1201, 13, 20, 17, 2, -20 },
  { 1234, 14, 20, 17, 1, -20 },
  { 1269, 13, 20, 17, 3, -20 },
  { 1302, 15, 23, 17, 1, -20 },
  { 1346, 14, 20, 17, 2, -20 },
  { 1381, 13, 20, 17, 2, -20 },
  { 1414, 15, 20, 17, 1, -20 },
  { 1452, 13, 20, 17, 2, -20 },
  { 1485, 15, 20, 17, 1, -20 },
  { 1523, 15, 20, 17, 1, -20 },
  { 1561, 15, 20, 17, 1, -20 },
  { 1599, 15, 20, 17, 1, -20 },
  { 1637, 13, 20, 17, 2, -20 },
  { 1670, 5, 27, 17, 6, -23 },
  { 1687, 11, 22, 17, 3, -20 },
  { 1718, 5, 27, 17, 6, -23 },
  { 1735, 11, 11, 17, 3, -20 },
  { 1751, 13, 2, 17, 2, 0 },
  { 1755, 5, 3, 17, 6, -20 },
  { 1757, 13, 15, 17, 2, -15 },
  { 1782, 13, 21, 17, 2, -21 },
  { 1817, 13, 15, 17, 2, -15 },
  { 1842, 12, 21, 17, 2, -21 },
  { 1874, 13, 15, 17, 2, -15 },
  { 1899, 13, 22, 17, 2, -22 },
  { 1935, 12, 21, 17, 2, -15 },
  { 1967, 13, 21, 17, 2, -21 },
  { 2002, 12, 20, 17, 3, -20 },
  { 2032, 9, 26, 17, 3, -20 },
  { 2062, 13, 21, 17, 2, -21 },
  { 2097, 12, 21, 17, 3, -21 },
  { 2129, 15, 15, 17, 1, -15 },
  { 2158, 13, 15, 17, 2, -15 },
  { 2183, 13, 15, 17, 2, -15 },
  { 2208, 13, 21, 17, 2, -15 },
  { 2243, 12, 21, 17, 2, -15 },
  { 2275, 11, 15, 17, 4, -15 },
  { 2296, 13, 15, 17, 2, -15 },
  { 2321, 13, 18, 17, 2, -18 },
  { 2351, 12, 15, 17, 2, -15 },
  { 2374, 14, 15, 17, 1, -15 },
  { 2401, 15, 15, 17, 1, -15 },
  { 2430, 15, 15, 17, 1, -15 },
  { 2459, 15, 21, 17, 1, -15 },
  { 2499, 13, 15, 17, 2, -15 },
  { 2524, 10, 27, 17, 4, -22 },
  { 2558, 2, 25, 17, 7, -20 },
  { 2565, 10, 27, 17, 4, -22 },
  { 2599, 15, 6, 17, 1, -11 },
};

const GFXfont RobotoMono_Regular28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular28pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_REGULAR28PT7B_H_
