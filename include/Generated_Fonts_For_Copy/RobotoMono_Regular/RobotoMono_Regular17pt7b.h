#ifndef _ROBOTOMONO_REGULAR17PT7B_H_
#define _ROBOTOMONO_REGULAR17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0x99, 0x99, 0x09, 0x82, 0x40, 0x91, 0xFF, 0x7F,
  0xC4, 0xC1, 0x23, 0xFE, 0xFF, 0x88, 0x82, 0x60, 0x90, 0x08, 0x08, 0x3E,
  0x63, 0x43, 0x43, 0x60, 0x38, 0x0E, 0x03, 0xC3, 0xC3, 0x63, 0x3E, 0x08,
  0x08, 0x70, 0x32, 0x4C, 0xB3, 0x28, 0x76, 0x01, 0x00, 0x80, 0x2E, 0x16,
  0x4D, 0x90, 0x64, 0x0E, 0x3C, 0x32, 0x11, 0x8C, 0x87, 0x81, 0x81, 0xE7,
  0x93, 0x8D, 0x43, 0xB1, 0xCF, 0xB0, 0xF0, 0x11, 0x26, 0x4C, 0xCC, 0xCC,
  0xCC, 0xC4, 0x62, 0x31, 0x88, 0x46, 0x23, 0x33, 0x33, 0x33, 0x32, 0x64,
  0xC8, 0x08, 0x08, 0x49, 0xFF, 0x18, 0x14, 0x26, 0x62, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x57, 0x80, 0xFC, 0xDC, 0x06, 0x08,
  0x30, 0x41, 0x82, 0x04, 0x18, 0x20, 0xC1, 0x02, 0x0C, 0x00, 0x3E, 0x62,
  0xC3, 0xC3, 0xC7, 0xCF, 0xF3, 0xE3, 0xC3, 0xC3, 0x62, 0x3C, 0x1F, 0x91,
  0x11, 0x11, 0x11, 0x11, 0x7C, 0xC6, 0x82, 0x02, 0x06, 0x04, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0xFF, 0x7D, 0x8E, 0x08, 0x10, 0x67, 0x83, 0x81, 0x03,
  0x07, 0x1B, 0xE0, 0x06, 0x0E, 0x1E, 0x16, 0x36, 0x66, 0x46, 0xC6, 0xFF,
  0x06, 0x06, 0x06, 0x7F, 0x83, 0x06, 0x0F, 0x9F, 0x81, 0x81, 0x03, 0x0F,
  0x1B, 0xE0, 0x1C, 0x30, 0x60, 0x40, 0xDC, 0xE6, 0xC3, 0xC3, 0xC3, 0x43,
  0x66, 0x3C, 0xFF, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x60, 0x3E, 0x63, 0x43, 0x43, 0x63, 0x3E, 0x76, 0x43, 0xC1, 0x41,
  0x63, 0x3E, 0x3C, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x3B, 0x02, 0x06,
  0x0C, 0x38, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x02, 0x4B, 0x40, 0x02, 0x1C,
  0xE6, 0x07, 0x03, 0xC1, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x70,
  0x1E, 0x03, 0x0E, 0x78, 0xC0, 0x7D, 0x8A, 0x18, 0x30, 0x41, 0x86, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x3E, 0x31, 0x92, 0x52, 0xAA, 0x4D, 0x26, 0x93,
  0x4A, 0xBF, 0x40, 0x11, 0x07, 0x80, 0x18, 0x0C, 0x07, 0x06, 0x83, 0x41,
  0x31, 0x98, 0xC4, 0x7F, 0x61, 0xB0, 0x50, 0x30, 0xFC, 0xC7, 0xC3, 0xC3,
  0xC3, 0xFC, 0xC7, 0xC1, 0xC1, 0xC1, 0xC7, 0xFC, 0x3E, 0x63, 0xC3, 0xC1,
  0x80, 0x80, 0x80, 0x80, 0xC1, 0xC3, 0x63, 0x3E, 0xFC, 0xC6, 0xC3, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC6, 0xFC, 0xFF, 0x02, 0x04, 0x08,
  0x1F, 0xA0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F,
  0xBF, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3E, 0x63, 0xC3, 0xC0, 0x80, 0x80,
  0x8F, 0x81, 0xC1, 0xC1, 0x63, 0x3E, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x83, 0xC3, 0xC6, 0x7C, 0xC3, 0xE3, 0x31, 0x99, 0x8D, 0x87,
  0xC3, 0xE1, 0x98, 0xC6, 0x63, 0x30, 0xD8, 0x30, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xC3, 0xE3, 0xE7, 0xE5, 0xF5,
  0xDD, 0xD9, 0xD9, 0xC9, 0xC1, 0xC1, 0xC1, 0xC3, 0xE3, 0xE3, 0xF3, 0xD3,
  0xDB, 0xCB, 0xCF, 0xC7, 0xC7, 0xC3, 0xC3, 0x3C, 0x66, 0xC3, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0xC3, 0x66, 0x3C, 0xFC, 0x86, 0x82, 0x83, 0x82,
  0x86, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C, 0x33, 0x30, 0xD8, 0x28,
  0x14, 0x0A, 0x05, 0x02, 0xC1, 0x61, 0x99, 0x87, 0xC0, 0x30, 0x0C, 0xFC,
  0xC7, 0xC3, 0xC1, 0xC3, 0xC7, 0xFC, 0xC4, 0xC6, 0xC2, 0xC3, 0xC1, 0x3E,
  0x63, 0xC1, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC1, 0x63, 0x3E, 0xFF,
  0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0x66,
  0x3C, 0x81, 0xE1, 0xB0, 0xC8, 0x46, 0x23, 0x30, 0x90, 0x48, 0x3C, 0x0E,
  0x06, 0x03, 0x00, 0x99, 0xCC, 0xE6, 0x53, 0xAD, 0xD6, 0xAB, 0xD4, 0xCA,
  0x67, 0x33, 0x98, 0xCC, 0x40, 0xC3, 0xA1, 0x99, 0x86, 0xC1, 0xC0, 0xC0,
  0x60, 0x78, 0x26, 0x31, 0x10, 0xD8, 0x30, 0xE1, 0xD8, 0x62, 0x10, 0xCC,
  0x12, 0x07, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0x02,
  0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xFF, 0xF2, 0x49,
  0x24, 0x92, 0x49, 0x27, 0xE0, 0xC1, 0x04, 0x18, 0x20, 0x83, 0x04, 0x18,
  0x20, 0x83, 0x04, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0,
  0x30, 0xC3, 0x9A, 0x4F, 0x10, 0xFF, 0xE3, 0x3C, 0x66, 0xC3, 0x03, 0x7F,
  0xC3, 0xC3, 0xC7, 0x7F, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xE6, 0xC3, 0xC3,
  0xC1, 0xC3, 0xC3, 0xE6, 0xFE, 0x3E, 0x62, 0xC3, 0xC0, 0xC0, 0xC0, 0xC3,
  0x63, 0x3C, 0x03, 0x03, 0x03, 0x03, 0x3F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x67, 0x3F, 0x3C, 0x62, 0xC3, 0xC1, 0xFF, 0xC0, 0xC0, 0x63, 0x3E,
  0x0F, 0x18, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x3F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x3F, 0x03, 0x42,
  0x7E, 0x10, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x10, 0x20, 0x07, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x47, 0xF0, 0x18, 0x41, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xDC,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xCC, 0xD8, 0xD0, 0xF8, 0xCC, 0xCC, 0xC6,
  0xC3, 0xF1, 0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F,
  0xE0, 0xF7, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0xDE, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x66, 0xC3, 0xC1, 0xC1,
  0xC1, 0xC3, 0x66, 0x3C, 0xFC, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6,
  0xFC, 0xC0, 0xC0, 0xC0, 0x3F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63,
  0x3F, 0x03, 0x03, 0x03, 0xBF, 0x9C, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3E,
  0x63, 0x43, 0x60, 0x3E, 0x03, 0xC3, 0x63, 0x3E, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x43, 0x43, 0x67, 0x3F, 0xC1, 0xC3, 0x42, 0x66, 0x26, 0x24, 0x3C, 0x18,
  0x18, 0xC4, 0xD3, 0x34, 0xC9, 0x3A, 0x6A, 0x8C, 0xA3, 0x38, 0xCC, 0x31,
  0x00, 0xC3, 0x66, 0x34, 0x1C, 0x18, 0x1C, 0x36, 0x62, 0xC3, 0x81, 0xE1,
  0x90, 0xCC, 0xC2, 0x61, 0xA0, 0xF0, 0x30, 0x18, 0x08, 0x0C, 0x1C, 0x0C,
  0x00, 0xFF, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xFF, 0x19, 0x8C,
  0x63, 0x18, 0x98, 0xE1, 0x0C, 0x63, 0x18, 0x43, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC3, 0x18, 0xC6, 0x30, 0x83, 0x39, 0x18, 0xC6, 0x31, 0x18, 0x30, 0x1F,
  0x3C, 0x78, 0x0C,
};

const GFXglyph RobotoMono_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 4, 10, 3, -13 },
  { 6, 10, 12, 10, 0, -12 },
  { 21, 8, 16, 10, 1, -14 },
  { 37, 10, 12, 10, 0, -12 },
  { 52, 9, 12, 10, 1, -12 },
  { 66, 1, 4, 10, 4, -13 },
  { 67, 4, 18, 10, 3, -14 },
  { 76, 4, 18, 10, 3, -14 },
  { 85, 8, 8, 10, 1, -12 },
  { 93, 8, 9, 10, 1, -10 },
  { 102, 2, 5, 10, 3, -2 },
  { 104, 6, 1, 10, 2, -6 },
  { 105, 3, 2, 10, 4, -2 },
  { 106, 7, 13, 10, 2, -12 },
  { 118, 8, 12, 10, 1, -12 },
  { 130, 4, 12, 10, 2, -12 },
  { 136, 8, 12, 10, 1, -12 },
  { 148, 7, 12, 10, 1, -12 },
  { 159, 8, 12, 10, 1, -12 },
  { 171, 7, 12, 10, 2, -12 },
  { 182, 8, 12, 10, 1, -12 },
  { 194, 8, 12, 10, 1, -12 },
  { 206, 8, 12, 10, 1, -12 },
  { 218, 8, 12, 10, 1, -12 },
  { 230, 2, 9, 10, 5, -9 },
  { 233, 3, 12, 10, 4, -9 },
  { 238, 7, 7, 10, 1, -9 },
  { 245, 8, 5, 10, 1, -8 },
  { 250, 8, 7, 10, 1, -9 },
  { 257, 7, 12, 10, 2, -12 },
  { 268, 9, 12, 10, 1, -12 },
  { 282, 9, 12, 10, 1, -12 },
  { 296, 8, 12, 10, 1, -12 },
  { 308, 8, 12, 10, 1, -12 },
  { 320, 8, 12, 10, 1, -12 },
  { 332, 7, 12, 10, 2, -12 },
  { 343, 7, 12, 10, 2, -12 },
  { 354, 8, 12, 10, 1, -12 },
  { 366, 8, 12, 10, 1, -12 },
  { 378, 8, 12, 10, 1, -12 },
  { 390, 8, 12, 10, 1, -12 },
  { 402, 9, 12, 10, 1, -12 },
  { 416, 7, 12, 10, 2, -12 },
  { 427, 8, 12, 10, 1, -12 },
  { 439, 8, 12, 10, 1, -12 },
  { 451, 8, 12, 10, 1, -12 },
  { 463, 8, 12, 10, 2, -12 },
  { 475, 9, 14, 10, 1, -12 },
  { 491, 8, 12, 10, 1, -12 },
  { 503, 8, 12, 10, 1, -12 },
  { 515, 9, 12, 10, 1, -12 },
  { 529, 8, 12, 10, 1, -12 },
  { 541, 9, 12, 10, 1, -12 },
  { 555, 9, 12, 10, 1, -12 },
  { 569, 9, 12, 10, 1, -12 },
  { 583, 10, 12, 10, 0, -12 },
  { 598, 8, 12, 10, 1, -12 },
  { 610, 3, 17, 10, 4, -14 },
  { 617, 6, 13, 10, 2, -12 },
  { 627, 4, 17, 10, 3, -14 },
  { 636, 6, 6, 10, 2, -12 },
  { 641, 8, 1, 10, 1, 0 },
  { 642, 4, 2, 10, 3, -12 },
  { 643, 8, 9, 10, 1, -9 },
  { 652, 8, 13, 10, 1, -13 },
  { 665, 8, 9, 10, 1, -9 },
  { 674, 8, 13, 10, 1, -13 },
  { 687, 8, 9, 10, 1, -9 },
  { 696, 8, 13, 10, 1, -13 },
  { 709, 8, 13, 10, 1, -9 },
  { 722, 8, 13, 10, 1, -13 },
  { 735, 7, 12, 10, 2, -12 },
  { 746, 5, 16, 10, 2, -12 },
  { 756, 8, 13, 10, 1, -13 },
  { 769, 7, 13, 10, 2, -13 },
  { 781, 8, 9, 10, 1, -9 },
  { 790, 8, 9, 10, 1, -9 },
  { 799, 8, 9, 10, 1, -9 },
  { 808, 8, 12, 10, 1, -9 },
  { 820, 8, 12, 10, 1, -9 },
  { 832, 6, 9, 10, 3, -9 },
  { 839, 8, 9, 10, 1, -9 },
  { 848, 8, 11, 10, 1, -11 },
  { 859, 8, 9, 10, 1, -9 },
  { 868, 8, 9, 10, 1, -9 },
  { 877, 10, 9, 10, 0, -9 },
  { 889, 8, 9, 10, 1, -9 },
  { 898, 9, 13, 10, 1, -9 },
  { 913, 8, 9, 10, 1, -9 },
  { 922, 5, 16, 10, 3, -13 },
  { 932, 2, 15, 10, 4, -12 },
  { 936, 5, 16, 10, 3, -13 },
  { 946, 10, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_Regular17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular17pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_REGULAR17PT7B_H_
