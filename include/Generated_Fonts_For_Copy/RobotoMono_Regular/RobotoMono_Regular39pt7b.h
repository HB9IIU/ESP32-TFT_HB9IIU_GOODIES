#ifndef _ROBOTOMONO_REGULAR39PT7B_H_
#define _ROBOTOMONO_REGULAR39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0x80, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x38, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x38, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x60,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00,
  0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xF8, 0x3C, 0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x0E, 0x78,
  0x03, 0xDE, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x1E, 0x7C,
  0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x38,
  0x00, 0x38, 0x70, 0x40, 0xE1, 0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x1C, 0x30,
  0x38, 0x71, 0xC0, 0xE1, 0xC6, 0x03, 0xCE, 0x38, 0x07, 0xF9, 0xC0, 0x0F,
  0x87, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE3, 0xC0, 0x03, 0x1F, 0xC0, 0x1C, 0xFF, 0x80, 0x63, 0x0E,
  0x03, 0x9C, 0x18, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC3, 0x87, 0x06, 0x00,
  0x1C, 0x18, 0x00, 0x38, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3C, 0x3C, 0x01, 0xC0, 0xE0, 0x1E,
  0x07, 0x00, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xF1, 0xE0,
  0x03, 0xBE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x0E, 0x7C, 0xF0, 0x73, 0xC3, 0xC3, 0xBC, 0x1E, 0x3D,
  0xE0, 0x79, 0xCF, 0x01, 0xEE, 0x78, 0x07, 0xF3, 0xC0, 0x3F, 0x1E, 0x00,
  0xF0, 0x78, 0x0F, 0xC1, 0xFB, 0xFF, 0x0F, 0xFF, 0x7C, 0x1F, 0xE1, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x02, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x10, 0x38, 0x07, 0x0E, 0x1F,
  0xF3, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xCE, 0x00, 0xF3, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0x07, 0x03,
  0x80, 0x80, 0x40, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEE, 0xF7, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0xF0, 0x3C, 0x78, 0x07, 0x1C, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7B, 0xF8, 0x7C,
  0xFE, 0x3E, 0x3F, 0x9E, 0x0F, 0xEF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x1E, 0x78,
  0x0F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x20, 0x3C, 0x1F,
  0x9F, 0xFF, 0xFF, 0xF3, 0xF8, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0xF0, 0x0F, 0x3C, 0x01,
  0xEE, 0x00, 0x7B, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x81, 0xE7, 0x80,
  0x77, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x78, 0x0F, 0x3F, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x77, 0x80, 0x0F, 0x78, 0x00, 0xE7,
  0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x07, 0x07, 0x80, 0xF0,
  0x78, 0x0E, 0x07, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0x80, 0x78, 0x70,
  0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1D, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xE3, 0xC1, 0xF8, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x1E, 0x78, 0x1F, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0xFE, 0x1D,
  0xFF, 0x8F, 0xFF, 0xE7, 0xE0, 0xFB, 0xE0, 0x3D, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D, 0xC0,
  0x1E, 0xF0, 0x0E, 0x3C, 0x0F, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xF8, 0x3C, 0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x39, 0xE0,
  0x0E, 0x78, 0x03, 0x9E, 0x01, 0xE3, 0x80, 0x78, 0xF0, 0x3C, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x07, 0x9E, 0x00, 0xE7,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0,
  0x0E, 0x7C, 0x07, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0x83, 0xC7, 0x80, 0xF7, 0x80, 0x3B, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3E, 0xFC, 0x7F, 0x3F, 0xFB, 0x8F, 0xF9,
  0xC0, 0xF1, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x79, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0xFF, 0xFD, 0xE0, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C,
  0x38, 0xF1, 0xC7, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F,
  0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xF8, 0x3E, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0xE0, 0x0E,
  0x0E, 0x00, 0x38, 0xE0, 0xF0, 0xC6, 0x0F, 0xC6, 0x30, 0xF7, 0x1B, 0x0E,
  0x30, 0xD8, 0x61, 0x86, 0xC7, 0x0C, 0x36, 0x30, 0x61, 0xF1, 0x83, 0x0F,
  0x8C, 0x18, 0x7C, 0x60, 0xC3, 0xE3, 0x06, 0x1F, 0x18, 0x71, 0xB8, 0xC3,
  0x8C, 0xC7, 0xFC, 0xE6, 0x3F, 0x7E, 0x38, 0xF1, 0xE0, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x01, 0x00, 0x7C, 0x30, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3B, 0xC0, 0x03, 0x9C, 0x00,
  0x39, 0xC0, 0x07, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x38, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00,
  0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x7B,
  0xC0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0x3E, 0xF0,
  0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x03, 0xC3,
  0xC0, 0x3C, 0xF0, 0x03, 0x9E, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x0E, 0xF0, 0x03, 0xDE, 0x00, 0x79, 0xE0, 0x1E, 0x3E,
  0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xF0, 0x78, 0x3F, 0x0F, 0x01, 0xF1, 0xE0, 0x1F, 0x3C,
  0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFC, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x07, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x39, 0xE0,
  0x07, 0x1E, 0x01, 0xE3, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x39, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07,
  0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0xF0, 0x0F,
  0x8F, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x03,
  0xEF, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xDF, 0xB8, 0x77, 0xEE, 0x1D, 0xFB,
  0x8E, 0x7E, 0xF3, 0x9F, 0x9C, 0xE7, 0xE7, 0x71, 0xF9, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0x78, 0x7E, 0x1C, 0x1F, 0x87, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xEF, 0x03, 0xFB, 0xC0, 0xFE, 0x78, 0x3F, 0x8E, 0x0F, 0xE3, 0xC3, 0xF8,
  0x70, 0xFE, 0x1E, 0x3F, 0x83, 0x8F, 0xE0, 0xF3, 0xF8, 0x1C, 0xFE, 0x07,
  0xBF, 0x80, 0xEF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E,
  0x00, 0x73, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xF0,
  0x03, 0x9E, 0x00, 0xF1, 0xE0, 0x1E, 0x3E, 0x0F, 0x83, 0xFF, 0xE0, 0x3F,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80,
  0xFC, 0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x07, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xE0, 0xF8, 0x3C, 0x07, 0xC7, 0x80, 0x3C, 0x78, 0x01,
  0xC7, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xE7,
  0x00, 0x1E, 0x78, 0x01, 0xC3, 0xC0, 0x3C, 0x3E, 0x07, 0x81, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x78, 0x0F, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x3C, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xCF, 0x00,
  0x79, 0xE0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x3C,
  0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x78, 0x00, 0xE7, 0x80,
  0x1E, 0x3E, 0x03, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xE0, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1C,
  0xF0, 0x01, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80,
  0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00,
  0xF0, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x8F,
  0x00, 0x1C, 0x70, 0x00, 0xF3, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x78, 0x3D, 0xC1, 0xE0, 0xE7,
  0x07, 0x83, 0x9C, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC3, 0xE0, 0xE7, 0x0F,
  0xC3, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x78, 0xE3, 0xF1, 0xC3, 0x8C, 0xC7,
  0x0E, 0x73, 0x1C, 0x39, 0xCE, 0x70, 0xE7, 0x39, 0xC3, 0x9C, 0xE7, 0x0E,
  0x73, 0x9C, 0x39, 0x86, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xF0, 0xF0,
  0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1,
  0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x1E, 0x00, 0x79, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0x79,
  0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x3C, 0x3C,
  0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7B,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01,
  0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x3D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xF0, 0xF0, 0xE1,
  0xC1, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x0F, 0x3C, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x7F, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0, 0x1E, 0x70,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0xBE, 0x07,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xE3, 0xC0, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF1, 0xF0, 0x3D, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x7C, 0xF8,
  0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B,
  0xC0, 0x1E, 0xF8, 0x07, 0xBF, 0x03, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xF3,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC1, 0xE7, 0x80,
  0x7B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x07,
  0x78, 0x07, 0xBE, 0x07, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x07, 0xE3, 0x8F, 0xFD, 0xCF, 0xFF, 0xEF, 0x83,
  0xF7, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0x78, 0x07, 0xBE, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0x70, 0xFF,
  0x38, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07,
  0x9C, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0x1F, 0x01, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xF0, 0x20, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xE3, 0x8F, 0xFD, 0xCF, 0xFF, 0xEF, 0x83, 0xF7, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x78,
  0x07, 0xBE, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0x70, 0xFF, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x40, 0x0F, 0x30, 0x0F, 0x3C, 0x0F, 0x9F, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xF8, 0x79, 0xFF,
  0x3D, 0xFF, 0xDF, 0xC1, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF3, 0xFF, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0x78, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x9E,
  0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7E, 0xF0, 0x0F, 0x9F,
  0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3E, 0x1E, 0x03,
  0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xCF, 0x00, 0x3E, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE7, 0x87,
  0x8E, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x1F, 0x0E, 0xE0, 0xF0, 0xFE, 0x0E,
  0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0,
  0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE,
  0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F,
  0xE0, 0xE0, 0xF0, 0xE1, 0xF8, 0x79, 0xFF, 0x3F, 0xFF, 0xDF, 0xC1, 0xEF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x38,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x7C,
  0xF0, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B,
  0xC0, 0x0E, 0x38, 0x03, 0xC7, 0xC0, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xC0, 0xF1, 0xF0, 0x3D, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x7C, 0xF8,
  0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBE, 0x03, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xF3,
  0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0x8F, 0xFD,
  0xCF, 0xFF, 0xEF, 0x83, 0xF7, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x78, 0x07, 0xBE, 0x07, 0xCF, 0xFF,
  0xE3, 0xFF, 0x70, 0xFF, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xF0, 0xFF,
  0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x3E, 0x78, 0x07, 0x9E, 0x00,
  0xE7, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3B, 0xC0, 0x0F, 0x70,
  0x03, 0x9E, 0x01, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0xCF, 0xFE, 0xE3,
  0xFF, 0x70, 0xFE, 0x38, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xBC,
  0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x00, 0xE0, 0xE0, 0x3C, 0x1E,
  0x07, 0x01, 0xC1, 0xE0, 0x38, 0x38, 0x07, 0x87, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x30, 0x1F, 0x81, 0xC0, 0xEE,
  0x07, 0x03, 0x9C, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC3, 0xE0, 0xE7, 0x0F,
  0x87, 0x1C, 0x37, 0x1C, 0x38, 0xDC, 0x70, 0xE7, 0x31, 0xC3, 0x9C, 0xC7,
  0x0E, 0x63, 0x98, 0x39, 0x8E, 0xE0, 0x6E, 0x1B, 0x81, 0xF8, 0x6E, 0x07,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x80,
  0xF0, 0x0E, 0x03, 0x80, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x3B, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0x78, 0x3C, 0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0xF0, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x0E, 0x00,
  0xF0, 0x78, 0x07, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x00, 0x07, 0x78,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0x3E, 0x01, 0xFC, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x3E,
  0x07, 0xF0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0xDF,
  0xFC, 0x0F, 0xE1, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0x80,
};

const GFXglyph RobotoMono_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 9, 9, 23, 7, -29 },
  { 30, 21, 28, 23, 1, -28 },
  { 104, 18, 36, 23, 3, -32 },
  { 185, 22, 28, 23, 1, -28 },
  { 262, 21, 28, 23, 2, -28 },
  { 336, 3, 9, 23, 9, -29 },
  { 340, 10, 40, 23, 7, -31 },
  { 390, 10, 40, 23, 6, -31 },
  { 440, 18, 19, 23, 3, -28 },
  { 483, 19, 20, 23, 2, -23 },
  { 531, 5, 10, 23, 7, -4 },
  { 538, 15, 3, 23, 4, -14 },
  { 544, 6, 5, 23, 9, -5 },
  { 548, 15, 30, 23, 5, -28 },
  { 605, 18, 28, 23, 3, -28 },
  { 668, 11, 28, 23, 4, -28 },
  { 707, 18, 28, 23, 2, -28 },
  { 770, 17, 28, 23, 2, -28 },
  { 830, 20, 28, 23, 1, -28 },
  { 900, 17, 28, 23, 4, -28 },
  { 960, 17, 28, 23, 3, -28 },
  { 1020, 19, 28, 23, 2, -28 },
  { 1087, 18, 28, 23, 3, -28 },
  { 1150, 17, 28, 23, 3, -28 },
  { 1210, 6, 22, 23, 10, -22 },
  { 1227, 7, 28, 23, 9, -22 },
  { 1252, 16, 17, 23, 3, -21 },
  { 1286, 17, 11, 23, 3, -18 },
  { 1310, 17, 17, 23, 3, -21 },
  { 1347, 16, 28, 23, 4, -28 },
  { 1403, 21, 28, 23, 1, -28 },
  { 1477, 20, 28, 23, 2, -28 },
  { 1547, 18, 28, 23, 3, -28 },
  { 1610, 19, 28, 23, 2, -28 },
  { 1677, 19, 28, 23, 3, -28 },
  { 1744, 17, 28, 23, 3, -28 },
  { 1804, 17, 28, 23, 4, -28 },
  { 1864, 19, 28, 23, 2, -28 },
  { 1931, 18, 28, 23, 3, -28 },
  { 1994, 17, 28, 23, 3, -28 },
  { 2054, 18, 28, 23, 2, -28 },
  { 2117, 20, 28, 23, 3, -28 },
  { 2187, 17, 28, 23, 4, -28 },
  { 2247, 18, 28, 23, 3, -28 },
  { 2310, 18, 28, 23, 3, -28 },
  { 2373, 19, 28, 23, 2, -28 },
  { 2440, 18, 28, 23, 4, -28 },
  { 2503, 20, 33, 23, 2, -28 },
  { 2586, 19, 28, 23, 3, -28 },
  { 2653, 20, 28, 23, 2, -28 },
  { 2723, 21, 28, 23, 1, -28 },
  { 2797, 18, 28, 23, 3, -28 },
  { 2860, 21, 28, 23, 1, -28 },
  { 2934, 22, 28, 23, 1, -28 },
  { 3011, 20, 28, 23, 2, -28 },
  { 3081, 21, 28, 23, 1, -28 },
  { 3155, 19, 28, 23, 2, -28 },
  { 3222, 8, 38, 23, 8, -32 },
  { 3260, 15, 30, 23, 4, -28 },
  { 3317, 7, 38, 23, 8, -32 },
  { 3351, 15, 15, 23, 4, -28 },
  { 3380, 17, 3, 23, 3, 0 },
  { 3387, 7, 5, 23, 8, -28 },
  { 3392, 18, 21, 23, 3, -21 },
  { 3440, 18, 29, 23, 3, -29 },
  { 3506, 17, 21, 23, 3, -21 },
  { 3551, 17, 29, 23, 3, -29 },
  { 3613, 18, 21, 23, 3, -21 },
  { 3661, 19, 30, 23, 3, -30 },
  { 3733, 17, 29, 23, 3, -21 },
  { 3795, 17, 29, 23, 3, -29 },
  { 3857, 17, 28, 23, 4, -28 },
  { 3917, 12, 36, 23, 4, -28 },
  { 3971, 19, 29, 23, 3, -29 },
  { 4040, 17, 29, 23, 4, -29 },
  { 4102, 20, 21, 23, 2, -21 },
  { 4155, 17, 21, 23, 3, -21 },
  { 4200, 19, 21, 23, 2, -21 },
  { 4250, 18, 29, 23, 3, -21 },
  { 4316, 17, 29, 23, 3, -21 },
  { 4378, 14, 21, 23, 6, -21 },
  { 4415, 18, 21, 23, 3, -21 },
  { 4463, 17, 26, 23, 3, -26 },
  { 4519, 17, 21, 23, 3, -21 },
  { 4564, 19, 21, 23, 2, -21 },
  { 4614, 22, 21, 23, 1, -21 },
  { 4672, 20, 21, 23, 2, -21 },
  { 4725, 21, 29, 23, 1, -21 },
  { 4802, 18, 21, 23, 3, -21 },
  { 4850, 13, 37, 23, 6, -30 },
  { 4911, 3, 36, 23, 10, -28 },
  { 4925, 13, 37, 23, 6, -30 },
  { 4986, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_Regular39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular39pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_REGULAR39PT7B_H_
