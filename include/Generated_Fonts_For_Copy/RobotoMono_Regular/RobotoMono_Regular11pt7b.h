#ifndef _ROBOTOMONO_REGULAR11PT7B_H_
#define _ROBOTOMONO_REGULAR11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0xB4, 0x14, 0x97, 0xCA, 0x2B, 0xF4, 0x94, 0x23, 0xA3, 0x14,
  0x18, 0x31, 0x71, 0x00, 0x62, 0xAA, 0x94, 0x10, 0xB3, 0x43, 0x64, 0xA4,
  0xCE, 0xDE, 0x7F, 0xC0, 0x29, 0x49, 0x24, 0x89, 0x10, 0x91, 0x24, 0x4A,
  0x4A, 0x40, 0x21, 0x3E, 0x4D, 0x00, 0x21, 0x3E, 0x42, 0x00, 0xE0, 0xF0,
  0x80, 0x18, 0x84, 0x42, 0x11, 0x08, 0x80, 0x74, 0x63, 0x7C, 0xC6, 0x2E,
  0x3C, 0x92, 0x49, 0x79, 0x28, 0x82, 0x10, 0x84, 0x1F, 0x7A, 0x42, 0x33,
  0xC5, 0x2F, 0x08, 0x62, 0x8A, 0x4B, 0xF0, 0x82, 0x7A, 0x21, 0xE0, 0x86,
  0x2E, 0x32, 0x21, 0xE8, 0xC6, 0x2E, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x74,
  0x62, 0xED, 0x46, 0x2E, 0x74, 0xA3, 0x1F, 0x84, 0x4C, 0xC0, 0x30, 0x87,
  0x17, 0x86, 0x10, 0xF8, 0x3E, 0x83, 0x06, 0xE8, 0x00, 0x74, 0x42, 0x22,
  0x10, 0x04, 0x39, 0x17, 0xEB, 0xAE, 0xF4, 0x0E, 0x10, 0x42, 0x8A, 0x29,
  0xE4, 0x71, 0xF4, 0x63, 0xE9, 0xC6, 0x3E, 0x74, 0x63, 0x08, 0x42, 0x2E,
  0xE4, 0xA3, 0x18, 0xC6, 0x7E, 0xFC, 0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21,
  0x0F, 0x42, 0x10, 0x74, 0x61, 0x0B, 0xC6, 0x2E, 0x8C, 0x63, 0xF8, 0xC6,
  0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x08, 0x42, 0x10, 0x86, 0x5E, 0x8C,
  0xA9, 0xCE, 0x4A, 0x51, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x8C, 0xF7, 0xDA,
  0xD6, 0x31, 0x8C, 0x73, 0xDA, 0xCE, 0x71, 0x74, 0xE3, 0x18, 0xC6, 0x2E,
  0xF4, 0x63, 0x1F, 0x42, 0x10, 0x39, 0x34, 0x51, 0xC5, 0x14, 0x4E, 0x04,
  0xF4, 0x63, 0x1F, 0x4A, 0x51, 0x74, 0x61, 0x83, 0x06, 0x2E, 0xFC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0xC5, 0x14, 0x92,
  0x28, 0xA3, 0x04, 0x95, 0x55, 0x5D, 0x6D, 0xB6, 0xD2, 0x45, 0x22, 0x8C,
  0x10, 0xA4, 0xB1, 0xC5, 0x26, 0x8A, 0x30, 0x41, 0x04, 0xF8, 0x84, 0x44,
  0x22, 0x1F, 0xEA, 0xAA, 0xAC, 0x84, 0x44, 0x22, 0x11, 0x10, 0xD5, 0x55,
  0x5C, 0x26, 0x5D, 0xF8, 0xC0, 0x74, 0xDF, 0x19, 0xF4, 0x84, 0x3D, 0x38,
  0xC6, 0x3E, 0x74, 0x61, 0x08, 0xB8, 0x08, 0x5B, 0x38, 0xC6, 0x2F, 0x74,
  0x7F, 0x08, 0x3C, 0x3A, 0x3E, 0x84, 0x21, 0x08, 0x6C, 0xE3, 0x18, 0xBC,
  0x3E, 0x84, 0x3D, 0x18, 0xC6, 0x31, 0x20, 0x38, 0x42, 0x10, 0x9F, 0x30,
  0x71, 0x11, 0x11, 0x1E, 0x84, 0x27, 0x4C, 0x52, 0x53, 0xE1, 0x08, 0x42,
  0x10, 0x9F, 0xFE, 0x59, 0x65, 0x96, 0x50, 0xF4, 0x63, 0x18, 0xC4, 0x74,
  0xE3, 0x18, 0xB8, 0xF4, 0xE3, 0x18, 0xFA, 0x10, 0x6C, 0xE3, 0x18, 0xBC,
  0x21, 0xF8, 0x88, 0x88, 0x74, 0x70, 0x68, 0xB8, 0x47, 0xD0, 0x84, 0x20,
  0xE0, 0x8C, 0x63, 0x18, 0xBC, 0x8C, 0x64, 0xA6, 0x10, 0x96, 0x57, 0x5B,
  0x69, 0x20, 0x8A, 0x98, 0xC5, 0x44, 0xC5, 0x14, 0x8A, 0x30, 0x42, 0x18,
  0xF8, 0x88, 0xCC, 0x7C, 0x25, 0x25, 0x12, 0x48, 0x80, 0xFF, 0xC0, 0x89,
  0x24, 0x52, 0x4A, 0x00, 0x76, 0x30,
};

const GFXglyph RobotoMono_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 3, 2, 7, 2, -8 },
  { 3, 6, 8, 7, 0, -8 },
  { 9, 5, 10, 7, 1, -9 },
  { 16, 6, 8, 7, 0, -8 },
  { 22, 5, 8, 7, 1, -8 },
  { 27, 1, 2, 7, 3, -8 },
  { 28, 3, 12, 7, 2, -9 },
  { 33, 3, 12, 7, 2, -9 },
  { 38, 5, 5, 7, 1, -8 },
  { 42, 5, 5, 7, 1, -6 },
  { 46, 1, 3, 7, 2, -1 },
  { 47, 4, 1, 7, 1, -4 },
  { 48, 1, 1, 7, 3, -1 },
  { 49, 5, 9, 7, 1, -8 },
  { 55, 5, 8, 7, 1, -8 },
  { 60, 3, 8, 7, 1, -8 },
  { 63, 6, 8, 7, 0, -8 },
  { 69, 5, 8, 7, 0, -8 },
  { 74, 6, 8, 7, 0, -8 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 5, 8, 7, 1, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 5, 8, 7, 1, -8 },
  { 105, 2, 6, 7, 3, -6 },
  { 107, 1, 8, 7, 3, -6 },
  { 108, 4, 5, 7, 1, -6 },
  { 111, 5, 3, 7, 1, -5 },
  { 113, 5, 5, 7, 1, -6 },
  { 117, 5, 8, 7, 1, -8 },
  { 122, 6, 8, 7, 0, -8 },
  { 128, 6, 8, 7, 0, -8 },
  { 134, 5, 8, 7, 1, -8 },
  { 139, 5, 8, 7, 1, -8 },
  { 144, 5, 8, 7, 1, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 5, 8, 7, 1, -8 },
  { 164, 5, 8, 7, 1, -8 },
  { 169, 5, 8, 7, 1, -8 },
  { 174, 5, 8, 7, 1, -8 },
  { 179, 5, 8, 7, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 5, 8, 7, 1, -8 },
  { 209, 6, 9, 7, 0, -8 },
  { 216, 5, 8, 7, 1, -8 },
  { 221, 5, 8, 7, 1, -8 },
  { 226, 6, 8, 7, 0, -8 },
  { 232, 5, 8, 7, 1, -8 },
  { 237, 6, 8, 7, 0, -8 },
  { 243, 6, 8, 7, 0, -8 },
  { 249, 6, 8, 7, 0, -8 },
  { 255, 6, 8, 7, 0, -8 },
  { 261, 5, 8, 7, 1, -8 },
  { 266, 2, 11, 7, 2, -9 },
  { 269, 4, 9, 7, 1, -8 },
  { 274, 2, 11, 7, 2, -9 },
  { 277, 4, 4, 7, 1, -8 },
  { 279, 5, 1, 7, 1, 0 },
  { 280, 2, 1, 7, 2, -8 },
  { 281, 5, 6, 7, 1, -6 },
  { 285, 5, 8, 7, 1, -8 },
  { 290, 5, 6, 7, 1, -6 },
  { 294, 5, 8, 7, 1, -8 },
  { 299, 5, 6, 7, 1, -6 },
  { 303, 5, 8, 7, 1, -8 },
  { 308, 5, 8, 7, 1, -6 },
  { 313, 5, 8, 7, 1, -8 },
  { 318, 5, 8, 7, 1, -8 },
  { 323, 4, 10, 7, 1, -8 },
  { 328, 5, 8, 7, 1, -8 },
  { 333, 5, 8, 7, 1, -8 },
  { 338, 6, 6, 7, 0, -6 },
  { 343, 5, 6, 7, 1, -6 },
  { 347, 5, 6, 7, 1, -6 },
  { 351, 5, 8, 7, 1, -6 },
  { 356, 5, 8, 7, 1, -6 },
  { 361, 4, 6, 7, 2, -6 },
  { 364, 5, 6, 7, 1, -6 },
  { 368, 5, 7, 7, 1, -7 },
  { 373, 5, 6, 7, 1, -6 },
  { 377, 5, 6, 7, 1, -6 },
  { 381, 6, 6, 7, 0, -6 },
  { 386, 5, 6, 7, 1, -6 },
  { 390, 6, 8, 7, 0, -6 },
  { 396, 5, 6, 7, 1, -6 },
  { 400, 3, 11, 7, 2, -9 },
  { 405, 1, 10, 7, 3, -8 },
  { 407, 3, 11, 7, 2, -9 },
  { 412, 6, 2, 7, 0, -4 },
};

const GFXfont RobotoMono_Regular11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular11pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_REGULAR11PT7B_H_
