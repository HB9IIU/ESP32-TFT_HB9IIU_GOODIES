#ifndef _ROBOTOMONO_REGULAR40PT7B_H_
#define _ROBOTOMONO_REGULAR40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0x00, 0x00, 0x00, 0x73, 0xFE, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0x80, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x18,
  0x18, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xC0, 0x03, 0x07, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x07, 0x07, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xC0, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0x7E, 0x3C, 0x07, 0x8E, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0x78, 0x03, 0xDF, 0x01, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x07, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC1, 0x83, 0x83, 0x07, 0x0E, 0x0C, 0x38, 0x38, 0x30, 0xE0, 0xE1, 0xC7,
  0x03, 0x87, 0x18, 0x07, 0xF8, 0xE0, 0x0F, 0xE7, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x8F, 0x80, 0x0E, 0x7F, 0x80, 0x73, 0xCE, 0x01, 0x8E, 0x1C, 0x0E, 0x30,
  0x70, 0x70, 0xC1, 0xC1, 0xC3, 0x07, 0x06, 0x0C, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE3, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3E, 0x3C, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x80,
  0x70, 0x3C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xF0, 0xF0, 0x07, 0x9F,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x3E, 0xF0, 0x7B, 0xE7, 0xC3, 0x9E, 0x1E, 0x1D, 0xE0, 0x78,
  0xEF, 0x01, 0xEF, 0x78, 0x0F, 0xF3, 0xC0, 0x3F, 0x9E, 0x00, 0xF8, 0x70,
  0x03, 0xC3, 0xC0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFD, 0xE0, 0xFF, 0x87,
  0x80, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x40, 0x70, 0x3C, 0x0E, 0x07, 0x03,
  0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xC0, 0x40, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC1, 0xC0, 0x9E, 0x38, 0xF7, 0xFF,
  0x7F, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3B,
  0x80, 0x0E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x3E, 0x0F, 0x01, 0x80,
  0xC0, 0x10, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0xF3, 0xCF,
  0x39, 0xE7, 0x9C, 0xF3, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x77, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07,
  0x9E, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3D, 0xF8, 0x1E, 0x7E, 0x1F, 0x1F, 0x8F,
  0x87, 0xE7, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x03, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x7C, 0x7F, 0xBF,
  0xFF, 0xFF, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x03, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0x0F, 0x87, 0x80, 0xF9, 0xE0, 0x0F,
  0x3C, 0x00, 0xE7, 0x00, 0x1E, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0x9E, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7,
  0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07,
  0x83, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xC0, 0x3C,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x10, 0x07, 0x7F, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1E, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x0F, 0x0F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x7E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x38, 0x0F, 0x7F, 0xC3, 0xFF, 0xF8, 0xFF, 0x3F, 0x3F,
  0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x3C, 0x0F, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x8F, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x03, 0xC1, 0xE1, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3E, 0x0F, 0x8F, 0x00, 0x71, 0xE0,
  0x0F, 0x38, 0x00, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x73, 0xC0,
  0x1E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xF8, 0xFC, 0x78, 0x0F,
  0x1E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xB8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7D, 0xF0,
  0x3F, 0x3F, 0xFF, 0xC7, 0xFE, 0xE0, 0xFF, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x77, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0xFC, 0x3C, 0x7D, 0xF9,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xC7, 0x82, 0x00, 0x00,
  0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xCF,
  0xCF, 0x80, 0xF7, 0x80, 0x7B, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x78, 0x1E, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0x70, 0x60, 0x20, 0xE3, 0x87,
  0xE1, 0x8C, 0x3F, 0xC6, 0x70, 0xE3, 0x19, 0x87, 0x0C, 0x76, 0x18, 0x31,
  0xD8, 0xE1, 0xC7, 0xE3, 0x87, 0x0F, 0x8C, 0x18, 0x7E, 0x30, 0x61, 0xB8,
  0xC1, 0x86, 0xE3, 0x06, 0x1B, 0x8C, 0x18, 0x66, 0x38, 0xE3, 0x18, 0xFF,
  0xDC, 0x61, 0xF3, 0xE1, 0xC3, 0x87, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x01, 0x00, 0x3E, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00, 0x1C,
  0x70, 0x01, 0xE3, 0x80, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80,
  0x38, 0x1E, 0x01, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1C, 0x00, 0xF1, 0xE0, 0x03, 0x8F,
  0x00, 0x1C, 0x70, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xC0, 0x00,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x07, 0xCF, 0x00,
  0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x1E, 0x78, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x0F,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x81, 0xF0, 0xFC, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x78,
  0x01, 0xE7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF7, 0x00, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0,
  0x3C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C,
  0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0,
  0x07, 0xBC, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81,
  0xF8, 0xFC, 0x3E, 0x03, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0F,
  0x70, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0xF0, 0x03, 0xFF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF0,
  0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0,
  0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xEF, 0x00, 0xFC, 0xF8, 0x0F, 0x87, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFE, 0xE0, 0xFF, 0xB8, 0x77, 0xEE, 0x1D, 0xFB, 0xC7, 0x7E, 0x73,
  0x9F, 0x9C, 0xE7, 0xE7, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x83, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xBC, 0x07, 0xEF, 0x01, 0xF9,
  0xE0, 0x7E, 0x78, 0x1F, 0x8F, 0x07, 0xE3, 0xC1, 0xF8, 0x78, 0x7E, 0x0E,
  0x1F, 0x83, 0xC7, 0xE0, 0x71, 0xF8, 0x1E, 0x7E, 0x03, 0x9F, 0x80, 0xF7,
  0xE0, 0x1D, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xF9, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x78, 0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0x80, 0x3E, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xB8, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x3F, 0x03, 0xE0, 0x7C, 0x1E,
  0x01, 0xE1, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x3C, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0x80,
  0x3C, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x1F, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xC0, 0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x03, 0xC3, 0x80,
  0xF0, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x07,
  0xB8, 0x01, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xF8, 0xFC, 0x3E, 0x03, 0xE3, 0xC0, 0x1E, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF3, 0xE0, 0x3E,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0x70, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x70, 0x03, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x38, 0x03, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x87,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x38, 0x1D, 0xC1, 0xE0, 0xF7,
  0x07, 0x83, 0xDC, 0x1F, 0x0F, 0x70, 0x7C, 0x39, 0xC1, 0xF0, 0xE7, 0x8F,
  0xC3, 0x9E, 0x3F, 0x0E, 0x78, 0xEC, 0x38, 0xE3, 0xB8, 0xE3, 0x8E, 0xE3,
  0x8E, 0x33, 0x9E, 0x39, 0xCE, 0x78, 0xE7, 0x39, 0xC3, 0x9C, 0x67, 0x0F,
  0x71, 0xDC, 0x3D, 0xC7, 0x70, 0x76, 0x1D, 0xC1, 0xF8, 0x77, 0x07, 0xE1,
  0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0xF8,
  0x00, 0xFB, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x9E, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x01, 0xE7,
  0x80, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x3D, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x70, 0x07, 0x07,
  0x80, 0x3C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x9C, 0x00, 0x1D, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81,
  0xCE, 0x0F, 0x3C, 0x38, 0x70, 0xE1, 0xC7, 0x87, 0x9C, 0x0E, 0xF0, 0x3F,
  0x80, 0x7E, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x78, 0x3C, 0x1E, 0x0F, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFD,
  0xFC, 0x78, 0x0F, 0x9C, 0x01, 0xEF, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x7F, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7C, 0x03, 0x9C, 0x00, 0xEF,
  0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x81, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFB, 0xC7, 0xF8, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x60, 0x3C, 0xFF, 0x0F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFC, 0x0F, 0xBE,
  0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x01, 0xEF, 0xC0, 0xFB, 0xFF, 0xFC, 0xF7, 0xFE, 0x3C,
  0xFF, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFE, 0xFC, 0x3C,
  0x07, 0x9E, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0x70, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x78, 0xFF, 0xFC, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0x83,
  0xC3, 0xFC, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7C, 0x0F, 0xDE, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03,
  0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFB, 0xC1, 0xFC, 0xF0,
  0x00, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0xFE, 0xFC, 0x3C, 0x07, 0x9E,
  0x01, 0xE7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x63, 0xE0, 0x3C, 0xFF, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x30,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x03, 0xFC, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7C, 0x0F, 0xDE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFB, 0xC3, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x20, 0x07,
  0x8C, 0x01, 0xE7, 0x80, 0xF1, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x20, 0x3C, 0x7F, 0x8F, 0x7F,
  0xF3, 0xFF, 0xFE, 0xFC, 0x07, 0xBE, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0xBF, 0xF9, 0xFF,
  0x8F, 0xF8, 0x1C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xFB, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xE0,
  0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xDE, 0x01, 0xF1, 0xE0, 0x3C, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00,
  0x7D, 0xE0, 0x07, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x01, 0x0E, 0xFC, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xFE, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F,
  0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0,
  0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E,
  0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0x00, 0x20, 0x3C, 0x7F, 0x8F,
  0x7F, 0xF3, 0xFF, 0xFE, 0xFC, 0x07, 0xBE, 0x00, 0xEF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x40, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x3C, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFC, 0x0F, 0xBE, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xBE, 0x01, 0xEF, 0xC0, 0xFB, 0xFF,
  0xFC, 0xF7, 0xFE, 0x3C, 0xFF, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x80, 0x03, 0xFC, 0xF1, 0xFF, 0xFC, 0xFE, 0xFF, 0x7C, 0x0F, 0xDE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x11, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFE, 0xFE, 0x3C,
  0x07, 0x9E, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0xC0, 0x7C, 0xFF, 0xFE, 0x1F,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xE0, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xDF, 0xFF, 0xE7, 0xFE, 0xF1, 0xFE, 0x78,
  0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xE0,
  0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x39, 0xC0, 0x03,
  0x9C, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x30, 0x1F, 0x80, 0xE0, 0x7F, 0x07,
  0x81, 0xDC, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC1, 0xF0, 0xE7, 0x0F, 0xC3,
  0x8E, 0x3B, 0x0E, 0x38, 0xCC, 0x30, 0xE3, 0x39, 0xC3, 0x9C, 0xE7, 0x0E,
  0x73, 0x9C, 0x19, 0x86, 0x70, 0x76, 0x1D, 0x81, 0xF8, 0x76, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0xF8, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xC1, 0xE0,
  0x78, 0x0F, 0x0F, 0x80, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3D, 0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0x7C,
  0x3C, 0x03, 0xC7, 0x80, 0x1E, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x07,
  0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x1C, 0x0E, 0x00,
  0x78, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x40, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3D, 0x00, 0x78,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x03, 0xF8,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x77,
  0xFE, 0x01, 0xDF, 0xFE, 0x07, 0xF0, 0x7C, 0x3B, 0x80, 0xFF, 0xEE, 0x01,
  0xFF, 0x00, 0x01, 0xF8,
};

const GFXglyph RobotoMono_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 5, 28, 24, 9, -28 },
  { 19, 10, 9, 24, 7, -30 },
  { 31, 22, 28, 24, 1, -28 },
  { 108, 18, 37, 24, 3, -33 },
  { 192, 22, 29, 24, 1, -29 },
  { 272, 21, 29, 24, 2, -29 },
  { 349, 3, 9, 24, 10, -30 },
  { 353, 10, 41, 24, 7, -32 },
  { 405, 11, 41, 24, 6, -32 },
  { 462, 19, 19, 24, 3, -28 },
  { 508, 20, 21, 24, 2, -24 },
  { 561, 6, 11, 24, 7, -4 },
  { 570, 15, 3, 24, 4, -14 },
  { 576, 5, 5, 24, 10, -5 },
  { 580, 15, 30, 24, 5, -28 },
  { 637, 18, 29, 24, 3, -29 },
  { 703, 11, 28, 24, 4, -28 },
  { 742, 19, 29, 24, 2, -29 },
  { 811, 18, 29, 24, 2, -29 },
  { 877, 21, 28, 24, 1, -28 },
  { 951, 18, 28, 24, 4, -28 },
  { 1014, 18, 28, 24, 3, -28 },
  { 1077, 19, 28, 24, 2, -28 },
  { 1144, 19, 29, 24, 3, -29 },
  { 1213, 18, 29, 24, 3, -29 },
  { 1279, 5, 22, 24, 11, -22 },
  { 1293, 7, 29, 24, 9, -22 },
  { 1319, 17, 17, 24, 3, -21 },
  { 1356, 18, 11, 24, 3, -18 },
  { 1381, 18, 17, 24, 3, -21 },
  { 1420, 17, 29, 24, 4, -29 },
  { 1482, 22, 28, 24, 1, -28 },
  { 1559, 21, 28, 24, 2, -28 },
  { 1633, 19, 28, 24, 3, -28 },
  { 1700, 20, 29, 24, 2, -29 },
  { 1773, 19, 28, 24, 3, -28 },
  { 1840, 17, 28, 24, 4, -28 },
  { 1900, 17, 28, 24, 4, -28 },
  { 1960, 20, 29, 24, 2, -29 },
  { 2033, 18, 28, 24, 3, -28 },
  { 2096, 18, 28, 24, 3, -28 },
  { 2159, 18, 28, 24, 2, -28 },
  { 2222, 20, 28, 24, 3, -28 },
  { 2292, 17, 28, 24, 4, -28 },
  { 2352, 18, 28, 24, 3, -28 },
  { 2415, 18, 28, 24, 3, -28 },
  { 2478, 20, 29, 24, 2, -29 },
  { 2551, 18, 28, 24, 4, -28 },
  { 2614, 21, 34, 24, 2, -29 },
  { 2704, 18, 28, 24, 4, -28 },
  { 2767, 20, 29, 24, 2, -29 },
  { 2840, 22, 28, 24, 1, -28 },
  { 2917, 18, 28, 24, 3, -28 },
  { 2980, 21, 28, 24, 1, -28 },
  { 3054, 22, 28, 24, 1, -28 },
  { 3131, 21, 28, 24, 2, -28 },
  { 3205, 21, 28, 24, 1, -28 },
  { 3279, 19, 28, 24, 2, -28 },
  { 3346, 8, 39, 24, 8, -33 },
  { 3385, 15, 30, 24, 5, -28 },
  { 3442, 8, 39, 24, 8, -33 },
  { 3481, 14, 15, 24, 5, -28 },
  { 3508, 18, 3, 24, 3, 0 },
  { 3515, 8, 5, 24, 8, -29 },
  { 3520, 18, 22, 24, 3, -22 },
  { 3570, 18, 30, 24, 3, -30 },
  { 3638, 18, 22, 24, 3, -22 },
  { 3688, 18, 30, 24, 3, -30 },
  { 3756, 18, 22, 24, 3, -22 },
  { 3806, 19, 31, 24, 3, -31 },
  { 3880, 18, 30, 24, 3, -22 },
  { 3948, 18, 30, 24, 3, -30 },
  { 4016, 18, 29, 24, 4, -29 },
  { 4082, 13, 38, 24, 4, -29 },
  { 4144, 19, 30, 24, 3, -30 },
  { 4216, 18, 30, 24, 4, -30 },
  { 4284, 20, 22, 24, 2, -22 },
  { 4339, 18, 22, 24, 3, -22 },
  { 4389, 20, 22, 24, 2, -22 },
  { 4444, 18, 30, 24, 3, -22 },
  { 4512, 18, 30, 24, 3, -22 },
  { 4580, 15, 22, 24, 6, -22 },
  { 4622, 18, 22, 24, 3, -22 },
  { 4672, 18, 26, 24, 3, -26 },
  { 4731, 17, 21, 24, 4, -21 },
  { 4776, 20, 21, 24, 2, -21 },
  { 4829, 22, 21, 24, 1, -21 },
  { 4887, 20, 21, 24, 2, -21 },
  { 4940, 22, 30, 24, 1, -21 },
  { 5023, 18, 21, 24, 3, -21 },
  { 5071, 14, 38, 24, 6, -31 },
  { 5138, 2, 36, 24, 11, -28 },
  { 5147, 14, 38, 24, 6, -31 },
  { 5214, 22, 8, 24, 1, -16 },
};

const GFXfont RobotoMono_Regular40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular40pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_REGULAR40PT7B_H_
