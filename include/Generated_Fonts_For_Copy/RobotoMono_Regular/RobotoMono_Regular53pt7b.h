#ifndef _ROBOTOMONO_REGULAR53PT7B_H_
#define _ROBOTOMONO_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0xBF, 0xFB, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x38, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x70, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x18, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0xF0, 0x0F, 0x03, 0xC3,
  0xC0, 0x3C, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x78, 0x01, 0xFF, 0xE3, 0xC0,
  0x03, 0xFF, 0x0E, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x07,
  0x8F, 0xF8, 0x00, 0x3C, 0x7F, 0xF0, 0x00, 0xE1, 0xE3, 0xE0, 0x07, 0x8F,
  0x07, 0x80, 0x1C, 0x38, 0x0E, 0x00, 0xF0, 0xE0, 0x3C, 0x03, 0x83, 0x80,
  0xF0, 0x1E, 0x0E, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x00, 0xC0, 0xE0, 0x38,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFB, 0xE0, 0x1E, 0x3F, 0x3F, 0x03, 0xE7, 0xE1, 0xF8, 0x3E, 0x7C,
  0x0F, 0xC3, 0xEF, 0x80, 0x7C, 0x3C, 0xF8, 0x07, 0xE7, 0xCF, 0x80, 0x3F,
  0x7C, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x0F, 0xF8, 0xF8, 0x00, 0xFF, 0x0F,
  0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xCF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC7, 0xE0, 0x3F, 0xF0, 0x3F,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xE0, 0x00,
  0x08, 0x00, 0x60, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x80,
  0x40, 0x01, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xC0, 0x04, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x80,
  0x38, 0x02, 0x70, 0x1C, 0x07, 0x3F, 0x0E, 0x0F, 0x9F, 0xE7, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x01, 0x00, 0x10, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0xF8, 0x70, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0x9F, 0xF8, 0x3F,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF9, 0xF8, 0x1F, 0xFB, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xE7,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xFC, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F,
  0xF7, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x78, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x3D, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7E, 0x01, 0xFC, 0x1C, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x3E, 0x3F, 0xF0, 0x7D, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xF3,
  0xFC, 0x03, 0xF7, 0xF0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7E, 0x03, 0xF0, 0x7F, 0xBF,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x01, 0xF8,
  0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0xEF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x3F, 0x01, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xDE, 0x0F, 0xFF, 0x9E, 0x03, 0xFE, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x1C, 0x3F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF0, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x1C, 0x07, 0xC1, 0xE3, 0xC0, 0xFF,
  0x0E, 0x38, 0x1F, 0xF8, 0xE7, 0x83, 0xE7, 0x07, 0x70, 0x78, 0x70, 0x77,
  0x07, 0x07, 0x07, 0x70, 0xF0, 0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE0, 0xE0,
  0x70, 0x7E, 0x1E, 0x07, 0x07, 0xE1, 0xC0, 0x70, 0x7E, 0x1C, 0x07, 0x07,
  0xE1, 0xC0, 0x70, 0x7E, 0x1C, 0x07, 0x07, 0xE1, 0xC0, 0x60, 0x6E, 0x1C,
  0x0E, 0x0E, 0xE1, 0xE0, 0xE0, 0xEE, 0x1E, 0x1F, 0x1C, 0xE0, 0xFF, 0xF3,
  0xCF, 0x0F, 0xF7, 0xF8, 0x70, 0x7E, 0x3F, 0x07, 0x03, 0x80, 0xE0, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x01,
  0x00, 0x0F, 0xE0, 0x70, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x03,
  0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0xC7, 0xC0, 0x07, 0xF3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3,
  0xE0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xC0, 0x03,
  0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x7C,
  0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xC0, 0x0F, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0x81,
  0xFF, 0x07, 0xC0, 0x1F, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0,
  0x01, 0xF8, 0xF8, 0x01, 0xFC, 0x7C, 0x03, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x07,
  0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x01, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x7F,
  0x00, 0x03, 0xEF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0x7E, 0x00, 0x3F, 0xC7, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF,
  0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF1, 0xE7, 0x8F,
  0xF1, 0xE7, 0x8F, 0xF1, 0xEF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x38, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFB, 0xE0, 0x1F, 0xF9, 0xE0, 0x1F,
  0xF9, 0xF0, 0x1F, 0xF8, 0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0x7C, 0x1F,
  0xF8, 0x7C, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1F, 0x1F,
  0xF8, 0x1F, 0x1F, 0xF8, 0x0F, 0x9F, 0xF8, 0x0F, 0x9F, 0xF8, 0x07, 0xDF,
  0xF8, 0x07, 0xDF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xC0,
  0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x04, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xFC, 0xF0, 0x07,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F,
  0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xC0, 0x7C, 0x07, 0xBE,
  0x03, 0xE0, 0x3D, 0xF0, 0x1F, 0x01, 0xEF, 0x81, 0xF8, 0x0F, 0x7C, 0x0F,
  0xC0, 0x79, 0xE0, 0x7E, 0x07, 0xCF, 0x03, 0xF8, 0x3E, 0x78, 0x1F, 0xC1,
  0xF3, 0xC0, 0xFE, 0x0F, 0x1F, 0x0F, 0xF0, 0x78, 0xF8, 0x7B, 0x83, 0xC7,
  0xC3, 0xDC, 0x1E, 0x3E, 0x1E, 0xF0, 0xF0, 0xF0, 0xE7, 0x87, 0x87, 0x8F,
  0x3C, 0x7C, 0x3C, 0x79, 0xE3, 0xE1, 0xE3, 0xC7, 0x1F, 0x0F, 0x1E, 0x3C,
  0xF0, 0x78, 0xF1, 0xE7, 0x83, 0xE7, 0x0F, 0x3C, 0x1F, 0x78, 0x79, 0xE0,
  0x7B, 0xC3, 0xCF, 0x03, 0xDE, 0x0E, 0x78, 0x1E, 0xF0, 0x7B, 0xC0, 0xF7,
  0x83, 0xFE, 0x07, 0xB8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0xF9, 0xE0, 0x0F, 0x1F,
  0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0x78, 0x3E, 0x07, 0x83, 0xC0,
  0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x10, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3E,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF8, 0x3E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x7E, 0x03, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0x3F, 0x07, 0xFE, 0x1F, 0x00,
  0x60, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xC0,
  0x0F, 0x1F, 0xF8, 0x1E, 0x7F, 0xF8, 0x3D, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFE, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xF0, 0x0F, 0xCF, 0xFF, 0xFF,
  0x1E, 0xFF, 0xFE, 0x3C, 0xFF, 0xF0, 0x78, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xF7, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x01, 0x01, 0xF0, 0x3F, 0xF3, 0xE0, 0xFF, 0xF7, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xF9, 0xF8,
  0x07, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xC1, 0xFF, 0xE7, 0x81, 0xFF,
  0x8F, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xFC, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x18, 0x7E, 0x00, 0x1E, 0x1F, 0xC0, 0x1F, 0x87, 0xFC,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x38, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFE, 0x3C, 0x1F, 0xFE, 0x78, 0xFF, 0xFE, 0xF1, 0xFF,
  0xFF, 0xE7, 0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF0, 0x3F, 0xF3, 0xE0, 0x06,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x10, 0x00, 0x3E, 0x70, 0x00,
  0xF8, 0xF0, 0x03, 0xF3, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x06, 0x00, 0xF8, 0x7F, 0xE0, 0xF8, 0xFF, 0xF0,
  0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0x80, 0xFE, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFE,
  0xF0, 0x01, 0xF8, 0xF0, 0x03, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x0F, 0xC0,
  0xF0, 0x1F, 0x80, 0xF0, 0x3F, 0x00, 0xF0, 0x7E, 0x00, 0xF0, 0xFC, 0x00,
  0xF1, 0xF8, 0x00, 0xF3, 0xF0, 0x00, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0xF8, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0,
  0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x01, 0xF8,
  0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x04,
  0x1F, 0x3F, 0x8F, 0xF3, 0xEF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xFE, 0x07, 0xC0, 0x7F, 0xC0, 0x78, 0x0F,
  0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x07,
  0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F,
  0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x3C,
  0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE,
  0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0,
  0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1E, 0x00,
  0x04, 0x00, 0xF8, 0x7F, 0xE0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB,
  0xFF, 0xFC, 0xFF, 0x80, 0xFE, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xF3, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF8, 0xFF, 0xC0, 0xF9, 0xFF,
  0xE0, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x01, 0xFC, 0xFE, 0x00,
  0x7C, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7C, 0xFF, 0x00, 0xFC, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF,
  0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0xFF, 0xC0, 0xF8, 0x0C, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFE, 0x3C, 0x1F, 0xFE,
  0x78, 0xFF, 0xFE, 0xF1, 0xFE, 0x7F, 0xE7, 0xE0, 0x1F, 0xDF, 0x80, 0x1F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00,
  0x3F, 0x3F, 0x00, 0xFE, 0x3F, 0xCF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD,
  0xF0, 0x3F, 0xF3, 0xE0, 0x04, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x06, 0x1E, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xEF, 0x7F, 0xFD, 0xFF,
  0xC1, 0xBF, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x8F, 0xC0,
  0x3F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x0F, 0xDF, 0x80, 0xFF, 0x7F, 0xFF, 0xBC, 0xFF, 0xFE, 0xF1, 0xFF,
  0xF3, 0xC1, 0xFF, 0x0F, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x07, 0x80, 0x7D, 0xE0, 0x1E, 0x01, 0xF7, 0x80, 0x78,
  0x07, 0x9E, 0x01, 0xE0, 0x1E, 0x78, 0x0F, 0xC0, 0x79, 0xF0, 0x3F, 0x01,
  0xE3, 0xC0, 0xFC, 0x0F, 0x0F, 0x03, 0xF0, 0x3C, 0x3C, 0x1F, 0xE0, 0xF0,
  0xF0, 0x7F, 0x83, 0xC3, 0xC1, 0xCE, 0x0F, 0x07, 0x87, 0x38, 0x38, 0x1E,
  0x3C, 0xF1, 0xE0, 0x78, 0xF3, 0xC7, 0x81, 0xE3, 0x87, 0x1E, 0x03, 0x8E,
  0x1C, 0x78, 0x0F, 0x78, 0x79, 0xC0, 0x3D, 0xE1, 0xE7, 0x00, 0xF7, 0x03,
  0xBC, 0x03, 0xDC, 0x0E, 0xF0, 0x07, 0x70, 0x3B, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x87,
  0xE0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x81, 0xFF, 0xE0, 0x03, 0xCF, 0xFF, 0xC0, 0x0E,
  0x7F, 0xFF, 0x80, 0x79, 0xE0, 0x7F, 0x83, 0xEF, 0x00, 0x7F, 0xFF, 0x3C,
  0x00, 0xFF, 0xFC, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00,
};

const GFXglyph RobotoMono_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 6, 38, 32, 13, -38 },
  { 30, 13, 13, 32, 9, -40 },
  { 52, 28, 38, 32, 2, -38 },
  { 185, 24, 49, 32, 4, -44 },
  { 332, 30, 39, 32, 1, -38 },
  { 479, 28, 39, 32, 3, -38 },
  { 616, 4, 13, 32, 13, -40 },
  { 623, 14, 55, 32, 9, -43 },
  { 720, 14, 55, 32, 8, -43 },
  { 817, 25, 26, 32, 4, -38 },
  { 899, 26, 27, 32, 3, -31 },
  { 987, 8, 15, 32, 9, -6 },
  { 1002, 19, 3, 32, 6, -18 },
  { 1010, 7, 7, 32, 13, -7 },
  { 1017, 20, 41, 32, 7, -38 },
  { 1120, 24, 39, 32, 4, -38 },
  { 1237, 15, 38, 32, 5, -38 },
  { 1309, 26, 38, 32, 2, -38 },
  { 1433, 24, 39, 32, 2, -38 },
  { 1550, 27, 38, 32, 2, -38 },
  { 1679, 24, 39, 32, 5, -38 },
  { 1796, 23, 39, 32, 4, -38 },
  { 1909, 25, 38, 32, 3, -38 },
  { 2028, 24, 39, 32, 5, -38 },
  { 2145, 24, 38, 32, 4, -38 },
  { 2259, 8, 30, 32, 14, -30 },
  { 2289, 8, 39, 32, 13, -30 },
  { 2328, 22, 23, 32, 4, -28 },
  { 2392, 24, 15, 32, 4, -24 },
  { 2437, 22, 23, 32, 5, -28 },
  { 2501, 22, 38, 32, 5, -38 },
  { 2606, 28, 38, 32, 2, -38 },
  { 2739, 28, 38, 32, 2, -38 },
  { 2872, 25, 38, 32, 4, -38 },
  { 2991, 26, 39, 32, 3, -38 },
  { 3118, 25, 38, 32, 4, -38 },
  { 3237, 23, 38, 32, 5, -38 },
  { 3347, 23, 38, 32, 5, -38 },
  { 3457, 26, 39, 32, 3, -38 },
  { 3584, 24, 38, 32, 4, -38 },
  { 3698, 23, 38, 32, 4, -38 },
  { 3808, 24, 39, 32, 3, -38 },
  { 3925, 27, 38, 32, 4, -38 },
  { 4054, 23, 38, 32, 5, -38 },
  { 4164, 24, 38, 32, 4, -38 },
  { 4278, 24, 38, 32, 4, -38 },
  { 4392, 26, 39, 32, 3, -38 },
  { 4519, 25, 38, 32, 5, -38 },
  { 4638, 28, 44, 32, 2, -38 },
  { 4792, 24, 38, 32, 5, -38 },
  { 4906, 26, 39, 32, 3, -38 },
  { 5033, 28, 38, 32, 2, -38 },
  { 5166, 24, 39, 32, 4, -38 },
  { 5283, 28, 38, 32, 2, -38 },
  { 5416, 29, 38, 32, 2, -38 },
  { 5554, 28, 38, 32, 2, -38 },
  { 5687, 28, 38, 32, 2, -38 },
  { 5820, 25, 38, 32, 3, -38 },
  { 5939, 10, 51, 32, 11, -43 },
  { 6003, 20, 41, 32, 6, -38 },
  { 6106, 11, 51, 32, 10, -43 },
  { 6177, 20, 20, 32, 6, -38 },
  { 6227, 24, 4, 32, 4, 0 },
  { 6239, 10, 7, 32, 11, -38 },
  { 6248, 24, 30, 32, 4, -29 },
  { 6338, 23, 41, 32, 5, -40 },
  { 6456, 24, 30, 32, 4, -29 },
  { 6546, 23, 41, 32, 4, -40 },
  { 6664, 25, 30, 32, 3, -29 },
  { 6758, 25, 41, 32, 4, -41 },
  { 6887, 23, 40, 32, 4, -29 },
  { 7002, 24, 40, 32, 4, -40 },
  { 7122, 24, 38, 32, 5, -38 },
  { 7236, 17, 49, 32, 5, -38 },
  { 7341, 24, 40, 32, 5, -40 },
  { 7461, 24, 40, 32, 5, -40 },
  { 7581, 27, 29, 32, 2, -29 },
  { 7679, 24, 29, 32, 4, -29 },
  { 7766, 26, 30, 32, 3, -29 },
  { 7864, 24, 40, 32, 4, -29 },
  { 7984, 23, 40, 32, 4, -29 },
  { 8099, 19, 29, 32, 9, -29 },
  { 8168, 23, 30, 32, 5, -29 },
  { 8255, 24, 36, 32, 4, -35 },
  { 8363, 22, 29, 32, 5, -28 },
  { 8443, 26, 28, 32, 3, -28 },
  { 8534, 30, 28, 32, 1, -28 },
  { 8639, 26, 28, 32, 3, -28 },
  { 8730, 28, 39, 32, 2, -28 },
  { 8867, 24, 28, 32, 4, -28 },
  { 8951, 18, 50, 32, 8, -41 },
  { 9064, 4, 48, 32, 14, -38 },
  { 9088, 18, 50, 32, 8, -41 },
  { 9201, 30, 11, 32, 1, -21 },
};

const GFXfont RobotoMono_Regular53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular53pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_REGULAR53PT7B_H_
