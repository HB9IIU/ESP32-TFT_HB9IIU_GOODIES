#ifndef _ROBOTOMONO_REGULAR21PT7B_H_
#define _ROBOTOMONO_REGULAR21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF0, 0x3C, 0x9C, 0xE7, 0x39, 0x80, 0x0C, 0xC1, 0x18,
  0x22, 0x0C, 0x4F, 0xFF, 0xFF, 0xC4, 0x60, 0x88, 0x11, 0x1F, 0xFB, 0xFF,
  0x11, 0x82, 0x20, 0x44, 0x19, 0x80, 0x08, 0x04, 0x0F, 0x8F, 0xEE, 0x1E,
  0x0F, 0x06, 0xC0, 0x78, 0x1F, 0x01, 0xC0, 0x30, 0x1E, 0x0F, 0x06, 0xEF,
  0x3E, 0x04, 0x02, 0x00, 0x78, 0x04, 0xC0, 0xC4, 0xCC, 0x48, 0x4D, 0x87,
  0x90, 0x03, 0x00, 0x20, 0x06, 0x00, 0x5E, 0x09, 0x31, 0x91, 0x11, 0x10,
  0x13, 0x01, 0xE0, 0x1E, 0x06, 0x61, 0x8C, 0x31, 0x83, 0x30, 0x6C, 0x07,
  0x01, 0xE0, 0x7C, 0x7C, 0xCF, 0x0D, 0x61, 0xEC, 0x18, 0xC7, 0x8F, 0x98,
  0xFF, 0xC0, 0x08, 0xCC, 0x46, 0x23, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0x43, 0x08, 0x61, 0x84, 0x83, 0x06, 0x0C, 0x10, 0x61, 0x86, 0x0C, 0x30,
  0xC3, 0x0C, 0x31, 0x86, 0x18, 0x43, 0x18, 0xC2, 0x00, 0x0C, 0x04, 0x02,
  0x19, 0x1F, 0xF8, 0xE0, 0x50, 0x6C, 0x63, 0x11, 0x80, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x6F,
  0x6C, 0xFF, 0x5F, 0x80, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x1F, 0x0C, 0xE6, 0x0D,
  0x83, 0x40, 0xF0, 0x7C, 0x3F, 0x3B, 0xD8, 0xFC, 0x36, 0x0D, 0x83, 0x60,
  0xCC, 0xE1, 0xF0, 0x04, 0xFF, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC0, 0x3E, 0x1D, 0xCC, 0x1B, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x3E, 0x3B,
  0xB0, 0x78, 0x30, 0x18, 0x0C, 0x1C, 0x3C, 0x03, 0x80, 0xC0, 0x38, 0x3C,
  0x1B, 0x9C, 0xF8, 0x03, 0x00, 0x60, 0x1C, 0x06, 0x80, 0x90, 0x32, 0x0C,
  0x41, 0x08, 0x61, 0x18, 0x23, 0xFF, 0xFF, 0xF0, 0x10, 0x02, 0x00, 0x40,
  0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x02, 0xE1, 0xFD, 0x87, 0x01, 0x80, 0xC0,
  0x78, 0x3C, 0x1B, 0x98, 0xF8, 0x07, 0x07, 0xC3, 0x81, 0x80, 0x60, 0x1B,
  0x85, 0xFB, 0x86, 0xE0, 0xF0, 0x34, 0x0D, 0x83, 0x61, 0x8C, 0xE1, 0xF0,
  0xFF, 0xFF, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x3E, 0x3B, 0xB0, 0x78, 0x3C,
  0x1E, 0x0D, 0xDC, 0x7C, 0x63, 0x60, 0xF0, 0x78, 0x3C, 0x1B, 0x18, 0xF8,
  0x3E, 0x3B, 0xB0, 0xD8, 0x38, 0x1C, 0x0F, 0x07, 0x87, 0x7F, 0x9E, 0xC0,
  0x40, 0x60, 0x71, 0xF0, 0xE0, 0xDF, 0x00, 0x00, 0x1B, 0xE0, 0x67, 0x60,
  0x00, 0x00, 0x00, 0x66, 0x66, 0xC0, 0x01, 0x0F, 0x3C, 0xF0, 0xC0, 0x78,
  0x1E, 0x07, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x18, 0x79, 0xF1, 0xC0, 0x80, 0x00, 0x3E, 0x3F, 0xB0,
  0x78, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x0F, 0x07, 0x31, 0x81, 0x23, 0x2C, 0xD3, 0x22, 0x64, 0x4C,
  0x99, 0x93, 0x32, 0x4A, 0x7D, 0x64, 0xC4, 0x00, 0xE2, 0x07, 0xC0, 0x04,
  0x01, 0xC0, 0x38, 0x05, 0x01, 0xB0, 0x36, 0x04, 0xC1, 0x8C, 0x31, 0x87,
  0xF1, 0xFF, 0x30, 0x66, 0x0D, 0x80, 0xF0, 0x18, 0xFE, 0x7F, 0xB0, 0x78,
  0x3C, 0x1E, 0x0F, 0xFD, 0xFE, 0xC3, 0xE0, 0xF0, 0x38, 0x3C, 0x1F, 0xFB,
  0xF8, 0x1F, 0x0E, 0xE6, 0x0D, 0x83, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x03, 0x60, 0xCC, 0x61, 0xF0, 0xFC, 0x3F, 0x8C, 0x33,
  0x06, 0xC1, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC3,
  0x3F, 0x8F, 0xC0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x1F, 0x0E, 0xE6, 0x0D, 0x83, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3,
  0xF0, 0x1C, 0x05, 0x81, 0x60, 0x4E, 0x71, 0xF8, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0C, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFF, 0xFE, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x03, 0xE1,
  0x9C, 0xE3, 0xE0, 0xC1, 0xF0, 0xEC, 0x33, 0x18, 0xCC, 0x36, 0x0F, 0x83,
  0xE0, 0xEC, 0x33, 0x8C, 0x63, 0x0C, 0xC3, 0xB0, 0x6C, 0x0C, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0xFF, 0xFE, 0xC1, 0xE1, 0xF8, 0xFC, 0x5A, 0x6D, 0xB6, 0xD3, 0x3B,
  0x9D, 0xCC, 0xE2, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xD8, 0xF6, 0x3C, 0xCF, 0x33, 0xC6, 0xF1, 0xBC, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x0C, 0x1F, 0x07, 0xF1, 0x87, 0x30, 0x6C, 0x0D, 0x80, 0xB0,
  0x16, 0x03, 0xC0, 0x58, 0x0B, 0x03, 0x30, 0x66, 0x1C, 0x77, 0x07, 0xC0,
  0xFE, 0x3F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0xFE, 0xFE, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x07, 0xF1, 0x83, 0x20,
  0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0x20, 0x66,
  0x0C, 0x77, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x08, 0xFE, 0x3F, 0xCC, 0x1B,
  0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0xFC, 0xFE, 0x31, 0x8C, 0x63, 0x0C, 0xC3,
  0x30, 0x6C, 0x1C, 0x1F, 0x07, 0x71, 0x83, 0x30, 0x66, 0x02, 0xC0, 0x0F,
  0x00, 0xF8, 0x03, 0x80, 0x18, 0x03, 0xE0, 0x36, 0x0C, 0xF7, 0x87, 0xE0,
  0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x83,
  0x60, 0xCE, 0xE1, 0xF0, 0xC0, 0x78, 0x19, 0x03, 0x30, 0x66, 0x18, 0xC3,
  0x0C, 0x61, 0x88, 0x33, 0x03, 0x60, 0x6C, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xC4, 0x79, 0xCF, 0x39, 0xE7, 0x3C, 0xA7, 0x94, 0x96, 0x92, 0xDA,
  0x5B, 0xCE, 0x79, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x0C, 0x60, 0xC0, 0xEC,
  0x19, 0xC6, 0x18, 0xC1, 0xB0, 0x36, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x60,
  0x6C, 0x18, 0xC7, 0x18, 0xC1, 0xB0, 0x38, 0xC0, 0xF8, 0x19, 0x87, 0x30,
  0xC3, 0x18, 0x66, 0x06, 0xC0, 0xF0, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xC0, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x02, 0x03,
  0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x18,
  0x1C, 0x1C, 0x34, 0x36, 0x66, 0x63, 0xC3, 0xFF, 0xFF, 0xC0, 0xE3, 0x10,
  0x7E, 0x71, 0xB0, 0x60, 0x31, 0xFB, 0xFF, 0x07, 0x83, 0xC3, 0xF7, 0xDF,
  0x60, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xF3, 0x9D, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xDD, 0xFC, 0x1F, 0x0C, 0x66, 0x0D, 0x83,
  0x40, 0x30, 0x04, 0x01, 0x83, 0x60, 0xCC, 0x61, 0xF0, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xCF, 0xB7, 0x3D, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x03,
  0x60, 0xD8, 0x33, 0xBC, 0x7B, 0x1F, 0x0C, 0x66, 0x0D, 0x83, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x60, 0x8E, 0x71, 0xF8, 0x0F, 0xC7, 0x21, 0x80, 0x60,
  0x18, 0x3F, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x3E, 0xDC, 0xF6, 0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x0D,
  0x83, 0x60, 0xCE, 0xF1, 0xEC, 0x03, 0x40, 0xD8, 0xE3, 0xF0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0xFB, 0x8D, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0x0C, 0x06, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x0E, 0x0C, 0x00,
  0x07, 0xEF, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x1B, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xEC, 0x63, 0x30,
  0xD8, 0x3C, 0x0F, 0x83, 0x30, 0xCE, 0x31, 0xCC, 0x33, 0x07, 0xFC, 0x7E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x63, 0xFF, 0xFF, 0xFF, 0xD9, 0xDF, 0x31, 0xE6, 0x3C, 0xC7, 0x98,
  0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0x80, 0xDF, 0x71, 0xB0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x1F, 0x1C, 0xE6,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x60, 0xCC, 0xE1, 0xF0, 0xFE,
  0x73, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xF3, 0xBF, 0x98,
  0x0C, 0x06, 0x03, 0x00, 0x3E, 0xDC, 0x76, 0x0D, 0x83, 0xC0, 0xF0, 0x3C,
  0x0D, 0x83, 0x60, 0xCC, 0xF1, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xDF,
  0xFF, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x31,
  0xB0, 0x78, 0x07, 0x01, 0xF0, 0x0E, 0x03, 0xC1, 0xF1, 0xCF, 0x80, 0x18,
  0x06, 0x01, 0x83, 0xFF, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x0E, 0xC1, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xF3, 0xDF, 0x60, 0xC0, 0xEC, 0x19, 0x82, 0x30, 0xC3,
  0x18, 0x62, 0x04, 0xC0, 0xD0, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0xC2, 0x34,
  0x63, 0x67, 0x36, 0x52, 0x65, 0x22, 0xD2, 0x29, 0xE3, 0x9E, 0x38, 0xC1,
  0x8C, 0x10, 0xC0, 0xE0, 0xEE, 0x30, 0xCE, 0x0D, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0xD8, 0x31, 0x8C, 0x3B, 0x83, 0x80, 0xC0, 0xF8, 0x19, 0x83, 0x30,
  0xC3, 0x18, 0x62, 0x06, 0xC0, 0xD8, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x3C, 0x00, 0xFF, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x7F, 0xFF, 0xE0, 0x06, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x31, 0xC1, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x38, 0x10, 0xFF,
  0xFF, 0xE0, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x18, 0x1C, 0x30,
  0xC1, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x86, 0x00, 0x3C, 0x16, 0xE3, 0x43,
  0xE8, 0x1C,
};

const GFXglyph RobotoMono_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 2, 15, 13, 5, -15 },
  { 5, 5, 5, 13, 4, -16 },
  { 9, 11, 15, 13, 1, -15 },
  { 30, 9, 19, 13, 2, -17 },
  { 52, 12, 15, 13, 0, -15 },
  { 75, 11, 15, 13, 1, -15 },
  { 96, 2, 5, 13, 5, -16 },
  { 98, 5, 22, 13, 4, -17 },
  { 112, 6, 22, 13, 3, -17 },
  { 129, 9, 10, 13, 2, -15 },
  { 141, 10, 11, 13, 1, -12 },
  { 155, 3, 5, 13, 4, -2 },
  { 157, 8, 1, 13, 2, -7 },
  { 158, 3, 3, 13, 5, -3 },
  { 160, 8, 16, 13, 3, -15 },
  { 176, 10, 15, 13, 1, -15 },
  { 195, 6, 15, 13, 2, -15 },
  { 207, 10, 15, 13, 1, -15 },
  { 226, 9, 15, 13, 1, -15 },
  { 243, 11, 15, 13, 1, -15 },
  { 264, 9, 15, 13, 2, -15 },
  { 281, 10, 15, 13, 1, -15 },
  { 300, 10, 15, 13, 1, -15 },
  { 319, 9, 15, 13, 2, -15 },
  { 336, 9, 15, 13, 2, -15 },
  { 353, 3, 12, 13, 6, -12 },
  { 358, 4, 15, 13, 5, -12 },
  { 366, 8, 9, 13, 2, -11 },
  { 375, 9, 6, 13, 2, -10 },
  { 382, 9, 9, 13, 2, -11 },
  { 393, 9, 15, 13, 2, -15 },
  { 410, 11, 15, 13, 1, -15 },
  { 431, 11, 15, 13, 1, -15 },
  { 452, 9, 15, 13, 2, -15 },
  { 469, 10, 15, 13, 1, -15 },
  { 488, 10, 15, 13, 2, -15 },
  { 507, 9, 15, 13, 2, -15 },
  { 524, 9, 15, 13, 2, -15 },
  { 541, 10, 15, 13, 1, -15 },
  { 560, 10, 15, 13, 1, -15 },
  { 579, 9, 15, 13, 2, -15 },
  { 596, 10, 15, 13, 1, -15 },
  { 615, 10, 15, 13, 2, -15 },
  { 634, 9, 15, 13, 2, -15 },
  { 651, 9, 15, 13, 2, -15 },
  { 668, 10, 15, 13, 1, -15 },
  { 687, 11, 15, 13, 1, -15 },
  { 708, 10, 15, 13, 2, -15 },
  { 727, 11, 18, 13, 1, -15 },
  { 752, 10, 15, 13, 2, -15 },
  { 771, 11, 15, 13, 1, -15 },
  { 792, 11, 15, 13, 1, -15 },
  { 813, 10, 15, 13, 1, -15 },
  { 832, 11, 15, 13, 1, -15 },
  { 853, 11, 15, 13, 1, -15 },
  { 874, 11, 15, 13, 1, -15 },
  { 895, 11, 15, 13, 1, -15 },
  { 916, 10, 15, 13, 1, -15 },
  { 935, 4, 20, 13, 4, -17 },
  { 945, 8, 16, 13, 2, -15 },
  { 961, 4, 20, 13, 4, -17 },
  { 971, 8, 8, 13, 2, -15 },
  { 979, 9, 2, 13, 2, 0 },
  { 982, 4, 3, 13, 4, -15 },
  { 984, 9, 11, 13, 2, -11 },
  { 997, 9, 16, 13, 2, -16 },
  { 1015, 10, 11, 13, 1, -11 },
  { 1029, 10, 16, 13, 1, -16 },
  { 1049, 10, 11, 13, 1, -11 },
  { 1063, 10, 16, 13, 2, -16 },
  { 1083, 10, 15, 13, 1, -11 },
  { 1102, 9, 16, 13, 2, -16 },
  { 1120, 9, 15, 13, 2, -15 },
  { 1137, 7, 19, 13, 2, -15 },
  { 1154, 10, 16, 13, 2, -16 },
  { 1174, 9, 16, 13, 2, -16 },
  { 1192, 11, 11, 13, 1, -11 },
  { 1208, 9, 11, 13, 2, -11 },
  { 1221, 10, 11, 13, 1, -11 },
  { 1235, 9, 15, 13, 2, -11 },
  { 1252, 10, 15, 13, 1, -11 },
  { 1271, 8, 11, 13, 3, -11 },
  { 1282, 9, 11, 13, 2, -11 },
  { 1295, 10, 14, 13, 1, -14 },
  { 1313, 9, 11, 13, 2, -11 },
  { 1326, 11, 11, 13, 1, -11 },
  { 1342, 12, 11, 13, 0, -11 },
  { 1359, 11, 11, 13, 1, -11 },
  { 1375, 11, 15, 13, 1, -11 },
  { 1396, 9, 11, 13, 2, -11 },
  { 1409, 7, 20, 13, 3, -16 },
  { 1427, 1, 19, 13, 6, -15 },
  { 1430, 7, 20, 13, 3, -16 },
  { 1448, 12, 4, 13, 0, -8 },
};

const GFXfont RobotoMono_Regular21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular21pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_REGULAR21PT7B_H_
