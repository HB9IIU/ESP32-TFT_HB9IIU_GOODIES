#ifndef _ROBOTOMONO_REGULAR6PT7B_H_
#define _ROBOTOMONO_REGULAR6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xE0, 0x7F, 0xD0, 0x55, 0x56, 0x80, 0xF5, 0x90, 0xE4, 0xAF,
  0xC0, 0x6A, 0xB0, 0xFC, 0xCD, 0x80, 0x5D, 0x20, 0xC0, 0xC0, 0x80, 0x5A,
  0xF7, 0xB0, 0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xF7, 0x7E, 0xB0,
  0xE5, 0x20, 0xFF, 0xF5, 0xB0, 0x90, 0x98, 0x7C, 0xFC, 0xB0, 0xDA, 0xFE,
  0xF0, 0x4D, 0xD0, 0xFE, 0xF0, 0xF2, 0x30, 0xF6, 0xF0, 0xFB, 0xFA, 0xF2,
  0xB0, 0xBE, 0xD0, 0xEB, 0x24, 0xF0, 0xBA, 0xD0, 0xAB, 0xBF, 0xD0, 0xBE,
  0xD0, 0xF6, 0xB0, 0xFA, 0xF6, 0xB2, 0xFF, 0xE8, 0xF0, 0xE9, 0x20, 0xB6,
  0xB0, 0xAD, 0xA0, 0xFD, 0xB0, 0xE9, 0xD0, 0xA9, 0x20, 0xE9, 0x70, 0xFC,
  0xA9, 0xFC, 0xB0, 0xE0, 0x80, 0xEF, 0x80, 0xAF, 0xC0, 0xF1, 0x80, 0x27,
  0xD6, 0xFD, 0x80, 0x2B, 0xA4, 0xF5, 0xF0, 0xAF, 0xC0, 0x2B, 0x75, 0xC0,
  0xAE, 0xC0, 0xAA, 0xC0, 0xFF, 0x80, 0xFC, 0xF5, 0x80, 0xF7, 0xC0, 0xF5,
  0x90, 0xE8, 0xFC, 0x5D, 0x30, 0xFC, 0xAD, 0x00, 0xFD, 0x80, 0xEB, 0x80,
  0xAD, 0x60, 0xEB, 0x80, 0x5A, 0x50, 0xF8, 0xA9, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -4 },
  { 18, 3, 4, 4, 0, -4 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 2, 4, 4, 1, -4 },
  { 24, 3, 4, 4, 0, -4 },
  { 26, 1, 4, 4, 1, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 2, 4, 4, 1, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 2, 4, 4, 1, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 1, 4, 4, 2, -4 },
  { 42, 1, 5, 4, 1, -4 },
  { 43, 3, 2, 4, 0, -3 },
  { 44, 3, 2, 4, 0, -3 },
  { 45, 2, 2, 4, 1, -3 },
  { 46, 2, 4, 4, 1, -4 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 3, 4, 4, 0, -4 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 2, 4, 4, 1, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 2, 4, 4, 1, -4 },
  { 76, 3, 5, 4, 0, -4 },
  { 78, 2, 4, 4, 1, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 3, 4, 4, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 0, -4 },
  { 93, 3, 4, 4, 0, -4 },
  { 95, 1, 6, 4, 1, -5 },
  { 96, 2, 4, 4, 1, -4 },
  { 97, 1, 6, 4, 1, -5 },
  { 98, 2, 2, 4, 1, -4 },
  { 99, 3, 1, 4, 0, 0 },
  { 100, 1, 1, 4, 1, -4 },
  { 101, 3, 3, 4, 0, -3 },
  { 103, 2, 5, 4, 1, -5 },
  { 105, 3, 3, 4, 0, -3 },
  { 107, 3, 5, 4, 0, -5 },
  { 109, 3, 3, 4, 0, -3 },
  { 111, 3, 5, 4, 0, -5 },
  { 113, 3, 4, 4, 0, -3 },
  { 115, 2, 5, 4, 1, -5 },
  { 117, 2, 4, 4, 1, -4 },
  { 118, 2, 5, 4, 1, -4 },
  { 120, 2, 5, 4, 1, -5 },
  { 122, 2, 5, 4, 1, -5 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 2, 3, 4, 1, -3 },
  { 127, 3, 3, 4, 0, -3 },
  { 129, 3, 4, 4, 0, -3 },
  { 131, 3, 4, 4, 0, -3 },
  { 133, 2, 3, 4, 1, -3 },
  { 134, 2, 3, 4, 1, -3 },
  { 135, 3, 4, 4, 0, -4 },
  { 137, 2, 3, 4, 1, -3 },
  { 138, 3, 3, 4, 0, -3 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 4, 4, 0, -3 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 2, 6, 4, 1, -5 },
  { 150, 1, 5, 4, 1, -4 },
  { 151, 2, 6, 4, 1, -5 },
  { 153, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_Regular6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular6pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_REGULAR6PT7B_H_
