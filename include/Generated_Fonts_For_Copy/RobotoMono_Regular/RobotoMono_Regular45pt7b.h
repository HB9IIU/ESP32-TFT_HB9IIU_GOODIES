#ifndef _ROBOTOMONO_REGULAR45PT7B_H_
#define _ROBOTOMONO_REGULAR45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x78, 0x00, 0x00, 0x00, 0x4F, 0x7F, 0xFE, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0xF0, 0x70, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF0, 0x0E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x78,
  0x00, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x0F, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0x0F, 0xC3, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x1C, 0x00, 0x0E, 0x07, 0x06, 0x07, 0x03, 0x83, 0x83, 0x81, 0xC3, 0x81,
  0xC0, 0xE1, 0xC0, 0xE0, 0x71, 0xC0, 0x70, 0x70, 0xE0, 0x1C, 0x78, 0xE0,
  0x0F, 0xF8, 0x70, 0x03, 0xFC, 0x70, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x0E, 0x3F, 0xC0, 0x07, 0x3F, 0xF0, 0x07, 0x1C, 0x38, 0x03,
  0x9E, 0x1E, 0x03, 0x8E, 0x07, 0x03, 0xC7, 0x03, 0x81, 0xC3, 0x81, 0xC1,
  0xE1, 0xC0, 0xE0, 0x20, 0xE0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x03, 0xC0, 0x1F, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1F, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x0E,
  0x3E, 0x7C, 0x0E, 0x3C, 0x3E, 0x0E, 0x7C, 0x1E, 0x1E, 0x78, 0x1F, 0x1E,
  0xF8, 0x0F, 0x9E, 0xF0, 0x07, 0xFC, 0xF0, 0x03, 0xFC, 0xF8, 0x03, 0xF8,
  0x78, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x07, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0x3E, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x20, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xC0, 0x40, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x04, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x01, 0x01, 0xC0, 0xDE, 0x0E, 0x1E, 0xFE, 0x73, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0E, 0xF0, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x0F,
  0x81, 0xE0, 0x38, 0x0F, 0x80, 0xC0, 0x30, 0x00, 0x01, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDF, 0x79, 0xEF,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3B, 0xFF,
  0xFF, 0xFD, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7E, 0x0F, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xF9, 0xFE, 0x0F, 0x8F,
  0xF1, 0xF8, 0x7F, 0x9F, 0x03, 0xFD, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xF0, 0x7E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF0, 0xFC, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7C, 0x0F, 0xC7, 0xC0, 0x3E, 0x3C, 0x00, 0xFB, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xE0, 0x7E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xF7, 0xC0, 0x1E, 0x3E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xCF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7,
  0xC0, 0x7E, 0x18, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x8F, 0xC0,
  0x73, 0xFF, 0x0F, 0x7F, 0xF8, 0xFF, 0xDF, 0xCF, 0xE0, 0x3E, 0xFC, 0x01,
  0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C,
  0x01, 0xE3, 0xE0, 0x3E, 0x1F, 0x07, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x1E,
  0x3C, 0x03, 0xC1, 0xF0, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x83, 0xF0, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xF7, 0xC0, 0x1E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC,
  0x3C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x1F, 0x3C, 0x03, 0xF3, 0xF0, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xEF, 0x03, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x39, 0xFF,
  0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x7F, 0xFF, 0xFF, 0x7C, 0x38, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC7,
  0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xC7, 0x8F, 0x3C, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x07, 0xE7, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0xF8, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x38, 0x3F, 0x0E, 0x38, 0x3F, 0xC7, 0x1C, 0x3C, 0xE1,
  0x8C, 0x3C, 0x30, 0xCE, 0x1C, 0x38, 0x67, 0x0C, 0x1C, 0x33, 0x0E, 0x0E,
  0x19, 0x87, 0x07, 0x0C, 0xC3, 0x83, 0x86, 0x61, 0x81, 0x83, 0x70, 0xC0,
  0xC1, 0xB8, 0x60, 0x60, 0xCC, 0x30, 0x30, 0xE6, 0x1C, 0x38, 0x63, 0x0E,
  0x3C, 0x71, 0xC7, 0xFF, 0xF0, 0xE1, 0xFB, 0xF8, 0x70, 0x78, 0xF0, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x04, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xEF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x7F, 0x8F, 0x00, 0x7E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x7C, 0x78, 0x0F, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x80, 0x3F, 0x3C, 0x00, 0x79, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x03,
  0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x0F, 0x81, 0xE0, 0x0F, 0x87,
  0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x7D, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF8, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3E, 0x1F, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8,
  0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x7F,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x1F,
  0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x3E, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0xFD, 0xE0, 0x1F, 0xFB, 0xC0, 0x3F, 0xF7, 0x80, 0x7F, 0xEF, 0x80,
  0x01, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xFC, 0x0F,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9F, 0x00, 0x7C,
  0x78, 0x03, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xC0, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3C, 0x00, 0xF8,
  0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF0,
  0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x7C, 0x00, 0xF3, 0xE0,
  0x03, 0xCF, 0x80, 0x0F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xC0,
  0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0E, 0xFF, 0xE0, 0xF7, 0xF7, 0x07,
  0xFF, 0xB8, 0x3B, 0xFD, 0xE3, 0xDF, 0xE7, 0x1E, 0xFF, 0x38, 0xE7, 0xF9,
  0xEF, 0x3F, 0xC7, 0x79, 0xFE, 0x3B, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xE3,
  0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x38, 0x3F, 0xC1,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF7, 0x80,
  0x7F, 0xBC, 0x03, 0xFC, 0xF0, 0x1F, 0xE7, 0x80, 0xFF, 0x1E, 0x07, 0xF8,
  0xF0, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3,
  0xFC, 0x0F, 0x1F, 0xE0, 0x78, 0xFF, 0x01, 0xE7, 0xF8, 0x0F, 0x3F, 0xC0,
  0x3D, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7E, 0x3F,
  0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x7C, 0x00,
  0x7C, 0x78, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x3F, 0xCF, 0x00, 0x1F, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07,
  0xDE, 0x00, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x7F, 0x8F, 0x00,
  0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x78, 0x00,
  0xF3, 0xC0, 0x1F, 0x9E, 0x07, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00,
  0x7D, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0x78,
  0x03, 0xC3, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0E, 0xF0,
  0x7E, 0x0E, 0xF0, 0x7E, 0x1E, 0x70, 0x7E, 0x1E, 0x70, 0x7E, 0x1E, 0x70,
  0xFE, 0x1E, 0x78, 0xEE, 0x1E, 0x78, 0xEF, 0x1E, 0x78, 0xE7, 0x1C, 0x78,
  0xE7, 0x1C, 0x79, 0xE7, 0x1C, 0x79, 0xC7, 0x1C, 0x39, 0xC7, 0x3C, 0x39,
  0xC7, 0xBC, 0x39, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3F, 0xC3, 0xB8, 0x3F,
  0x83, 0xB8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x03,
  0xC7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x03,
  0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x0F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0E, 0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xC0,
  0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xC7, 0xC0, 0x3E,
  0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0x0F, 0x3F, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00,
  0x7C, 0xF0, 0x07, 0xE7, 0xE0, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFB, 0xC1,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF1, 0xFC, 0x0F, 0x7F, 0xF0, 0xFF, 0xFF, 0x8F, 0xF1,
  0xFC, 0xFC, 0x07, 0xCF, 0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E,
  0xF8, 0x03, 0xEF, 0xC0, 0x3C, 0xFE, 0x0F, 0xCF, 0xFF, 0xF8, 0xF7, 0xFF,
  0x0F, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0x0F, 0xC3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xDF, 0x00, 0x3C, 0x7C, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xF8, 0xF0, 0xFF, 0xEF,
  0x1F, 0xFF, 0xF3, 0xF8, 0xFF, 0x3E, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x3F, 0x07, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFE, 0xF0, 0x3F, 0xCF, 0x01, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x08, 0x7C, 0x00, 0xF3,
  0xF8, 0x1F, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xF8, 0x04,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF8, 0xF0, 0xFF, 0xEF, 0x1F, 0xFF, 0xF3, 0xF8, 0xFF, 0x3E, 0x03, 0xF7,
  0xC0, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x0F, 0xFE, 0xF0, 0x3F, 0xCF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF1, 0x00, 0x1E, 0x38, 0x03, 0xE7,
  0xE0, 0x7C, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0xF8,
  0x79, 0xFF, 0xCF, 0x7F, 0xFD, 0xFE, 0x1F, 0xBF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xCF, 0xFF, 0x3F,
  0xF8, 0xFF, 0x81, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF9, 0xE0, 0x0F,
  0x8F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0,
  0xF8, 0x07, 0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF8, 0xF8, 0x07, 0x83,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0xC3,
  0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF0, 0x03, 0xF7, 0x80, 0x0F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xE1, 0xF9, 0xFF, 0xE7, 0xFB, 0xFF, 0xFF, 0xF7, 0xC7, 0xF1, 0xFF,
  0x07, 0xC1, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0,
  0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03,
  0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38,
  0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81,
  0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0xFE, 0x1E,
  0x7F, 0xF3, 0xDF, 0xFF, 0x7F, 0x87, 0xEF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xF0, 0x7E, 0x0F, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03,
  0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x03, 0xC3, 0xF0,
  0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xF1, 0xFC, 0x0F,
  0x7F, 0xF0, 0xFF, 0xFF, 0x8F, 0xE1, 0xFC, 0xFC, 0x07, 0xCF, 0x80, 0x3E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x80, 0x7C, 0xFC,
  0x0F, 0xCF, 0xFF, 0xF8, 0xF7, 0xFF, 0x0F, 0x3F, 0xE0, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0xF0, 0xFF,
  0xEF, 0x1F, 0xFF, 0xF3, 0xF8, 0x7F, 0x3E, 0x01, 0xF7, 0xC0, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xF3, 0xE0, 0x1F, 0x3F, 0x07,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFE, 0xF0, 0x3F, 0xCF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x7F, 0xF8, 0xFF, 0xBC,
  0xFF, 0xDE, 0xFF, 0xEF, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xE0, 0xFC, 0x7C, 0x03, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1E,
  0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x10, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xBC, 0x03,
  0xF7, 0xC0, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0x78, 0x7F, 0x8F, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x70, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0x80, 0x01, 0xE7, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x1C, 0x03, 0xF8, 0x0E,
  0x03, 0xDC, 0x07, 0x81, 0xEE, 0x07, 0xC0, 0xE7, 0x03, 0xE0, 0x73, 0xC1,
  0xF0, 0x39, 0xE0, 0xDC, 0x3C, 0x70, 0xEE, 0x1E, 0x38, 0x77, 0x0E, 0x1C,
  0x3B, 0x87, 0x0F, 0x1D, 0xE3, 0x87, 0x9C, 0x71, 0xC1, 0xCE, 0x39, 0xE0,
  0xE7, 0x1C, 0xE0, 0x73, 0x8E, 0x70, 0x3B, 0x83, 0xB8, 0x0F, 0xC1, 0xDC,
  0x07, 0xE0, 0xEC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x7C, 0x00,
  0x3E, 0x78, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0xF0, 0x1F,
  0x00, 0xF0, 0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xC0, 0x01, 0xEF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xE7, 0x80, 0x0F,
  0x87, 0x80, 0x1E, 0x0F, 0x80, 0x78, 0x0F, 0x81, 0xF0, 0x0F, 0x07, 0xC0,
  0x1F, 0x0F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x7C, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xE1,
  0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0x0F, 0xFC, 0x00, 0xEF, 0xFF, 0x80, 0xF7,
  0x87, 0xE0, 0x77, 0x81, 0xFC, 0xFB, 0x80, 0x3F, 0xF9, 0xC0, 0x0F, 0xFC,
  0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoMono_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 5, 32, 27, 11, -32 },
  { 21, 11, 11, 27, 8, -34 },
  { 37, 25, 32, 27, 1, -32 },
  { 137, 20, 42, 27, 4, -37 },
  { 242, 25, 32, 27, 1, -32 },
  { 342, 24, 32, 27, 2, -32 },
  { 438, 3, 11, 27, 11, -34 },
  { 443, 11, 46, 27, 8, -36 },
  { 507, 12, 46, 27, 7, -36 },
  { 576, 21, 22, 27, 4, -32 },
  { 634, 22, 24, 27, 3, -27 },
  { 700, 6, 12, 27, 8, -5 },
  { 709, 17, 4, 27, 5, -16 },
  { 718, 6, 6, 27, 11, -6 },
  { 723, 17, 35, 27, 6, -32 },
  { 798, 21, 32, 27, 3, -32 },
  { 882, 12, 32, 27, 5, -32 },
  { 930, 21, 32, 27, 2, -32 },
  { 1014, 20, 32, 27, 2, -32 },
  { 1094, 23, 32, 27, 2, -32 },
  { 1186, 20, 32, 27, 4, -32 },
  { 1266, 20, 32, 27, 3, -32 },
  { 1346, 22, 32, 27, 2, -32 },
  { 1434, 20, 32, 27, 4, -32 },
  { 1514, 20, 32, 27, 3, -32 },
  { 1594, 6, 25, 27, 12, -25 },
  { 1613, 7, 32, 27, 11, -25 },
  { 1641, 18, 20, 27, 4, -24 },
  { 1686, 19, 13, 27, 4, -21 },
  { 1717, 19, 20, 27, 4, -24 },
  { 1765, 19, 32, 27, 4, -32 },
  { 1841, 25, 32, 27, 1, -32 },
  { 1941, 24, 32, 27, 2, -32 },
  { 2037, 21, 32, 27, 4, -32 },
  { 2121, 23, 32, 27, 2, -32 },
  { 2213, 22, 32, 27, 3, -32 },
  { 2301, 20, 32, 27, 4, -32 },
  { 2381, 20, 32, 27, 4, -32 },
  { 2461, 23, 32, 27, 2, -32 },
  { 2553, 21, 32, 27, 3, -32 },
  { 2637, 19, 32, 27, 4, -32 },
  { 2713, 21, 32, 27, 2, -32 },
  { 2797, 22, 32, 27, 4, -32 },
  { 2885, 20, 32, 27, 4, -32 },
  { 2965, 21, 32, 27, 3, -32 },
  { 3049, 21, 32, 27, 3, -32 },
  { 3133, 23, 32, 27, 2, -32 },
  { 3225, 21, 32, 27, 4, -32 },
  { 3309, 24, 37, 27, 2, -32 },
  { 3420, 21, 32, 27, 4, -32 },
  { 3504, 22, 32, 27, 3, -32 },
  { 3592, 23, 32, 27, 2, -32 },
  { 3684, 21, 32, 27, 3, -32 },
  { 3768, 23, 32, 27, 2, -32 },
  { 3860, 24, 32, 27, 2, -32 },
  { 3956, 24, 32, 27, 2, -32 },
  { 4052, 24, 32, 27, 1, -32 },
  { 4148, 22, 32, 27, 2, -32 },
  { 4236, 9, 44, 27, 9, -37 },
  { 4286, 17, 35, 27, 5, -32 },
  { 4361, 9, 44, 27, 9, -37 },
  { 4411, 17, 17, 27, 5, -32 },
  { 4448, 21, 3, 27, 3, 0 },
  { 4456, 9, 6, 27, 9, -33 },
  { 4463, 21, 24, 27, 3, -24 },
  { 4526, 20, 34, 27, 4, -34 },
  { 4611, 21, 24, 27, 3, -24 },
  { 4674, 20, 34, 27, 3, -34 },
  { 4759, 21, 24, 27, 3, -24 },
  { 4822, 22, 35, 27, 3, -35 },
  { 4919, 20, 33, 27, 3, -24 },
  { 5002, 19, 34, 27, 4, -34 },
  { 5083, 20, 32, 27, 4, -32 },
  { 5163, 14, 42, 27, 5, -32 },
  { 5237, 21, 34, 27, 4, -34 },
  { 5327, 20, 34, 27, 4, -34 },
  { 5412, 23, 24, 27, 2, -24 },
  { 5481, 19, 24, 27, 4, -24 },
  { 5538, 21, 24, 27, 3, -24 },
  { 5601, 20, 33, 27, 4, -24 },
  { 5684, 20, 33, 27, 3, -24 },
  { 5767, 17, 24, 27, 7, -24 },
  { 5818, 20, 24, 27, 4, -24 },
  { 5878, 20, 30, 27, 3, -30 },
  { 5953, 19, 24, 27, 4, -24 },
  { 6010, 23, 24, 27, 2, -24 },
  { 6079, 25, 24, 27, 1, -24 },
  { 6154, 23, 24, 27, 2, -24 },
  { 6223, 24, 34, 27, 1, -24 },
  { 6325, 20, 24, 27, 4, -24 },
  { 6385, 15, 43, 27, 7, -35 },
  { 6466, 3, 41, 27, 12, -32 },
  { 6482, 15, 43, 27, 7, -35 },
  { 6563, 25, 9, 27, 1, -18 },
};

const GFXfont RobotoMono_Regular45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular45pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_REGULAR45PT7B_H_
