#ifndef _ROBOTOMONO_REGULAR10PT7B_H_
#define _ROBOTOMONO_REGULAR10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8C, 0xFC, 0x28, 0xA7, 0xCA, 0xF9, 0x45, 0x00, 0x2F, 0x98,
  0x61, 0x9F, 0x20, 0xE2, 0xA7, 0x08, 0x3D, 0x51, 0xC0, 0xE5, 0x29, 0x8A,
  0xCB, 0xE0, 0xE0, 0x5A, 0xAA, 0x90, 0xA5, 0x55, 0xA0, 0x2B, 0x66, 0x90,
  0x22, 0xF2, 0x20, 0xE0, 0xF0, 0xC0, 0x12, 0x22, 0x44, 0x48, 0xF9, 0x9F,
  0x99, 0xF0, 0x74, 0x92, 0x48, 0x74, 0x42, 0x22, 0x21, 0xE0, 0x74, 0x42,
  0x60, 0xC5, 0xC0, 0x18, 0xA2, 0x92, 0xFC, 0x20, 0x80, 0xF8, 0xE9, 0x19,
  0x70, 0x68, 0xE9, 0x99, 0xF0, 0xF1, 0x22, 0x24, 0xC0, 0xF9, 0x96, 0x99,
  0xF0, 0xF9, 0x99, 0x71, 0x60, 0x88, 0x40, 0x58, 0x3C, 0x61, 0xF0, 0xF0,
  0xC3, 0x68, 0xF9, 0x12, 0x40, 0x60, 0x39, 0x5B, 0x6D, 0xB6, 0x27, 0x00,
  0x30, 0xC3, 0x12, 0x79, 0x28, 0x40, 0xF9, 0x9F, 0x99, 0xF0, 0xF9, 0x88,
  0x89, 0xF0, 0xE4, 0xA3, 0x18, 0xCB, 0x80, 0xF8, 0x8F, 0x88, 0xF0, 0xF8,
  0x8F, 0x88, 0x80, 0x7A, 0x61, 0x38, 0xA4, 0xE0, 0x99, 0x9F, 0x99, 0x90,
  0xF4, 0x44, 0x44, 0xF0, 0x08, 0x42, 0x10, 0xE5, 0xC0, 0x9D, 0x39, 0x8A,
  0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0x99, 0xFF, 0xD9, 0x90, 0x99, 0xDB,
  0xB9, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF4, 0x63, 0xE8, 0x42, 0x00, 0x79,
  0x28, 0x61, 0x85, 0x27, 0x83, 0xF4, 0xA5, 0xEA, 0x4A, 0x60, 0xF4, 0xE0,
  0xC1, 0x47, 0xC0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x00, 0x99, 0x99, 0x99,
  0xF0, 0xCD, 0x24, 0x92, 0x30, 0xC3, 0x00, 0x96, 0xD7, 0x5E, 0x69, 0x24,
  0x80, 0xCD, 0x23, 0x04, 0x31, 0x2C, 0xC0, 0xCD, 0x23, 0x0C, 0x20, 0x82,
  0x00, 0xF1, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x11,
  0xD5, 0x55, 0x70, 0x66, 0x69, 0xF0, 0xC0, 0xF1, 0xF9, 0xF0, 0x88, 0x8F,
  0x99, 0x9F, 0xF9, 0x89, 0xF0, 0x11, 0x1F, 0x99, 0x9F, 0xF9, 0xF8, 0xF0,
  0x3A, 0x11, 0xE4, 0x21, 0x08, 0xF9, 0x99, 0xF1, 0xF0, 0x88, 0x8F, 0x99,
  0x99, 0x20, 0xE2, 0x22, 0xF0, 0x23, 0x92, 0x49, 0xE0, 0x84, 0x21, 0x6C,
  0x72, 0x93, 0xE2, 0x22, 0x22, 0x2F, 0xFE, 0x59, 0x65, 0x94, 0xF9, 0x99,
  0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10,
  0xF2, 0x48, 0xF8, 0x79, 0xF0, 0x44, 0xF4, 0x44, 0x70, 0x99, 0x99, 0xF0,
  0xCD, 0x23, 0x0C, 0x30, 0x96, 0xD7, 0x92, 0x48, 0x9B, 0x18, 0xC9, 0x80,
  0xCD, 0x23, 0x0C, 0x30, 0x86, 0x00, 0xF2, 0x4C, 0xF0, 0x29, 0x29, 0x12,
  0x44, 0xFF, 0x80, 0x91, 0x24, 0xD2, 0x90, 0x66, 0x60,
};

const GFXglyph RobotoMono_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -8 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 5, 7, 6, 1, -7 },
  { 26, 1, 3, 6, 2, -8 },
  { 27, 2, 10, 6, 2, -8 },
  { 30, 2, 10, 6, 2, -8 },
  { 33, 4, 5, 6, 1, -7 },
  { 36, 4, 5, 6, 1, -6 },
  { 39, 1, 3, 6, 2, -1 },
  { 40, 4, 1, 6, 1, -4 },
  { 41, 2, 1, 6, 2, -1 },
  { 42, 4, 8, 6, 1, -7 },
  { 46, 4, 7, 6, 1, -7 },
  { 50, 3, 7, 6, 1, -7 },
  { 53, 5, 7, 6, 0, -7 },
  { 58, 5, 7, 6, 0, -7 },
  { 63, 6, 7, 6, 0, -7 },
  { 69, 4, 7, 6, 1, -7 },
  { 73, 4, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 4, 7, 6, 1, -7 },
  { 85, 4, 7, 6, 1, -7 },
  { 89, 1, 5, 6, 3, -5 },
  { 90, 2, 7, 6, 2, -5 },
  { 92, 4, 4, 6, 1, -5 },
  { 94, 4, 3, 6, 1, -5 },
  { 96, 4, 4, 6, 1, -5 },
  { 98, 4, 7, 6, 1, -7 },
  { 102, 6, 7, 6, 0, -7 },
  { 108, 6, 7, 6, 0, -7 },
  { 114, 4, 7, 6, 1, -7 },
  { 118, 4, 7, 6, 1, -7 },
  { 122, 5, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 5, 7, 6, 0, -7 },
  { 140, 4, 7, 6, 1, -7 },
  { 144, 4, 7, 6, 1, -7 },
  { 148, 5, 7, 6, 0, -7 },
  { 153, 5, 7, 6, 1, -7 },
  { 158, 4, 7, 6, 1, -7 },
  { 162, 4, 7, 6, 1, -7 },
  { 166, 4, 7, 6, 1, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 5, 7, 6, 1, -7 },
  { 179, 6, 8, 6, 0, -7 },
  { 185, 5, 7, 6, 1, -7 },
  { 190, 5, 7, 6, 1, -7 },
  { 195, 6, 7, 6, 0, -7 },
  { 201, 4, 7, 6, 1, -7 },
  { 205, 6, 7, 6, 0, -7 },
  { 211, 6, 7, 6, 0, -7 },
  { 217, 6, 7, 6, 0, -7 },
  { 223, 6, 7, 6, 0, -7 },
  { 229, 4, 7, 6, 1, -7 },
  { 233, 2, 10, 6, 2, -8 },
  { 236, 4, 8, 6, 1, -7 },
  { 240, 2, 10, 6, 2, -8 },
  { 243, 4, 4, 6, 1, -7 },
  { 245, 4, 1, 6, 1, 0 },
  { 246, 2, 1, 6, 2, -7 },
  { 247, 4, 5, 6, 1, -5 },
  { 250, 4, 8, 6, 1, -8 },
  { 254, 4, 5, 6, 1, -5 },
  { 257, 4, 8, 6, 1, -8 },
  { 261, 4, 5, 6, 1, -5 },
  { 264, 5, 8, 6, 1, -8 },
  { 269, 4, 7, 6, 1, -5 },
  { 273, 4, 8, 6, 1, -8 },
  { 277, 4, 7, 6, 1, -7 },
  { 281, 3, 9, 6, 1, -7 },
  { 285, 5, 8, 6, 1, -8 },
  { 290, 4, 8, 6, 1, -8 },
  { 294, 6, 5, 6, 0, -5 },
  { 298, 4, 5, 6, 1, -5 },
  { 301, 4, 5, 6, 1, -5 },
  { 304, 4, 7, 6, 1, -5 },
  { 308, 4, 7, 6, 1, -5 },
  { 312, 3, 5, 6, 2, -5 },
  { 314, 4, 5, 6, 1, -5 },
  { 317, 4, 7, 6, 1, -7 },
  { 321, 4, 5, 6, 1, -5 },
  { 324, 6, 5, 6, 0, -5 },
  { 328, 6, 5, 6, 0, -5 },
  { 332, 5, 5, 6, 1, -5 },
  { 336, 6, 7, 6, 0, -5 },
  { 342, 4, 5, 6, 1, -5 },
  { 345, 3, 10, 6, 2, -8 },
  { 349, 1, 9, 6, 3, -7 },
  { 351, 3, 10, 6, 2, -8 },
  { 355, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_Regular10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular10pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_REGULAR10PT7B_H_
