#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoMono_Regular
// Headers: 67

#include "RobotoMono_Regular6pt7b.h"
#include "RobotoMono_Regular7pt7b.h"
#include "RobotoMono_Regular8pt7b.h"
#include "RobotoMono_Regular9pt7b.h"
#include "RobotoMono_Regular10pt7b.h"
#include "RobotoMono_Regular11pt7b.h"
#include "RobotoMono_Regular12pt7b.h"
#include "RobotoMono_Regular13pt7b.h"
#include "RobotoMono_Regular14pt7b.h"
#include "RobotoMono_Regular15pt7b.h"
#include "RobotoMono_Regular16pt7b.h"
#include "RobotoMono_Regular17pt7b.h"
#include "RobotoMono_Regular18pt7b.h"
#include "RobotoMono_Regular19pt7b.h"
#include "RobotoMono_Regular20pt7b.h"
#include "RobotoMono_Regular21pt7b.h"
#include "RobotoMono_Regular22pt7b.h"
#include "RobotoMono_Regular23pt7b.h"
#include "RobotoMono_Regular24pt7b.h"
#include "RobotoMono_Regular25pt7b.h"
#include "RobotoMono_Regular26pt7b.h"
#include "RobotoMono_Regular27pt7b.h"
#include "RobotoMono_Regular28pt7b.h"
#include "RobotoMono_Regular29pt7b.h"
#include "RobotoMono_Regular30pt7b.h"
#include "RobotoMono_Regular31pt7b.h"
#include "RobotoMono_Regular32pt7b.h"
#include "RobotoMono_Regular33pt7b.h"
#include "RobotoMono_Regular34pt7b.h"
#include "RobotoMono_Regular35pt7b.h"
#include "RobotoMono_Regular36pt7b.h"
#include "RobotoMono_Regular37pt7b.h"
#include "RobotoMono_Regular38pt7b.h"
#include "RobotoMono_Regular39pt7b.h"
#include "RobotoMono_Regular40pt7b.h"
#include "RobotoMono_Regular41pt7b.h"
#include "RobotoMono_Regular42pt7b.h"
#include "RobotoMono_Regular43pt7b.h"
#include "RobotoMono_Regular44pt7b.h"
#include "RobotoMono_Regular45pt7b.h"
#include "RobotoMono_Regular46pt7b.h"
#include "RobotoMono_Regular47pt7b.h"
#include "RobotoMono_Regular48pt7b.h"
#include "RobotoMono_Regular49pt7b.h"
#include "RobotoMono_Regular50pt7b.h"
#include "RobotoMono_Regular51pt7b.h"
#include "RobotoMono_Regular52pt7b.h"
#include "RobotoMono_Regular53pt7b.h"
#include "RobotoMono_Regular54pt7b.h"
#include "RobotoMono_Regular55pt7b.h"
#include "RobotoMono_Regular56pt7b.h"
#include "RobotoMono_Regular57pt7b.h"
#include "RobotoMono_Regular58pt7b.h"
#include "RobotoMono_Regular59pt7b.h"
#include "RobotoMono_Regular60pt7b.h"
#include "RobotoMono_Regular61pt7b.h"
#include "RobotoMono_Regular62pt7b.h"
#include "RobotoMono_Regular63pt7b.h"
#include "RobotoMono_Regular64pt7b.h"
#include "RobotoMono_Regular65pt7b.h"
#include "RobotoMono_Regular66pt7b.h"
#include "RobotoMono_Regular67pt7b.h"
#include "RobotoMono_Regular68pt7b.h"
#include "RobotoMono_Regular69pt7b.h"
#include "RobotoMono_Regular70pt7b.h"
#include "RobotoMono_Regular71pt7b.h"
#include "RobotoMono_Regular72pt7b.h"
