#ifndef _ROBOTOMONO_REGULAR46PT7B_H_
#define _ROBOTOMONO_REGULAR46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x70, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x0F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01,
  0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x3C, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xDF, 0xC1, 0xF0, 0x1F,
  0x1F, 0x00, 0x78, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xEF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF8, 0x00,
  0xF3, 0xE0, 0x0F, 0x9F, 0xC1, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xE0, 0x70, 0x20, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC3, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x1C, 0x70, 0x0F,
  0x0F, 0x1C, 0x01, 0xFF, 0x8E, 0x00, 0x3F, 0xC3, 0x80, 0x07, 0xE1, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x71, 0xFF, 0x00,
  0x1C, 0x7F, 0xC0, 0x0E, 0x3C, 0x78, 0x03, 0x8E, 0x0E, 0x01, 0xC3, 0x83,
  0x80, 0xF1, 0xE0, 0xF0, 0x38, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x01, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xC1,
  0xE0, 0x01, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xDF, 0x03, 0xC7, 0xC7, 0xC1, 0xE7, 0xC3, 0xE0, 0xF3, 0xE0, 0xF8, 0x79,
  0xE0, 0x3E, 0x79, 0xF0, 0x0F, 0xBC, 0xF8, 0x07, 0xDE, 0x7C, 0x01, 0xFE,
  0x1E, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x3F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x3E, 0x07, 0xFE, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x00, 0x20, 0x06, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x60, 0x02, 0x40, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x60, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x02, 0x01, 0xC0, 0x1E,
  0x0E, 0x06, 0xFC, 0x71, 0xFF, 0xFB, 0xBF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x73, 0xC0, 0x07,
  0x8F, 0x00, 0x78, 0x78, 0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0x3C,
  0x02, 0x00, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x79, 0xEF, 0x1C, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x1F, 0xC3,
  0xE0, 0x1F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7D, 0xFE, 0x07, 0xCF, 0xF0, 0x7C, 0x7F, 0x8F, 0xC3,
  0xFC, 0xF8, 0x1F, 0xEF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E,
  0xF8, 0x01, 0xE3, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x07, 0x03, 0xF0, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFE, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x07, 0xCF, 0x80,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0xC3,
  0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3E,
  0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07,
  0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xDF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF3, 0xFC, 0x7C, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x1F, 0x83, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x9F, 0xF0, 0x3D, 0xFF, 0xC3, 0xDF, 0xFF, 0x1F, 0xE0, 0xFC,
  0xFE, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x07, 0x9F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x1E, 0x0F, 0xC3,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0x1F, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE3,
  0xC0, 0x1E, 0x1F, 0x01, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x0F, 0x7C,
  0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0x1F, 0x03, 0xF0, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0,
  0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00,
  0x1F, 0x7C, 0x01, 0xF9, 0xF0, 0x1F, 0xCF, 0xE7, 0xFE, 0x3F, 0xFE, 0xF0,
  0x7F, 0xE7, 0x01, 0xFC, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x38, 0xFB,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x8F, 0xBF, 0xFF, 0xFE, 0xF8, 0x1C, 0x3E, 0x7F,
  0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x70, 0x20, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7C, 0x03, 0xE7,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x78,
  0x03, 0xC0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x18, 0x38, 0x1F, 0x0E, 0x18,
  0x1F, 0xC3, 0x1C, 0x1F, 0xF1, 0xCE, 0x1C, 0x30, 0xEE, 0x1C, 0x18, 0x77,
  0x0E, 0x0C, 0x3B, 0x86, 0x06, 0x0D, 0xC7, 0x03, 0x06, 0xC3, 0x83, 0x83,
  0x61, 0xC1, 0xC1, 0xB0, 0xE0, 0xE1, 0xD8, 0x70, 0x70, 0xEC, 0x38, 0x38,
  0x66, 0x1C, 0x1C, 0x33, 0x0E, 0x1E, 0x39, 0xC7, 0x9F, 0x18, 0xE1, 0xFF,
  0xFC, 0x70, 0xFC, 0xFC, 0x1C, 0x3C, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xE3, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7E, 0x78, 0x00,
  0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x03, 0xF3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3C, 0x00, 0xF9, 0xE0,
  0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x00,
  0x3F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0x81,
  0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0x81,
  0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0x80,
  0xFE, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0x79, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03,
  0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x79, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x7E, 0x1F, 0x0F,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0xC1, 0xF0, 0x0F, 0x83, 0xC0,
  0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF8,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xE1, 0xF8, 0x1F, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F,
  0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xFE, 0x1F, 0x81, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x07,
  0xC7, 0x80, 0x1F, 0x0F, 0x00, 0x7E, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x07,
  0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x7B,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFB, 0xE0, 0x07, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x1F,
  0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF7, 0x03, 0xBF, 0xDC, 0x1E, 0xFF, 0x78, 0x7B,
  0xFC, 0xE1, 0xCF, 0xF3, 0x8F, 0x3F, 0xCF, 0x3C, 0xFF, 0x1C, 0xE3, 0xFC,
  0x77, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3E,
  0x0F, 0xF0, 0xF8, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x03, 0xFC, 0x1C, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xBC, 0x03, 0xFD, 0xF0, 0x1F, 0xE7, 0x80, 0xFF, 0x1E, 0x07, 0xF8,
  0xF0, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3,
  0xFC, 0x0F, 0x1F, 0xE0, 0x78, 0xFF, 0x01, 0xE7, 0xF8, 0x0F, 0x3F, 0xC0,
  0x3D, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x1E,
  0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x1F, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xF0, 0x03,
  0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7C, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x01,
  0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x00,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0xE3, 0xC0, 0x07, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F,
  0x3C, 0x01, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0,
  0x00, 0x7C, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xF3,
  0xFC, 0x3E, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xDE, 0x00, 0x1F,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xF8, 0xFE, 0x0F,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF8,
  0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0xC3, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF8,
  0x1E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03,
  0xBC, 0x0F, 0x03, 0xDE, 0x07, 0x81, 0xEF, 0x03, 0xE0, 0xF7, 0x83, 0xF0,
  0x7B, 0xC1, 0xF8, 0x3C, 0xE0, 0xFC, 0x1E, 0x70, 0x7E, 0x0F, 0x3C, 0x3F,
  0x87, 0x1E, 0x3F, 0xC3, 0x8F, 0x1E, 0xE3, 0xC7, 0x8E, 0x71, 0xE3, 0xC7,
  0x38, 0xF1, 0xE3, 0x9C, 0x78, 0xF1, 0xCF, 0x3C, 0x39, 0xE7, 0x9E, 0x1C,
  0xF1, 0xCE, 0x0F, 0x70, 0xE7, 0x07, 0xB8, 0x73, 0x83, 0xDC, 0x39, 0xC1,
  0xEE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE3, 0xC0, 0x03,
  0xC3, 0xE0, 0x07, 0xC1, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x78,
  0x01, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0xCF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x87, 0x03, 0xC3,
  0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x0E, 0x78, 0x07, 0xF8,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xC0, 0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x3F,
  0x3F, 0x07, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0x0F, 0xF8, 0x78, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x01, 0xE7, 0xFE, 0x0F, 0x7F, 0xF8, 0x7F, 0xFF, 0xE3,
  0xF8, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF3, 0xF0, 0x0F, 0x9F, 0xE1, 0xF8, 0xFF,
  0xFF, 0xC7, 0xBF, 0xFC, 0x3C, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF0, 0x3F, 0x1F, 0x00, 0x79, 0xF0,
  0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x01, 0xF3,
  0xE0, 0x0F, 0x0F, 0x81, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x3E, 0x0F, 0xFD, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFC, 0x0F, 0xE7, 0xC0, 0x3F, 0x7C, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E,
  0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0,
  0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFB, 0xC0, 0xFF, 0x1E, 0x00, 0x7C, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xF8,
  0x03, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x0C, 0x3E, 0x00, 0x78, 0x7E, 0x07, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0x01, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF3,
  0xC3, 0xFF, 0xDE, 0x3F, 0xFF, 0xF3, 0xF0, 0x3F, 0x9F, 0x00, 0xFD, 0xF0,
  0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xF3,
  0xE0, 0x1F, 0x9F, 0x83, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFC,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE1, 0x00, 0x0F, 0x1C,
  0x00, 0xF9, 0xF8, 0x1F, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x08, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x1F, 0xF0, 0xF3, 0xFF, 0xCF,
  0x7F, 0xFC, 0xFE, 0x07, 0xEF, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x1F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x05, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x07, 0xC3, 0xC0,
  0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x7C, 0x01,
  0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFC, 0xF8, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x81, 0xE0, 0x7C, 0x0F,
  0x01, 0xF0, 0x78, 0x07, 0xC3, 0xC0, 0x1F, 0x1E, 0x00, 0xFC, 0xF0, 0x03,
  0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3E, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0xF0, 0xF7, 0xF3, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E,
  0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0x00, 0x3C, 0x0F, 0x1F, 0xF0, 0xF7, 0xFF, 0xCF, 0x7F, 0xFC, 0xFE,
  0x03, 0xEF, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9E,
  0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3E,
  0x01, 0xF0, 0xFC, 0x0F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0xF8, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE,
  0x07, 0xCF, 0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1E, 0xF8, 0x03, 0xEF, 0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0x7F,
  0xF0, 0xF3, 0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF3, 0xC3, 0xFF, 0xDE, 0x3F, 0xFF,
  0xF3, 0xF0, 0x3F, 0x9F, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x78,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x81, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x78, 0x7F,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3E, 0x03, 0xE7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xE0, 0x3E, 0x3F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x04, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7,
  0x80, 0x3F, 0x7E, 0x0F, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0xFF, 0x8F,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xE7,
  0x00, 0x01, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x1C, 0x03,
  0xFC, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0x39, 0xC0, 0x78, 0x1E, 0x78, 0x3E,
  0x07, 0x9E, 0x0F, 0xC1, 0xE3, 0x83, 0xF0, 0x70, 0xE0, 0xFC, 0x1C, 0x38,
  0x77, 0x07, 0x0F, 0x1C, 0xE3, 0xC3, 0xC7, 0x38, 0xE0, 0x71, 0xCE, 0x38,
  0x1C, 0xE3, 0x8E, 0x07, 0x38, 0x73, 0x81, 0xCE, 0x1D, 0xE0, 0x7B, 0x87,
  0x70, 0x0F, 0xC1, 0xDC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0,
  0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x81, 0xE0,
  0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x60, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0xF3, 0xFF, 0x80, 0x39, 0xFF, 0xF8, 0x0E,
  0x78, 0x3F, 0x07, 0xBC, 0x07, 0xFF, 0xCE, 0x00, 0xFF, 0xF1, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 5, 33, 28, 11, -33 },
  { 22, 11, 11, 28, 8, -35 },
  { 38, 25, 33, 28, 1, -33 },
  { 142, 21, 43, 28, 4, -38 },
  { 255, 26, 33, 28, 1, -33 },
  { 363, 25, 33, 28, 2, -33 },
  { 467, 4, 11, 28, 11, -35 },
  { 473, 12, 48, 28, 8, -37 },
  { 545, 12, 48, 28, 7, -37 },
  { 617, 21, 22, 28, 4, -33 },
  { 675, 22, 24, 28, 3, -27 },
  { 741, 6, 13, 28, 8, -5 },
  { 751, 17, 3, 28, 5, -16 },
  { 758, 7, 6, 28, 11, -6 },
  { 764, 17, 36, 28, 6, -33 },
  { 841, 21, 33, 28, 3, -33 },
  { 928, 12, 33, 28, 5, -33 },
  { 978, 22, 33, 28, 2, -33 },
  { 1069, 21, 33, 28, 2, -33 },
  { 1156, 23, 33, 28, 2, -33 },
  { 1251, 21, 33, 28, 4, -33 },
  { 1338, 21, 33, 28, 3, -33 },
  { 1425, 22, 33, 28, 3, -33 },
  { 1516, 21, 33, 28, 4, -33 },
  { 1603, 21, 33, 28, 3, -33 },
  { 1690, 7, 26, 28, 12, -26 },
  { 1713, 8, 34, 28, 11, -26 },
  { 1747, 19, 21, 28, 4, -25 },
  { 1797, 20, 13, 28, 4, -21 },
  { 1830, 20, 21, 28, 4, -25 },
  { 1883, 20, 33, 28, 4, -33 },
  { 1966, 25, 33, 28, 1, -33 },
  { 2070, 24, 33, 28, 2, -33 },
  { 2169, 21, 33, 28, 4, -33 },
  { 2256, 23, 33, 28, 2, -33 },
  { 2351, 23, 33, 28, 3, -33 },
  { 2446, 20, 33, 28, 4, -33 },
  { 2529, 20, 33, 28, 4, -33 },
  { 2612, 23, 33, 28, 2, -33 },
  { 2707, 21, 33, 28, 3, -33 },
  { 2794, 20, 33, 28, 4, -33 },
  { 2877, 22, 33, 28, 2, -33 },
  { 2968, 23, 33, 28, 4, -33 },
  { 3063, 21, 33, 28, 4, -33 },
  { 3150, 22, 33, 28, 3, -33 },
  { 3241, 21, 33, 28, 3, -33 },
  { 3328, 23, 33, 28, 2, -33 },
  { 3423, 22, 33, 28, 4, -33 },
  { 3514, 24, 39, 28, 2, -33 },
  { 3631, 22, 33, 28, 4, -33 },
  { 3722, 22, 33, 28, 3, -33 },
  { 3813, 24, 33, 28, 2, -33 },
  { 3912, 21, 33, 28, 3, -33 },
  { 3999, 24, 33, 28, 2, -33 },
  { 4098, 25, 33, 28, 2, -33 },
  { 4202, 24, 33, 28, 2, -33 },
  { 4301, 25, 33, 28, 1, -33 },
  { 4405, 21, 33, 28, 3, -33 },
  { 4492, 8, 44, 28, 10, -37 },
  { 4536, 18, 36, 28, 5, -33 },
  { 4617, 9, 44, 28, 9, -37 },
  { 4667, 17, 18, 28, 5, -33 },
  { 4706, 21, 3, 28, 3, 0 },
  { 4714, 9, 6, 28, 9, -33 },
  { 4721, 21, 25, 28, 3, -25 },
  { 4787, 21, 35, 28, 4, -35 },
  { 4879, 21, 25, 28, 3, -25 },
  { 4945, 21, 35, 28, 3, -35 },
  { 5037, 22, 25, 28, 3, -25 },
  { 5106, 22, 35, 28, 3, -35 },
  { 5203, 21, 35, 28, 3, -25 },
  { 5295, 20, 35, 28, 4, -35 },
  { 5383, 20, 33, 28, 5, -33 },
  { 5466, 14, 43, 28, 5, -33 },
  { 5542, 21, 35, 28, 4, -35 },
  { 5634, 20, 35, 28, 5, -35 },
  { 5722, 24, 25, 28, 2, -25 },
  { 5797, 20, 25, 28, 4, -25 },
  { 5860, 22, 25, 28, 3, -25 },
  { 5929, 20, 34, 28, 4, -25 },
  { 6014, 21, 34, 28, 3, -25 },
  { 6104, 17, 25, 28, 7, -25 },
  { 6158, 20, 25, 28, 4, -25 },
  { 6221, 21, 30, 28, 3, -30 },
  { 6300, 20, 24, 28, 4, -24 },
  { 6360, 23, 24, 28, 2, -24 },
  { 6429, 26, 24, 28, 1, -24 },
  { 6507, 24, 24, 28, 2, -24 },
  { 6579, 24, 34, 28, 2, -24 },
  { 6681, 20, 24, 28, 4, -24 },
  { 6741, 15, 44, 28, 7, -36 },
  { 6824, 3, 42, 28, 12, -33 },
  { 6840, 15, 44, 28, 7, -36 },
  { 6923, 26, 9, 28, 1, -18 },
};

const GFXfont RobotoMono_Regular46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular46pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_REGULAR46PT7B_H_
