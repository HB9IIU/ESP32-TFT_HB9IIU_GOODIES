#ifndef _ROBOTOMONO_REGULAR36PT7B_H_
#define _ROBOTOMONO_REGULAR36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x00,
  0x4E, 0xFE, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x00,
  0xC1, 0xC0, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x18, 0x38, 0x01, 0x83, 0x00, 0x38, 0x30, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x03, 0x07, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x60, 0xE0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xE1,
  0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x1C,
  0x38, 0x01, 0x83, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0F,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x0F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x20, 0xC1, 0x87,
  0x0C, 0x18, 0x60, 0xC1, 0x8E, 0x0C, 0x18, 0xC0, 0xE3, 0x9C, 0x07, 0xF1,
  0x80, 0x3E, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x78, 0x01, 0x8F, 0xC0, 0x39, 0xCE, 0x03, 0x18, 0x70,
  0x73, 0x87, 0x06, 0x38, 0x70, 0xE3, 0x87, 0x04, 0x38, 0x70, 0x01, 0x86,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x0E, 0x1E, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xE1, 0xC0,
  0x3C, 0x78, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x73, 0xCF, 0x0E, 0x70, 0xF1, 0xDE, 0x0E, 0x3B,
  0x81, 0xEF, 0x70, 0x1F, 0xCE, 0x01, 0xF9, 0xE0, 0x1E, 0x1C, 0x07, 0xC3,
  0xE3, 0xFC, 0x3F, 0xFB, 0xC3, 0xFC, 0x3C, 0xFF, 0xFF, 0x00, 0x80, 0x60,
  0x3C, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x80, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x02, 0x0E, 0x0B, 0xC6, 0x1D, 0xFB, 0x7E, 0x7F, 0xFF, 0x83, 0xF8, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xE7, 0x00, 0x73, 0xC0, 0x70, 0xE0, 0x78, 0x38,
  0x18, 0x18, 0x04, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x39, 0xCE,
  0x73, 0x9D, 0xEE, 0xF3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x27, 0xFF,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70,
  0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xE0, 0xF7, 0xE1, 0xE7, 0xE7, 0xC7, 0xEF, 0x07, 0xFE, 0x07, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x78,
  0x1E, 0x3E, 0x7C, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x40, 0xF0, 0xFD, 0xFF,
  0xFF, 0xFC, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0,
  0x7C, 0x78, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0xF0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0,
  0x1E, 0x7C, 0x7C, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x78, 0x0E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x39, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7E, 0x30,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0E, 0x3E, 0x7E, 0x1F, 0xFC, 0x0F,
  0xF0, 0x00, 0x18, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0xF0, 0x1D, 0xFF,
  0x0F, 0xFF, 0xC7, 0xE1, 0xE3, 0xC0, 0x7B, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0,
  0x07, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0xC0, 0x38,
  0xF0, 0x3C, 0x3E, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x1E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x0F, 0x78,
  0x0E, 0x38, 0x1E, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3C, 0x3E, 0x78,
  0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0x78, 0x0F, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x78, 0x3C, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x70,
  0x1F, 0x7C, 0x7F, 0x3F, 0xFE, 0x1F, 0xEE, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F,
  0x00, 0x67, 0xBF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xF7,
  0xFF, 0xE0, 0x31, 0xEF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x38, 0xE1, 0x00, 0x00, 0x06,
  0x00, 0x3C, 0x01, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xC0, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xC0, 0xF7, 0x00, 0xFE, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x70,
  0x01, 0x8C, 0x3F, 0x19, 0x8F, 0xE3, 0x61, 0x8C, 0x6C, 0x61, 0x8D, 0x8C,
  0x31, 0xF3, 0x86, 0x3C, 0x60, 0xC7, 0x8C, 0x18, 0xF1, 0x83, 0x1E, 0x30,
  0x63, 0xC6, 0x1C, 0x7C, 0xE7, 0x99, 0x8F, 0xFF, 0x31, 0xF7, 0xC7, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x60, 0x0F, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x39, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00,
  0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1C, 0x07, 0xCE, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x0F, 0x70, 0x07, 0x38, 0x07, 0x9F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xE3,
  0x80, 0x79, 0xC0, 0x1E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x7D, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x38,
  0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3D, 0xC0, 0x0E, 0x70,
  0x03, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0x7C, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1C, 0x1F, 0x8E, 0x03, 0xE7,
  0x00, 0x73, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0xF3,
  0x81, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xF0, 0x3C, 0x38, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x1F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3D,
  0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0x7E, 0x7E, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0x78, 0x1E, 0x3F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0xE0, 0x07, 0xB8, 0x03,
  0xCE, 0x00, 0xF3, 0x80, 0x78, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x0F, 0x03,
  0x83, 0xC0, 0xE1, 0xE0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xBC, 0x00, 0xEF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xE7, 0x80, 0xF0, 0xF0, 0x38, 0x3C,
  0x0E, 0x07, 0x83, 0x80, 0xF0, 0xE0, 0x3C, 0x38, 0x07, 0x8E, 0x00, 0xF3,
  0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEE, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE1,
  0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEE, 0x07, 0xEF, 0x07, 0xE7,
  0x07, 0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xC7, 0xE1, 0xE7, 0xE0,
  0xE7, 0xE0, 0xF7, 0xE0, 0x77, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x03, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0xF8, 0x78, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x3B, 0xC0,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEF,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x9E, 0x01, 0xC3, 0xC0, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xEF, 0x01, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x78, 0x78,
  0x0F, 0x1C, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0xC0, 0x0E, 0x70,
  0x07, 0x9E, 0x01, 0xC3, 0xC0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0x80,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x07, 0xCE, 0x00, 0xF7, 0x00, 0x7B, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xEE,
  0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x3C,
  0x38, 0x0E, 0x1C, 0x07, 0x8E, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x39, 0xC0,
  0x1E, 0xE0, 0x07, 0x70, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x0F,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0xC0, 0x78, 0xFE, 0xFC,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x7B, 0xC0, 0x38, 0xF0, 0x3C, 0x7E, 0xFC, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0xBC, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x1C, 0x07,
  0x83, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x07, 0x80, 0xE0, 0xE0, 0x1E, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0xF0,
  0x01, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x60, 0x7E, 0x0F, 0x07, 0x70, 0xF0,
  0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x70, 0xF8, 0xE7, 0x1F,
  0x8E, 0x71, 0xF8, 0xE7, 0x1D, 0x8E, 0x71, 0x98, 0xE3, 0x99, 0x8C, 0x3B,
  0x9D, 0xC3, 0xB9, 0xDC, 0x3B, 0x9D, 0xC3, 0xB8, 0xDC, 0x3B, 0x0D, 0xC3,
  0xB0, 0xDC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xF0, 0x03,
  0xDE, 0x00, 0x79, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x38, 0x1C,
  0x07, 0x87, 0x80, 0x70, 0xE0, 0x0F, 0x3C, 0x00, 0xE7, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x00, 0xE7, 0x80, 0x3C, 0x70, 0x0F, 0x0F, 0x01, 0xC0, 0xE0,
  0x78, 0x1E, 0x0E, 0x01, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7C,
  0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0xC0, 0x38,
  0x38, 0x0F, 0x07, 0x81, 0xC0, 0x70, 0x78, 0x0E, 0x0E, 0x00, 0xE3, 0xC0,
  0x1C, 0x70, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xFF, 0xFC, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFC, 0x03,
  0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xDC, 0x07,
  0x38, 0x38, 0xE0, 0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x3B, 0x80, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x70, 0x70, 0x60, 0x0F,
  0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0x70, 0x1E, 0xF0, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x01, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x78, 0x0E, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFE, 0x7F, 0xEF, 0x1F,
  0xCF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE7, 0xF0, 0xEF, 0xFC, 0xFE, 0x7C, 0xF8,
  0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF8,
  0x1E, 0xFE, 0x7C, 0xEF, 0xF8, 0xE7, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E,
  0x7E, 0x78, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xF0,
  0x0F, 0x78, 0x0E, 0x3E, 0x7E, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x07, 0xF7, 0x8F, 0xFF, 0xCF, 0xCF, 0xE7, 0x81, 0xF7, 0x80,
  0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x1F,
  0x3F, 0x3F, 0x8F, 0xFF, 0xC1, 0xFD, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x07,
  0xCF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x04, 0x78, 0x07, 0x1F, 0x9F, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x78, 0x10, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x07, 0xF3, 0x8F, 0xFF, 0xCF, 0xCF, 0xE7, 0x81, 0xF7, 0x80, 0x7B, 0x80,
  0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEE,
  0x00, 0xF7, 0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x1F, 0x3F, 0x3F,
  0x8F, 0xFF, 0xC1, 0xFD, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x80, 0x38, 0xC0,
  0x3C, 0xF8, 0x7C, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE3, 0xF8, 0xEF, 0xFC, 0xEE, 0x7E, 0xF8, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x81,
  0xF7, 0xFC, 0xFF, 0x1F, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x1F,
  0x70, 0x1E, 0x38, 0x1E, 0x1C, 0x1E, 0x0E, 0x1E, 0x07, 0x1E, 0x03, 0x9E,
  0x01, 0xDE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xF0, 0x1E, 0x3C, 0x0E,
  0x0F, 0x07, 0x07, 0x83, 0x81, 0xE1, 0xC0, 0x78, 0xE0, 0x1E, 0x70, 0x07,
  0xB8, 0x03, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9F, 0x3F,
  0xFF, 0xEF, 0x3F, 0x7F, 0x87, 0x87, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C,
  0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07,
  0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8,
  0x70, 0x7E, 0x1C, 0x1C, 0xE3, 0xF8, 0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0x8F,
  0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x3D,
  0xE0, 0x1C, 0x78, 0x1E, 0x3E, 0x3E, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xE7,
  0xF0, 0xEF, 0xF8, 0xFE, 0x7C, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xFC, 0x7C, 0xEF, 0xF8, 0xE7,
  0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x07, 0xF7, 0x8F, 0xFF, 0xCF, 0xCF, 0xE7, 0x81, 0xF7,
  0x80, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x1E, 0x78,
  0x1F, 0x3F, 0x3F, 0x8F, 0xFF, 0xC1, 0xFD, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xE3,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x7E,
  0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x0F, 0x7C, 0x3E, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x98, 0x07, 0xFE, 0x01, 0xFE, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F, 0x7E, 0xFF, 0x3F, 0xEF, 0x1F,
  0xC7, 0xE0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x38, 0x07,
  0x0E, 0x03, 0xC3, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x60, 0x7E, 0x0E,
  0x07, 0xE0, 0xF0, 0x66, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x0E, 0x71,
  0xF8, 0xE7, 0x1B, 0x8C, 0x31, 0x98, 0xC3, 0x39, 0x9C, 0x3B, 0x9D, 0xC3,
  0xB1, 0xD8, 0x3B, 0x0D, 0x81, 0xB0, 0xD8, 0x1F, 0x0D, 0x81, 0xE0, 0xF8,
  0x1E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0x03, 0xDE, 0x01,
  0xE3, 0xC0, 0xF0, 0x70, 0x78, 0x0E, 0x1C, 0x03, 0xCF, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0x38, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0x70, 0x38, 0x3C, 0x0F, 0x1E, 0x01,
  0xEF, 0x00, 0x3C, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x1C, 0x01,
  0xE3, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x0F,
  0x01, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x1F, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0xF8, 0x0F,
  0x00, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xF0,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0xF0, 0x0E, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x07, 0x7F, 0xE0,
  0x7E, 0x1F, 0x0E, 0xE0, 0x7F, 0xEC, 0x03, 0xFC, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 26, 22, 9, -26 },
  { 14, 9, 8, 22, 6, -27 },
  { 23, 20, 26, 22, 1, -26 },
  { 88, 16, 34, 22, 3, -30 },
  { 156, 20, 26, 22, 1, -26 },
  { 221, 19, 26, 22, 2, -26 },
  { 283, 2, 8, 22, 9, -27 },
  { 285, 10, 37, 22, 6, -29 },
  { 332, 9, 37, 22, 6, -29 },
  { 374, 17, 18, 22, 3, -26 },
  { 413, 18, 18, 22, 2, -21 },
  { 454, 5, 10, 22, 6, -4 },
  { 461, 13, 3, 22, 4, -13 },
  { 466, 5, 5, 22, 9, -5 },
  { 470, 14, 28, 22, 4, -26 },
  { 519, 16, 26, 22, 3, -26 },
  { 571, 10, 26, 22, 4, -26 },
  { 604, 18, 26, 22, 1, -26 },
  { 663, 16, 26, 22, 2, -26 },
  { 715, 19, 26, 22, 1, -26 },
  { 777, 16, 26, 22, 3, -26 },
  { 829, 17, 26, 22, 2, -26 },
  { 885, 17, 26, 22, 2, -26 },
  { 941, 16, 26, 22, 3, -26 },
  { 993, 16, 26, 22, 3, -26 },
  { 1045, 5, 20, 22, 10, -20 },
  { 1058, 6, 26, 22, 9, -20 },
  { 1078, 15, 16, 22, 3, -19 },
  { 1108, 16, 11, 22, 3, -17 },
  { 1130, 16, 16, 22, 3, -19 },
  { 1162, 15, 26, 22, 3, -26 },
  { 1211, 19, 26, 22, 1, -26 },
  { 1273, 20, 26, 22, 1, -26 },
  { 1338, 17, 26, 22, 3, -26 },
  { 1394, 18, 26, 22, 2, -26 },
  { 1453, 17, 26, 22, 3, -26 },
  { 1509, 16, 26, 22, 3, -26 },
  { 1561, 16, 26, 22, 3, -26 },
  { 1613, 18, 26, 22, 2, -26 },
  { 1672, 17, 26, 22, 2, -26 },
  { 1728, 16, 26, 22, 3, -26 },
  { 1780, 16, 26, 22, 2, -26 },
  { 1832, 18, 26, 22, 3, -26 },
  { 1891, 16, 26, 22, 3, -26 },
  { 1943, 16, 26, 22, 3, -26 },
  { 1995, 16, 26, 22, 3, -26 },
  { 2047, 18, 26, 22, 2, -26 },
  { 2106, 17, 26, 22, 3, -26 },
  { 2162, 18, 30, 22, 2, -26 },
  { 2230, 17, 26, 22, 3, -26 },
  { 2286, 18, 26, 22, 2, -26 },
  { 2345, 19, 26, 22, 1, -26 },
  { 2407, 17, 26, 22, 2, -26 },
  { 2463, 19, 26, 22, 1, -26 },
  { 2525, 20, 26, 22, 1, -26 },
  { 2590, 19, 26, 22, 2, -26 },
  { 2652, 19, 26, 22, 1, -26 },
  { 2714, 17, 26, 22, 2, -26 },
  { 2770, 7, 34, 22, 7, -29 },
  { 2800, 14, 28, 22, 4, -26 },
  { 2849, 7, 34, 22, 7, -29 },
  { 2879, 14, 14, 22, 4, -26 },
  { 2904, 16, 3, 22, 3, 0 },
  { 2910, 7, 5, 22, 7, -26 },
  { 2915, 16, 19, 22, 3, -19 },
  { 2953, 16, 27, 22, 3, -27 },
  { 3007, 16, 19, 22, 3, -19 },
  { 3045, 17, 27, 22, 2, -27 },
  { 3103, 17, 19, 22, 2, -19 },
  { 3144, 17, 28, 22, 3, -28 },
  { 3204, 17, 26, 22, 2, -19 },
  { 3260, 16, 27, 22, 3, -27 },
  { 3314, 16, 26, 22, 4, -26 },
  { 3366, 11, 34, 22, 4, -26 },
  { 3413, 17, 27, 22, 3, -27 },
  { 3471, 16, 27, 22, 4, -27 },
  { 3525, 18, 19, 22, 2, -19 },
  { 3568, 16, 19, 22, 3, -19 },
  { 3606, 17, 19, 22, 2, -19 },
  { 3647, 16, 26, 22, 3, -19 },
  { 3699, 17, 26, 22, 2, -19 },
  { 3755, 13, 19, 22, 6, -19 },
  { 3786, 16, 19, 22, 3, -19 },
  { 3824, 17, 24, 22, 2, -24 },
  { 3875, 16, 19, 22, 3, -19 },
  { 3913, 18, 19, 22, 2, -19 },
  { 3956, 20, 19, 22, 1, -19 },
  { 4004, 18, 19, 22, 2, -19 },
  { 4047, 19, 27, 22, 1, -19 },
  { 4112, 16, 19, 22, 3, -19 },
  { 4150, 12, 34, 22, 6, -28 },
  { 4201, 3, 33, 22, 9, -26 },
  { 4214, 12, 34, 22, 6, -28 },
  { 4265, 20, 7, 22, 1, -14 },
};

const GFXfont RobotoMono_Regular36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular36pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_REGULAR36PT7B_H_
