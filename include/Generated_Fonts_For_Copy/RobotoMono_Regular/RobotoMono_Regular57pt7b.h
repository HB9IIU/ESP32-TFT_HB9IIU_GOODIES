#ifndef _ROBOTOMONO_REGULAR57PT7B_H_
#define _ROBOTOMONO_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0xFB, 0xFF, 0xFF, 0xF8, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0x80, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0x87, 0xF0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F,
  0xE0, 0x3F, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x02, 0x00, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x78, 0x1E,
  0x1E, 0x00, 0x78, 0x3C, 0x3C, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x3F, 0xF8,
  0x78, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x07, 0xF0, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x1E,
  0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x1E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78,
  0x78, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x00, 0x40, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7C, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0x87, 0xE7, 0xE0, 0x3E, 0x3F, 0x0F, 0xC0, 0xF9, 0xF8, 0x3F, 0x03, 0xE7,
  0xC0, 0x7E, 0x0F, 0xBF, 0x00, 0xFC, 0x3E, 0xFC, 0x01, 0xF9, 0xF3, 0xE0,
  0x07, 0xE7, 0xCF, 0x80, 0x0F, 0xDF, 0x3E, 0x00, 0x1F, 0xF8, 0xF8, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0xFF, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xF0, 0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xBF,
  0x03, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x70, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x10, 0x40, 0x00,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x20, 0x0F, 0x00, 0x4F, 0x81, 0xE0, 0x79, 0xFC,
  0x3C, 0x3F, 0x3F, 0xE7, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x08, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0xF8, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0x3F,
  0x1F, 0xF8, 0x3F, 0x87, 0xFE, 0x1F, 0xC1, 0xFF, 0x8F, 0xC0, 0x7F, 0xEF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFC, 0x1F, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3E, 0x00, 0x7F,
  0x01, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x60, 0x01, 0xF1, 0xFF,
  0x80, 0xF9, 0xFF, 0xF8, 0x3E, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE3,
  0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xC7,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x3F,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xE1, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xEF, 0x81, 0xFF, 0xF3, 0xE0, 0x1F, 0xF8, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x3F, 0x3F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC7, 0xC3,
  0xC0, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFE, 0x7F, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x0F, 0xC1, 0xE3, 0xC0, 0xFF,
  0xC3, 0x8F, 0x07, 0xFF, 0x0F, 0x38, 0x1F, 0x1C, 0x1D, 0xE0, 0xF0, 0x70,
  0x77, 0x03, 0x81, 0xC1, 0xDC, 0x1E, 0x07, 0x07, 0x70, 0x70, 0x1C, 0x1F,
  0xC3, 0xC0, 0x70, 0x7F, 0x0F, 0x03, 0xC1, 0xF8, 0x38, 0x0F, 0x07, 0xE0,
  0xE0, 0x38, 0x1F, 0x83, 0x80, 0xE0, 0x7E, 0x0E, 0x03, 0x81, 0xF8, 0x38,
  0x0E, 0x07, 0xE0, 0xE0, 0x38, 0x1F, 0x83, 0x80, 0xE0, 0xEE, 0x0F, 0x07,
  0x83, 0xBC, 0x3C, 0x3E, 0x1E, 0xF0, 0xFF, 0xFC, 0xF1, 0xC1, 0xFF, 0xFF,
  0x87, 0x07, 0xF9, 0xFC, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x0C, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0xF3,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xFB, 0xE0, 0x01, 0xFC, 0xF8, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8,
  0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xFC,
  0x00, 0x3F, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF8, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0xC0, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0x83, 0xF8, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x9F, 0xC0, 0x00,
  0xFB, 0xF8, 0x00, 0x0F, 0xBF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xBF, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x1F, 0x80,
  0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0x7F, 0xFF, 0x01,
  0xEF, 0xFD, 0xE0, 0x7D, 0xFF, 0xBC, 0x0F, 0x3F, 0xF7, 0xC1, 0xE7, 0xFE,
  0x78, 0x7C, 0xFF, 0xCF, 0x0F, 0x1F, 0xF9, 0xF1, 0xE3, 0xFF, 0x1E, 0x7C,
  0x7F, 0xE3, 0xCF, 0x0F, 0xFC, 0x7D, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xF0,
  0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x3F, 0x03,
  0xFF, 0x07, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x01, 0xFF, 0x81,
  0xE0, 0x3F, 0xF0, 0x3C, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0x80, 0x1F, 0xFB, 0xE0,
  0x07, 0xFE, 0x7C, 0x01, 0xFF, 0x9F, 0x80, 0x7F, 0xE3, 0xE0, 0x1F, 0xF8,
  0xFC, 0x07, 0xFE, 0x1F, 0x01, 0xFF, 0x87, 0xE0, 0x7F, 0xE0, 0xF8, 0x1F,
  0xF8, 0x3F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF8, 0x7F, 0xE0, 0x3E,
  0x1F, 0xF8, 0x0F, 0xC7, 0xFE, 0x01, 0xF1, 0xFF, 0x80, 0x7E, 0x7F, 0xE0,
  0x0F, 0x9F, 0xF8, 0x03, 0xF7, 0xFE, 0x00, 0x7D, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0xFF, 0x3E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xCF, 0x80, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x31, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x08, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8,
  0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x7E, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF,
  0xC0, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x03, 0xCF, 0x01, 0xFC, 0x07, 0x9F,
  0x03, 0xF8, 0x1F, 0x3E, 0x07, 0xF0, 0x3E, 0x7C, 0x0F, 0xE0, 0x7C, 0xF8,
  0x1F, 0xC0, 0xF9, 0xF0, 0x7F, 0x81, 0xF3, 0xE0, 0xF7, 0x83, 0xE7, 0xC1,
  0xEF, 0x07, 0x87, 0x83, 0xDE, 0x0F, 0x0F, 0x07, 0xBC, 0x1E, 0x1F, 0x0F,
  0x78, 0x7C, 0x3E, 0x3C, 0x78, 0xF8, 0x7C, 0x78, 0xF1, 0xF0, 0xF8, 0xF1,
  0xE3, 0xE1, 0xF1, 0xE3, 0xC7, 0xC3, 0xE3, 0xC7, 0x8F, 0x03, 0xC7, 0x8F,
  0x1E, 0x07, 0x9E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x3C,
  0xF0, 0x3E, 0xF0, 0x7B, 0xE0, 0x7D, 0xE0, 0xF7, 0xC0, 0xFF, 0xC1, 0xEF,
  0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xE0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x01, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x3E, 0x7C, 0x00,
  0xFB, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFC, 0x0F, 0x8F, 0xC0,
  0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0xE7, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xEF, 0x83, 0xFF, 0xF3, 0xF0, 0x3F, 0xF0, 0xFC, 0x00, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x07, 0xC7, 0xFF, 0x03, 0xE7, 0xFF, 0xC1, 0xF7, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80,
  0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x03, 0xF3, 0xFE, 0x07,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0x7C, 0xFF, 0xF8, 0x3E, 0x3F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F,
  0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x0F, 0xFC, 0x7C, 0x1F, 0xFF, 0xBE,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0xCF, 0xC0, 0x0F,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x01, 0xFC,
  0x7F, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xF7,
  0xC0, 0x7F, 0xE3, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xF0, 0x1F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x08, 0x3F, 0x00, 0x03, 0x0F, 0xE0, 0x01, 0xF1, 0xFC, 0x01, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xC3, 0xC1, 0xFF, 0xF9, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9,
  0xFE, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7C, 0x07, 0xFE, 0x3E, 0x00, 0x20, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE3, 0x00, 0x03,
  0xE3, 0xC0, 0x03, 0xF3, 0xF8, 0x03, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x07, 0xC3, 0xFF, 0x83, 0xE3, 0xFF, 0xE1, 0xF3, 0xFF,
  0xF8, 0xFB, 0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0x3F, 0x80, 0x0F, 0xDF, 0x80,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x80,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3,
  0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x7E,
  0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0x87,
  0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03,
  0xF8, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70,
  0x06, 0x07, 0x9F, 0xE1, 0xFE, 0x3D, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0x0F, 0xE0, 0xFB, 0xE0, 0x7E, 0x07, 0xFE,
  0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0x80, 0x7C, 0x07, 0xFC, 0x03,
  0xE0, 0x3F, 0xE0, 0x1F, 0x01, 0xFF, 0x00, 0xF8, 0x0F, 0xF8, 0x07, 0xC0,
  0x7F, 0xC0, 0x3E, 0x03, 0xFE, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0xFF,
  0x80, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x01, 0xFF, 0x00,
  0xF8, 0x0F, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x3E, 0x03, 0xFE, 0x01, 0xF0,
  0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0x80, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x3F,
  0xE0, 0x1F, 0x01, 0xFF, 0x00, 0xF8, 0x0F, 0xF8, 0x07, 0xC0, 0x7F, 0xC0,
  0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x7C, 0x3F, 0xF8, 0x3E, 0x3F, 0xFE,
  0x1F, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFC, 0x03, 0xF3, 0xF8, 0x00,
  0xFD, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x7C,
  0x7F, 0xF0, 0x3E, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xF8, 0x0F, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0xC0, 0x7F, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xCF, 0xFF, 0x83, 0xE3, 0xFF, 0x01, 0xF0, 0x08, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xC7, 0xC1, 0xFF, 0xFB, 0xE1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7C, 0x07, 0xFE, 0x3E,
  0x00, 0x38, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC7, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFB, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0x9F, 0xC0, 0x1F,
  0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F,
  0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x8F, 0x07,
  0xFE, 0x0F, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x78, 0x03, 0xC0, 0x1F, 0x78, 0x03,
  0xE0, 0x1F, 0x7C, 0x03, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x3C, 0x07,
  0xE0, 0x1E, 0x3C, 0x07, 0xF0, 0x3E, 0x3C, 0x07, 0xF0, 0x3E, 0x3C, 0x0F,
  0xF0, 0x3C, 0x3E, 0x0F, 0x70, 0x3C, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0x0E,
  0x78, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1F, 0x1E,
  0x3C, 0x78, 0x0F, 0x1C, 0x3C, 0x78, 0x0F, 0x3C, 0x3C, 0x78, 0x0F, 0x3C,
  0x3C, 0x70, 0x0F, 0x3C, 0x1E, 0xF0, 0x0F, 0x38, 0x1E, 0xF0, 0x07, 0xB8,
  0x1E, 0xF0, 0x07, 0xF8, 0x0E, 0xF0, 0x07, 0xF8, 0x0E, 0xE0, 0x07, 0xF0,
  0x0E, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0xFE, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x1F,
  0xFF, 0x00, 0x0F, 0x3F, 0xFF, 0xC0, 0x1F, 0x7E, 0x3F, 0xE0, 0x1E, 0x7C,
  0x07, 0xF0, 0x3E, 0x78, 0x03, 0xFF, 0xFE, 0xF0, 0x01, 0xFF, 0xFC, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoMono_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 6, 41, 34, 14, -41 },
  { 32, 14, 14, 34, 10, -43 },
  { 57, 31, 41, 34, 2, -41 },
  { 216, 25, 53, 34, 5, -47 },
  { 382, 32, 42, 34, 1, -41 },
  { 550, 30, 42, 34, 3, -41 },
  { 708, 4, 14, 34, 14, -43 },
  { 715, 15, 59, 34, 10, -46 },
  { 826, 15, 59, 34, 9, -46 },
  { 937, 27, 28, 34, 4, -41 },
  { 1032, 28, 30, 34, 3, -34 },
  { 1137, 8, 15, 34, 10, -6 },
  { 1152, 21, 4, 34, 6, -20 },
  { 1163, 8, 8, 34, 14, -7 },
  { 1171, 22, 44, 34, 7, -41 },
  { 1292, 26, 42, 34, 4, -41 },
  { 1429, 16, 41, 34, 6, -41 },
  { 1511, 28, 41, 34, 2, -41 },
  { 1655, 25, 42, 34, 3, -41 },
  { 1787, 29, 41, 34, 2, -41 },
  { 1936, 26, 42, 34, 5, -41 },
  { 2073, 26, 42, 34, 4, -41 },
  { 2210, 28, 41, 34, 3, -41 },
  { 2354, 26, 42, 34, 5, -41 },
  { 2491, 26, 41, 34, 4, -41 },
  { 2625, 8, 32, 34, 15, -31 },
  { 2657, 9, 40, 34, 14, -31 },
  { 2702, 23, 26, 34, 5, -31 },
  { 2777, 25, 16, 34, 5, -26 },
  { 2827, 25, 26, 34, 5, -31 },
  { 2909, 24, 41, 34, 5, -41 },
  { 3032, 30, 41, 34, 2, -41 },
  { 3186, 31, 41, 34, 2, -41 },
  { 3345, 26, 41, 34, 5, -41 },
  { 3479, 28, 42, 34, 3, -41 },
  { 3626, 28, 41, 34, 4, -41 },
  { 3770, 25, 41, 34, 5, -41 },
  { 3899, 25, 41, 34, 5, -41 },
  { 4028, 28, 42, 34, 3, -41 },
  { 4175, 26, 41, 34, 4, -41 },
  { 4309, 24, 41, 34, 5, -41 },
  { 4432, 26, 42, 34, 3, -41 },
  { 4569, 28, 41, 34, 5, -41 },
  { 4713, 24, 41, 34, 6, -41 },
  { 4836, 27, 41, 34, 4, -41 },
  { 4975, 26, 41, 34, 4, -41 },
  { 5109, 28, 42, 34, 3, -41 },
  { 5256, 27, 41, 34, 5, -41 },
  { 5395, 29, 48, 34, 3, -41 },
  { 5569, 27, 41, 34, 5, -41 },
  { 5708, 28, 42, 34, 3, -41 },
  { 5855, 30, 41, 34, 2, -41 },
  { 6009, 26, 42, 34, 4, -41 },
  { 6146, 30, 41, 34, 2, -41 },
  { 6300, 31, 41, 34, 2, -41 },
  { 6459, 30, 41, 34, 2, -41 },
  { 6613, 30, 41, 34, 2, -41 },
  { 6767, 27, 41, 34, 3, -41 },
  { 6906, 11, 55, 34, 12, -46 },
  { 6982, 22, 44, 34, 6, -41 },
  { 7103, 11, 55, 34, 11, -46 },
  { 7179, 22, 22, 34, 6, -41 },
  { 7240, 26, 4, 34, 4, 0 },
  { 7253, 11, 7, 34, 12, -41 },
  { 7263, 26, 32, 34, 4, -31 },
  { 7367, 25, 44, 34, 5, -43 },
  { 7505, 26, 32, 34, 4, -31 },
  { 7609, 25, 44, 34, 4, -43 },
  { 7747, 26, 32, 34, 4, -31 },
  { 7851, 27, 44, 34, 4, -44 },
  { 8000, 25, 43, 34, 4, -31 },
  { 8135, 25, 43, 34, 5, -43 },
  { 8270, 25, 41, 34, 6, -41 },
  { 8399, 18, 53, 34, 6, -41 },
  { 8519, 26, 43, 34, 5, -43 },
  { 8659, 25, 43, 34, 6, -43 },
  { 8794, 29, 31, 34, 3, -31 },
  { 8907, 25, 31, 34, 5, -31 },
  { 9004, 28, 32, 34, 3, -31 },
  { 9116, 25, 43, 34, 5, -31 },
  { 9251, 25, 43, 34, 4, -31 },
  { 9386, 21, 31, 34, 9, -31 },
  { 9468, 25, 32, 34, 5, -31 },
  { 9568, 26, 38, 34, 4, -37 },
  { 9692, 24, 31, 34, 5, -30 },
  { 9785, 28, 30, 34, 3, -30 },
  { 9890, 32, 30, 34, 1, -30 },
  { 10010, 29, 30, 34, 3, -30 },
  { 10119, 30, 42, 34, 2, -30 },
  { 10277, 26, 30, 34, 4, -30 },
  { 10375, 19, 54, 34, 9, -44 },
  { 10504, 4, 52, 34, 15, -41 },
  { 10530, 19, 54, 34, 9, -44 },
  { 10659, 32, 11, 34, 1, -22 },
};

const GFXfont RobotoMono_Regular57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular57pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_REGULAR57PT7B_H_
