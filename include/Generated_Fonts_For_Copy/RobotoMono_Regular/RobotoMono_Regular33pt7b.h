#ifndef _ROBOTOMONO_REGULAR33PT7B_H_
#define _ROBOTOMONO_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00, 0xEF,
  0xE0, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x01, 0x87, 0x00,
  0x61, 0xC0, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x87, 0xFF,
  0xFD, 0xFF, 0xFF, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x70,
  0x06, 0x18, 0x03, 0x86, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x0C, 0x38, 0x03,
  0x0C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x01, 0x87,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x01, 0xFF, 0x07, 0xFF,
  0x1E, 0x0E, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0xEE, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0x78, 0x0E, 0x78, 0x7C,
  0x7F, 0xF0, 0x7F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0E, 0x70, 0x03, 0x0C, 0x20, 0xC3, 0x0E, 0x30, 0xC3, 0x0C,
  0x31, 0x83, 0x0C, 0xE0, 0xFF, 0x30, 0x1F, 0x9C, 0x01, 0x86, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0xF0, 0x0C, 0xFE, 0x03, 0x31,
  0xC1, 0x9C, 0x30, 0xE7, 0x0C, 0x31, 0xC3, 0x04, 0x70, 0xC0, 0x0C, 0x70,
  0x03, 0xF8, 0x00, 0x7C, 0x03, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x8E,
  0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x3C, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xDC, 0x1D, 0xC7, 0x0F,
  0xE3, 0xC6, 0xE0, 0xF7, 0x70, 0x3B, 0xB8, 0x0F, 0x9C, 0x07, 0xCE, 0x01,
  0xE3, 0xC3, 0xF0, 0xFF, 0xDC, 0x3F, 0x8F, 0xFF, 0x6D, 0xB6, 0x03, 0x07,
  0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0x40, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0C, 0x30, 0x5E, 0x63, 0xFF, 0xFF,
  0x8F, 0xFC, 0x07, 0x80, 0x0F, 0x80, 0x3B, 0x80, 0xE7, 0x03, 0x87, 0x0F,
  0x07, 0x04, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x77, 0x77, 0x77, 0x7E, 0xC0, 0xFF, 0xFF, 0xFF, 0x77, 0xFF,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xF8,
  0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0xF7, 0xE1, 0xE7, 0xE3, 0xC7, 0xE7, 0x07, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0x0E, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1C,
  0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0x87, 0xDF, 0xFF, 0xFF, 0x3C,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0xC0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x78, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0x80, 0xFF, 0xC7,
  0xFF, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x0F, 0x83, 0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xE1, 0xE3, 0xFF,
  0x07, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03,
  0x87, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0xFF, 0xF1, 0xF3, 0xE1,
  0x81, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x73, 0x80, 0xE7, 0x87, 0x87, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x77, 0xF1, 0xDF, 0xF3, 0xF0, 0xF7, 0xC0, 0xEF, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0xC0,
  0xE3, 0xC7, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xC7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x70,
  0xF3, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0x0F, 0x1C, 0x07, 0x70, 0x0E, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xCF, 0x0F, 0x8F, 0xFE,
  0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xC1, 0xE7, 0x01, 0xCE,
  0x03, 0xD8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0x80,
  0x77, 0x81, 0xE7, 0xCF, 0xC7, 0xFF, 0x87, 0xE7, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0xF7,
  0xBF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0xFF, 0x80, 0x7B,
  0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x9C, 0xE7,
  0x73, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0xFE, 0x1F, 0x83,
  0xF0, 0x1C, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0x80,
  0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0xFC, 0x0F,
  0xC1, 0xFC, 0x3F, 0xC0, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x07, 0x80,
  0xFF, 0xC7, 0xFF, 0x9C, 0x0E, 0xE0, 0x3F, 0x80, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x40, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x70,
  0x1C, 0x18, 0x03, 0x0C, 0x18, 0x63, 0x1F, 0x99, 0x8F, 0x62, 0x63, 0x18,
  0xD1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0x63, 0xC6, 0x18, 0xF1, 0x84, 0x2C,
  0x61, 0x0B, 0x18, 0xC6, 0xC7, 0x79, 0x99, 0xF7, 0xC6, 0x38, 0xE1, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x02, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xEC, 0x00,
  0x33, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x0E, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEE,
  0x00, 0x1C, 0xFF, 0xE1, 0xFF, 0xF3, 0x81, 0xE7, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC3, 0xF3, 0xFF, 0x87, 0xFF,
  0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x01, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xC0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x38, 0x1E, 0x70, 0x0E, 0x70, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x0E, 0x78, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xF0, 0x78, 0xF0, 0x1C, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF3, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x38, 0x07,
  0x3E, 0x1E, 0x1F, 0xFC, 0x07, 0xF8, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x81, 0xE7, 0xC7,
  0x87, 0xFE, 0x07, 0xF8, 0x00, 0xE0, 0x1F, 0xE0, 0x3C, 0xE0, 0x38, 0xE0,
  0x70, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0x80, 0xF3, 0xC0, 0xE1, 0xE0, 0xE0,
  0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x37, 0xEC,
  0x37, 0xEE, 0x77, 0xEE, 0x67, 0xE6, 0x67, 0xE7, 0xE7, 0xE7, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE1, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xEE, 0x0F, 0xEE,
  0x0F, 0xE7, 0x0F, 0xE7, 0x8F, 0xE3, 0x8F, 0xE3, 0xCF, 0xE1, 0xCF, 0xE0,
  0xEF, 0xE0, 0xEF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3C, 0x3C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x78,
  0x1C, 0x3E, 0x7C, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0x80,
  0xF7, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xE0, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x0F, 0xFE, 0x07, 0x87, 0x87,
  0x01, 0xE3, 0x80, 0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xC1,
  0xF3, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x40, 0xFF, 0xE1, 0xFF, 0xF3, 0x81, 0xF7, 0x00, 0xEE, 0x01,
  0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x81, 0xE7,
  0xFF, 0x8F, 0xFE, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x38, 0xE0, 0x71, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0x80, 0x03,
  0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0F, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0x78, 0x0F, 0x3C, 0x3E, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x3E, 0x7C, 0x1F, 0xF8, 0x0F,
  0xE0, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x01, 0x8E, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0xE1, 0xF8, 0x78, 0x76, 0x1E, 0x1D,
  0x87, 0x87, 0x71, 0xE1, 0x9C, 0x78, 0x67, 0x1F, 0x39, 0xCF, 0xCE, 0x73,
  0xB3, 0x9C, 0xCC, 0xE7, 0x33, 0x38, 0xCC, 0xEE, 0x33, 0x3B, 0x0D, 0xC6,
  0xC3, 0xF1, 0xB0, 0xF8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x03, 0xCE,
  0x01, 0xE3, 0xC0, 0xF0, 0x70, 0x38, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0x73,
  0xC0, 0x1C, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x0F, 0x1C, 0x03,
  0x87, 0x81, 0xC0, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1E, 0x01, 0xEF, 0x00,
  0x3C, 0xF0, 0x03, 0xB8, 0x03, 0x9E, 0x01, 0xC7, 0x01, 0xC3, 0xC0, 0xE0,
  0xE0, 0xF0, 0x78, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x03, 0x9C, 0x01, 0xDC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70,
  0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF,
  0x0E, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0x98, 0x39, 0xC3, 0x1C,
  0x70, 0xE7, 0x0E, 0xE0, 0x6E, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3,
  0x87, 0x07, 0x80, 0xFF, 0xC7, 0xFF, 0xBC, 0x0E, 0xE0, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x7F, 0x3F, 0xFD, 0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xFC, 0x3F, 0x7F, 0xDC, 0xFE, 0x70, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x71, 0xE0,
  0xEF, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x00, 0xEE, 0x01,
  0xDE, 0x07, 0xBE, 0x1E, 0x7F, 0xF8, 0xEF, 0xE0, 0x03, 0xC0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xE0, 0xE7, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0xEE, 0x01, 0xDE, 0x03,
  0x9E, 0x1E, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xC7, 0x1F, 0xEE, 0x7F,
  0xFC, 0xE0, 0xFB, 0x80, 0xF7, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0x77, 0x00, 0xEF, 0x03, 0xCF,
  0x0F, 0x8F, 0xFF, 0x0F, 0xEE, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3C,
  0x1C, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x06, 0x3E,
  0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xC1, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x3F, 0xDC, 0xFF,
  0xF9, 0xC1, 0xF7, 0x01, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0x9E,
  0x1F, 0x1F, 0xFE, 0x1F, 0xDC, 0x00, 0x38, 0x00, 0x72, 0x01, 0xCE, 0x07,
  0x8F, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x70, 0xEF, 0xF3, 0xFF, 0xEF,
  0x83, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE6, 0xF8, 0xFF, 0x3F, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x02, 0xE0, 0x39, 0xC0,
  0xE3, 0x83, 0x87, 0x0E, 0x0E, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x7F, 0x80,
  0xFF, 0x01, 0xE7, 0x03, 0x8F, 0x07, 0x0F, 0x0E, 0x0F, 0x1C, 0x0E, 0x38,
  0x1E, 0x70, 0x1E, 0xE0, 0x1E, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x0E, 0x77, 0xFF, 0xBF, 0xFF, 0xFE, 0x3C,
  0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F,
  0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xC0, 0x03, 0xC3, 0xBF, 0xCF, 0xFF,
  0xBE, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x70, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xF8, 0x38, 0x3C, 0x70,
  0x1E, 0x70, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F,
  0xF8, 0x0F, 0xE0, 0x03, 0xC1, 0xDF, 0xE3, 0xFF, 0xE7, 0x83, 0xCE, 0x03,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x77,
  0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x7C, 0x3C, 0xFF, 0xF1, 0xDF,
  0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0xDC, 0xFF, 0xF9, 0xC0, 0xF7, 0x80, 0xEE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x77, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0x9E, 0x1F, 0x1F, 0xFE, 0x1F, 0xDC,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x01, 0xFE, 0x7F, 0xEF, 0xFF, 0xE1, 0xF8, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x7F, 0xC3, 0xFF, 0x9C, 0x0F, 0xF0,
  0x1F, 0x80, 0x77, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0x0F, 0x00, 0x1F, 0x80, 0x7F, 0x01, 0xDE, 0x0F, 0x3F, 0xF8, 0x7F, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xFF, 0xFF,
  0xFF, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3E, 0x10, 0x3F, 0xE0, 0x3F, 0xC0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xF7, 0x8F, 0xDF, 0xF7, 0x1F, 0x9C,
  0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x18, 0x1C, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x60,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xE0, 0xC1,
  0xF8, 0x30, 0x7E, 0x1E, 0x1D, 0x87, 0x86, 0x61, 0xE1, 0x9C, 0x78, 0x67,
  0x37, 0x39, 0xCC, 0xCE, 0x33, 0x33, 0x0C, 0xCC, 0xC3, 0x63, 0xB0, 0xF8,
  0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x3C, 0x1C, 0x1C, 0x38, 0x0E, 0x70, 0x0F,
  0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0x70, 0x1E, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x0E, 0xF0, 0x07, 0xF0,
  0x03, 0xDC, 0x00, 0xE7, 0x80, 0x70, 0xE0, 0x1C, 0x3C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x3C, 0x0F, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x07, 0xC0, 0xF8, 0x07, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xE0,
  0x1F, 0x03, 0xE0, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x3C, 0x07, 0x00, 0x1E,
  0x00, 0x1F, 0xE0, 0x37, 0xFC, 0x1F, 0x87, 0xCE, 0xC0, 0xFF, 0x90, 0x0F,
  0xC0, 0x00, 0x40,
};

const GFXglyph RobotoMono_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 23, 20, 8, -23 },
  { 13, 8, 8, 20, 6, -25 },
  { 21, 18, 23, 20, 1, -23 },
  { 73, 15, 30, 20, 3, -27 },
  { 130, 18, 24, 20, 1, -24 },
  { 184, 17, 24, 20, 2, -24 },
  { 235, 3, 8, 20, 8, -25 },
  { 238, 8, 34, 20, 6, -26 },
  { 272, 9, 34, 20, 5, -26 },
  { 311, 15, 15, 20, 3, -23 },
  { 340, 16, 17, 20, 2, -19 },
  { 374, 4, 9, 20, 6, -4 },
  { 379, 12, 2, 20, 4, -11 },
  { 382, 5, 4, 20, 8, -4 },
  { 385, 13, 25, 20, 4, -23 },
  { 426, 16, 24, 20, 2, -24 },
  { 474, 9, 23, 20, 3, -23 },
  { 500, 16, 24, 20, 1, -24 },
  { 548, 14, 24, 20, 2, -24 },
  { 590, 17, 23, 20, 1, -23 },
  { 639, 15, 23, 20, 3, -23 },
  { 683, 15, 23, 20, 2, -23 },
  { 727, 16, 23, 20, 2, -23 },
  { 773, 15, 24, 20, 3, -24 },
  { 818, 15, 24, 20, 2, -24 },
  { 863, 5, 18, 20, 9, -18 },
  { 875, 5, 23, 20, 8, -18 },
  { 890, 13, 15, 20, 3, -18 },
  { 915, 14, 9, 20, 3, -15 },
  { 931, 14, 15, 20, 3, -18 },
  { 958, 14, 24, 20, 3, -24 },
  { 1000, 18, 24, 20, 1, -24 },
  { 1054, 18, 23, 20, 1, -23 },
  { 1106, 15, 23, 20, 3, -23 },
  { 1150, 16, 24, 20, 2, -24 },
  { 1198, 16, 23, 20, 2, -23 },
  { 1244, 14, 23, 20, 3, -23 },
  { 1285, 14, 23, 20, 3, -23 },
  { 1326, 16, 24, 20, 2, -24 },
  { 1374, 16, 23, 20, 2, -23 },
  { 1420, 14, 23, 20, 3, -23 },
  { 1461, 15, 23, 20, 2, -23 },
  { 1505, 16, 23, 20, 3, -23 },
  { 1551, 15, 23, 20, 3, -23 },
  { 1595, 16, 23, 20, 2, -23 },
  { 1641, 16, 23, 20, 2, -23 },
  { 1687, 16, 24, 20, 2, -24 },
  { 1735, 15, 23, 20, 3, -23 },
  { 1779, 17, 28, 20, 2, -24 },
  { 1839, 15, 23, 20, 3, -23 },
  { 1883, 16, 24, 20, 2, -24 },
  { 1931, 18, 23, 20, 1, -23 },
  { 1983, 16, 23, 20, 2, -23 },
  { 2029, 18, 23, 20, 1, -23 },
  { 2081, 18, 23, 20, 1, -23 },
  { 2133, 18, 23, 20, 1, -23 },
  { 2185, 17, 23, 20, 1, -23 },
  { 2234, 15, 23, 20, 2, -23 },
  { 2278, 6, 32, 20, 7, -27 },
  { 2302, 12, 25, 20, 4, -23 },
  { 2340, 6, 32, 20, 7, -27 },
  { 2364, 12, 12, 20, 4, -23 },
  { 2382, 15, 2, 20, 2, 0 },
  { 2386, 6, 4, 20, 7, -24 },
  { 2389, 14, 18, 20, 3, -18 },
  { 2421, 15, 25, 20, 3, -25 },
  { 2468, 15, 18, 20, 2, -18 },
  { 2502, 15, 25, 20, 2, -25 },
  { 2549, 16, 18, 20, 2, -18 },
  { 2585, 16, 25, 20, 2, -25 },
  { 2635, 15, 25, 20, 2, -18 },
  { 2682, 14, 25, 20, 3, -25 },
  { 2726, 15, 24, 20, 3, -24 },
  { 2771, 11, 31, 20, 3, -24 },
  { 2814, 15, 25, 20, 3, -25 },
  { 2861, 15, 25, 20, 3, -25 },
  { 2908, 17, 18, 20, 1, -18 },
  { 2947, 14, 18, 20, 3, -18 },
  { 2979, 16, 18, 20, 2, -18 },
  { 3015, 15, 25, 20, 3, -18 },
  { 3062, 15, 25, 20, 2, -18 },
  { 3109, 12, 18, 20, 5, -18 },
  { 3136, 14, 18, 20, 3, -18 },
  { 3168, 15, 22, 20, 2, -22 },
  { 3210, 14, 17, 20, 3, -17 },
  { 3240, 16, 17, 20, 2, -17 },
  { 3274, 18, 17, 20, 1, -17 },
  { 3313, 16, 17, 20, 2, -17 },
  { 3347, 18, 24, 20, 1, -17 },
  { 3401, 14, 17, 20, 3, -17 },
  { 3431, 11, 32, 20, 5, -26 },
  { 3475, 2, 29, 20, 9, -23 },
  { 3483, 11, 32, 20, 5, -26 },
  { 3527, 18, 7, 20, 1, -13 },
};

const GFXfont RobotoMono_Regular33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular33pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_REGULAR33PT7B_H_
