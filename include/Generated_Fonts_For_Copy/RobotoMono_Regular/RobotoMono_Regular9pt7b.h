#ifndef _ROBOTOMONO_REGULAR9PT7B_H_
#define _ROBOTOMONO_REGULAR9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x2B, 0xD5, 0xF5, 0x28, 0x4B, 0x9C, 0x39, 0xE4, 0xF5,
  0x98, 0x75, 0x8C, 0x72, 0x88, 0xD9, 0xBC, 0xC0, 0x6A, 0xAA, 0x40, 0xC8,
  0x92, 0x4A, 0x80, 0x4F, 0x6A, 0x4F, 0x44, 0xC0, 0xE0, 0x80, 0x32, 0x24,
  0x48, 0x80, 0xE9, 0xF9, 0x9E, 0xD5, 0x50, 0x74, 0x84, 0x44, 0x7C, 0x79,
  0x31, 0x97, 0x11, 0x94, 0xAF, 0x88, 0xF8, 0xE1, 0x9E, 0xE8, 0xE9, 0x9E,
  0xF8, 0x84, 0x42, 0x20, 0xF9, 0x69, 0x9E, 0xE9, 0x9F, 0x26, 0xC0, 0xC0,
  0xC0, 0xA0, 0x3B, 0x10, 0xFF, 0x86, 0x3C, 0xF1, 0x24, 0x04, 0x7D, 0xF7,
  0xBB, 0x38, 0x21, 0x94, 0xE4, 0xC4, 0xF9, 0xE9, 0x9E, 0x7C, 0x61, 0x04,
  0xB8, 0xE9, 0x99, 0x9E, 0xF8, 0xE8, 0x8F, 0xF8, 0xE8, 0x88, 0x7C, 0x21,
  0x34, 0xBC, 0x99, 0xF9, 0x99, 0xF4, 0x44, 0x4F, 0x08, 0x42, 0x18, 0xB8,
  0xBA, 0xCA, 0xA9, 0x88, 0x88, 0x8F, 0x9B, 0xFD, 0x99, 0x99, 0xDB, 0xB9,
  0x74, 0x63, 0x14, 0xB8, 0xF9, 0x9E, 0x88, 0x74, 0x63, 0x14, 0xB8, 0x20,
  0xF9, 0xBE, 0xA9, 0xF8, 0xC3, 0x9E, 0xF9, 0x08, 0x42, 0x10, 0x99, 0x99,
  0x9E, 0xCA, 0x54, 0xA3, 0x10, 0xAD, 0x5E, 0xB5, 0xA8, 0xCA, 0x88, 0x65,
  0x64, 0xCA, 0x8C, 0x42, 0x10, 0x78, 0x88, 0x44, 0x7C, 0xEA, 0xAB, 0x89,
  0x22, 0x48, 0xD5, 0x57, 0x4E, 0x80, 0xF0, 0x90, 0xE9, 0xF9, 0xF0, 0x88,
  0xE9, 0x99, 0xE0, 0x69, 0x89, 0xE0, 0x11, 0xF9, 0x99, 0xF0, 0x69, 0xF8,
  0xF0, 0x34, 0xF4, 0x44, 0x40, 0xF9, 0x99, 0xF1, 0xE0, 0x88, 0xE9, 0x99,
  0x90, 0x4C, 0x44, 0x4F, 0x3C, 0x92, 0x4E, 0x88, 0xBC, 0xCA, 0x90, 0xC4,
  0x44, 0x44, 0xF0, 0xFD, 0x6B, 0x5A, 0x80, 0xE9, 0x99, 0x90, 0x69, 0x99,
  0xE0, 0xE9, 0x99, 0xE8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xB8, 0x88, 0x80,
  0x69, 0x61, 0xE0, 0x4F, 0x44, 0x47, 0x99, 0x99, 0xF0, 0x8A, 0x54, 0x62,
  0x00, 0xAD, 0x56, 0xB5, 0x00, 0x4A, 0x88, 0x6C, 0x80, 0x8A, 0x54, 0x62,
  0x11, 0x00, 0xF2, 0x48, 0xF0, 0x24, 0xAC, 0x49, 0x20, 0xFF, 0xC9, 0x22,
  0x92, 0x80, 0x45, 0xC0,
};

const GFXglyph RobotoMono_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 5, 2, -7 },
  { 20, 2, 9, 5, 2, -7 },
  { 23, 3, 9, 5, 1, -7 },
  { 27, 4, 4, 5, 1, -6 },
  { 29, 4, 4, 5, 1, -5 },
  { 31, 1, 2, 5, 2, -1 },
  { 32, 3, 1, 5, 1, -3 },
  { 33, 1, 1, 5, 2, -1 },
  { 34, 4, 7, 5, 1, -6 },
  { 38, 4, 6, 5, 1, -6 },
  { 41, 2, 6, 5, 1, -6 },
  { 43, 5, 6, 5, 0, -6 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 4, 6, 5, 1, -6 },
  { 57, 4, 6, 5, 1, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 4, 6, 5, 1, -6 },
  { 70, 2, 5, 5, 2, -5 },
  { 72, 2, 6, 5, 2, -5 },
  { 74, 3, 4, 5, 1, -5 },
  { 76, 4, 2, 5, 1, -4 },
  { 77, 4, 4, 5, 1, -5 },
  { 79, 4, 6, 5, 1, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 1, -6 },
  { 93, 5, 6, 5, 0, -6 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 5, 6, 5, 0, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 5, 7, 5, 0, -6 },
  { 144, 4, 6, 5, 1, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 4, 6, 5, 1, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 2, 8, 5, 2, -7 },
  { 179, 3, 7, 5, 1, -6 },
  { 182, 2, 8, 5, 2, -7 },
  { 184, 3, 3, 5, 1, -6 },
  { 186, 4, 1, 5, 1, 0 },
  { 187, 2, 2, 5, 2, -7 },
  { 188, 4, 5, 5, 1, -5 },
  { 191, 4, 7, 5, 1, -7 },
  { 195, 4, 5, 5, 1, -5 },
  { 198, 4, 7, 5, 1, -7 },
  { 202, 4, 5, 5, 1, -5 },
  { 205, 4, 7, 5, 1, -7 },
  { 209, 4, 7, 5, 1, -5 },
  { 213, 4, 7, 5, 1, -7 },
  { 217, 4, 6, 5, 1, -6 },
  { 220, 3, 8, 5, 1, -6 },
  { 223, 4, 7, 5, 1, -7 },
  { 227, 4, 7, 5, 1, -7 },
  { 231, 5, 5, 5, 0, -5 },
  { 235, 4, 5, 5, 1, -5 },
  { 238, 4, 5, 5, 1, -5 },
  { 241, 4, 7, 5, 1, -5 },
  { 245, 4, 7, 5, 1, -5 },
  { 249, 4, 5, 5, 1, -5 },
  { 252, 4, 5, 5, 1, -5 },
  { 255, 4, 6, 5, 1, -6 },
  { 258, 4, 5, 5, 1, -5 },
  { 261, 5, 5, 5, 0, -5 },
  { 265, 5, 5, 5, 0, -5 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 5, 7, 5, 0, -5 },
  { 278, 4, 5, 5, 1, -5 },
  { 281, 3, 9, 5, 1, -7 },
  { 285, 1, 8, 5, 2, -6 },
  { 286, 3, 9, 5, 1, -7 },
  { 290, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoMono_Regular9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular9pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_REGULAR9PT7B_H_
