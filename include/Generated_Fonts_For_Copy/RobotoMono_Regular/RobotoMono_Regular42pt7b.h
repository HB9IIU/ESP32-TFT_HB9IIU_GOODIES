#ifndef _ROBOTOMONO_REGULAR42PT7B_H_
#define _ROBOTOMONO_REGULAR42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xE0, 0x00, 0x00, 0x00, 0x3D, 0xFF, 0xF8, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x37, 0x06, 0xE0, 0xDC, 0x18, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x81, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x0F, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x9C, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xCF, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xF0, 0x03,
  0xDF, 0x00, 0xF9, 0xF0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x71, 0xC0, 0xE0, 0xE3, 0x81,
  0xC3, 0x8E, 0x01, 0xFF, 0x1C, 0x01, 0xFC, 0x70, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0xC0, 0x03, 0x8F, 0xE0, 0x07, 0x3F, 0xE0, 0x1C, 0x70, 0xE0, 0x39,
  0xC1, 0xC0, 0xE3, 0x83, 0x81, 0xC7, 0x07, 0x07, 0x0E, 0x0E, 0x06, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xC3, 0xC0,
  0x1E, 0x07, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x3C,
  0xF9, 0xE0, 0xF7, 0xC7, 0xC3, 0xDE, 0x0F, 0x0E, 0xF0, 0x1E, 0x3B, 0xC0,
  0x3D, 0xEF, 0x00, 0xFF, 0x3C, 0x01, 0xFC, 0xF0, 0x03, 0xE1, 0xE0, 0x0F,
  0x87, 0xC0, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFE, 0x78, 0x1F, 0xE0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x10, 0x80, 0x30, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x0C, 0x02, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x60, 0x70, 0x67, 0xC7, 0x1E, 0xFF, 0x6F, 0xF7, 0xFF,
  0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0x9E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0x40, 0x20, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x7B, 0xC2, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x03,
  0xC7, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFB,
  0xFC, 0x3E, 0x7F, 0x8F, 0x8F, 0xF7, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0x80, 0x0F,
  0x78, 0x01, 0xCF, 0x00, 0x78, 0xF8, 0x1E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x10, 0x0F, 0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC0, 0xF8, 0x78, 0x07,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x07,
  0xC7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xCF, 0x00, 0x79, 0xF0, 0x1F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF0,
  0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x78,
  0x78, 0x07, 0x83, 0xC0, 0x38, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81,
  0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x03, 0xE0, 0x80, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xF8, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0xF9,
  0xF0, 0x3E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x80,
  0x79, 0xFE, 0x0F, 0x7F, 0xF1, 0xFF, 0xFF, 0x3F, 0x01, 0xE7, 0xC0, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x80, 0xF8,
  0xF8, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x07, 0xC7, 0x80,
  0x78, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC3, 0xE0, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x3E, 0x1F, 0x0F, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0E, 0xF0, 0x03,
  0xDF, 0x00, 0x79, 0xF0, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0,
  0x78, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00,
  0xFB, 0xE0, 0x3F, 0x3E, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xF7, 0x03, 0xF8,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0x8F, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x7E,
  0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0,
  0x07, 0x83, 0x80, 0x07, 0x07, 0x03, 0x87, 0x1C, 0x1F, 0x86, 0x30, 0x7F,
  0x8C, 0x61, 0xC7, 0x19, 0xC7, 0x0E, 0x3B, 0x0E, 0x1C, 0x76, 0x18, 0x30,
  0xEC, 0x70, 0x60, 0xF8, 0xE0, 0xC1, 0xF1, 0xC1, 0x87, 0xE3, 0x83, 0x0D,
  0xC7, 0x06, 0x1B, 0x8E, 0x0C, 0x33, 0x1C, 0x38, 0xE6, 0x3D, 0xF1, 0x8C,
  0x3F, 0x7F, 0x1C, 0x3C, 0x7C, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x02, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x77, 0x80,
  0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xE1, 0xC0, 0x07,
  0x87, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xE0, 0x0F, 0x03,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x71, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x3F, 0xCE, 0x00,
  0x79, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00,
  0x7B, 0x80, 0x0F, 0x70, 0x03, 0xCE, 0x01, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xF8, 0xE0, 0x0F, 0x9C, 0x00, 0xFB, 0x80, 0x0F, 0x70, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xDC, 0x00, 0xFB, 0x80, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3,
  0xE0, 0x1E, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x87, 0xC0, 0xF8,
  0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0x07, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0,
  0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00,
  0xF8, 0xF0, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E,
  0x0F, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F,
  0x78, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x79, 0xF0, 0x03, 0xC7,
  0xC0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x80, 0x78, 0xF8, 0x1F, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x3E, 0xE0,
  0x07, 0xCE, 0x00, 0xF8, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x3E, 0x0E,
  0x07, 0xC0, 0xE0, 0xF8, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x3E, 0x00,
  0xE7, 0xC0, 0x0E, 0xF8, 0x00, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xE0,
  0x0F, 0xCF, 0x00, 0xF8, 0xF8, 0x0F, 0x07, 0x80, 0xE0, 0x3C, 0x0E, 0x03,
  0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x78, 0xE0,
  0x07, 0xCE, 0x00, 0x3E, 0xE0, 0x01, 0xEE, 0x00, 0x1F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xEE, 0x07, 0xFE, 0xE0,
  0xFF, 0xFE, 0x0E, 0xFF, 0x70, 0xEF, 0xF7, 0x1E, 0xFF, 0x71, 0xCF, 0xF7,
  0xBC, 0xFF, 0x3B, 0x8F, 0xF3, 0xB8, 0xFF, 0x3F, 0x8F, 0xF1, 0xF0, 0xFF,
  0x1F, 0x0F, 0xF1, 0xF0, 0xFF, 0x0E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0E, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0xF0, 0x3F, 0xDE, 0x07, 0xF9, 0xE0,
  0xFF, 0x3C, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x87, 0x8F, 0xF0, 0xF1,
  0xFE, 0x0F, 0x3F, 0xC1, 0xE7, 0xF8, 0x1E, 0xFF, 0x03, 0xDF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x0F, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x73, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xF7, 0x00, 0x07, 0xBC, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C,
  0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC1, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x78, 0x0F,
  0xEF, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xBC, 0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xE1, 0xF0, 0x3E, 0x03, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x70, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x79, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF8, 0x07, 0x81, 0xF0, 0x7C, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70,
  0x1F, 0xCE, 0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x0E, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0,
  0x0F, 0x38, 0x0F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0x80,
  0xF0, 0x70, 0x1E, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x00,
  0x78, 0xE0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00,
  0x1F, 0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x07,
  0x8F, 0xC0, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x03, 0xEF, 0x80, 0x78,
  0xF8, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x00,
  0xE0, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3D,
  0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x3C, 0x0E, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x7B, 0x81, 0xE0,
  0xF7, 0x87, 0xC1, 0xEF, 0x0F, 0x83, 0xDE, 0x1F, 0x87, 0x3C, 0x3F, 0x0E,
  0x38, 0x7E, 0x1C, 0x70, 0xFC, 0x38, 0xE3, 0xB8, 0x71, 0xC7, 0x39, 0xE3,
  0x8E, 0x73, 0xC7, 0x9C, 0xE7, 0x8F, 0x39, 0xCE, 0x1E, 0x73, 0x9C, 0x3D,
  0xC7, 0x38, 0x3B, 0x87, 0x70, 0x77, 0x0E, 0xE0, 0xEE, 0x1D, 0xC1, 0xDC,
  0x3B, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x0F, 0x00, 0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3C, 0x03,
  0xC1, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x07,
  0xCF, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0x7B,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x78, 0x1C, 0x70,
  0x78, 0xF0, 0xF0, 0xE1, 0xC1, 0xE7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x78, 0x3C,
  0x1E, 0x0F, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0xC7,
  0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x1C, 0xF0, 0x03, 0x9C,
  0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x7B, 0xE0, 0x1F, 0x3E,
  0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFB, 0xC3, 0xFC, 0x78, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x10, 0x0E, 0x7F, 0xC3, 0xBF, 0xF8,
  0xFF, 0xFF, 0x3F, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1E,
  0xFC, 0x1F, 0xBF, 0xFF, 0xCE, 0xFF, 0xE3, 0x8F, 0xE0, 0x00, 0x60, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x1F, 0x03, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x38, 0x3C, 0x1F, 0xE7, 0x8F, 0xFE, 0xF3, 0xFF, 0xFE, 0x7C,
  0x0F, 0xDE, 0x00, 0xFB, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0x78, 0x3F, 0xCF, 0x00, 0x60, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x11, 0xF0, 0x03, 0x1F, 0x01, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0x01, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF3, 0xE0, 0x7E, 0xF0,
  0x07, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x07, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFB, 0xC1, 0xFE, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0xC0, 0x0F, 0x3C, 0x03, 0xC7, 0xF3, 0xF8, 0x7F, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x0C, 0x0E, 0x3F, 0xE3, 0x9F, 0xFC, 0xEF, 0xFF, 0xBF, 0x03, 0xEF, 0x00,
  0x7B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xA0, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0B,
  0x80, 0x3E, 0x70, 0x0F, 0x8E, 0x03, 0xE1, 0xC0, 0xF8, 0x38, 0x3E, 0x07,
  0x0F, 0x80, 0xE3, 0xE0, 0x1C, 0x78, 0x03, 0x9E, 0x00, 0x77, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0x87, 0x80, 0xE0, 0xF8, 0x1C,
  0x0F, 0x83, 0x80, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0xF1, 0xC0, 0x1F, 0x38,
  0x01, 0xF7, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x87, 0x3F,
  0x3F, 0xBB, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xF8, 0x3C, 0x1F,
  0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC, 0x1C,
  0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xFE,
  0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0,
  0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xE0, 0x00, 0x30, 0x38,
  0xFF, 0x8E, 0x7F, 0xF3, 0xBF, 0xFE, 0xFC, 0x0F, 0xBE, 0x01, 0xEF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0x80, 0x03, 0xDC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xB8,
  0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x78, 0x3E, 0x07, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x40, 0x39, 0xFF, 0x0E, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8,
  0x1F, 0xBC, 0x01, 0xEE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xEF, 0x00, 0x7B, 0xE0, 0x7C, 0xFF,
  0xFF, 0x3B, 0xFF, 0x8E, 0x7F, 0x83, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF3,
  0xE0, 0x7E, 0xF8, 0x07, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x9F,
  0x03, 0xF3, 0xFF, 0xFE, 0x3F, 0xFB, 0xC1, 0xFE, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x39, 0xC3, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x78,
  0x0F, 0x9C, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xF0, 0x1E, 0x7F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xF7, 0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0xFB,
  0xC7, 0xF8, 0xF0, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0x70,
  0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x70, 0x07, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x78,
  0xF0, 0x01, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x7B, 0xC0, 0x01, 0xDC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0xE0, 0x38, 0x0F, 0xE0, 0x70, 0x1D, 0xC0, 0xF0, 0x3B, 0x81, 0xE0,
  0xF7, 0x07, 0xC1, 0xCE, 0x0F, 0x83, 0x9E, 0x1B, 0x87, 0x1C, 0x37, 0x0E,
  0x38, 0xEE, 0x1C, 0x71, 0xCC, 0x70, 0xE3, 0x9C, 0xE1, 0xE6, 0x39, 0xC1,
  0xDC, 0x73, 0x83, 0xB8, 0x67, 0x07, 0x70, 0xEC, 0x0E, 0xC1, 0xF8, 0x0F,
  0x83, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xF8, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x80,
  0x78, 0x3E, 0x07, 0x80, 0xF0, 0x7C, 0x03, 0xC3, 0xC0, 0x0F, 0x3C, 0x00,
  0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0x7C, 0x00, 0xF1, 0xE0, 0x0F,
  0x87, 0x80, 0x78, 0x1E, 0x07, 0x80, 0xF8, 0x7C, 0x03, 0xC7, 0xC0, 0x0F,
  0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xF1,
  0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xF7,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x0F, 0x81, 0xF8, 0x0F, 0x80,
  0x7E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0xFC,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x03, 0xE0, 0x1E, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x08, 0x7F, 0xE0,
  0x1D, 0xFF, 0xE0, 0x3B, 0x87, 0xE0, 0xFE, 0x03, 0xFF, 0xDC, 0x03, 0xFF,
  0x88, 0x01, 0xFE, 0x00, 0x00, 0xF0,
};

const GFXglyph RobotoMono_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 30, 25, 10, -30 },
  { 20, 11, 10, 25, 7, -32 },
  { 34, 23, 30, 25, 1, -30 },
  { 121, 19, 39, 25, 3, -35 },
  { 214, 23, 30, 25, 1, -30 },
  { 301, 22, 30, 25, 2, -30 },
  { 384, 3, 10, 25, 10, -32 },
  { 388, 11, 44, 25, 7, -34 },
  { 449, 10, 44, 25, 7, -34 },
  { 504, 20, 20, 25, 3, -30 },
  { 554, 21, 22, 25, 2, -25 },
  { 612, 6, 11, 25, 7, -4 },
  { 621, 16, 4, 25, 4, -15 },
  { 629, 6, 5, 25, 10, -5 },
  { 633, 16, 33, 25, 5, -30 },
  { 699, 19, 30, 25, 3, -30 },
  { 771, 12, 30, 25, 4, -30 },
  { 816, 20, 30, 25, 2, -30 },
  { 891, 19, 30, 25, 2, -30 },
  { 963, 21, 30, 25, 2, -30 },
  { 1042, 19, 30, 25, 4, -30 },
  { 1114, 19, 30, 25, 3, -30 },
  { 1186, 20, 30, 25, 2, -30 },
  { 1261, 19, 30, 25, 4, -30 },
  { 1333, 19, 30, 25, 3, -30 },
  { 1405, 6, 23, 25, 11, -23 },
  { 1423, 7, 30, 25, 10, -23 },
  { 1450, 18, 19, 25, 3, -23 },
  { 1493, 18, 12, 25, 4, -19 },
  { 1520, 18, 19, 25, 4, -23 },
  { 1563, 18, 30, 25, 4, -30 },
  { 1631, 23, 30, 25, 1, -30 },
  { 1718, 22, 30, 25, 2, -30 },
  { 1801, 19, 30, 25, 4, -30 },
  { 1873, 21, 30, 25, 2, -30 },
  { 1952, 20, 30, 25, 3, -30 },
  { 2027, 18, 30, 25, 4, -30 },
  { 2095, 18, 30, 25, 4, -30 },
  { 2163, 21, 30, 25, 2, -30 },
  { 2242, 19, 30, 25, 3, -30 },
  { 2314, 18, 30, 25, 4, -30 },
  { 2382, 19, 30, 25, 2, -30 },
  { 2454, 20, 30, 25, 4, -30 },
  { 2529, 18, 30, 25, 4, -30 },
  { 2597, 20, 30, 25, 3, -30 },
  { 2672, 19, 30, 25, 3, -30 },
  { 2744, 21, 30, 25, 2, -30 },
  { 2823, 19, 30, 25, 4, -30 },
  { 2895, 22, 35, 25, 2, -30 },
  { 2992, 19, 30, 25, 4, -30 },
  { 3064, 21, 30, 25, 2, -30 },
  { 3143, 22, 30, 25, 2, -30 },
  { 3226, 19, 30, 25, 3, -30 },
  { 3298, 23, 30, 25, 1, -30 },
  { 3385, 23, 30, 25, 1, -30 },
  { 3472, 22, 30, 25, 2, -30 },
  { 3555, 22, 30, 25, 1, -30 },
  { 3638, 20, 30, 25, 2, -30 },
  { 3713, 8, 40, 25, 9, -34 },
  { 3753, 16, 33, 25, 5, -30 },
  { 3819, 8, 40, 25, 8, -34 },
  { 3859, 15, 16, 25, 5, -30 },
  { 3889, 19, 3, 25, 3, 0 },
  { 3897, 8, 5, 25, 9, -30 },
  { 3902, 19, 23, 25, 3, -23 },
  { 3957, 18, 32, 25, 4, -32 },
  { 4029, 19, 23, 25, 3, -23 },
  { 4084, 19, 32, 25, 3, -32 },
  { 4160, 19, 23, 25, 3, -23 },
  { 4215, 20, 32, 25, 3, -32 },
  { 4295, 19, 32, 25, 3, -23 },
  { 4371, 18, 32, 25, 4, -32 },
  { 4443, 19, 30, 25, 4, -30 },
  { 4515, 14, 39, 25, 4, -30 },
  { 4584, 19, 32, 25, 4, -32 },
  { 4660, 19, 32, 25, 4, -32 },
  { 4736, 21, 23, 25, 2, -23 },
  { 4797, 18, 23, 25, 4, -23 },
  { 4849, 21, 23, 25, 2, -23 },
  { 4910, 18, 32, 25, 4, -23 },
  { 4982, 19, 32, 25, 3, -23 },
  { 5058, 15, 23, 25, 7, -23 },
  { 5102, 18, 23, 25, 4, -23 },
  { 5154, 19, 28, 25, 3, -28 },
  { 5221, 18, 22, 25, 4, -22 },
  { 5271, 21, 22, 25, 2, -22 },
  { 5329, 23, 22, 25, 1, -22 },
  { 5393, 21, 22, 25, 2, -22 },
  { 5451, 23, 31, 25, 1, -22 },
  { 5541, 19, 22, 25, 3, -22 },
  { 5594, 13, 41, 25, 7, -33 },
  { 5661, 3, 38, 25, 11, -30 },
  { 5676, 13, 41, 25, 7, -33 },
  { 5743, 23, 8, 25, 1, -16 },
};

const GFXfont RobotoMono_Regular42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular42pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_REGULAR42PT7B_H_
