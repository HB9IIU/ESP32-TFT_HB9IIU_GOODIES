#ifndef _ROBOTOMONO_REGULAR23PT7B_H_
#define _ROBOTOMONO_REGULAR23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x3B, 0xCF, 0x3C, 0xF3, 0x88, 0x0C,
  0x60, 0xC4, 0x0C, 0x40, 0xCC, 0x7F, 0xF7, 0xFF, 0x18, 0x81, 0x88, 0x19,
  0x81, 0x18, 0xFF, 0xE3, 0x18, 0x31, 0x03, 0x10, 0x23, 0x06, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xFE, 0x73, 0x98, 0x3E, 0x0F, 0x83, 0x60, 0x1E, 0x03,
  0xE0, 0x3E, 0x01, 0xC0, 0x3C, 0x0F, 0x03, 0xE0, 0xDF, 0xE3, 0xF0, 0x30,
  0x0C, 0x00, 0x10, 0x03, 0xE0, 0x11, 0x00, 0x8C, 0xCC, 0x64, 0x22, 0x61,
  0xF6, 0x02, 0x30, 0x03, 0x00, 0x10, 0x01, 0x9C, 0x09, 0xB0, 0xD8, 0x84,
  0xC4, 0x66, 0x20, 0x13, 0x00, 0xF0, 0x06, 0x01, 0xF0, 0x39, 0x83, 0x18,
  0x31, 0x83, 0x18, 0x37, 0x01, 0xE0, 0x1C, 0x03, 0xE3, 0x66, 0x3E, 0x33,
  0xC1, 0xEC, 0x1E, 0x60, 0xC7, 0xBE, 0x3F, 0x30, 0xF8, 0x0C, 0x61, 0x0C,
  0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x86, 0x0C,
  0x18, 0x60, 0xC0, 0x83, 0x06, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x61, 0xC7,
  0x1C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x63, 0x08, 0x00, 0x0C, 0x01, 0x80,
  0x30, 0x66, 0x6F, 0xFE, 0x3E, 0x07, 0x80, 0xD8, 0x33, 0x0C, 0x30, 0x84,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x6D, 0xBC, 0x80, 0xFF, 0xFF,
  0xC0, 0xDF, 0x80, 0x03, 0x81, 0x80, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x00, 0x0C,
  0x0F, 0xC6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x1F, 0xCE, 0xF6, 0x3F,
  0x0F, 0x83, 0xC0, 0xF0, 0x3E, 0x19, 0xCE, 0x3F, 0x00, 0x0E, 0x7F, 0xDC,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C,
  0x07, 0xF1, 0xC7, 0x60, 0x6C, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0xFF, 0xFF, 0xE0, 0x0C,
  0x0F, 0xE7, 0x1F, 0x83, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x1F, 0x07, 0xE0,
  0x0C, 0x03, 0x00, 0xF0, 0x3E, 0x0D, 0xEE, 0x3F, 0x00, 0x01, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x0D, 0x81, 0x98, 0x19, 0x83, 0x18, 0x61, 0x86, 0x18,
  0xC1, 0x8F, 0xFF, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x7F, 0xDF, 0xF6,
  0x01, 0x80, 0x60, 0x1B, 0x87, 0xF9, 0x87, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xC0, 0xD8, 0x37, 0xB8, 0xFC, 0x1F, 0x0F, 0xC7, 0x01, 0x80, 0xC0, 0x33,
  0x8F, 0xF3, 0x8E, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x67, 0xF8,
  0xFC, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x0C,
  0x0F, 0xC7, 0x19, 0x83, 0xC0, 0xF0, 0x36, 0x0D, 0xCE, 0x1F, 0x1C, 0xE6,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0D, 0xEE, 0x3F, 0x00, 0x0C, 0x0F, 0xC6,
  0x3B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xD8, 0xF7, 0xEC, 0x23,
  0x01, 0x80, 0x60, 0x70, 0xF8, 0x3C, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x77, 0x70, 0x00, 0x00, 0x00, 0x07, 0x77, 0x66, 0xC0, 0x00, 0x83, 0xC7,
  0xCF, 0x0E, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0x80, 0x40, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xC0, 0xF1, 0xF3, 0xE0, 0xE0, 0x20, 0x00, 0x0C, 0x0F, 0xC7, 0x3B, 0x07,
  0x00, 0xC0, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x1F, 0x83, 0x0C, 0x60, 0x24, 0x73, 0xCD,
  0x9C, 0x99, 0x99, 0x99, 0x11, 0x91, 0x19, 0x13, 0x9B, 0x2D, 0xFE, 0xC0,
  0x06, 0x00, 0x39, 0x81, 0xF0, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0D,
  0x01, 0x98, 0x19, 0x81, 0x98, 0x30, 0xC3, 0x0C, 0x3F, 0xC7, 0xFE, 0x60,
  0x66, 0x06, 0xC0, 0x3C, 0x03, 0xFF, 0x18, 0x73, 0x03, 0x60, 0x6C, 0x0D,
  0x81, 0xB0, 0xE7, 0xF8, 0xC3, 0x98, 0x1B, 0x03, 0x60, 0x7C, 0x0D, 0x83,
  0xBF, 0xE7, 0xF8, 0x06, 0x01, 0xF8, 0x30, 0xC6, 0x06, 0x60, 0x6E, 0x07,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x76, 0x06,
  0x70, 0xE3, 0x9C, 0x1F, 0x80, 0xFE, 0x18, 0xF3, 0x06, 0x60, 0x6C, 0x0D,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x0D, 0x87,
  0x3F, 0xC7, 0xE0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x06, 0x01, 0xF8, 0x38, 0xC6,
  0x06, 0x60, 0x6C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x3F, 0xC3, 0xFC,
  0x03, 0x60, 0x36, 0x03, 0x70, 0x73, 0xFE, 0x1F, 0x80, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xE0, 0x3C, 0x0E, 0xC1, 0x9F, 0xE0, 0xF8, 0xC0,
  0xF8, 0x33, 0x0E, 0x63, 0x8C, 0x61, 0x98, 0x36, 0x07, 0xE0, 0xFC, 0x1C,
  0xC3, 0x1C, 0x61, 0x8C, 0x19, 0x83, 0xB0, 0x36, 0x07, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xF3, 0xFC,
  0xFD, 0x6F, 0x7B, 0xDC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xF6, 0x3D, 0x8F, 0x33, 0xCC,
  0xF1, 0xBC, 0x6F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x03, 0x06, 0x01, 0xF8,
  0x39, 0xC6, 0x0E, 0x60, 0x6E, 0x06, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x06, 0x60, 0x66, 0x06, 0x70, 0xC3, 0xFC, 0x1F, 0x80, 0xFF,
  0x98, 0x3B, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x36, 0x0E, 0xFF, 0x98,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x06, 0x01, 0xF8,
  0x39, 0xC6, 0x0E, 0x60, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x66, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0xC0, 0x0E,
  0x00, 0x70, 0x02, 0xFF, 0x18, 0x73, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0,
  0x36, 0x1C, 0xFF, 0x18, 0xE3, 0x0C, 0x61, 0xCC, 0x19, 0x83, 0xB0, 0x36,
  0x07, 0x06, 0x01, 0xFC, 0x38, 0xE6, 0x06, 0x60, 0x76, 0x00, 0x70, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x06, 0xC0, 0x76, 0x07, 0x70, 0x63,
  0xFE, 0x1F, 0x80, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x77, 0xF8, 0xFC, 0xC0,
  0x7E, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x19,
  0x81, 0x98, 0x1B, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0xF3, 0xCF, 0x34, 0xF3, 0x6D, 0x26, 0x96, 0x69,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x0E, 0x30, 0xC3, 0x0C, 0xE0,
  0x77, 0x06, 0x30, 0xC3, 0x9C, 0x19, 0x80, 0xF8, 0x0F, 0x00, 0x60, 0x0F,
  0x00, 0xF0, 0x19, 0x81, 0x98, 0x30, 0xC7, 0x0E, 0x60, 0x6E, 0x07, 0xC0,
  0x76, 0x06, 0x60, 0xC3, 0x0C, 0x31, 0x81, 0x98, 0x1B, 0x00, 0xF0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF,
  0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06,
  0x03, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xF0, 0x18, 0x38, 0x3C, 0x2C, 0x66, 0x66, 0xC2, 0xC3, 0xFF, 0xFF,
  0xF0, 0xC6, 0x30, 0x3F, 0x18, 0xEC, 0x1C, 0x03, 0x00, 0xDF, 0xFE, 0x0F,
  0x03, 0xC0, 0xF0, 0x7F, 0xFD, 0xFB, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x37, 0xCF, 0x3B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x1F, 0xFE, 0xDF, 0x00, 0x3F, 0x1C, 0xEE, 0x0F, 0x03, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xF8, 0x37, 0xB8, 0xFC, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xCF, 0xB7, 0x3F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x1D, 0xFF, 0x3E, 0xC0, 0x3F, 0x1C, 0xEE, 0x1F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x38, 0x37, 0xBC, 0xFC, 0x03, 0xC1, 0xFC, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x3F, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3E, 0xDC, 0xFE,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x77, 0xFC, 0xFB,
  0x00, 0xD0, 0x7C, 0x19, 0xFC, 0x1E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x37, 0xEF, 0x3B, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x04, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3,
  0xFF, 0xFF, 0xC0, 0x02, 0x07, 0x06, 0x00, 0x00, 0x7E, 0x7E, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0xFC,
  0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0, 0xC6, 0x30,
  0xCC, 0x1B, 0x03, 0xE0, 0x76, 0x0C, 0x61, 0x8E, 0x30, 0xE6, 0x0C, 0xC0,
  0xE0, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0xFD,
  0xEE, 0xF7, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xDF, 0xBC, 0xEE, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x1F, 0x87, 0x39, 0x83,
  0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x60, 0x6E, 0x1C, 0xEF, 0x0F,
  0xC0, 0xDF, 0x3C, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7F, 0x7B, 0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3E,
  0xDC, 0xFE, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x77,
  0x7C, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xDF, 0xFF, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x1C, 0xEE,
  0x0F, 0x80, 0x70, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x37, 0xB8, 0xFC,
  0x18, 0x06, 0x01, 0x83, 0xFF, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0xF0, 0xFC, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x77, 0xFC, 0xFB, 0xC0, 0x76,
  0x06, 0x60, 0x63, 0x0C, 0x30, 0xC3, 0x18, 0x19, 0x81, 0x98, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x60, 0x86, 0x3C, 0x63, 0xC6, 0x3C, 0xF3, 0x4F, 0x24,
  0xB2, 0x69, 0x67, 0x9E, 0x79, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0xE0, 0x73,
  0x0C, 0x39, 0xC1, 0x98, 0x0F, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x19, 0x83,
  0x0C, 0x70, 0xEE, 0x07, 0xC0, 0x76, 0x06, 0x60, 0x67, 0x0C, 0x30, 0xC3,
  0x1C, 0x19, 0x81, 0x98, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x1C, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0F, 0xFF, 0xFF, 0x06, 0x18, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x63, 0x87, 0x03, 0x03, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x78, 0x71, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x86, 0x18, 0x00, 0x78, 0x2F, 0xC1, 0xC7, 0x38, 0x3E,
};

const GFXglyph RobotoMono_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 16, 14, 5, -16 },
  { 7, 6, 5, 14, 4, -17 },
  { 11, 12, 16, 14, 1, -16 },
  { 35, 10, 21, 14, 2, -19 },
  { 62, 13, 17, 14, 0, -17 },
  { 90, 12, 17, 14, 1, -17 },
  { 116, 1, 5, 14, 6, -17 },
  { 117, 6, 23, 14, 4, -18 },
  { 135, 6, 23, 14, 4, -18 },
  { 153, 11, 11, 14, 2, -16 },
  { 169, 12, 12, 14, 1, -14 },
  { 187, 3, 6, 14, 4, -2 },
  { 190, 9, 2, 14, 2, -8 },
  { 193, 3, 3, 14, 6, -3 },
  { 195, 9, 17, 14, 3, -16 },
  { 215, 10, 17, 14, 2, -17 },
  { 237, 7, 16, 14, 2, -16 },
  { 251, 11, 17, 14, 1, -17 },
  { 275, 10, 17, 14, 1, -17 },
  { 297, 12, 16, 14, 1, -16 },
  { 321, 10, 16, 14, 2, -16 },
  { 341, 10, 16, 14, 2, -16 },
  { 361, 11, 16, 14, 1, -16 },
  { 383, 10, 17, 14, 2, -17 },
  { 405, 10, 17, 14, 2, -17 },
  { 427, 3, 13, 14, 6, -13 },
  { 432, 4, 17, 14, 5, -13 },
  { 441, 9, 10, 14, 2, -12 },
  { 453, 10, 7, 14, 2, -11 },
  { 462, 10, 10, 14, 2, -12 },
  { 475, 10, 17, 14, 2, -17 },
  { 497, 12, 16, 14, 1, -16 },
  { 521, 12, 16, 14, 1, -16 },
  { 545, 11, 16, 14, 2, -16 },
  { 567, 12, 17, 14, 1, -17 },
  { 593, 11, 16, 14, 2, -16 },
  { 615, 10, 16, 14, 2, -16 },
  { 635, 10, 16, 14, 2, -16 },
  { 655, 12, 17, 14, 1, -17 },
  { 681, 10, 16, 14, 2, -16 },
  { 701, 10, 16, 14, 2, -16 },
  { 721, 11, 16, 14, 1, -16 },
  { 743, 11, 16, 14, 2, -16 },
  { 765, 10, 16, 14, 2, -16 },
  { 785, 10, 16, 14, 2, -16 },
  { 805, 10, 16, 14, 2, -16 },
  { 825, 12, 17, 14, 1, -17 },
  { 851, 11, 16, 14, 2, -16 },
  { 873, 12, 20, 14, 1, -17 },
  { 903, 11, 16, 14, 2, -16 },
  { 925, 12, 17, 14, 1, -17 },
  { 951, 12, 16, 14, 1, -16 },
  { 975, 10, 16, 14, 2, -16 },
  { 995, 12, 16, 14, 1, -16 },
  { 1019, 12, 16, 14, 1, -16 },
  { 1043, 12, 16, 14, 1, -16 },
  { 1067, 12, 16, 14, 1, -16 },
  { 1091, 11, 16, 14, 1, -16 },
  { 1113, 4, 23, 14, 5, -19 },
  { 1125, 8, 17, 14, 3, -16 },
  { 1142, 4, 23, 14, 5, -19 },
  { 1154, 8, 8, 14, 3, -16 },
  { 1162, 10, 2, 14, 2, 0 },
  { 1165, 4, 3, 14, 5, -17 },
  { 1167, 10, 12, 14, 2, -12 },
  { 1182, 10, 17, 14, 2, -17 },
  { 1204, 10, 12, 14, 2, -12 },
  { 1219, 10, 17, 14, 2, -17 },
  { 1241, 10, 12, 14, 2, -12 },
  { 1256, 11, 18, 14, 2, -18 },
  { 1281, 10, 17, 14, 2, -12 },
  { 1303, 10, 17, 14, 2, -17 },
  { 1325, 10, 17, 14, 2, -17 },
  { 1347, 8, 22, 14, 2, -17 },
  { 1369, 11, 17, 14, 2, -17 },
  { 1393, 10, 17, 14, 2, -17 },
  { 1415, 12, 12, 14, 1, -12 },
  { 1433, 10, 12, 14, 2, -12 },
  { 1448, 11, 12, 14, 1, -12 },
  { 1465, 10, 17, 14, 2, -12 },
  { 1487, 10, 17, 14, 2, -12 },
  { 1509, 8, 12, 14, 4, -12 },
  { 1521, 10, 12, 14, 2, -12 },
  { 1536, 10, 15, 14, 2, -15 },
  { 1555, 10, 12, 14, 2, -12 },
  { 1570, 12, 12, 14, 1, -12 },
  { 1588, 12, 12, 14, 1, -12 },
  { 1606, 12, 12, 14, 1, -12 },
  { 1624, 12, 17, 14, 1, -12 },
  { 1650, 10, 12, 14, 2, -12 },
  { 1665, 7, 22, 14, 4, -18 },
  { 1685, 2, 20, 14, 6, -16 },
  { 1690, 7, 22, 14, 4, -18 },
  { 1710, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_Regular23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular23pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_REGULAR23PT7B_H_
