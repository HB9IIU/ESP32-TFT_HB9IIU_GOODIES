#ifndef _ROBOTOMONO_REGULAR61PT7B_H_
#define _ROBOTOMONO_REGULAR61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xBF,
  0xFE, 0xFD, 0xF0, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7,
  0x81, 0xEF, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xF0, 0x0C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x1F,
  0x00, 0xF8, 0x0F, 0x07, 0x80, 0x1E, 0x03, 0xC3, 0xC0, 0x07, 0xC1, 0xF0,
  0xF0, 0x00, 0xFF, 0xF8, 0x78, 0x00, 0x3F, 0xFC, 0x1E, 0x00, 0x07, 0xFE,
  0x0F, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x0F, 0x0F,
  0xFF, 0x80, 0x07, 0xC7, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x7C, 0x00, 0xF8,
  0xF8, 0x0F, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0xF0, 0x07,
  0x83, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0,
  0x18, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x3E, 0x0F, 0xE7, 0xE0, 0x1F, 0x0F, 0xE1, 0xF8,
  0x0F, 0x87, 0xE0, 0x7E, 0x07, 0xC7, 0xE0, 0x3F, 0x83, 0xE3, 0xF0, 0x0F,
  0xC1, 0xF3, 0xF0, 0x03, 0xF1, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0xFC, 0x00,
  0x7F, 0xFC, 0x7E, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x07, 0xFE, 0x1F, 0x80,
  0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0xFC, 0x07, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x04, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x60, 0x0F, 0x00, 0x67, 0xC0, 0xF0, 0x1E, 0x7F, 0x0F, 0x0F,
  0xFF, 0xFE, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x01, 0xC0,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E,
  0x7C, 0xFC, 0xF8, 0xF0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0xFC, 0x07, 0xF1,
  0xFF, 0xC0, 0xFE, 0x1F, 0xFC, 0x1F, 0xC1, 0xFF, 0xC7, 0xF8, 0x1F, 0xFC,
  0xFE, 0x01, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x07,
  0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xF0, 0x07, 0xF8,
  0x7C, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC3,
  0xFF, 0x00, 0x7C, 0x7F, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0x07, 0xF8, 0xFF, 0xC0, 0x1F, 0xCF, 0xF0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xF3, 0xF8, 0x03, 0xFF,
  0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFB, 0xE0, 0x3F,
  0xFF, 0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x00, 0xC0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x8F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F,
  0x82, 0x00, 0x0F, 0x03, 0xF8, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF0,
  0xFC, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83,
  0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE3, 0xFC, 0x07, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0xFE, 0x0F, 0x07, 0x81, 0xFF,
  0x83, 0x87, 0x81, 0xFF, 0xE1, 0xE3, 0xC0, 0xF8, 0xF0, 0x71, 0xC0, 0xF0,
  0x78, 0x39, 0xE0, 0xF0, 0x3C, 0x1C, 0xF0, 0x78, 0x1E, 0x0E, 0x70, 0x38,
  0x0E, 0x07, 0x38, 0x3C, 0x07, 0x03, 0xFC, 0x1E, 0x03, 0x81, 0xFE, 0x0E,
  0x01, 0xC0, 0xFF, 0x07, 0x00, 0xE0, 0x77, 0x87, 0x80, 0x70, 0x3B, 0xC3,
  0xC0, 0x38, 0x1D, 0xE1, 0xE0, 0x1C, 0x0E, 0xF0, 0xF0, 0x1E, 0x07, 0x78,
  0x78, 0x0F, 0x03, 0xBC, 0x3C, 0x07, 0x83, 0x9E, 0x1E, 0x07, 0xC1, 0xCF,
  0x07, 0x87, 0xE1, 0xE3, 0x83, 0xFF, 0xF1, 0xE1, 0xC1, 0xFF, 0xBF, 0xF0,
  0xF0, 0x7F, 0x9F, 0xF0, 0x78, 0x1F, 0x87, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x18, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xE0,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x03, 0xFC,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0xFF, 0xE0, 0x7C, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x03,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7F, 0x0F, 0x80, 0x07, 0xF8, 0x7C, 0x00,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x7C, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xF7,
  0xE0, 0x00, 0xFF, 0x8F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x7E,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xDE, 0x01, 0xF7, 0xFE, 0xF8, 0x0F, 0xBF, 0xF7, 0xC0, 0x7D, 0xFF,
  0x9E, 0x07, 0xCF, 0xFC, 0xF8, 0x3E, 0x7F, 0xF7, 0xC1, 0xE3, 0xFF, 0x9E,
  0x1F, 0x1F, 0xFC, 0xF8, 0xF8, 0xFF, 0xE7, 0xC7, 0x87, 0xFF, 0x1E, 0x7C,
  0x3F, 0xF8, 0xFB, 0xE1, 0xFF, 0xC7, 0xDE, 0x0F, 0xFE, 0x1F, 0xF0, 0x7F,
  0xF0, 0xFF, 0x87, 0xFF, 0x87, 0xF8, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8,
  0x1F, 0xFE, 0x07, 0x80, 0xFF, 0xF0, 0x1C, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xF8,
  0x01, 0xFF, 0xDF, 0x80, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xCF, 0xC0, 0x1F,
  0xFC, 0x7E, 0x01, 0xFF, 0xC7, 0xE0, 0x1F, 0xFC, 0x3F, 0x01, 0xFF, 0xC1,
  0xF0, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0xC1,
  0xFF, 0xC0, 0x7C, 0x1F, 0xFC, 0x07, 0xE1, 0xFF, 0xC0, 0x3E, 0x1F, 0xFC,
  0x03, 0xF1, 0xFF, 0xC0, 0x1F, 0x1F, 0xFC, 0x01, 0xF9, 0xFF, 0xC0, 0x0F,
  0x9F, 0xFC, 0x00, 0xFD, 0xFF, 0xC0, 0x07, 0xDF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xFC, 0xF8, 0x00,
  0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F,
  0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x17,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xDF, 0x00,
  0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x01, 0xF7, 0xC0, 0x7F, 0x01, 0xFB, 0xE0,
  0x3F, 0x80, 0xF9, 0xF0, 0x1F, 0xC0, 0x7C, 0xF8, 0x0F, 0xE0, 0x3E, 0x7C,
  0x07, 0xF8, 0x1F, 0x3E, 0x03, 0xFC, 0x0F, 0x9F, 0x83, 0xFE, 0x07, 0xC7,
  0xC1, 0xFF, 0x03, 0xE3, 0xE0, 0xF7, 0x81, 0xF1, 0xF0, 0x7B, 0xE0, 0xF8,
  0xF8, 0x3D, 0xF0, 0xF8, 0x7C, 0x1E, 0x78, 0x7C, 0x3E, 0x1F, 0x3C, 0x3E,
  0x1F, 0x0F, 0x1E, 0x1F, 0x0F, 0x87, 0x8F, 0x0F, 0x83, 0xE3, 0xC7, 0xC7,
  0xC1, 0xF1, 0xE3, 0xE3, 0xE0, 0xF9, 0xF0, 0xF1, 0xF0, 0x7C, 0xF8, 0x78,
  0xF0, 0x3E, 0x78, 0x3C, 0xF8, 0x1F, 0x3C, 0x1E, 0x7C, 0x0F, 0x9E, 0x0F,
  0xBE, 0x07, 0xCF, 0x07, 0xDF, 0x01, 0xEF, 0x81, 0xEF, 0x80, 0xF7, 0xC0,
  0xF7, 0xC0, 0x7F, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0x1F,
  0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xE7, 0xFC, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0,
  0x7F, 0xFE, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0x06, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x7F, 0xF0, 0x0F, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0x8F, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xE0, 0xF8, 0xFF, 0xFC, 0x0F,
  0x87, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0xF8, 0xF8, 0x1F, 0xFF, 0x9F,
  0x07, 0xFF, 0xFB, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0x9F, 0xC0,
  0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xE3, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFD, 0xF0, 0x3F,
  0xFF, 0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x0F, 0xE0, 0x00, 0x78, 0x3F,
  0x80, 0x07, 0xE0, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x08, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x7C, 0x0F,
  0xFF, 0xCF, 0x83, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F,
  0xCF, 0xE0, 0x07, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0xF8, 0x1F, 0xFF, 0x9F, 0x00, 0xFF, 0xC3, 0xE0, 0x03, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x10, 0x00, 0x0F,
  0xC7, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x83, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x0F, 0xFF, 0x07, 0xE3, 0xFF, 0xF0, 0xFD, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0x80, 0xFE, 0x7F, 0xC0, 0x0F, 0xEF,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x13, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xC1, 0xF3,
  0xFE, 0x3F, 0xE3, 0xEF, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x83, 0xFE, 0x1F, 0xFE, 0x03, 0xF8, 0x1F, 0xFC, 0x03,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F,
  0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8,
  0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F,
  0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F,
  0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0xFF, 0x83, 0xE3, 0xFF,
  0xF8, 0x7C, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF, 0xF9, 0xFF, 0xC0, 0x7F, 0x3F,
  0xE0, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x81, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0x0F, 0xFE, 0x03, 0xE7, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xCF, 0xFC, 0x0F,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xC0, 0xFC,
  0x7F, 0xF0, 0x1F, 0x80, 0x70, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x7C, 0x0F, 0xFF, 0xCF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC0, 0x7F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0x9F, 0x00, 0xFF, 0xE3, 0xE0, 0x03,
  0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x07, 0xF3, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFB, 0xEF, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xE3, 0xFC, 0x03, 0xFC,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x0E, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7E,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x03, 0xFC, 0xFF, 0x03, 0xFF,
  0x1F, 0xFF, 0xF7, 0xC3, 0xFF, 0xF9, 0xF0, 0x7F, 0xFC, 0x7C, 0x0F, 0xFE,
  0x1F, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xDF, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x7D, 0xF0, 0x07,
  0xC0, 0x1F, 0x7C, 0x03, 0xF0, 0x07, 0x8F, 0x00, 0xFE, 0x01, 0xE3, 0xE0,
  0x3F, 0x80, 0xF8, 0xF8, 0x0F, 0xE0, 0x3E, 0x3E, 0x07, 0xB8, 0x0F, 0x8F,
  0x81, 0xEF, 0x03, 0xC1, 0xE0, 0x7B, 0xC0, 0xF0, 0x78, 0x1E, 0xF0, 0x3C,
  0x1F, 0x0F, 0xBC, 0x1F, 0x07, 0xC3, 0xC7, 0x87, 0xC0, 0xF0, 0xF1, 0xE1,
  0xE0, 0x3C, 0x3C, 0x78, 0x78, 0x0F, 0x1F, 0x1E, 0x1E, 0x03, 0xE7, 0x83,
  0xC7, 0x80, 0xF9, 0xE0, 0xF3, 0xC0, 0x1E, 0x78, 0x3C, 0xF0, 0x07, 0xBE,
  0x0F, 0x3C, 0x01, 0xEF, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x1F,
  0xF0, 0x1E, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x81, 0xFF, 0xF8, 0x00,
  0x3C, 0x7F, 0xFF, 0x00, 0x0F, 0x3F, 0xFF, 0xE0, 0x07, 0xDF, 0x83, 0xFE,
  0x01, 0xF7, 0xC0, 0x3F, 0xC1, 0xF9, 0xE0, 0x07, 0xFF, 0xFE, 0x78, 0x00,
  0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoMono_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 7, 43, 37, 14, -43 },
  { 39, 15, 15, 37, 11, -46 },
  { 68, 33, 43, 37, 2, -43 },
  { 246, 28, 56, 37, 5, -50 },
  { 442, 34, 45, 37, 1, -44 },
  { 634, 33, 45, 37, 3, -44 },
  { 820, 4, 15, 37, 15, -46 },
  { 828, 15, 63, 37, 11, -49 },
  { 947, 15, 63, 37, 10, -49 },
  { 1066, 28, 29, 37, 5, -43 },
  { 1168, 29, 32, 37, 4, -36 },
  { 1284, 8, 17, 37, 11, -7 },
  { 1301, 23, 4, 37, 6, -21 },
  { 1313, 8, 9, 37, 15, -8 },
  { 1322, 24, 47, 37, 7, -43 },
  { 1463, 28, 45, 37, 4, -44 },
  { 1621, 17, 43, 37, 6, -43 },
  { 1713, 29, 44, 37, 3, -44 },
  { 1873, 27, 45, 37, 3, -44 },
  { 2025, 32, 43, 37, 2, -43 },
  { 2197, 27, 44, 37, 6, -43 },
  { 2346, 28, 44, 37, 4, -43 },
  { 2500, 30, 43, 37, 3, -43 },
  { 2662, 28, 45, 37, 5, -44 },
  { 2820, 28, 44, 37, 4, -44 },
  { 2974, 9, 35, 37, 16, -34 },
  { 3014, 11, 44, 37, 14, -34 },
  { 3075, 25, 27, 37, 5, -33 },
  { 3160, 27, 17, 37, 5, -28 },
  { 3218, 27, 27, 37, 5, -33 },
  { 3310, 25, 44, 37, 6, -44 },
  { 3448, 33, 43, 37, 2, -43 },
  { 3626, 33, 43, 37, 2, -43 },
  { 3804, 28, 43, 37, 5, -43 },
  { 3955, 30, 45, 37, 3, -44 },
  { 4124, 29, 43, 37, 5, -43 },
  { 4280, 27, 43, 37, 5, -43 },
  { 4426, 26, 43, 37, 6, -43 },
  { 4566, 30, 45, 37, 3, -44 },
  { 4735, 28, 43, 37, 4, -43 },
  { 4886, 26, 43, 37, 5, -43 },
  { 5026, 28, 44, 37, 3, -43 },
  { 5180, 30, 43, 37, 5, -43 },
  { 5342, 27, 43, 37, 6, -43 },
  { 5488, 29, 43, 37, 4, -43 },
  { 5644, 28, 43, 37, 4, -43 },
  { 5795, 30, 45, 37, 3, -44 },
  { 5964, 28, 43, 37, 6, -43 },
  { 6115, 32, 51, 37, 3, -44 },
  { 6319, 29, 43, 37, 5, -43 },
  { 6475, 30, 45, 37, 4, -44 },
  { 6644, 32, 43, 37, 2, -43 },
  { 6816, 28, 44, 37, 4, -43 },
  { 6970, 32, 43, 37, 2, -43 },
  { 7142, 33, 43, 37, 2, -43 },
  { 7320, 32, 43, 37, 3, -43 },
  { 7492, 32, 43, 37, 2, -43 },
  { 7664, 29, 43, 37, 3, -43 },
  { 7820, 11, 59, 37, 13, -50 },
  { 7902, 23, 47, 37, 7, -43 },
  { 8038, 12, 59, 37, 12, -50 },
  { 8127, 23, 23, 37, 7, -43 },
  { 8194, 27, 5, 37, 5, 0 },
  { 8211, 12, 8, 37, 12, -44 },
  { 8223, 27, 34, 37, 5, -33 },
  { 8338, 28, 47, 37, 5, -46 },
  { 8503, 28, 34, 37, 4, -33 },
  { 8622, 27, 47, 37, 4, -46 },
  { 8781, 29, 34, 37, 4, -33 },
  { 8905, 29, 47, 37, 5, -47 },
  { 9076, 27, 46, 37, 4, -33 },
  { 9232, 27, 46, 37, 5, -46 },
  { 9388, 27, 44, 37, 6, -44 },
  { 9537, 20, 57, 37, 6, -44 },
  { 9680, 29, 46, 37, 5, -46 },
  { 9847, 27, 46, 37, 6, -46 },
  { 10003, 31, 33, 37, 3, -33 },
  { 10131, 27, 33, 37, 5, -33 },
  { 10243, 29, 34, 37, 4, -33 },
  { 10367, 27, 45, 37, 5, -33 },
  { 10519, 27, 45, 37, 4, -33 },
  { 10671, 22, 33, 37, 10, -33 },
  { 10762, 27, 34, 37, 5, -33 },
  { 10877, 28, 41, 37, 4, -40 },
  { 11021, 26, 33, 37, 5, -32 },
  { 11129, 31, 32, 37, 3, -32 },
  { 11253, 34, 32, 37, 1, -32 },
  { 11389, 31, 32, 37, 3, -32 },
  { 11513, 32, 45, 37, 2, -32 },
  { 11693, 27, 32, 37, 5, -32 },
  { 11801, 20, 59, 37, 10, -48 },
  { 11949, 5, 55, 37, 16, -43 },
  { 11984, 20, 59, 37, 10, -48 },
  { 12132, 34, 12, 37, 1, -24 },
};

const GFXfont RobotoMono_Regular61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular61pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_REGULAR61PT7B_H_
