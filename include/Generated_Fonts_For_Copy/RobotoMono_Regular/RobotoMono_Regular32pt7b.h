#ifndef _ROBOTOMONO_REGULAR32PT7B_H_
#define _ROBOTOMONO_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0x80, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80,
  0x60, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0xFF, 0xFF, 0x7F, 0xFF,
  0x83, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x70, 0xC3, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x0E, 0x01,
  0x87, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0xF0, 0x3F, 0xF1, 0xFF, 0xE7, 0x03, 0x9C, 0x0F, 0xE0, 0x1F, 0x80, 0x77,
  0x00, 0x1C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xDE, 0x1E,
  0x7F, 0xF0, 0x7F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x31, 0xC0, 0x18, 0x61, 0x0C, 0x31, 0xC6, 0x18, 0xC3, 0x0C, 0xE1,
  0xCE, 0x60, 0x7E, 0x70, 0x1E, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x60, 0x0C, 0xFC, 0x0E, 0x67, 0x06, 0x61, 0x87, 0x30, 0xC3,
  0x18, 0x63, 0x8C, 0x30, 0x07, 0x18, 0x01, 0xFC, 0x00, 0x7C, 0x0F, 0xC0,
  0x0F, 0xF0, 0x0F, 0x3C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1,
  0xC0, 0x71, 0xC0, 0x3D, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xF8, 0x73, 0xDC, 0x3B, 0xC7, 0x1D, 0xC1, 0xCE, 0xE0, 0xF6, 0x70, 0x3F,
  0x38, 0x0F, 0x1C, 0x07, 0x87, 0x07, 0xE3, 0xFF, 0xF8, 0x7F, 0x1E, 0xFF,
  0xFC, 0x01, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x41, 0x80, 0x71, 0x8E, 0x7D, 0xBE, 0xBF, 0xFF, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x1C, 0x70, 0x3C, 0x3C, 0x18,
  0x18, 0x00, 0x10, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x77,
  0x77, 0x7E, 0xEC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xF1, 0xE3, 0xC0, 0xE7, 0x01, 0xCE, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xBF, 0x1E, 0x7E, 0x70, 0xFF, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x73, 0x80, 0xE3,
  0xC3, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x81, 0xC7, 0xFF, 0xFF, 0xBE,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE0, 0x1F, 0xF8,
  0x3E, 0x78, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0xF9, 0xE3,
  0xC0, 0xE7, 0x01, 0xCE, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0xC3, 0xC7, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0D,
  0x80, 0x0E, 0xC0, 0x0E, 0x60, 0x06, 0x30, 0x07, 0x18, 0x07, 0x0C, 0x03,
  0x86, 0x03, 0x83, 0x03, 0x81, 0x81, 0xC0, 0xC1, 0xC0, 0x61, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCC, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x77, 0xC1, 0xFF, 0xC7, 0xFF, 0x9C, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x7E, 0x01,
  0xDC, 0x0F, 0x78, 0x78, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x63,
  0xC1, 0xDF, 0xE3, 0xFF, 0xE7, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x03,
  0xF0, 0x07, 0xE0, 0x0E, 0xE0, 0x19, 0xC0, 0x73, 0xC0, 0xE3, 0xC7, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0xC7, 0xCF, 0x9C, 0x0E, 0xF0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0x70, 0x39, 0xE1, 0xE3, 0xFF, 0x07, 0xF8, 0x3F, 0xF1, 0xC0,
  0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0x78,
  0x78, 0xFF, 0xC1, 0xFE, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFB, 0xE3, 0xC1,
  0xC7, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1D,
  0xC0, 0x7B, 0x80, 0xF3, 0x87, 0xE7, 0xFD, 0x83, 0xF3, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xC0,
  0x00, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x77, 0xFE,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x73, 0x9C, 0xEE, 0x73,
  0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x03, 0xC0,
  0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3E,
  0x00, 0xE0, 0x02, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0x7F, 0xE0, 0x7E,
  0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x03,
  0x87, 0x83, 0x80, 0xC3, 0x00, 0x31, 0x87, 0x99, 0x8F, 0xE6, 0xC6, 0x33,
  0x46, 0x11, 0xE3, 0x08, 0xF1, 0x84, 0x78, 0x86, 0x3C, 0xC3, 0x1E, 0x61,
  0x8F, 0x30, 0xC5, 0x8C, 0xE6, 0xC7, 0xFF, 0x31, 0xCF, 0x18, 0x00, 0x06,
  0x00, 0x03, 0xC1, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x0E,
  0x60, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x86, 0x01, 0xC3, 0x80, 0xC1, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x3F, 0xFC, 0x3F, 0xFE, 0x1C, 0x03, 0x8E, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x1F, 0x80, 0x0E, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x39, 0xC0, 0xF3, 0xFF, 0x87, 0xFF, 0x0E, 0x0F, 0x9C, 0x07, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xEE, 0x1F,
  0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF9, 0xF3, 0xC0,
  0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0xE3, 0xC3, 0xC3, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xE0, 0x78, 0xE0, 0x1C, 0xE0,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE1, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFB, 0xF3, 0xC0, 0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0xF8, 0x1F, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0xC0, 0x1B, 0xC0, 0x73, 0xC1,
  0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x0E, 0x78, 0x78, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x1E, 0xE0, 0x1C,
  0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xF0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3, 0x80,
  0xE7, 0x00, 0xEF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF3, 0x80,
  0xE1, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x38,
  0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x86, 0xFF, 0x1D,
  0xF6, 0x3B, 0xEE, 0x67, 0xDD, 0xDF, 0x9B, 0xBF, 0x3E, 0x7E, 0x7C, 0xFC,
  0x79, 0xF8, 0xE3, 0xF1, 0xC7, 0xE1, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xF7, 0x07, 0xEE, 0x0F,
  0xCE, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x1C, 0xFC, 0x39, 0xF8, 0x3B, 0xF0,
  0x77, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x78, 0x3C, 0x70,
  0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x78, 0x1C, 0x3C, 0x78, 0x1F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x06, 0x60, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x06, 0x70, 0x07, 0x38, 0x03, 0x8E,
  0x01, 0xC7, 0x01, 0xC1, 0xE3, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x40, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3B, 0x81, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0x71, 0xC0, 0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3E, 0xFC, 0x78, 0x1E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x7C, 0x3E, 0x3F, 0xFC, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D,
  0xC0, 0x7B, 0x80, 0xE3, 0xC7, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x03,
  0xF8, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC3, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x18, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xB8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xE1,
  0xC1, 0xF0, 0xE0, 0xF8, 0x70, 0xEC, 0x3C, 0x76, 0x1E, 0x3B, 0x0F, 0x1D,
  0xCF, 0x8E, 0xE7, 0xC7, 0x73, 0x73, 0x39, 0xB9, 0x9C, 0xCC, 0xCE, 0x66,
  0x63, 0x73, 0x71, 0xB9, 0xB8, 0xD8, 0xFC, 0x6C, 0x7E, 0x3E, 0x1E, 0x1F,
  0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x70, 0x03, 0xBC, 0x03, 0x8E, 0x03, 0xC7, 0x81, 0xC1, 0xC1, 0xE0, 0x70,
  0xE0, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0E, 0x70, 0x0E, 0x38,
  0x07, 0x0E, 0x07, 0x07, 0x87, 0x81, 0xC3, 0x80, 0xF3, 0xC0, 0x3B, 0xC0,
  0x0E, 0xE0, 0x07, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xE0,
  0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x38, 0x01, 0xDC,
  0x00, 0x6C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFF, 0xC0, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x7F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1B, 0x03,
  0xB8, 0x3B, 0x83, 0x1C, 0x71, 0xC6, 0x0C, 0xE0, 0xEE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x70, 0x70, 0x70, 0x0F, 0xE0, 0x7F, 0xF0, 0xE1, 0xE3,
  0x80, 0xE7, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFE, 0x3F, 0xFC, 0xF0,
  0x39, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xCE, 0x07, 0x9E, 0x1F, 0x1F, 0xFE,
  0x1F, 0xCE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3B, 0xF0, 0xFF, 0xF3, 0xE3, 0xEF, 0x03, 0xB8, 0x0E, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0E, 0xE0, 0x3B, 0xE3, 0xEF, 0xFF, 0x33, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0,
  0xF0, 0xF3, 0xC0, 0xE7, 0x00, 0xEE, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0xEF, 0x03, 0x8F, 0x0F,
  0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC3, 0xF3, 0x1F, 0xEC, 0xF1, 0xF7, 0x81, 0xDC,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xDC, 0x03, 0x78, 0x1C, 0xF1, 0xF1, 0xFE, 0xC3, 0xF3, 0x07, 0xE0,
  0x3F, 0xF0, 0xF1, 0xF3, 0xC0, 0xE7, 0x00, 0xEC, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x01,
  0x8F, 0x07, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x1C, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0xCC, 0x7F, 0xB3,
  0xC7, 0xDE, 0x07, 0x70, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0x70, 0x1D, 0xE0, 0x73, 0xC7, 0xC7, 0xFB,
  0x0F, 0xCC, 0x00, 0x30, 0x01, 0xC8, 0x07, 0x70, 0x38, 0xFF, 0xE1, 0xFF,
  0x00, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x39, 0xF8, 0xEF, 0xF3, 0xE1, 0xEF, 0x03, 0xB8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x3F,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0xFE,
  0xFF, 0x3F, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x1E, 0xE0, 0x71, 0xC1, 0xC3, 0x87, 0x07,
  0x1C, 0x0E, 0x70, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xF7, 0x81, 0xC7,
  0x03, 0x87, 0x07, 0x0F, 0x0E, 0x0F, 0x1C, 0x0F, 0x38, 0x0E, 0x70, 0x0F,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9E, 0x7F, 0xFF, 0xBC, 0xF9,
  0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1,
  0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F,
  0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0x80, 0xC7, 0xE3, 0x7F, 0xCF, 0x87,
  0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1C, 0x0F, 0xE0, 0x3F, 0xE0, 0xF1, 0xE3, 0x80, 0xE7, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77,
  0x00, 0xEE, 0x03, 0x8F, 0x0F, 0x0F, 0xFC, 0x0F, 0xE0, 0xCF, 0xC3, 0x7F,
  0xCF, 0x8F, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEF, 0x0F, 0xBF,
  0xFC, 0xEF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x0F, 0xCC, 0x7F, 0xB3, 0xC7, 0xDE, 0x07, 0x70, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0x70, 0x0D, 0xE0, 0x73, 0xC3, 0xC7, 0xFF, 0x0F, 0xCC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xE3, 0xFE, 0xFF,
  0xFF, 0xEF, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0xC7, 0x87, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x0F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x77,
  0x87, 0x9F, 0xFC, 0x1F, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x0F, 0xFF, 0xDF, 0xFF, 0x81, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x10, 0x1F, 0xE0, 0x1F, 0xE0, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1D, 0xC3, 0xEF, 0xFB, 0x3F,
  0x98, 0xE0, 0x0F, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x38,
  0x18, 0x38, 0x38, 0x18, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0C, 0x60, 0x0E,
  0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x80, 0xC0,
  0xC1, 0xF8, 0x70, 0x6E, 0x1C, 0x1B, 0x87, 0x0E, 0x61, 0xE3, 0x98, 0xD8,
  0xC7, 0x36, 0x31, 0xCD, 0x8C, 0x33, 0x33, 0x0D, 0xCD, 0xC3, 0x63, 0x60,
  0xD8, 0xD8, 0x3E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0x70, 0x70, 0x1C,
  0x0C, 0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x70,
  0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x0E, 0xF0, 0x1C, 0x70, 0x3C, 0x38, 0x38, 0x1C, 0x70, 0x1E, 0xE0, 0x0F,
  0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xE0,
  0x70, 0x70, 0x70, 0x38, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x01, 0xCE, 0x00,
  0xEE, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xC0, 0x3C, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x3E, 0x07, 0x80, 0xFC, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x1E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1E,
  0x01, 0xF8, 0x0F, 0x07, 0xE1, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x30, 0x00,
  0x08, 0x00, 0x1F, 0x80, 0xDF, 0xE0, 0x7C, 0x7C, 0x7C, 0x0F, 0xFE, 0x03,
  0xF8, 0x00, 0x70,
};

const GFXglyph RobotoMono_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 23, 19, 8, -23 },
  { 10, 7, 7, 19, 6, -24 },
  { 17, 17, 23, 19, 1, -23 },
  { 66, 14, 29, 19, 3, -26 },
  { 117, 17, 23, 19, 1, -23 },
  { 166, 17, 23, 19, 2, -23 },
  { 215, 2, 7, 19, 8, -24 },
  { 217, 8, 33, 19, 6, -26 },
  { 250, 8, 33, 19, 5, -26 },
  { 283, 16, 16, 19, 2, -23 },
  { 315, 15, 17, 19, 2, -19 },
  { 347, 4, 8, 19, 6, -3 },
  { 351, 12, 2, 19, 3, -11 },
  { 354, 4, 4, 19, 8, -4 },
  { 356, 12, 25, 19, 4, -23 },
  { 394, 15, 23, 19, 2, -23 },
  { 438, 9, 23, 19, 3, -23 },
  { 464, 16, 23, 19, 1, -23 },
  { 510, 15, 23, 19, 1, -23 },
  { 554, 17, 23, 19, 1, -23 },
  { 603, 14, 23, 19, 3, -23 },
  { 644, 15, 23, 19, 2, -23 },
  { 688, 15, 23, 19, 2, -23 },
  { 732, 14, 23, 19, 3, -23 },
  { 773, 15, 23, 19, 2, -23 },
  { 817, 4, 18, 19, 9, -18 },
  { 826, 5, 23, 19, 8, -18 },
  { 841, 13, 14, 19, 3, -17 },
  { 864, 14, 9, 19, 3, -15 },
  { 880, 14, 14, 19, 3, -17 },
  { 905, 13, 23, 19, 3, -23 },
  { 943, 17, 23, 19, 1, -23 },
  { 992, 17, 23, 19, 1, -23 },
  { 1041, 15, 23, 19, 3, -23 },
  { 1085, 15, 23, 19, 2, -23 },
  { 1129, 16, 23, 19, 2, -23 },
  { 1175, 14, 23, 19, 3, -23 },
  { 1216, 14, 23, 19, 3, -23 },
  { 1257, 15, 23, 19, 2, -23 },
  { 1301, 15, 23, 19, 2, -23 },
  { 1345, 13, 23, 19, 3, -23 },
  { 1383, 14, 23, 19, 2, -23 },
  { 1424, 16, 23, 19, 3, -23 },
  { 1470, 14, 23, 19, 3, -23 },
  { 1511, 15, 23, 19, 2, -23 },
  { 1555, 15, 23, 19, 2, -23 },
  { 1599, 16, 23, 19, 2, -23 },
  { 1645, 15, 23, 19, 3, -23 },
  { 1689, 17, 27, 19, 1, -23 },
  { 1747, 15, 23, 19, 3, -23 },
  { 1791, 16, 23, 19, 2, -23 },
  { 1837, 17, 23, 19, 1, -23 },
  { 1886, 15, 23, 19, 2, -23 },
  { 1930, 17, 23, 19, 1, -23 },
  { 1979, 17, 23, 19, 1, -23 },
  { 2028, 17, 23, 19, 1, -23 },
  { 2077, 17, 23, 19, 1, -23 },
  { 2126, 15, 23, 19, 2, -23 },
  { 2170, 6, 31, 19, 7, -26 },
  { 2194, 12, 25, 19, 4, -23 },
  { 2232, 7, 31, 19, 6, -26 },
  { 2260, 12, 12, 19, 4, -23 },
  { 2278, 15, 2, 19, 2, 0 },
  { 2282, 7, 4, 19, 6, -23 },
  { 2286, 15, 17, 19, 2, -17 },
  { 2318, 14, 24, 19, 3, -24 },
  { 2360, 15, 17, 19, 2, -17 },
  { 2392, 14, 24, 19, 2, -24 },
  { 2434, 15, 17, 19, 2, -17 },
  { 2466, 16, 25, 19, 2, -25 },
  { 2516, 14, 24, 19, 2, -17 },
  { 2558, 14, 24, 19, 3, -24 },
  { 2600, 14, 23, 19, 3, -23 },
  { 2641, 10, 30, 19, 3, -23 },
  { 2679, 15, 24, 19, 3, -24 },
  { 2724, 14, 24, 19, 3, -24 },
  { 2766, 17, 17, 19, 1, -17 },
  { 2803, 14, 17, 19, 3, -17 },
  { 2833, 15, 17, 19, 2, -17 },
  { 2865, 14, 24, 19, 3, -17 },
  { 2907, 14, 24, 19, 2, -17 },
  { 2949, 12, 17, 19, 5, -17 },
  { 2975, 14, 17, 19, 3, -17 },
  { 3005, 15, 21, 19, 2, -21 },
  { 3045, 13, 17, 19, 3, -17 },
  { 3073, 16, 17, 19, 2, -17 },
  { 3107, 18, 17, 19, 1, -17 },
  { 3146, 16, 17, 19, 2, -17 },
  { 3180, 17, 24, 19, 1, -17 },
  { 3231, 15, 17, 19, 2, -17 },
  { 3263, 11, 31, 19, 5, -25 },
  { 3306, 3, 29, 19, 8, -23 },
  { 3317, 11, 31, 19, 5, -25 },
  { 3360, 17, 7, 19, 1, -13 },
};

const GFXfont RobotoMono_Regular32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular32pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_REGULAR32PT7B_H_
