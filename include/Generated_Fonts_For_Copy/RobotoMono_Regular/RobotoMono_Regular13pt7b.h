#ifndef _ROBOTOMONO_REGULAR13PT7B_H_
#define _ROBOTOMONO_REGULAR13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA0, 0xC0, 0xB6, 0x80, 0x12, 0x29, 0xF9, 0x22, 0x5E, 0xCA,
  0x14, 0x48, 0x10, 0x47, 0xB3, 0xC5, 0x83, 0x83, 0x87, 0x37, 0x84, 0xE0,
  0x94, 0x98, 0x68, 0x10, 0x16, 0x29, 0x29, 0x0E, 0x71, 0x91, 0x63, 0x86,
  0x12, 0xA7, 0x44, 0x76, 0xE0, 0x32, 0x44, 0xC8, 0x88, 0x44, 0x42, 0x10,
  0x88, 0x92, 0x49, 0x25, 0x28, 0x12, 0x4F, 0xCC, 0x69, 0x20, 0x30, 0xC3,
  0x3F, 0x30, 0xC3, 0x00, 0x5C, 0xF8, 0xF0, 0x18, 0x88, 0x42, 0x21, 0x18,
  0x84, 0x00, 0x7A, 0x38, 0x67, 0xB7, 0x18, 0x73, 0x78, 0x3D, 0x11, 0x11,
  0x11, 0x10, 0xFA, 0x20, 0x82, 0x10, 0x86, 0x30, 0xFC, 0xFC, 0x42, 0x37,
  0x04, 0x31, 0x78, 0x0C, 0x38, 0x51, 0x22, 0x48, 0xBF, 0x82, 0x04, 0x7D,
  0x04, 0x1E, 0x4C, 0x10, 0x73, 0x78, 0x31, 0x08, 0x3E, 0xCA, 0x18, 0x72,
  0x78, 0xFC, 0x20, 0x86, 0x10, 0x42, 0x08, 0x40, 0x7B, 0x3C, 0x52, 0x7B,
  0x18, 0x71, 0x78, 0x7A, 0x28, 0x61, 0xCD, 0xD0, 0x86, 0x70, 0x70, 0x07,
  0x70, 0x01, 0x60, 0x09, 0xF1, 0xC1, 0x84, 0xFC, 0x00, 0x3F, 0x81, 0xC0,
  0xC6, 0xE2, 0x00, 0x7A, 0x30, 0xC2, 0x10, 0xC0, 0x00, 0x30, 0x3C, 0x85,
  0x7D, 0x3A, 0xB5, 0x55, 0xA0, 0x3C, 0x30, 0xC3, 0x12, 0x49, 0x2F, 0xE1,
  0x84, 0xFA, 0x38, 0x62, 0xFA, 0x18, 0x63, 0xF8, 0x7A, 0x18, 0x60, 0x82,
  0x08, 0x73, 0x78, 0xFA, 0x38, 0x61, 0x86, 0x18, 0x62, 0xF0, 0xFE, 0x08,
  0x20, 0xFA, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x80,
  0x7A, 0x18, 0x20, 0x9E, 0x18, 0x71, 0x78, 0x86, 0x18, 0x61, 0xFE, 0x18,
  0x61, 0x84, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x0C, 0x30, 0xC3,
  0x0C, 0x38, 0xE2, 0x78, 0x8D, 0x12, 0x45, 0x0F, 0x1A, 0x26, 0x46, 0x86,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xCF, 0x3C, 0xED, 0xB6, 0xD8,
  0x61, 0x84, 0x87, 0x1E, 0x69, 0xB6, 0x59, 0xE3, 0x8C, 0x7A, 0x38, 0x61,
  0x86, 0x18, 0x73, 0x78, 0xFA, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x7A,
  0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0x30, 0x40, 0xFA, 0x18, 0x61, 0xFA,
  0x68, 0xA3, 0x84, 0x7A, 0x18, 0x10, 0x38, 0x38, 0x61, 0x78, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x73,
  0x78, 0xC2, 0x85, 0x91, 0x22, 0x45, 0x06, 0x0C, 0x18, 0xDB, 0x5A, 0x5A,
  0x5A, 0x5A, 0x66, 0x66, 0x66, 0x24, 0x85, 0x25, 0x8C, 0x30, 0xC4, 0xB3,
  0x84, 0xC2, 0xC8, 0x91, 0x41, 0x82, 0x04, 0x08, 0x10, 0xFC, 0x21, 0x84,
  0x21, 0x84, 0x20, 0xFC, 0xEA, 0xAA, 0xAA, 0xC0, 0xC2, 0x08, 0x42, 0x08,
  0x43, 0x08, 0x40, 0xD5, 0x55, 0x55, 0xC0, 0x31, 0x94, 0x9C, 0x80, 0xFC,
  0xC0, 0x7A, 0x20, 0xDF, 0x8E, 0x37, 0xC0, 0x82, 0x08, 0x2E, 0xCE, 0x18,
  0x61, 0xCE, 0xE0, 0x7B, 0x38, 0x60, 0x83, 0x37, 0x80, 0x0C, 0x30, 0xDF,
  0xCE, 0x38, 0xE3, 0xCD, 0xD0, 0x7B, 0x38, 0x7F, 0x83, 0x17, 0x80, 0x1C,
  0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x80, 0x77, 0x38, 0x61, 0x87, 0x37,
  0x43, 0xC8, 0xC0, 0x82, 0x08, 0x2E, 0xCE, 0x18, 0x61, 0x86, 0x10, 0x30,
  0x0F, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x10, 0x71, 0x11, 0x11, 0x11, 0x1E,
  0x82, 0x08, 0x23, 0x92, 0x8E, 0x24, 0x8A, 0x30, 0xF0, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x13, 0xF0, 0xFE, 0xDA, 0x69, 0xA6, 0x9A, 0x40, 0xBB, 0x38,
  0x61, 0x86, 0x18, 0x40, 0x7B, 0x38, 0x61, 0x86, 0x37, 0x80, 0xBB, 0x38,
  0x61, 0x86, 0x3F, 0xA0, 0x82, 0x00, 0x77, 0x38, 0xE3, 0x8F, 0x37, 0xC3,
  0x0C, 0x30, 0xBE, 0x21, 0x08, 0x42, 0x00, 0x7B, 0x3C, 0x1E, 0x0E, 0x17,
  0x80, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x3C, 0x86, 0x18, 0x61, 0x87,
  0x37, 0x40, 0x86, 0x34, 0x92, 0x50, 0xC3, 0x00, 0x93, 0x5A, 0x5A, 0x5A,
  0x6A, 0x64, 0x24, 0x85, 0x23, 0x0C, 0x31, 0x28, 0xC0, 0xC2, 0x8C, 0x91,
  0x23, 0x83, 0x06, 0x08, 0x30, 0xC0, 0xFC, 0x21, 0x0C, 0x61, 0x0F, 0xC0,
  0x12, 0x22, 0x24, 0xC2, 0x22, 0x21, 0xFF, 0xF0, 0xC4, 0x66, 0x62, 0x32,
  0x66, 0x4C, 0x73, 0x3C,
};

const GFXglyph RobotoMono_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 2, -10 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 9, 8, 0, -9 },
  { 32, 7, 9, 8, 1, -9 },
  { 40, 1, 3, 8, 3, -10 },
  { 41, 4, 13, 8, 2, -10 },
  { 48, 3, 13, 8, 2, -10 },
  { 53, 6, 6, 8, 1, -9 },
  { 58, 6, 7, 8, 1, -8 },
  { 64, 2, 3, 8, 2, -1 },
  { 65, 5, 1, 8, 1, -5 },
  { 66, 2, 2, 8, 3, -2 },
  { 67, 5, 10, 8, 2, -9 },
  { 74, 6, 9, 8, 1, -9 },
  { 81, 4, 9, 8, 1, -9 },
  { 86, 6, 9, 8, 1, -9 },
  { 93, 5, 9, 8, 1, -9 },
  { 99, 7, 9, 8, 0, -9 },
  { 107, 6, 9, 8, 1, -9 },
  { 114, 6, 9, 8, 1, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 2, 8, 8, 3, -8 },
  { 144, 2, 10, 8, 3, -8 },
  { 147, 5, 6, 8, 1, -7 },
  { 151, 6, 4, 8, 1, -6 },
  { 154, 6, 6, 8, 1, -7 },
  { 159, 6, 9, 8, 1, -9 },
  { 166, 7, 9, 8, 0, -9 },
  { 174, 6, 9, 8, 1, -9 },
  { 181, 6, 9, 8, 1, -9 },
  { 188, 6, 9, 8, 1, -9 },
  { 195, 6, 9, 8, 1, -9 },
  { 202, 6, 9, 8, 1, -9 },
  { 209, 6, 9, 8, 1, -9 },
  { 216, 6, 9, 8, 1, -9 },
  { 223, 6, 9, 8, 1, -9 },
  { 230, 6, 9, 8, 1, -9 },
  { 237, 6, 9, 8, 1, -9 },
  { 244, 7, 9, 8, 1, -9 },
  { 252, 6, 9, 8, 1, -9 },
  { 259, 6, 9, 8, 1, -9 },
  { 266, 6, 9, 8, 1, -9 },
  { 273, 6, 9, 8, 1, -9 },
  { 280, 6, 9, 8, 1, -9 },
  { 287, 6, 11, 8, 1, -9 },
  { 296, 6, 9, 8, 1, -9 },
  { 303, 6, 9, 8, 1, -9 },
  { 310, 7, 9, 8, 0, -9 },
  { 318, 6, 9, 8, 1, -9 },
  { 325, 7, 9, 8, 0, -9 },
  { 333, 8, 9, 8, 0, -9 },
  { 342, 6, 9, 8, 1, -9 },
  { 349, 7, 9, 8, 0, -9 },
  { 357, 6, 9, 8, 1, -9 },
  { 364, 2, 13, 8, 3, -11 },
  { 368, 5, 10, 8, 1, -9 },
  { 375, 2, 13, 8, 3, -11 },
  { 379, 5, 5, 8, 1, -9 },
  { 383, 6, 1, 8, 1, 0 },
  { 384, 2, 1, 8, 3, -9 },
  { 385, 6, 7, 8, 1, -7 },
  { 391, 6, 10, 8, 1, -10 },
  { 399, 6, 7, 8, 1, -7 },
  { 405, 6, 10, 8, 1, -10 },
  { 413, 6, 7, 8, 1, -7 },
  { 419, 6, 10, 8, 1, -10 },
  { 427, 6, 10, 8, 1, -7 },
  { 435, 6, 10, 8, 1, -10 },
  { 443, 6, 9, 8, 1, -9 },
  { 450, 4, 12, 8, 1, -9 },
  { 456, 6, 10, 8, 1, -10 },
  { 464, 6, 10, 8, 1, -10 },
  { 472, 6, 7, 8, 1, -7 },
  { 478, 6, 7, 8, 1, -7 },
  { 484, 6, 7, 8, 1, -7 },
  { 490, 6, 10, 8, 1, -7 },
  { 498, 6, 10, 8, 1, -7 },
  { 506, 5, 7, 8, 2, -7 },
  { 511, 6, 7, 8, 1, -7 },
  { 517, 6, 9, 8, 1, -9 },
  { 524, 6, 7, 8, 1, -7 },
  { 530, 6, 7, 8, 1, -7 },
  { 536, 8, 7, 8, 0, -7 },
  { 543, 6, 7, 8, 1, -7 },
  { 549, 7, 10, 8, 0, -7 },
  { 558, 6, 7, 8, 1, -7 },
  { 564, 4, 12, 8, 2, -10 },
  { 570, 1, 12, 8, 3, -9 },
  { 572, 4, 12, 8, 2, -10 },
  { 578, 7, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_Regular13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular13pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_REGULAR13PT7B_H_
