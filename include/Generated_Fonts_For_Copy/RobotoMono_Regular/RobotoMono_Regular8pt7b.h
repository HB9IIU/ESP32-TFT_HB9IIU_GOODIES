#ifndef _ROBOTOMONO_REGULAR8PT7B_H_
#define _ROBOTOMONO_REGULAR8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x31, 0x96, 0xAF, 0x30, 0x4E, 0xC7, 0x7A, 0xC6, 0x98,
  0x66, 0x9C, 0x62, 0x98, 0xD9, 0x3C, 0xC0, 0x5A, 0xA5, 0xD5, 0x56, 0x5D,
  0x50, 0x22, 0xF2, 0x70, 0xE0, 0x80, 0x25, 0x25, 0x00, 0xD6, 0xFB, 0xC0,
  0x75, 0x50, 0x69, 0x12, 0x4F, 0x69, 0x13, 0x97, 0x13, 0x55, 0xF1, 0xF3,
  0x1B, 0xC0, 0x53, 0x5B, 0xC0, 0xF1, 0x12, 0x24, 0xF6, 0xFB, 0xC0, 0xD6,
  0xF3, 0x80, 0x90, 0x98, 0x71, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xF4, 0xA0,
  0x80, 0x33, 0x77, 0xAB, 0x38, 0x21, 0x14, 0xA7, 0x44, 0xD6, 0xFB, 0xC0,
  0x65, 0x88, 0x97, 0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00,
  0x65, 0x8B, 0x97, 0xB6, 0xFB, 0x40, 0xE9, 0x25, 0xC0, 0x11, 0x11, 0x97,
  0xBA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0xB7, 0xFB, 0x40, 0xB6, 0xFB, 0x40,
  0x65, 0x99, 0x97, 0xD6, 0xF9, 0x00, 0x62, 0xA3, 0x19, 0x38, 0x60, 0xD6,
  0xEB, 0x40, 0x65, 0x43, 0x97, 0xF9, 0x08, 0x42, 0x10, 0xB6, 0xDB, 0xC0,
  0x8A, 0x94, 0xA2, 0x10, 0xAD, 0x6B, 0xA5, 0x28, 0x9A, 0x88, 0x45, 0x6C,
  0x95, 0x52, 0x22, 0xF1, 0x22, 0x4F, 0xFF, 0x91, 0x24, 0x40, 0xFF, 0x4A,
  0x80, 0xE0, 0x80, 0xEE, 0xF0, 0x93, 0xDB, 0xC0, 0xF2, 0x70, 0x27, 0xDB,
  0xC0, 0xFE, 0x70, 0x6B, 0xA4, 0x80, 0xF6, 0xFA, 0x80, 0x93, 0xDB, 0x40,
  0x43, 0x25, 0xC0, 0x4D, 0x57, 0x93, 0xCD, 0x40, 0xC9, 0x25, 0xC0, 0xFB,
  0xBB, 0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF9, 0x00, 0xF6, 0xF2, 0x40, 0xF2,
  0x40, 0xF8, 0xF0, 0x5D, 0x26, 0xB6, 0xF0, 0xD5, 0x62, 0xAD, 0x94, 0xA0,
  0xD2, 0x6D, 0x9A, 0x98, 0x42, 0x20, 0xEA, 0x70, 0x69, 0x44, 0x98, 0xFF,
  0xC9, 0x14, 0xB0, 0xF8,
};

const GFXglyph RobotoMono_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 2, 5, 2, -6 },
  { 19, 2, 8, 5, 1, -6 },
  { 21, 2, 8, 5, 1, -6 },
  { 23, 3, 4, 5, 1, -6 },
  { 25, 4, 4, 5, 0, -5 },
  { 27, 2, 2, 5, 1, -1 },
  { 28, 3, 1, 5, 1, -3 },
  { 29, 1, 1, 5, 2, -1 },
  { 30, 3, 6, 5, 1, -6 },
  { 33, 3, 6, 5, 1, -6 },
  { 36, 2, 6, 5, 1, -6 },
  { 38, 4, 6, 5, 0, -6 },
  { 41, 4, 6, 5, 0, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 3, 6, 5, 1, -6 },
  { 62, 1, 4, 5, 2, -4 },
  { 63, 1, 5, 5, 2, -4 },
  { 64, 3, 3, 5, 1, -4 },
  { 66, 3, 3, 5, 1, -4 },
  { 68, 3, 3, 5, 1, -4 },
  { 70, 3, 6, 5, 1, -6 },
  { 73, 5, 6, 5, 0, -6 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 3, 6, 5, 1, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 4, 6, 5, 0, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 0, -6 },
  { 123, 3, 6, 5, 1, -6 },
  { 126, 5, 7, 5, 0, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 4, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 3, 6, 5, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 4, 6, 5, 0, -6 },
  { 159, 4, 6, 5, 0, -6 },
  { 162, 1, 8, 5, 2, -7 },
  { 163, 3, 6, 5, 1, -6 },
  { 166, 1, 8, 5, 2, -7 },
  { 167, 3, 3, 5, 1, -6 },
  { 169, 3, 1, 5, 1, 0 },
  { 170, 1, 1, 5, 2, -6 },
  { 171, 3, 4, 5, 1, -4 },
  { 173, 3, 6, 5, 1, -6 },
  { 176, 3, 4, 5, 1, -4 },
  { 178, 3, 6, 5, 1, -6 },
  { 181, 3, 4, 5, 1, -4 },
  { 183, 3, 6, 5, 1, -6 },
  { 186, 3, 6, 5, 1, -4 },
  { 189, 3, 6, 5, 1, -6 },
  { 192, 3, 6, 5, 1, -6 },
  { 195, 2, 8, 5, 1, -6 },
  { 197, 3, 6, 5, 1, -6 },
  { 200, 3, 6, 5, 1, -6 },
  { 203, 4, 4, 5, 0, -4 },
  { 205, 3, 4, 5, 1, -4 },
  { 207, 4, 4, 5, 0, -4 },
  { 209, 3, 6, 5, 1, -4 },
  { 212, 3, 6, 5, 1, -4 },
  { 215, 3, 4, 5, 1, -4 },
  { 217, 3, 4, 5, 1, -4 },
  { 219, 3, 5, 5, 1, -5 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 4, 4, 5, 0, -4 },
  { 225, 5, 4, 5, 0, -4 },
  { 228, 4, 4, 5, 0, -4 },
  { 230, 5, 6, 5, 0, -4 },
  { 234, 3, 4, 5, 1, -4 },
  { 236, 3, 7, 5, 1, -6 },
  { 239, 1, 8, 5, 2, -6 },
  { 240, 3, 7, 5, 1, -6 },
  { 243, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_Regular8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular8pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_REGULAR8PT7B_H_
