#ifndef _ROBOTOMONO_REGULAR20PT7B_H_
#define _ROBOTOMONO_REGULAR20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0xCE, 0x73, 0x9C, 0x80, 0x08, 0x81, 0x10,
  0x66, 0x0C, 0xCF, 0xFE, 0x22, 0x04, 0x41, 0x98, 0x33, 0x1F, 0xF8, 0x88,
  0x11, 0x06, 0x60, 0xCC, 0x00, 0x08, 0x04, 0x02, 0x0F, 0xC6, 0x36, 0x1B,
  0x07, 0x80, 0x60, 0x1E, 0x03, 0x80, 0x60, 0x1C, 0x0F, 0x07, 0xCE, 0x7E,
  0x0C, 0x06, 0x00, 0x78, 0x04, 0xC8, 0xCC, 0x8C, 0xD8, 0x49, 0x03, 0x30,
  0x02, 0x00, 0x40, 0x0D, 0xE0, 0x92, 0x1B, 0x31, 0x33, 0x03, 0x20, 0x1E,
  0x3E, 0x06, 0x61, 0x8C, 0x31, 0x83, 0x60, 0x78, 0x0E, 0x03, 0xE2, 0x6C,
  0x58, 0xDB, 0x0F, 0x60, 0xC6, 0x3C, 0x7D, 0xC0, 0xF8, 0x0C, 0x61, 0x0C,
  0x21, 0x86, 0x10, 0x43, 0x0C, 0x10, 0x41, 0x86, 0x18, 0x20, 0xC1, 0x83,
  0x04, 0x82, 0x18, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x62, 0x31,
  0x19, 0x88, 0x00, 0x18, 0x04, 0x22, 0x3D, 0x77, 0xF0, 0xC0, 0xD0, 0xCC,
  0x63, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x6D, 0xBC, 0xFF, 0xFF, 0x5F, 0x80, 0x03, 0x02,
  0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60,
  0xC0, 0x3F, 0x18, 0x66, 0x19, 0x02, 0xC1, 0xF0, 0xFC, 0xEF, 0x63, 0xF0,
  0xF8, 0x34, 0x09, 0x86, 0x73, 0x8F, 0xC0, 0x0D, 0xFE, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x7E, 0x31, 0xB0, 0x78, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0xFC, 0x3E, 0x31,
  0xB0, 0x78, 0x30, 0x18, 0x18, 0x78, 0x1E, 0x01, 0x80, 0xF0, 0x78, 0x36,
  0x31, 0xF0, 0x03, 0x01, 0xC0, 0xF0, 0x2C, 0x1B, 0x0C, 0xC2, 0x31, 0x8C,
  0xC3, 0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0x3F, 0x90, 0x08,
  0x04, 0x07, 0xF3, 0x9C, 0x06, 0x01, 0x80, 0xF0, 0x78, 0x26, 0x71, 0xF0,
  0x0E, 0x1E, 0x0C, 0x0C, 0x06, 0x02, 0xFB, 0xCF, 0xC3, 0xC1, 0xE0, 0x50,
  0x6C, 0x33, 0x30, 0xF0, 0xFF, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x7E, 0x31,
  0xB0, 0xD8, 0x2C, 0x33, 0x18, 0xF8, 0xEE, 0xC3, 0x60, 0xF0, 0x78, 0x3E,
  0x71, 0xF0, 0x3F, 0x31, 0x98, 0x68, 0x3C, 0x0A, 0x05, 0x86, 0xE7, 0x3E,
  0x80, 0xC0, 0x60, 0x63, 0xE1, 0xE0, 0x5F, 0x80, 0x00, 0x0B, 0xF0, 0x5F,
  0x80, 0x00, 0x01, 0xB5, 0xB0, 0x01, 0x07, 0x1E, 0x78, 0xC0, 0xF0, 0x3C,
  0x0F, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x03,
  0x0F, 0x3C, 0xE0, 0x80, 0x7E, 0xE3, 0xC3, 0x03, 0x03, 0x07, 0x06, 0x0C,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x1F, 0x0C, 0x64, 0x0F, 0x3D, 0x9A,
  0x64, 0x99, 0x26, 0xC9, 0xB2, 0x65, 0xB9, 0x9B, 0x00, 0x62, 0x0F, 0xC0,
  0x0C, 0x03, 0x01, 0xE0, 0x78, 0x1A, 0x04, 0xC3, 0x30, 0xC4, 0x21, 0x9F,
  0xE6, 0x09, 0x03, 0xC0, 0xF0, 0x30, 0xFE, 0x63, 0xB0, 0xD8, 0x3C, 0x16,
  0x3B, 0xF1, 0x8E, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xF7, 0xF0, 0x3F, 0x1C,
  0x66, 0x0F, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0D,
  0x82, 0x73, 0x87, 0xC0, 0xFC, 0x47, 0x20, 0xD0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x50, 0x69, 0xE7, 0xC0, 0xFF, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0xFD, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC,
  0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x00, 0x3F, 0x1C, 0x66, 0x0F, 0x03, 0xC0, 0x30, 0x0C,
  0x03, 0x1F, 0xC0, 0xF0, 0x3C, 0x0D, 0x83, 0x31, 0xC7, 0xC0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x30, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xF0, 0x78, 0x37, 0x31, 0xF0, 0xC1, 0xB0,
  0xCC, 0x63, 0x30, 0xD8, 0x36, 0x0F, 0x83, 0xE0, 0xCC, 0x33, 0x8C, 0x63,
  0x0C, 0xC3, 0xB0, 0x70, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC, 0xE1, 0xF8, 0x7F, 0x1F,
  0xCF, 0xD2, 0xF7, 0xBD, 0xEF, 0x33, 0xCC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x30, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xD8, 0xF6, 0x3C, 0xCF, 0x33,
  0xC6, 0xF1, 0xBC, 0x3F, 0x0F, 0xC1, 0xF0, 0x30, 0x3F, 0x1C, 0xE6, 0x1B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x86, 0x33,
  0x87, 0x80, 0xFE, 0x61, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0xFC, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x3F, 0x1C, 0xE6, 0x1B, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x86, 0x73, 0x87, 0xC0,
  0x1C, 0x03, 0xFE, 0x63, 0xB0, 0x78, 0x3C, 0x1E, 0x0B, 0x1D, 0xFC, 0xC4,
  0x63, 0x30, 0x98, 0x6C, 0x36, 0x0C, 0x3F, 0x1C, 0x66, 0x0D, 0x03, 0x60,
  0x1C, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x0D, 0x83, 0x73, 0x8F, 0xC0,
  0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x86, 0x73, 0x87, 0x80,
  0xC0, 0xF0, 0x34, 0x09, 0x86, 0x61, 0x98, 0x43, 0x30, 0xCC, 0x32, 0x05,
  0x81, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0xCC, 0x79, 0x8B, 0x31, 0x67, 0x6C,
  0xED, 0xB5, 0x96, 0xB2, 0x96, 0x52, 0x8A, 0x71, 0xCE, 0x38, 0xC7, 0x18,
  0xC3, 0x00, 0xC0, 0xD8, 0x63, 0x18, 0xCC, 0x1B, 0x07, 0x80, 0xC0, 0x38,
  0x1E, 0x04, 0xC3, 0x31, 0x86, 0x61, 0xF0, 0x30, 0xC0, 0xF0, 0x66, 0x19,
  0x8C, 0x33, 0x0C, 0x81, 0xE0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x02, 0x03, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x18, 0x3C, 0x2C, 0x66,
  0x66, 0xC3, 0xFF, 0xE3, 0x3C, 0x3F, 0x30, 0xC0, 0x60, 0x33, 0xFB, 0x0D,
  0x06, 0x83, 0x77, 0x9F, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xC7, 0xF3,
  0x0D, 0x86, 0xC1, 0xE0, 0xF0, 0x78, 0x2C, 0x37, 0x3A, 0xF8, 0x1E, 0x0F,
  0xC6, 0x19, 0x82, 0xC0, 0x70, 0x0C, 0x01, 0x01, 0x60, 0x8C, 0xE1, 0xF0,
  0x01, 0x80, 0xC0, 0x60, 0x31, 0xD9, 0xFD, 0x86, 0xC3, 0xC1, 0xE0, 0xF0,
  0x68, 0x36, 0x1B, 0x9C, 0xFA, 0x0E, 0x0F, 0xC6, 0x19, 0x82, 0xC0, 0xFF,
  0xFC, 0x03, 0x00, 0x60, 0x9C, 0x71, 0xF0, 0x07, 0xC3, 0x00, 0x80, 0x60,
  0xFF, 0xBF, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x1C, 0x9F, 0x58, 0x6C, 0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x61,
  0xB9, 0xCF, 0xE0, 0x34, 0x1B, 0x98, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC,
  0xFF, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x1C, 0x04,
  0x00, 0x1F, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x0F,
  0xFF, 0xFC, 0x0C, 0x10, 0x1F, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x1F, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x36, 0x33, 0x31,
  0xB0, 0xF0, 0x7C, 0x36, 0x19, 0x8C, 0x66, 0x1B, 0x0E, 0xF8, 0x7C, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87,
  0xFF, 0xFE, 0xD9, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33,
  0xCC, 0xF3, 0x3C, 0xCC, 0x9C, 0xBF, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0x1E, 0x0F, 0xC6, 0x19, 0x02, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x61, 0x9C, 0xE3, 0xF0, 0x9C, 0x7F, 0x30, 0xD8, 0x6C, 0x1E, 0x0F,
  0x07, 0x82, 0xC3, 0x73, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0x00, 0x1C, 0x9F,
  0xD8, 0x6C, 0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x61, 0xB9, 0xCF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0xCF, 0xBF, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x00, 0x3C, 0x3F, 0xB0, 0xD8, 0x2E, 0x03, 0xE0, 0x1C, 0x02, 0xC1, 0xF1,
  0x9F, 0x80, 0x18, 0x0C, 0x3F, 0xFF, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x01, 0x90, 0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xE7, 0x7D, 0xC0, 0xF0, 0x36, 0x19, 0x86, 0x21, 0x0C, 0xC3,
  0x30, 0x48, 0x1E, 0x03, 0x00, 0xC0, 0xC6, 0x34, 0x62, 0x46, 0x26, 0x66,
  0x6F, 0x62, 0xD6, 0x29, 0x42, 0x94, 0x29, 0xC3, 0x8C, 0x10, 0x80, 0xC0,
  0xD8, 0x63, 0x30, 0xCC, 0x1E, 0x03, 0x01, 0xE0, 0x78, 0x33, 0x18, 0x6E,
  0x0C, 0xC0, 0xF0, 0x36, 0x19, 0x86, 0x21, 0x8C, 0xC3, 0x30, 0x78, 0x1E,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x0F, 0x00, 0xFF, 0x7F, 0x81, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x3F, 0xE0, 0x02, 0x1C, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x31, 0xC3, 0x81, 0x81, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x38, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x81, 0xC0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x18, 0x1C, 0x38, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x43,
  0x84, 0x00, 0x38, 0x17, 0xC2, 0x47, 0xEC, 0x1C,
};

const GFXglyph RobotoMono_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 5, 5, 12, 3, -15 },
  { 9, 11, 14, 12, 1, -14 },
  { 29, 9, 19, 12, 2, -17 },
  { 51, 12, 14, 12, 0, -14 },
  { 72, 11, 14, 12, 1, -14 },
  { 92, 1, 5, 12, 5, -15 },
  { 93, 6, 21, 12, 3, -16 },
  { 109, 5, 21, 12, 3, -16 },
  { 123, 9, 9, 12, 2, -14 },
  { 134, 10, 11, 12, 1, -12 },
  { 148, 3, 5, 12, 3, -2 },
  { 150, 8, 2, 12, 2, -7 },
  { 152, 3, 3, 12, 5, -3 },
  { 154, 8, 15, 12, 2, -14 },
  { 169, 10, 14, 12, 1, -14 },
  { 187, 6, 14, 12, 2, -14 },
  { 198, 9, 14, 12, 1, -14 },
  { 214, 9, 14, 12, 1, -14 },
  { 230, 10, 14, 12, 1, -14 },
  { 248, 9, 14, 12, 2, -14 },
  { 264, 9, 14, 12, 1, -14 },
  { 280, 10, 14, 12, 1, -14 },
  { 298, 9, 14, 12, 2, -14 },
  { 314, 9, 14, 12, 1, -14 },
  { 330, 3, 12, 12, 5, -12 },
  { 335, 3, 15, 12, 5, -12 },
  { 341, 8, 9, 12, 2, -11 },
  { 350, 8, 5, 12, 2, -9 },
  { 355, 8, 9, 12, 2, -11 },
  { 364, 8, 14, 12, 2, -14 },
  { 378, 10, 14, 12, 1, -14 },
  { 396, 10, 14, 12, 1, -14 },
  { 414, 9, 14, 12, 2, -14 },
  { 430, 10, 14, 12, 1, -14 },
  { 448, 9, 14, 12, 2, -14 },
  { 464, 9, 14, 12, 2, -14 },
  { 480, 9, 14, 12, 2, -14 },
  { 496, 10, 14, 12, 1, -14 },
  { 514, 10, 14, 12, 1, -14 },
  { 532, 8, 14, 12, 2, -14 },
  { 546, 9, 14, 12, 1, -14 },
  { 562, 10, 14, 12, 2, -14 },
  { 580, 9, 14, 12, 2, -14 },
  { 596, 10, 14, 12, 1, -14 },
  { 614, 10, 14, 12, 1, -14 },
  { 632, 10, 14, 12, 1, -14 },
  { 650, 9, 14, 12, 2, -14 },
  { 666, 10, 16, 12, 1, -14 },
  { 686, 9, 14, 12, 2, -14 },
  { 702, 10, 14, 12, 1, -14 },
  { 720, 10, 14, 12, 1, -14 },
  { 738, 10, 14, 12, 1, -14 },
  { 756, 10, 14, 12, 1, -14 },
  { 774, 11, 14, 12, 1, -14 },
  { 794, 10, 14, 12, 1, -14 },
  { 812, 10, 14, 12, 1, -14 },
  { 830, 10, 14, 12, 1, -14 },
  { 848, 4, 19, 12, 4, -16 },
  { 858, 8, 15, 12, 2, -14 },
  { 873, 4, 19, 12, 4, -16 },
  { 883, 8, 7, 12, 2, -14 },
  { 890, 8, 1, 12, 2, 0 },
  { 891, 4, 2, 12, 4, -14 },
  { 892, 9, 11, 12, 2, -11 },
  { 905, 9, 15, 12, 2, -15 },
  { 922, 10, 11, 12, 1, -11 },
  { 936, 9, 15, 12, 1, -15 },
  { 953, 10, 11, 12, 1, -11 },
  { 967, 10, 15, 12, 1, -15 },
  { 986, 9, 15, 12, 1, -11 },
  { 1003, 8, 15, 12, 2, -15 },
  { 1018, 9, 14, 12, 2, -14 },
  { 1034, 6, 18, 12, 2, -14 },
  { 1048, 9, 15, 12, 2, -15 },
  { 1065, 9, 15, 12, 2, -15 },
  { 1082, 10, 11, 12, 1, -11 },
  { 1096, 8, 11, 12, 2, -11 },
  { 1107, 10, 11, 12, 1, -11 },
  { 1121, 9, 15, 12, 2, -11 },
  { 1138, 9, 15, 12, 1, -11 },
  { 1155, 7, 11, 12, 3, -11 },
  { 1165, 9, 11, 12, 2, -11 },
  { 1178, 9, 13, 12, 1, -13 },
  { 1193, 8, 11, 12, 2, -11 },
  { 1204, 10, 11, 12, 1, -11 },
  { 1218, 12, 11, 12, 0, -11 },
  { 1235, 10, 11, 12, 1, -11 },
  { 1249, 10, 15, 12, 1, -11 },
  { 1268, 9, 11, 12, 2, -11 },
  { 1281, 7, 20, 12, 3, -16 },
  { 1299, 2, 18, 12, 5, -14 },
  { 1304, 7, 20, 12, 3, -16 },
  { 1322, 12, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_Regular20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular20pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_REGULAR20PT7B_H_
