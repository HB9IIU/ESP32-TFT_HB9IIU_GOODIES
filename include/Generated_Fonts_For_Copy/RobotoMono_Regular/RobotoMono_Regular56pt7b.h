#ifndef _ROBOTOMONO_REGULAR56PT7B_H_
#define _ROBOTOMONO_REGULAR56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xEF, 0xDF, 0xFF, 0x3E,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0x78, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x60, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x78,
  0x07, 0x80, 0xF0, 0xF0, 0x07, 0x83, 0xC3, 0xC0, 0x0F, 0x8F, 0x87, 0x80,
  0x0F, 0xFE, 0x1E, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x0F, 0xE0, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x83, 0xF0, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x3C, 0x7F, 0xF8, 0x00,
  0xF0, 0xF9, 0xF0, 0x01, 0xE3, 0xC0, 0xF0, 0x07, 0x87, 0x81, 0xE0, 0x0F,
  0x0F, 0x03, 0xC0, 0x3C, 0x1C, 0x07, 0x80, 0x78, 0x38, 0x07, 0x01, 0xE0,
  0x70, 0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x01, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8,
  0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x0F, 0x8F,
  0xC7, 0xE0, 0x3C, 0x7E, 0x0F, 0xC0, 0xF1, 0xF0, 0x1F, 0x83, 0xCF, 0xC0,
  0x7E, 0x1F, 0x3E, 0x00, 0xFC, 0x7C, 0xF8, 0x01, 0xF9, 0xE3, 0xE0, 0x03,
  0xFF, 0x8F, 0x80, 0x0F, 0xFE, 0x3E, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFE, 0x3F, 0x80,
  0xFF, 0xE0, 0x7F, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xEE, 0xE0, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x20, 0x40, 0x03, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x01,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x30, 0x0E, 0x01, 0x8F, 0xC1, 0xC0, 0xF9,
  0xFE, 0x38, 0xFF, 0x3F, 0xF7, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0x60, 0x07, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0xFE, 0xFE,
  0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0x80, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0x80, 0xFC, 0x7F,
  0xE0, 0x7E, 0x1F, 0xF8, 0x7F, 0x07, 0xFE, 0x3F, 0x01, 0xFF, 0x9F, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE3, 0xF0, 0x03,
  0xF1, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x1F, 0xC3, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xC1, 0xC0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0xFE, 0x00,
  0xF1, 0xFF, 0xE0, 0xFB, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F,
  0x9F, 0xE0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F,
  0xC0, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x83, 0xF8, 0x0F, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFE, 0x03,
  0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F,
  0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xF8,
  0x1F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x7C,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x07,
  0xF3, 0xF0, 0x07, 0xF9, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xDF, 0x07, 0xFF, 0xCF, 0x81, 0xFF, 0xC7, 0x80, 0x0E, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x1F,
  0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x80,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0xC0, 0x70, 0x70, 0x1F, 0xC1, 0xC3, 0xC0, 0xFF, 0xC3, 0x8E, 0x07, 0xFF,
  0x0E, 0x78, 0x3C, 0x1C, 0x39, 0xC0, 0xE0, 0x70, 0xE7, 0x07, 0x83, 0x81,
  0xDC, 0x1C, 0x0E, 0x07, 0xF0, 0xF0, 0x38, 0x1F, 0xC3, 0xC0, 0xE0, 0x7E,
  0x0E, 0x03, 0x81, 0xF8, 0x38, 0x0E, 0x07, 0xE0, 0xE0, 0x38, 0x1F, 0x87,
  0x80, 0xE0, 0x6E, 0x1E, 0x03, 0x83, 0xB8, 0x78, 0x0E, 0x0E, 0xE1, 0xE0,
  0x78, 0x3B, 0x83, 0x81, 0xE0, 0xCF, 0x0F, 0x0F, 0x87, 0x3C, 0x3F, 0xFE,
  0x3C, 0xF0, 0xFF, 0xBF, 0xE1, 0xC1, 0xFE, 0x7F, 0x07, 0x83, 0xE0, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x3F, 0x8F,
  0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3E, 0x00, 0xFF, 0x8F, 0x80, 0x07, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xEF, 0x80, 0x07, 0xF3, 0xE0, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x03, 0xFC, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xE3, 0xE0, 0x07, 0xF8,
  0x7C, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xEF,
  0x80, 0x1F, 0xFE, 0xF8, 0x01, 0xFF, 0xEF, 0x80, 0x1F, 0xFE, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC7, 0xF0,
  0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C,
  0x0F, 0xE0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xF0, 0x07, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0xFE, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0xCF,
  0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7B, 0xFF,
  0xE0, 0x1E, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0x03, 0xDF, 0xFB, 0xC1, 0xF7,
  0xFE, 0xF8, 0x7D, 0xFF, 0x9E, 0x1E, 0x7F, 0xE7, 0x8F, 0x9F, 0xF9, 0xF3,
  0xC7, 0xFE, 0x3C, 0xF1, 0xFF, 0x8F, 0x7C, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8,
  0x7F, 0x87, 0xFE, 0x1F, 0xE1, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F,
  0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78,
  0x1F, 0xF8, 0x1C, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0x80, 0x1F, 0xFB, 0xE0, 0x07, 0xFE, 0x7C,
  0x01, 0xFF, 0x9F, 0x80, 0x7F, 0xE3, 0xE0, 0x1F, 0xF8, 0xFC, 0x07, 0xFE,
  0x1F, 0x01, 0xFF, 0x87, 0xE0, 0x7F, 0xE0, 0xF8, 0x1F, 0xF8, 0x3F, 0x07,
  0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF8, 0x7F, 0xE0, 0x3E, 0x1F, 0xF8, 0x0F,
  0xC7, 0xFE, 0x01, 0xF1, 0xFF, 0x80, 0x3E, 0x7F, 0xE0, 0x0F, 0x9F, 0xF8,
  0x01, 0xF7, 0xFE, 0x00, 0x7D, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0xFB, 0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x06, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xFE, 0x3E, 0x00, 0x3F, 0x8F, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x0F, 0xE3, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0,
  0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x03, 0xF0,
  0x1F, 0x78, 0x0F, 0xC0, 0x7D, 0xE0, 0x3F, 0x01, 0xF7, 0x80, 0xFC, 0x07,
  0xDF, 0x03, 0xF8, 0x1E, 0x7C, 0x1F, 0xE0, 0x79, 0xF0, 0x7F, 0x81, 0xE7,
  0xC1, 0xFE, 0x0F, 0x9F, 0x07, 0xF8, 0x3E, 0x7C, 0x1E, 0xF0, 0xF8, 0xF0,
  0x7B, 0xC3, 0xE3, 0xC3, 0xCF, 0x0F, 0x8F, 0x0F, 0x3C, 0x3C, 0x3E, 0x3C,
  0xF0, 0xF0, 0xF8, 0xF3, 0xC3, 0xC3, 0xE3, 0xC7, 0x8F, 0x0F, 0x8F, 0x1E,
  0x3C, 0x3E, 0x78, 0x79, 0xF0, 0x79, 0xE1, 0xE7, 0xC1, 0xE7, 0x87, 0x9F,
  0x07, 0x9E, 0x1E, 0x78, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xE0, 0xF7, 0x81,
  0xFF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0x78, 0x1F, 0xF0, 0x3D, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xDF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x7C,
  0x07, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x8F, 0x00, 0x7C, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8,
  0x0F, 0xE1, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFD, 0xF0, 0xFF, 0xF8, 0xF8, 0x3F, 0xF0, 0x7C, 0x00, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x87, 0xF8, 0x07, 0xCF, 0xFF, 0x03, 0xEF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC3, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xCF, 0xE0, 0x07, 0xE7, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0xF9, 0xFF, 0xF0, 0x78, 0x7F, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7D, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x3F, 0x83,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0xF8, 0x1F, 0xFE, 0x7C, 0x1F,
  0xFF, 0xBE, 0x1F, 0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0x9F, 0xC0, 0x3F, 0xCF,
  0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF8, 0xFC,
  0x07, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xDF, 0x07, 0xFF, 0xCF, 0x80,
  0xFF, 0xC7, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xE0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x21, 0xF8, 0x00, 0x1C,
  0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xFC, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x0F, 0x81, 0xFF, 0xE7, 0xC3, 0xFF, 0xFB, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFE, 0x1F, 0xF9, 0xFC, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x7F, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFD, 0xF0, 0x7F, 0xFC, 0xF8, 0x0F, 0xFC, 0x7C, 0x00,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x08, 0x00, 0x0F, 0x86,
  0x00, 0x0F, 0xC7, 0x80, 0x07, 0xC7, 0xF0, 0x0F, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x3F, 0xC0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF,
  0xFC, 0xFF, 0xC1, 0xFE, 0xFF, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFD, 0x87,
  0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0,
  0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0,
  0x03, 0xE7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0xF8, 0x01, 0xFC, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0xBE,
  0x00, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x3F,
  0x8F, 0x3F, 0xE7, 0xFC, 0xF7, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x3F, 0xC3, 0xFF, 0x81, 0xF8, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0,
  0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF,
  0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F,
  0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F,
  0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01,
  0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01,
  0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0,
  0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xF0,
  0xF1, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE, 0xFF, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x83, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x7F, 0x80,
  0x78, 0xFF, 0xF0, 0x3E, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC7, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xBF, 0xFE, 0x07, 0xC7, 0xFE, 0x03, 0xE0, 0x10, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0x81, 0xFF, 0xE7,
  0xC3, 0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xF9, 0xFC, 0x01,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x9F, 0xC0, 0x3F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0xF8, 0x0F, 0xFC, 0x7C, 0x00, 0x40, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x81, 0xFE, 0x7E, 0x00, 0x7E,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x06, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7F, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFE, 0x1F, 0x00, 0x30, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x78, 0x03, 0xC0, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0x03, 0xC0, 0x1E,
  0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3C, 0x3C, 0x07, 0xE0, 0x3C,
  0x3C, 0x07, 0xE0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x7C,
  0x3E, 0x0E, 0xF0, 0x78, 0x1E, 0x0E, 0x70, 0x78, 0x1E, 0x1E, 0x78, 0x78,
  0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x0F, 0x1C, 0x38, 0xF0,
  0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x38, 0x3C, 0xF0,
  0x0F, 0x38, 0x1C, 0xF0, 0x07, 0x78, 0x1C, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x10, 0x7F,
  0xF8, 0x00, 0x79, 0xFF, 0xFC, 0x00, 0xF7, 0xFF, 0xFC, 0x01, 0xEF, 0x81,
  0xFE, 0x07, 0xDE, 0x01, 0xFF, 0x7F, 0x78, 0x00, 0xFF, 0xFE, 0xF0, 0x00,
  0xFF, 0xF8, 0x20, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 7, 40, 34, 13, -40 },
  { 36, 14, 13, 34, 10, -42 },
  { 59, 30, 40, 34, 2, -40 },
  { 209, 26, 52, 34, 4, -46 },
  { 378, 31, 41, 34, 1, -40 },
  { 537, 30, 41, 34, 3, -40 },
  { 691, 4, 13, 34, 14, -42 },
  { 698, 14, 58, 34, 10, -45 },
  { 800, 14, 58, 34, 9, -45 },
  { 902, 27, 27, 34, 4, -40 },
  { 994, 28, 29, 34, 3, -33 },
  { 1096, 8, 15, 34, 10, -6 },
  { 1111, 21, 5, 34, 6, -20 },
  { 1125, 8, 8, 34, 14, -7 },
  { 1133, 21, 43, 34, 7, -40 },
  { 1246, 26, 41, 34, 4, -40 },
  { 1380, 15, 40, 34, 6, -40 },
  { 1455, 27, 40, 34, 2, -40 },
  { 1590, 25, 41, 34, 3, -40 },
  { 1719, 29, 40, 34, 2, -40 },
  { 1864, 25, 41, 34, 5, -40 },
  { 1993, 25, 41, 34, 4, -40 },
  { 2122, 27, 40, 34, 3, -40 },
  { 2257, 25, 41, 34, 5, -40 },
  { 2386, 25, 40, 34, 4, -40 },
  { 2511, 8, 32, 34, 15, -31 },
  { 2543, 10, 40, 34, 13, -31 },
  { 2593, 23, 25, 34, 5, -30 },
  { 2665, 24, 16, 34, 5, -26 },
  { 2713, 24, 25, 34, 5, -30 },
  { 2788, 24, 40, 34, 5, -40 },
  { 2908, 30, 40, 34, 2, -40 },
  { 3058, 30, 40, 34, 2, -40 },
  { 3208, 26, 40, 34, 5, -40 },
  { 3338, 28, 41, 34, 3, -40 },
  { 3482, 27, 40, 34, 4, -40 },
  { 3617, 24, 40, 34, 5, -40 },
  { 3737, 25, 40, 34, 5, -40 },
  { 3862, 28, 41, 34, 3, -40 },
  { 4006, 26, 40, 34, 4, -40 },
  { 4136, 24, 40, 34, 5, -40 },
  { 4256, 26, 41, 34, 3, -40 },
  { 4390, 27, 40, 34, 5, -40 },
  { 4525, 25, 40, 34, 5, -40 },
  { 4650, 26, 40, 34, 4, -40 },
  { 4780, 26, 40, 34, 4, -40 },
  { 4910, 28, 41, 34, 3, -40 },
  { 5054, 26, 40, 34, 5, -40 },
  { 5184, 29, 47, 34, 3, -40 },
  { 5355, 26, 40, 34, 5, -40 },
  { 5485, 28, 41, 34, 3, -40 },
  { 5629, 30, 40, 34, 2, -40 },
  { 5779, 26, 41, 34, 4, -40 },
  { 5913, 29, 40, 34, 2, -40 },
  { 6058, 30, 40, 34, 2, -40 },
  { 6208, 30, 40, 34, 2, -40 },
  { 6358, 29, 40, 34, 2, -40 },
  { 6503, 27, 40, 34, 3, -40 },
  { 6638, 10, 55, 34, 12, -46 },
  { 6707, 22, 43, 34, 6, -40 },
  { 6826, 11, 55, 34, 11, -46 },
  { 6902, 21, 21, 34, 6, -40 },
  { 6958, 25, 4, 34, 4, 0 },
  { 6971, 11, 8, 34, 11, -41 },
  { 6982, 25, 31, 34, 4, -30 },
  { 7079, 25, 43, 34, 5, -42 },
  { 7214, 25, 31, 34, 4, -30 },
  { 7311, 25, 43, 34, 4, -42 },
  { 7446, 26, 31, 34, 4, -30 },
  { 7547, 27, 43, 34, 4, -43 },
  { 7693, 25, 42, 34, 4, -30 },
  { 7825, 24, 42, 34, 5, -42 },
  { 7951, 24, 40, 34, 6, -40 },
  { 8071, 17, 52, 34, 6, -40 },
  { 8182, 26, 42, 34, 5, -42 },
  { 8319, 24, 42, 34, 6, -42 },
  { 8445, 28, 30, 34, 3, -30 },
  { 8550, 24, 30, 34, 5, -30 },
  { 8640, 27, 31, 34, 3, -30 },
  { 8745, 25, 41, 34, 5, -30 },
  { 8874, 25, 41, 34, 4, -30 },
  { 9003, 20, 30, 34, 9, -30 },
  { 9078, 24, 31, 34, 5, -30 },
  { 9171, 25, 38, 34, 4, -37 },
  { 9290, 24, 31, 34, 5, -30 },
  { 9383, 28, 30, 34, 3, -30 },
  { 9488, 32, 30, 34, 1, -30 },
  { 9608, 28, 30, 34, 3, -30 },
  { 9713, 30, 42, 34, 2, -30 },
  { 9871, 26, 30, 34, 4, -30 },
  { 9969, 18, 54, 34, 9, -44 },
  { 10091, 4, 51, 34, 15, -40 },
  { 10117, 18, 54, 34, 9, -44 },
  { 10239, 31, 11, 34, 1, -22 },
};

const GFXfont RobotoMono_Regular56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular56pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_REGULAR56PT7B_H_
