#ifndef _ROBOTOMONO_REGULAR63PT7B_H_
#define _ROBOTOMONO_REGULAR63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x87,
  0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x80, 0x3E, 0x03, 0xE0, 0x18, 0x07, 0xC0,
  0x3C, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x03,
  0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x80, 0xF8, 0x7C,
  0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xC3, 0xE0, 0x01, 0xFB, 0xF8,
  0x78, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x03, 0xFF, 0x83, 0xC0, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xF0, 0x00, 0x03, 0xE1, 0xFF, 0x80, 0x00, 0x78, 0x7F, 0xF8, 0x00,
  0x1F, 0x1F, 0xFF, 0x80, 0x03, 0xC3, 0xE0, 0xF8, 0x00, 0xF0, 0xF8, 0x1F,
  0x00, 0x3E, 0x1E, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x01, 0xF0, 0x78,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x0C, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0x87, 0xFB, 0xF8, 0x07, 0xC1, 0xFC, 0x7F, 0x01, 0xF0, 0xFE, 0x0F, 0xC0,
  0x7C, 0x7F, 0x01, 0xF8, 0x1F, 0x1F, 0x80, 0x7F, 0x07, 0xC7, 0xE0, 0x0F,
  0xE3, 0xF3, 0xF0, 0x01, 0xF8, 0xF8, 0xFC, 0x00, 0x3F, 0x3E, 0x3F, 0x00,
  0x0F, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0x3F, 0xF0, 0x7E,
  0x00, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x02, 0x40, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x01, 0x9F,
  0x01, 0xE0, 0x7C, 0xFF, 0x0F, 0x0F, 0xFF, 0xFE, 0x79, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x38, 0x00, 0xF0, 0x00, 0x80, 0x02, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF0, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E,
  0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFD, 0xFF, 0xC0, 0x3F, 0xCF, 0xFE, 0x03, 0xF8,
  0x7F, 0xF0, 0x3F, 0x83, 0xFF, 0x87, 0xF8, 0x1F, 0xFC, 0x7F, 0x00, 0xFF,
  0xE7, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7D, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0xE0, 0x03, 0xEF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87,
  0xF8, 0x07, 0xFC, 0x7E, 0x00, 0x1F, 0xC0, 0x40, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x1F, 0xF8, 0x03, 0xE3, 0xFF, 0xF0, 0x1F, 0x3F, 0xFF, 0xC0,
  0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0, 0x0F, 0xE3, 0xFE,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x83, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1,
  0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xF1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0x3E, 0x03, 0xFF,
  0xE3, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0x81, 0x00, 0x1F, 0x07, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0x8F,
  0xF0, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x04, 0x03, 0xC1, 0xE0, 0x1F, 0xE0, 0x70, 0x78, 0x0F, 0xFC, 0x1E, 0x3C,
  0x07, 0xFF, 0x87, 0x8F, 0x03, 0xF1, 0xE0, 0xE3, 0x81, 0xF0, 0x78, 0x39,
  0xE0, 0x78, 0x1E, 0x0E, 0x78, 0x3C, 0x07, 0x03, 0xDE, 0x0F, 0x01, 0xC0,
  0xF7, 0x03, 0xC0, 0x70, 0x3D, 0xC1, 0xE0, 0x1C, 0x0F, 0xF0, 0x78, 0x07,
  0x03, 0xFC, 0x1E, 0x01, 0xC0, 0xFF, 0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xE0,
  0x3C, 0x0E, 0xF0, 0x70, 0x0F, 0x03, 0xBC, 0x1C, 0x03, 0xC0, 0xEF, 0x07,
  0x00, 0xF0, 0x3B, 0xC1, 0xE0, 0x38, 0x1E, 0xF0, 0x78, 0x1E, 0x07, 0x3C,
  0x1E, 0x07, 0x81, 0xCF, 0x07, 0xC7, 0xF0, 0xF1, 0xE1, 0xFF, 0xFE, 0x78,
  0x78, 0x3F, 0xE7, 0xFC, 0x1E, 0x07, 0xF9, 0xFE, 0x07, 0xC0, 0xF8, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x07, 0xF0,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x07, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07,
  0xF0, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x0F,
  0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xF7, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x07, 0xC3,
  0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x01, 0xFE, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0xFD, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xF7,
  0xFF, 0xF0, 0x0F, 0xBF, 0xFF, 0x80, 0x7D, 0xFF, 0xBE, 0x07, 0xCF, 0xFD,
  0xF0, 0x3E, 0x7F, 0xEF, 0x81, 0xF3, 0xFF, 0x3E, 0x1F, 0x1F, 0xF9, 0xF0,
  0xF8, 0xFF, 0xCF, 0x87, 0xC7, 0xFE, 0x3E, 0x7C, 0x3F, 0xF1, 0xF3, 0xE3,
  0xFF, 0x8F, 0x9F, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0,
  0xFF, 0xE0, 0x3C, 0x07, 0xFF, 0x01, 0xE0, 0x3F, 0xF8, 0x0F, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0x80, 0x0F, 0xFE, 0xFC, 0x00, 0x7F, 0xF3,
  0xF0, 0x03, 0xFF, 0x9F, 0x80, 0x1F, 0xFC, 0x7E, 0x00, 0xFF, 0xE3, 0xF0,
  0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xF8, 0x7E, 0x01, 0xFF, 0xC1, 0xF8, 0x0F,
  0xFE, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFC,
  0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0x00, 0xFC, 0x3F, 0xF8, 0x03,
  0xE1, 0xFF, 0xC0, 0x1F, 0x8F, 0xFE, 0x00, 0x7C, 0x7F, 0xF0, 0x03, 0xF3,
  0xFF, 0x80, 0x0F, 0x9F, 0xFC, 0x00, 0x7E, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x1F,
  0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x3F, 0xC3,
  0xE0, 0x00, 0x7F, 0x1F, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x1F, 0x8F, 0x80, 0x03, 0xFC, 0x7C, 0x00, 0x7F, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xFF, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x00, 0x7D, 0xF0, 0x0F, 0xC0,
  0x1F, 0x7C, 0x03, 0xF8, 0x07, 0xDF, 0x00, 0xFE, 0x03, 0xF7, 0xC0, 0x3F,
  0x80, 0xFD, 0xF0, 0x0F, 0xE0, 0x3E, 0x7E, 0x07, 0xF8, 0x0F, 0x9F, 0x81,
  0xFE, 0x03, 0xE7, 0xE0, 0x7F, 0xC0, 0xF8, 0xF8, 0x1F, 0xF0, 0x3E, 0x3E,
  0x07, 0xBC, 0x0F, 0x8F, 0x83, 0xEF, 0x03, 0xE3, 0xE0, 0xFB, 0xC1, 0xF8,
  0xF8, 0x3E, 0xF0, 0x7E, 0x3E, 0x0F, 0x3E, 0x1F, 0x0F, 0x83, 0xCF, 0x87,
  0xC3, 0xF0, 0xF1, 0xE1, 0xF0, 0x7C, 0x7C, 0x78, 0x7C, 0x1F, 0x1F, 0x1E,
  0x1F, 0x07, 0xC7, 0xC7, 0xC7, 0xC1, 0xF1, 0xE1, 0xF1, 0xF0, 0x7C, 0x78,
  0x7C, 0x7C, 0x1F, 0x1E, 0x0F, 0x3E, 0x07, 0xCF, 0x83, 0xCF, 0x81, 0xF3,
  0xE0, 0xF3, 0xE0, 0x3E, 0xF8, 0x3E, 0xF8, 0x0F, 0xBC, 0x0F, 0xBE, 0x03,
  0xEF, 0x03, 0xEF, 0x80, 0xFB, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1E, 0xF8,
  0x0F, 0xFC, 0x07, 0xBC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0,
  0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xC0, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0xE7, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x7F,
  0x0F, 0xFF, 0xE3, 0xF0, 0x3F, 0xF8, 0x3F, 0x00, 0x30, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x03, 0xF1, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC,
  0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0xFE, 0x3F, 0xFC, 0x3F, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xF0, 0x7E, 0x7F, 0xFE, 0x03, 0xF0, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xF8,
  0x1F, 0x00, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF, 0x9F, 0x07, 0xFF, 0xFD, 0xF0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x1F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFD, 0xF0, 0x1F, 0xFF, 0x9F, 0x00, 0xFF, 0xE1, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0x03, 0xF8, 0x00, 0x06, 0x07, 0xF0, 0x00, 0x3C, 0x1F, 0xE0, 0x03,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xE1, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x1F, 0x03,
  0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xDF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x03,
  0xFF, 0x1F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x87,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0x01, 0xFF, 0xF9, 0xF0,
  0x0F, 0xFE, 0x1F, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xC7, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF,
  0x8F, 0xDF, 0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0xCF, 0xF8, 0x00, 0xFE, 0xFF,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC7, 0x1F, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x4F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0xF9,
  0xFF, 0x0F, 0xF8, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xF0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x07, 0xF0, 0x0F, 0xC1, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0x0F, 0xCF, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xEF,
  0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xC7, 0xFF, 0x80, 0xFC, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xCF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFC,
  0xFF, 0x80, 0x3F, 0xCF, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xDF,
  0xFF, 0xF0, 0xFC, 0xFF, 0xFC, 0x0F, 0xC3, 0xFF, 0x80, 0xFC, 0x07, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0x1F, 0x03, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xDF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0x01,
  0xFF, 0xF9, 0xF0, 0x0F, 0xFE, 0x1F, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFD, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE3,
  0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x01,
  0xFF, 0x7F, 0xC3, 0xFF, 0xCF, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE, 0x7C, 0x3F,
  0xFF, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0x3C,
  0x3E, 0x01, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x03, 0xFC,
  0x07, 0xC1, 0xE0, 0x3F, 0xC0, 0x7C, 0x1F, 0x03, 0xDE, 0x07, 0x81, 0xF0,
  0x79, 0xE0, 0x78, 0x1F, 0x07, 0x9E, 0x0F, 0x81, 0xF0, 0x79, 0xE0, 0xF8,
  0x0F, 0x07, 0x9F, 0x0F, 0x80, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x8F, 0x0F,
  0x0F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F, 0x8F, 0x0F, 0x9F, 0x00, 0x79,
  0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x79, 0xE0,
  0x07, 0xDE, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0x8F, 0xFF, 0xE0, 0x00, 0xF3, 0xFF, 0xFE, 0x00, 0x1E, 0x7F, 0x3F, 0xF0,
  0x07, 0xDF, 0x80, 0xFF, 0x01, 0xF3, 0xE0, 0x0F, 0xFC, 0xFE, 0x78, 0x00,
  0xFF, 0xFF, 0x8F, 0x00, 0x07, 0xFF, 0xF3, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00,
};

const GFXglyph RobotoMono_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 7, 45, 38, 15, -45 },
  { 41, 16, 14, 38, 11, -47 },
  { 69, 34, 45, 38, 2, -45 },
  { 261, 29, 58, 38, 5, -52 },
  { 472, 35, 46, 38, 1, -45 },
  { 674, 34, 46, 38, 3, -45 },
  { 870, 5, 14, 38, 15, -47 },
  { 879, 16, 65, 38, 11, -51 },
  { 1009, 16, 65, 38, 10, -51 },
  { 1139, 29, 30, 38, 5, -45 },
  { 1248, 30, 33, 38, 4, -37 },
  { 1372, 9, 17, 38, 11, -7 },
  { 1392, 23, 5, 38, 7, -22 },
  { 1407, 9, 9, 38, 15, -8 },
  { 1418, 24, 49, 38, 8, -45 },
  { 1565, 29, 46, 38, 4, -45 },
  { 1732, 18, 45, 38, 6, -45 },
  { 1834, 30, 45, 38, 3, -45 },
  { 2003, 28, 46, 38, 3, -45 },
  { 2164, 33, 45, 38, 2, -45 },
  { 2350, 28, 46, 38, 6, -45 },
  { 2511, 29, 46, 38, 4, -45 },
  { 2678, 31, 45, 38, 3, -45 },
  { 2853, 29, 46, 38, 5, -45 },
  { 3020, 28, 45, 38, 5, -45 },
  { 3178, 9, 36, 38, 17, -35 },
  { 3219, 11, 45, 38, 15, -35 },
  { 3281, 26, 28, 38, 5, -34 },
  { 3372, 28, 18, 38, 5, -29 },
  { 3435, 28, 28, 38, 5, -34 },
  { 3533, 26, 45, 38, 6, -45 },
  { 3680, 34, 45, 38, 2, -45 },
  { 3872, 34, 45, 38, 2, -45 },
  { 4064, 29, 45, 38, 5, -45 },
  { 4228, 31, 46, 38, 3, -45 },
  { 4407, 30, 45, 38, 5, -45 },
  { 4576, 27, 45, 38, 6, -45 },
  { 4728, 27, 45, 38, 6, -45 },
  { 4880, 31, 46, 38, 3, -45 },
  { 5059, 29, 45, 38, 4, -45 },
  { 5223, 27, 45, 38, 5, -45 },
  { 5375, 29, 46, 38, 3, -45 },
  { 5542, 32, 45, 38, 5, -45 },
  { 5722, 28, 45, 38, 6, -45 },
  { 5880, 29, 45, 38, 5, -45 },
  { 6044, 29, 45, 38, 4, -45 },
  { 6208, 31, 46, 38, 3, -45 },
  { 6387, 29, 45, 38, 6, -45 },
  { 6551, 33, 53, 38, 3, -45 },
  { 6770, 29, 45, 38, 6, -45 },
  { 6934, 31, 46, 38, 4, -45 },
  { 7113, 34, 45, 38, 2, -45 },
  { 7305, 30, 46, 38, 4, -45 },
  { 7478, 33, 45, 38, 2, -45 },
  { 7664, 34, 45, 38, 2, -45 },
  { 7856, 33, 45, 38, 3, -45 },
  { 8042, 33, 45, 38, 2, -45 },
  { 8228, 30, 45, 38, 3, -45 },
  { 8397, 12, 61, 38, 13, -51 },
  { 8489, 24, 49, 38, 7, -45 },
  { 8636, 13, 61, 38, 12, -51 },
  { 8736, 24, 24, 38, 7, -45 },
  { 8808, 28, 5, 38, 5, 0 },
  { 8826, 12, 9, 38, 13, -46 },
  { 8840, 28, 35, 38, 5, -34 },
  { 8963, 29, 48, 38, 5, -47 },
  { 9137, 29, 35, 38, 4, -34 },
  { 9264, 28, 48, 38, 4, -47 },
  { 9432, 30, 35, 38, 4, -34 },
  { 9564, 30, 49, 38, 5, -49 },
  { 9748, 28, 47, 38, 4, -34 },
  { 9913, 28, 47, 38, 5, -47 },
  { 10078, 28, 45, 38, 6, -45 },
  { 10236, 20, 58, 38, 6, -45 },
  { 10381, 30, 47, 38, 5, -47 },
  { 10558, 28, 47, 38, 6, -47 },
  { 10723, 32, 34, 38, 3, -34 },
  { 10859, 28, 34, 38, 5, -34 },
  { 10978, 30, 35, 38, 4, -34 },
  { 11110, 28, 47, 38, 5, -34 },
  { 11275, 28, 47, 38, 4, -34 },
  { 11440, 23, 34, 38, 10, -34 },
  { 11538, 28, 35, 38, 5, -34 },
  { 11661, 29, 42, 38, 4, -41 },
  { 11814, 26, 34, 38, 6, -33 },
  { 11925, 32, 33, 38, 3, -33 },
  { 12057, 36, 33, 38, 1, -33 },
  { 12206, 32, 33, 38, 3, -33 },
  { 12338, 34, 46, 38, 2, -33 },
  { 12534, 28, 33, 38, 5, -33 },
  { 12650, 21, 60, 38, 10, -49 },
  { 12808, 4, 57, 38, 17, -45 },
  { 12837, 21, 60, 38, 10, -49 },
  { 12995, 35, 13, 38, 1, -25 },
};

const GFXfont RobotoMono_Regular63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular63pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_REGULAR63PT7B_H_
