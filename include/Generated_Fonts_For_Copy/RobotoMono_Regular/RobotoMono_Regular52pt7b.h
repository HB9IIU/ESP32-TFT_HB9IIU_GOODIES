#ifndef _ROBOTOMONO_REGULAR52PT7B_H_
#define _ROBOTOMONO_REGULAR52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x70, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x3C,
  0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xC0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x0F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x78, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x1C, 0x04, 0x03, 0xC0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x3C,
  0x0F, 0x0F, 0x01, 0xE0, 0x78, 0xF0, 0x07, 0x07, 0x87, 0x00, 0x3E, 0x7C,
  0x78, 0x00, 0xFF, 0xC3, 0x80, 0x03, 0xFC, 0x3C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0x87, 0xF8, 0x00, 0x3C, 0x7F, 0xE0, 0x01, 0xC7, 0xCF, 0x80, 0x1E, 0x3C,
  0x1E, 0x00, 0xE1, 0xC0, 0xF0, 0x0F, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x3C,
  0x07, 0x87, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xC1, 0xE0, 0x78, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0x8F,
  0xCF, 0x80, 0xF3, 0xF0, 0xF8, 0x1E, 0x7C, 0x0F, 0x83, 0xDF, 0x01, 0xF8,
  0xFB, 0xE0, 0x1F, 0x9F, 0x7C, 0x01, 0xF3, 0xCF, 0x00, 0x1F, 0xF9, 0xE0,
  0x03, 0xFE, 0x3E, 0x00, 0x3F, 0xC7, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0xF7, 0xC0, 0xFF,
  0xFC, 0x7C, 0x0F, 0xFE, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEE,
  0xEE, 0xEE, 0xEE, 0x00, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x04, 0x40, 0x01, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x60, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x60, 0x3C, 0x02, 0x78, 0x1C, 0x0F, 0x7F, 0x1C, 0x7F,
  0xFF, 0xDD, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xE7, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x00, 0xF8, 0x06, 0x00, 0x70, 0x02, 0x00, 0x40, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x79, 0xF3, 0xCF, 0x8E, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xCF, 0xF8,
  0x3F, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0x9F, 0xF0, 0x3F, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0xF8, 0x1F,
  0xF3, 0xF0, 0x1F, 0xF7, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C,
  0x3F, 0x00, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF8,
  0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xE0, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x3F, 0x00, 0x7C, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F,
  0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x9F, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFE, 0x0F, 0xF1, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7F, 0x8F,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x0F, 0xE0, 0x3E, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF1, 0xFE, 0x03, 0xF3, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80,
  0x07, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x7E, 0x3F, 0x01, 0xF8,
  0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xF7, 0xF8, 0x1F,
  0x80, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xC1, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x81, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0x7E, 0x1F, 0xE7, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0xFF, 0x7F, 0x83, 0xF0, 0x3F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xFB,
  0xF0, 0x0F, 0xF3, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0x83,
  0xFF, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x0C, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9,
  0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x1F, 0x07, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x3C, 0x0F, 0xE1, 0xC3, 0x81, 0xFF, 0x0E, 0x38, 0x3F,
  0xF0, 0xE7, 0x07, 0x87, 0x0E, 0x70, 0x70, 0x70, 0xE7, 0x0F, 0x07, 0x06,
  0xE0, 0xE0, 0x70, 0x6E, 0x0E, 0x07, 0x06, 0xE1, 0xC0, 0x70, 0x6E, 0x1C,
  0x06, 0x06, 0xE1, 0xC0, 0x60, 0x6E, 0x1C, 0x0E, 0x0E, 0xE1, 0xC0, 0xE0,
  0xEE, 0x1C, 0x0E, 0x0E, 0xE1, 0xC0, 0xE0, 0xEE, 0x1C, 0x0E, 0x0C, 0xE1,
  0xE1, 0xE1, 0xCE, 0x1F, 0xFF, 0x38, 0xF0, 0xFF, 0x7F, 0x87, 0x0F, 0xE7,
  0xF0, 0x70, 0x38, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x10, 0x00, 0xFC, 0x07, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0xF8, 0x1E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x7C, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xF8,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x7C,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xEF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0x80, 0xFF,
  0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x03, 0xF1, 0xF0, 0x03,
  0xF0, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xF8,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3E,
  0x00, 0x1F, 0x1F, 0xC0, 0x1F, 0x87, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF,
  0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xE7,
  0xE0, 0x00, 0xFB, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xBE, 0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x83, 0xCF, 0xF7, 0x83, 0xCF, 0xF3, 0xC3,
  0xCF, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xEF,
  0x0F, 0xF1, 0xEF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE,
  0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C,
  0x1F, 0xF0, 0x38, 0x1F, 0xF0, 0x38, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xF7, 0x80, 0x1F, 0xF7, 0xC0, 0x1F, 0xF3, 0xC0,
  0x1F, 0xF3, 0xE0, 0x1F, 0xF1, 0xE0, 0x1F, 0xF1, 0xF0, 0x1F, 0xF0, 0xF0,
  0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x3E,
  0x1F, 0xF0, 0x3E, 0x1F, 0xF0, 0x1F, 0x1F, 0xF0, 0x1F, 0x1F, 0xF0, 0x0F,
  0x9F, 0xF0, 0x0F, 0x9F, 0xF0, 0x07, 0xDF, 0xF0, 0x07, 0xDF, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x3C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x63, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03,
  0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E,
  0x3F, 0x80, 0x3F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xEF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0x78, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81,
  0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81,
  0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x3F, 0x81, 0xE7, 0x83, 0xFC, 0x1E, 0x78,
  0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x39, 0xC3, 0xC7, 0xC3, 0x9C,
  0x3C, 0x3C, 0x79, 0xE3, 0xC3, 0xC7, 0x9E, 0x3C, 0x3C, 0x79, 0xE3, 0xC3,
  0xC7, 0x9E, 0x3C, 0x3C, 0x70, 0xE3, 0xC3, 0xCF, 0x0E, 0x3C, 0x3C, 0xF0,
  0xF7, 0xC3, 0xEF, 0x0F, 0x78, 0x1E, 0xF0, 0xF7, 0x81, 0xEE, 0x0F, 0x78,
  0x1E, 0xE0, 0x77, 0x81, 0xFE, 0x07, 0x78, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x01,
  0xE3, 0xC0, 0x3C, 0x7C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF0,
  0x1F, 0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x80, 0x1E, 0x7C, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF,
  0x00, 0x0F, 0xBF, 0x00, 0x3F, 0x3F, 0x01, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0x7C, 0x7F, 0xFC, 0xF8, 0x3F, 0xE1, 0xF0, 0x04, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0xF9,
  0xFF, 0xC0, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xF8, 0xFE,
  0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x7C, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFB,
  0xFF, 0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x1F, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x80, 0x07, 0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0xC7, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xE1, 0xF0, 0x7F, 0xF3,
  0xE1, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0x7E, 0x00, 0xFE,
  0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7,
  0xC0, 0xFF, 0x8F, 0x80, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x20, 0xFC, 0x00, 0x3C, 0x3F, 0x00, 0x3E, 0x0F, 0xF1, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xE0, 0x10, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x7C,
  0x3F, 0xFE, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0xEF, 0xC0, 0x1F, 0xDF,
  0x00, 0x1F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F,
  0x9F, 0x80, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFE, 0xF8,
  0x1F, 0xF1, 0xF0, 0x03, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x08,
  0x00, 0x3E, 0x38, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xFC, 0x0F, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x0F, 0x8F, 0xFE,
  0x1F, 0x3F, 0xFE, 0x3E, 0xFF, 0xFE, 0x7F, 0xC0, 0xFE, 0xFF, 0x00, 0x7D,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x4F, 0x80,
  0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F,
  0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x1F, 0xC7, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFE, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x3E, 0x1F, 0x7F, 0x9F, 0xF3, 0xFF,
  0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xC3, 0xF8, 0x7F, 0xF0, 0x3E, 0x07,
  0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03,
  0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3F,
  0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F,
  0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF,
  0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8,
  0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC,
  0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x81, 0xF1, 0xFF, 0xC3, 0xE7, 0xFF, 0xC7,
  0xDF, 0xFF, 0xCF, 0xF8, 0x1F, 0xDF, 0xE0, 0x0F, 0xBF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0xE3, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xF9, 0xFF,
  0xC0, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xF8, 0xFE, 0x00,
  0xFC, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7C, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFB, 0xFF, 0xE0, 0xF8, 0xFF, 0x80, 0xF8, 0x0C, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x7C, 0x3F, 0xFE,
  0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0xEF, 0xC0, 0x1F, 0xDF, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x80, 0x1F, 0x9F, 0x80,
  0x7F, 0x3F, 0xC7, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFE, 0xF8, 0x1F, 0xF1,
  0xF0, 0x03, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xDF,
  0x0F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x9F, 0x00,
  0x3F, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x04, 0x00, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x3F,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7C, 0x7F, 0xF9, 0xF0, 0xFF, 0xC7, 0xC0,
  0x30, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x07,
  0x00, 0x7B, 0xC0, 0x3C, 0x03, 0xDE, 0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x01,
  0xE7, 0x80, 0xF8, 0x0F, 0x3C, 0x07, 0xE0, 0x78, 0xF0, 0x7F, 0x03, 0xC7,
  0x83, 0xB8, 0x1E, 0x3C, 0x1D, 0xC0, 0xE1, 0xE0, 0xEF, 0x0F, 0x07, 0x0F,
  0x78, 0x78, 0x3C, 0x79, 0xC3, 0xC1, 0xE3, 0x8E, 0x1C, 0x0F, 0x1C, 0x78,
  0xE0, 0x79, 0xE3, 0xCF, 0x01, 0xCF, 0x0E, 0x78, 0x0E, 0x70, 0x73, 0xC0,
  0x7B, 0x83, 0xDC, 0x03, 0xDC, 0x0E, 0xE0, 0x1F, 0xE0, 0x77, 0x00, 0x7E,
  0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x03,
  0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0,
  0xFC, 0x00, 0x1F, 0xCF, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xE0, 0x7C, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x8F, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xCF, 0xFF, 0x80, 0x1E, 0xFF, 0xFE, 0x00, 0xF7, 0xC1,
  0xFC, 0x0F, 0x3C, 0x07, 0xF9, 0xFB, 0xC0, 0x1F, 0xFF, 0x9E, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph RobotoMono_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 6, 37, 31, 12, -37 },
  { 29, 13, 12, 31, 9, -39 },
  { 49, 28, 37, 31, 2, -37 },
  { 179, 24, 48, 31, 4, -43 },
  { 323, 29, 39, 31, 1, -38 },
  { 465, 27, 39, 31, 3, -38 },
  { 597, 4, 12, 31, 13, -39 },
  { 603, 13, 54, 31, 9, -42 },
  { 691, 14, 54, 31, 8, -42 },
  { 786, 24, 25, 31, 4, -37 },
  { 861, 25, 27, 31, 3, -31 },
  { 946, 7, 15, 31, 9, -6 },
  { 960, 19, 4, 31, 6, -18 },
  { 970, 7, 7, 31, 13, -7 },
  { 977, 20, 40, 31, 6, -37 },
  { 1077, 24, 39, 31, 4, -38 },
  { 1194, 15, 37, 31, 5, -37 },
  { 1264, 25, 37, 31, 2, -37 },
  { 1380, 24, 38, 31, 2, -37 },
  { 1494, 27, 37, 31, 2, -37 },
  { 1619, 23, 38, 31, 5, -37 },
  { 1729, 23, 38, 31, 4, -37 },
  { 1839, 25, 37, 31, 3, -37 },
  { 1955, 24, 38, 31, 4, -37 },
  { 2069, 23, 37, 31, 4, -37 },
  { 2176, 7, 29, 31, 14, -29 },
  { 2202, 9, 38, 31, 12, -29 },
  { 2245, 22, 23, 31, 4, -28 },
  { 2309, 23, 15, 31, 4, -24 },
  { 2353, 22, 23, 31, 5, -28 },
  { 2417, 22, 37, 31, 5, -37 },
  { 2519, 28, 37, 31, 2, -37 },
  { 2649, 28, 37, 31, 2, -37 },
  { 2779, 24, 37, 31, 4, -37 },
  { 2890, 25, 38, 31, 3, -37 },
  { 3009, 25, 37, 31, 4, -37 },
  { 3125, 22, 37, 31, 5, -37 },
  { 3227, 23, 37, 31, 5, -37 },
  { 3334, 25, 38, 31, 3, -37 },
  { 3453, 24, 37, 31, 4, -37 },
  { 3564, 23, 37, 31, 4, -37 },
  { 3671, 25, 38, 31, 2, -37 },
  { 3790, 26, 37, 31, 4, -37 },
  { 3911, 23, 37, 31, 5, -37 },
  { 4018, 24, 37, 31, 4, -37 },
  { 4129, 24, 37, 31, 4, -37 },
  { 4240, 25, 38, 31, 3, -37 },
  { 4359, 24, 37, 31, 5, -37 },
  { 4470, 28, 43, 31, 2, -37 },
  { 4621, 24, 37, 31, 5, -37 },
  { 4732, 26, 38, 31, 3, -37 },
  { 4856, 27, 37, 31, 2, -37 },
  { 4981, 24, 38, 31, 4, -37 },
  { 5095, 27, 37, 31, 2, -37 },
  { 5220, 28, 37, 31, 2, -37 },
  { 5350, 28, 37, 31, 2, -37 },
  { 5480, 27, 37, 31, 2, -37 },
  { 5605, 24, 37, 31, 3, -37 },
  { 5716, 10, 50, 31, 11, -42 },
  { 5779, 20, 40, 31, 6, -37 },
  { 5879, 10, 50, 31, 10, -42 },
  { 5942, 19, 20, 31, 6, -37 },
  { 5990, 23, 4, 31, 4, 0 },
  { 6002, 10, 7, 31, 11, -38 },
  { 6011, 23, 29, 31, 4, -28 },
  { 6095, 24, 40, 31, 4, -39 },
  { 6215, 23, 29, 31, 4, -28 },
  { 6299, 23, 40, 31, 4, -39 },
  { 6414, 25, 29, 31, 3, -28 },
  { 6505, 25, 40, 31, 4, -40 },
  { 6630, 23, 39, 31, 4, -28 },
  { 6743, 23, 39, 31, 4, -39 },
  { 6856, 23, 37, 31, 5, -37 },
  { 6963, 17, 48, 31, 5, -37 },
  { 7065, 25, 39, 31, 4, -39 },
  { 7187, 23, 39, 31, 5, -39 },
  { 7300, 27, 28, 31, 2, -28 },
  { 7395, 23, 28, 31, 4, -28 },
  { 7476, 25, 29, 31, 3, -28 },
  { 7567, 24, 39, 31, 4, -28 },
  { 7684, 23, 39, 31, 4, -28 },
  { 7797, 19, 28, 31, 8, -28 },
  { 7864, 23, 29, 31, 4, -28 },
  { 7948, 23, 35, 31, 4, -34 },
  { 8049, 22, 28, 31, 5, -27 },
  { 8126, 27, 27, 31, 2, -27 },
  { 8218, 29, 27, 31, 1, -27 },
  { 8316, 26, 27, 31, 3, -27 },
  { 8404, 27, 38, 31, 2, -27 },
  { 8533, 24, 27, 31, 4, -27 },
  { 8614, 17, 50, 31, 8, -41 },
  { 8721, 4, 47, 31, 14, -37 },
  { 8745, 17, 50, 31, 8, -41 },
  { 8852, 29, 10, 31, 1, -20 },
};

const GFXfont RobotoMono_Regular52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular52pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_REGULAR52PT7B_H_
