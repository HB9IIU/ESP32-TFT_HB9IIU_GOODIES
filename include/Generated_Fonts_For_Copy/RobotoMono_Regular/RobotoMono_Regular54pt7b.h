#ifndef _ROBOTOMONO_REGULAR54PT7B_H_
#define _ROBOTOMONO_REGULAR54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x23, 0xEF, 0xFF, 0xFD, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEF,
  0x03, 0xBC, 0x0E, 0xF0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1C,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x38,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0xE0, 0x00, 0x38,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x7F, 0x03, 0xF0, 0x0F,
  0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x7C, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x10, 0x0F, 0x01,
  0xC0, 0x70, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x1C, 0x0E, 0x03, 0xC0, 0x70,
  0x78, 0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x78,
  0x01, 0xF3, 0xE1, 0xE0, 0x03, 0xFF, 0x8F, 0x00, 0x07, 0xFC, 0x3C, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0xF1,
  0xFF, 0xE0, 0x03, 0xC7, 0x87, 0x80, 0x1E, 0x3C, 0x0F, 0x00, 0x78, 0xF0,
  0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0x0E, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x0F,
  0x01, 0xC0, 0xF0, 0x3C, 0x01, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x1E, 0x3F,
  0x3F, 0x01, 0xE3, 0xE1, 0xF8, 0x1E, 0x7E, 0x0F, 0x81, 0xEF, 0xC0, 0xFC,
  0x1E, 0xF8, 0x07, 0xE3, 0xEF, 0x80, 0x3F, 0x3E, 0xF8, 0x01, 0xF7, 0xCF,
  0x80, 0x1F, 0xFC, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x07, 0xF8, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x83, 0xFC, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF7, 0xE0, 0xFF, 0xFE, 0x7E, 0x03, 0xFF, 0x83, 0xF0, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x70, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x60, 0x01,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x78,
  0x04, 0x7C, 0x1E, 0x0F, 0x9F, 0xC7, 0x8F, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF7, 0xFE, 0x07, 0xE3, 0xFF, 0x07,
  0xE1, 0xFF, 0x8F, 0xE0, 0xFF, 0xCF, 0xC0, 0x7F, 0xEF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x3F,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F,
  0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x7F, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0x87, 0xFC, 0x7E,
  0x00, 0xFC, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F,
  0xF7, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x7F, 0x80, 0xF9, 0xFF, 0xE0, 0xFB,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFE, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7F, 0x00, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x3E, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xDF, 0x07, 0xFF, 0x9E, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7,
  0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0x80, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1C, 0x1C, 0x07, 0xF0, 0xE1, 0xC0, 0xFF, 0xC3, 0x8E, 0x0F,
  0xFE, 0x1C, 0xF0, 0x78, 0x70, 0xE7, 0x07, 0x83, 0x87, 0x38, 0x38, 0x1C,
  0x1B, 0xC3, 0xC0, 0xE0, 0xFC, 0x1C, 0x06, 0x07, 0xE0, 0xE0, 0x70, 0x3F,
  0x07, 0x03, 0x81, 0xF8, 0x78, 0x1C, 0x0D, 0xC3, 0x80, 0xE0, 0xEE, 0x1C,
  0x07, 0x07, 0x70, 0xE0, 0x38, 0x3B, 0x87, 0x01, 0xC1, 0xDC, 0x3C, 0x0E,
  0x0E, 0xE1, 0xE0, 0xF0, 0xE7, 0x0F, 0x8F, 0x87, 0x3C, 0x3F, 0xFE, 0xF0,
  0xE1, 0xFE, 0x7F, 0x87, 0x07, 0xE3, 0xF8, 0x3C, 0x08, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x40, 0x03, 0xF8, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x00,
  0x1F, 0xC7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xE7, 0x80, 0x03, 0xF3, 0xC0, 0x03, 0xF1, 0xE0, 0x07, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x0F, 0x00, 0x1F, 0xC7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xE0,
  0x00, 0x7E, 0xF0, 0x00, 0x7E, 0x78, 0x01, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3,
  0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xFC, 0x3E, 0x01, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x07,
  0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F,
  0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0x3F, 0x00, 0x03, 0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x01,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xEF, 0xF7, 0x80, 0xF7, 0xFB, 0xC0,
  0xFB, 0xFD, 0xF0, 0x79, 0xFE, 0x78, 0x3C, 0xFF, 0x3C, 0x3E, 0x7F, 0x9E,
  0x1E, 0x7F, 0xC7, 0x8F, 0x3F, 0xE3, 0xCF, 0x9F, 0xF9, 0xE7, 0x8F, 0xFC,
  0x7B, 0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xE1, 0xFF, 0x87, 0xF0, 0xFF,
  0xC3, 0xF8, 0x7F, 0xE1, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F,
  0xFC, 0x1E, 0x07, 0xFE, 0x0F, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0x7C, 0x01, 0xFF, 0xBE, 0x00, 0xFF, 0xCF, 0x80,
  0x7F, 0xE7, 0xC0, 0x3F, 0xF1, 0xF0, 0x1F, 0xF8, 0xFC, 0x0F, 0xFC, 0x3E,
  0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0xFF, 0xC0,
  0xF8, 0x7F, 0xE0, 0x3E, 0x3F, 0xF0, 0x1F, 0x1F, 0xF8, 0x07, 0xCF, 0xFC,
  0x03, 0xE7, 0xFE, 0x00, 0xFB, 0xFF, 0x00, 0x7D, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x0F, 0xE7, 0xC0,
  0x01, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x3E, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x67, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x7E,
  0x1F, 0xC0, 0x7E, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0,
  0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xFF,
  0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xF7, 0x80,
  0xFC, 0x0F, 0xBC, 0x0F, 0xE0, 0x79, 0xE0, 0x7F, 0x03, 0xCF, 0x03, 0xF8,
  0x1E, 0x7C, 0x1F, 0xC0, 0xF3, 0xE0, 0xFE, 0x07, 0x9F, 0x07, 0x78, 0x7C,
  0xF8, 0x7B, 0xC3, 0xE7, 0xC3, 0xDE, 0x1F, 0x1E, 0x1E, 0xF0, 0xF0, 0xF0,
  0xF7, 0x87, 0x87, 0x87, 0x1C, 0x3C, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7,
  0x8F, 0x0F, 0x9E, 0x3C, 0x78, 0x7C, 0xF1, 0xE7, 0xC3, 0xE7, 0x87, 0x3E,
  0x0F, 0x38, 0x3D, 0xF0, 0x7B, 0xC1, 0xEF, 0x03, 0xDE, 0x0F, 0x78, 0x1E,
  0xF0, 0x7B, 0xC0, 0xF7, 0x83, 0xDE, 0x07, 0xBC, 0x0E, 0xF0, 0x3D, 0xC0,
  0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xE0, 0x07, 0x9F, 0x00,
  0xF9, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE0, 0x1E,
  0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0x7E, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F,
  0x07, 0xFE, 0x1F, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0xF9, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xF8, 0xFE, 0x00, 0xFC,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xF8,
  0xF7, 0xFF, 0xF0, 0xF3, 0xFF, 0xE0, 0xF0, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x3F, 0x80, 0x7E, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x1F, 0x03, 0xFF, 0x9F,
  0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x03, 0xFF, 0x1F, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x18,
  0x7E, 0x00, 0x1E, 0x3F, 0x80, 0x3F, 0x0F, 0xFD, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x07, 0xFF, 0x9F, 0x0F, 0xFF, 0xDF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xDF, 0x03, 0xFF, 0x1F, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x10, 0x00, 0x3E, 0x18, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xF8, 0x1E, 0x1F, 0xFC, 0x3C, 0xFF, 0xFC, 0x7B, 0xFF,
  0xFC, 0xF7, 0x81, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF3,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x02, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF0, 0x07,
  0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF7,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x01,
  0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xFC,
  0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01,
  0xF9, 0xF0, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x1F, 0x0F, 0xBF, 0xE7, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x1F, 0xC3, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF,
  0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F,
  0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F,
  0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80,
  0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81,
  0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8,
  0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8,
  0x1F, 0xF8, 0x0F, 0x81, 0xF0, 0xF0, 0x3F, 0x81, 0xE1, 0xFF, 0xC3, 0xCF,
  0xFF, 0xC7, 0xBF, 0xFF, 0xCF, 0xF8, 0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0x9F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0xF1, 0xFF,
  0xC0, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFF, 0xFF,
  0xF8, 0xF7, 0xFF, 0xF0, 0xF3, 0xFF, 0xE0, 0xF1, 0xFF, 0x80, 0xF0, 0x1C,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x07, 0xFF,
  0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F, 0x80, 0xFF, 0x1F, 0xF7,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x03, 0xFF, 0x1F, 0x00, 0x10,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0xCF, 0xC0, 0x1F, 0x9F, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x7E, 0x00, 0x7E, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xBE, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0xFF, 0xF9, 0xF0, 0x7F, 0xC3, 0xE0, 0x18, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x03, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0xF7, 0x80, 0x78, 0x03, 0xDE,
  0x01, 0xF0, 0x0F, 0x78, 0x07, 0xC0, 0x7D, 0xF0, 0x3F, 0x01, 0xE3, 0xC0,
  0xFC, 0x07, 0x8F, 0x03, 0xF8, 0x1E, 0x3C, 0x0E, 0xE0, 0x78, 0xF0, 0x7B,
  0x81, 0xC3, 0xC1, 0xEE, 0x0F, 0x07, 0x87, 0xBC, 0x3C, 0x1E, 0x1C, 0xF0,
  0xF0, 0x78, 0xF1, 0xC3, 0xC1, 0xE3, 0xC7, 0x0E, 0x07, 0x8F, 0x1E, 0x78,
  0x0F, 0x38, 0x79, 0xE0, 0x3D, 0xE0, 0xE7, 0x80, 0xF7, 0x83, 0x9E, 0x03,
  0xDE, 0x0F, 0x70, 0x0F, 0x70, 0x3D, 0xC0, 0x1D, 0xC0, 0x7F, 0x00, 0x77,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x1F,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x73, 0xFF, 0xE0, 0x03, 0xCF, 0xFF, 0xE0,
  0x0F, 0x7E, 0x3F, 0xC0, 0x7D, 0xE0, 0x3F, 0xC3, 0xEF, 0x00, 0x7F, 0xFF,
  0xBC, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph RobotoMono_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 6, 38, 32, 13, -38 },
  { 30, 14, 13, 32, 9, -41 },
  { 53, 29, 38, 32, 2, -38 },
  { 191, 25, 50, 32, 4, -45 },
  { 348, 30, 40, 32, 1, -39 },
  { 498, 28, 40, 32, 3, -39 },
  { 638, 4, 13, 32, 13, -41 },
  { 645, 14, 55, 32, 9, -43 },
  { 742, 14, 55, 32, 8, -43 },
  { 839, 26, 26, 32, 4, -38 },
  { 924, 26, 28, 32, 3, -32 },
  { 1015, 8, 15, 32, 9, -6 },
  { 1030, 20, 4, 32, 6, -19 },
  { 1040, 8, 8, 32, 13, -7 },
  { 1048, 20, 41, 32, 7, -38 },
  { 1151, 25, 40, 32, 4, -39 },
  { 1276, 15, 38, 32, 5, -38 },
  { 1348, 26, 39, 32, 2, -39 },
  { 1475, 25, 40, 32, 2, -39 },
  { 1600, 28, 38, 32, 2, -38 },
  { 1733, 24, 39, 32, 5, -38 },
  { 1850, 24, 39, 32, 4, -38 },
  { 1967, 26, 38, 32, 3, -38 },
  { 2091, 24, 40, 32, 5, -39 },
  { 2211, 24, 39, 32, 4, -39 },
  { 2328, 8, 31, 32, 14, -30 },
  { 2359, 9, 39, 32, 13, -30 },
  { 2403, 23, 24, 32, 4, -29 },
  { 2472, 23, 15, 32, 5, -25 },
  { 2516, 23, 24, 32, 5, -29 },
  { 2585, 23, 39, 32, 5, -39 },
  { 2698, 29, 38, 32, 2, -38 },
  { 2836, 29, 38, 32, 2, -38 },
  { 2974, 25, 38, 32, 5, -38 },
  { 3093, 26, 40, 32, 3, -39 },
  { 3223, 26, 38, 32, 4, -38 },
  { 3347, 23, 38, 32, 5, -38 },
  { 3457, 24, 38, 32, 5, -38 },
  { 3571, 26, 40, 32, 3, -39 },
  { 3701, 25, 38, 32, 4, -38 },
  { 3820, 23, 38, 32, 5, -38 },
  { 3930, 25, 39, 32, 3, -38 },
  { 4052, 26, 38, 32, 5, -38 },
  { 4176, 24, 38, 32, 5, -38 },
  { 4290, 25, 38, 32, 4, -38 },
  { 4409, 25, 38, 32, 4, -38 },
  { 4528, 27, 40, 32, 3, -39 },
  { 4663, 25, 38, 32, 5, -38 },
  { 4782, 29, 45, 32, 2, -39 },
  { 4946, 25, 38, 32, 5, -38 },
  { 5065, 27, 40, 32, 3, -39 },
  { 5200, 28, 38, 32, 2, -38 },
  { 5333, 25, 39, 32, 4, -38 },
  { 5455, 28, 38, 32, 2, -38 },
  { 5588, 29, 38, 32, 2, -38 },
  { 5726, 29, 38, 32, 2, -38 },
  { 5864, 28, 38, 32, 2, -38 },
  { 5997, 25, 38, 32, 3, -38 },
  { 6116, 11, 52, 32, 11, -44 },
  { 6188, 21, 41, 32, 6, -38 },
  { 6296, 10, 52, 32, 11, -44 },
  { 6361, 20, 20, 32, 6, -38 },
  { 6411, 24, 4, 32, 4, 0 },
  { 6423, 10, 7, 32, 11, -39 },
  { 6432, 24, 30, 32, 4, -29 },
  { 6522, 24, 42, 32, 5, -41 },
  { 6648, 24, 30, 32, 4, -29 },
  { 6738, 24, 42, 32, 4, -41 },
  { 6864, 25, 30, 32, 4, -29 },
  { 6958, 26, 42, 32, 4, -42 },
  { 7095, 24, 40, 32, 4, -29 },
  { 7215, 23, 41, 32, 5, -41 },
  { 7333, 24, 39, 32, 5, -39 },
  { 7450, 17, 51, 32, 6, -39 },
  { 7559, 25, 41, 32, 5, -41 },
  { 7688, 24, 41, 32, 5, -41 },
  { 7811, 28, 29, 32, 2, -29 },
  { 7913, 23, 29, 32, 5, -29 },
  { 7997, 26, 30, 32, 3, -29 },
  { 8095, 24, 40, 32, 5, -29 },
  { 8215, 24, 40, 32, 4, -29 },
  { 8335, 19, 29, 32, 9, -29 },
  { 8404, 23, 30, 32, 5, -29 },
  { 8491, 24, 36, 32, 4, -35 },
  { 8599, 23, 30, 32, 5, -29 },
  { 8686, 27, 29, 32, 3, -29 },
  { 8784, 30, 29, 32, 1, -29 },
  { 8893, 27, 29, 32, 3, -29 },
  { 8991, 29, 41, 32, 2, -29 },
  { 9140, 25, 29, 32, 4, -29 },
  { 9231, 17, 52, 32, 9, -42 },
  { 9342, 4, 49, 32, 14, -38 },
  { 9367, 17, 52, 32, 9, -42 },
  { 9478, 30, 10, 32, 1, -21 },
};

const GFXfont RobotoMono_Regular54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular54pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_REGULAR54PT7B_H_
