#ifndef _ROBOTOMONO_REGULAR67PT7B_H_
#define _ROBOTOMONO_REGULAR67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x7C, 0x01, 0x00, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x1F,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0xF0, 0x00,
  0x3F, 0x3F, 0x87, 0xC0, 0x00, 0xFF, 0xFC, 0x1E, 0x00, 0x01, 0xFF, 0xE0,
  0xF8, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x7F, 0x80, 0x00, 0x0F, 0x87, 0xFF, 0x00, 0x00, 0x7C, 0x3F, 0xFE, 0x00,
  0x01, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0x87, 0xC1, 0xF8, 0x00, 0x3E, 0x1E,
  0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x38, 0x0F, 0x80, 0x7C, 0x00,
  0x40, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF7,
  0xF0, 0x07, 0xE0, 0xFE, 0x7F, 0x00, 0x7E, 0x1F, 0xC3, 0xF8, 0x07, 0xE3,
  0xF8, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFE, 0x07, 0xC7, 0xF0, 0x0F, 0xE0,
  0x7C, 0x7E, 0x00, 0x7F, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x7E, 0x00,
  0x1F, 0xCF, 0x8F, 0xE0, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x0F, 0xFF, 0x07,
  0xE0, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x03, 0xFE, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x40, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x03, 0xC0, 0x04, 0x38,
  0x03, 0xC0, 0x1C, 0x7F, 0x03, 0xC0, 0x7E, 0x7F, 0xC3, 0xC3, 0xFE, 0x7F,
  0xF3, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x80, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF8, 0x78, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0x00, 0xFE, 0x1F,
  0xFE, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x7F, 0xF8, 0x7F, 0x00, 0xFF,
  0xF3, 0xFC, 0x01, 0xFF, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x80, 0x7F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xF9, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0xC0, 0x03, 0xF7,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x3F, 0xE0, 0x0F, 0xC7, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0xC0, 0xFD, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0xFE, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x01, 0xFE,
  0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xFC, 0xFF, 0x00, 0x3F, 0xF1, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x1F, 0x80,
  0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x08, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x41, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x20, 0x03,
  0x03, 0xF8, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFE, 0x1F, 0xC0,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x03, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03,
  0xC0, 0xF0, 0x0F, 0xF8, 0x1C, 0x1E, 0x01, 0xFF, 0xC1, 0xE1, 0xE0, 0x3F,
  0xFE, 0x1E, 0x3C, 0x07, 0xE3, 0xC0, 0xE3, 0xC0, 0xF8, 0x1C, 0x0E, 0x3C,
  0x0F, 0x01, 0xC0, 0xF7, 0x81, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x03, 0xC0,
  0xF7, 0x81, 0xE0, 0x3C, 0x0F, 0x78, 0x3C, 0x03, 0xC0, 0xF7, 0x83, 0xC0,
  0x3C, 0x0F, 0xF8, 0x3C, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x3C, 0x0F, 0xF0,
  0x7C, 0x03, 0x80, 0xFF, 0x07, 0x80, 0x38, 0x0F, 0xF0, 0x78, 0x03, 0x80,
  0xEF, 0x07, 0x80, 0x38, 0x0E, 0xF0, 0x78, 0x07, 0x80, 0xEF, 0x07, 0xC0,
  0x78, 0x1E, 0xF0, 0x7C, 0x07, 0x81, 0xEF, 0x83, 0xC0, 0xF8, 0x1C, 0x78,
  0x3E, 0x3F, 0x83, 0xC7, 0x83, 0xFF, 0xFC, 0x78, 0x78, 0x1F, 0xFB, 0xFF,
  0x87, 0xC1, 0xFF, 0x1F, 0xF0, 0x3C, 0x0F, 0xE0, 0xFE, 0x03, 0xC0, 0x30,
  0x02, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x40,
  0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFF, 0x0F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x00,
  0x7F, 0xC7, 0xE0, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xF3,
  0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x17,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xBF, 0x00, 0x0F, 0xFF,
  0xEF, 0xC0, 0x03, 0xFF, 0xFB, 0xF0, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0x3F,
  0xFF, 0xBF, 0x80, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xF0,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F, 0x8F,
  0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x7E,
  0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0x81,
  0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x03, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF9,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x81,
  0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xFC,
  0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F,
  0xE7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0x7F, 0xFF, 0x80, 0x3E, 0xFF, 0xDF, 0x00, 0x7D, 0xFF,
  0xBE, 0x01, 0xF3, 0xFF, 0x7E, 0x03, 0xEF, 0xFE, 0x7C, 0x07, 0xDF, 0xFC,
  0xF8, 0x1F, 0x3F, 0xF9, 0xF8, 0x3E, 0x7F, 0xF1, 0xF0, 0xFC, 0xFF, 0xE3,
  0xE1, 0xF1, 0xFF, 0xE7, 0xE3, 0xE3, 0xFF, 0xC7, 0xCF, 0xC7, 0xFF, 0x8F,
  0x9F, 0x0F, 0xFF, 0x1F, 0xBE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xE0, 0xFF,
  0x03, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0x1F, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x00,
  0xFF, 0xF0, 0x1E, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x7E, 0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0xFC, 0x00,
  0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xE1, 0xF8, 0x07,
  0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x83, 0xF0, 0x1F, 0xFF, 0x07, 0xE0, 0x3F,
  0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xC1, 0xFF,
  0xF0, 0x1F, 0x83, 0xFF, 0xE0, 0x1F, 0x87, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF,
  0x80, 0x3F, 0x1F, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x00, 0x7E, 0x7F, 0xFC,
  0x00, 0xFE, 0xFF, 0xF8, 0x00, 0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0x80, 0x0F, 0xFE, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01,
  0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFE, 0x7E,
  0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE3, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0x80, 0x1F, 0xFC, 0x3F, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF8, 0x7E, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFF,
  0x1F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xFB, 0xE0, 0x07, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x00, 0x7C, 0xF8, 0x03,
  0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0xC0, 0x1F, 0x3F, 0x00, 0xFE, 0x01, 0xF9,
  0xF8, 0x07, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x80, 0x7E, 0x7E, 0x03, 0xFE,
  0x03, 0xF3, 0xF0, 0x1F, 0xF0, 0x1F, 0x8F, 0x80, 0xFF, 0x80, 0xF8, 0x7C,
  0x07, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0xE0, 0x3E, 0x1F, 0x81, 0xEF, 0x01,
  0xF0, 0xFC, 0x1F, 0x7C, 0x1F, 0x87, 0xE0, 0xFB, 0xE0, 0xFC, 0x3F, 0x07,
  0xDF, 0x07, 0xE1, 0xF8, 0x3E, 0xF8, 0x3F, 0x07, 0xC1, 0xE3, 0xC1, 0xF0,
  0x3E, 0x0F, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0xF8, 0x7C, 0x0F, 0x87, 0xC7,
  0xC3, 0xE0, 0x7C, 0x3E, 0x3E, 0x1F, 0x03, 0xF1, 0xF1, 0xF0, 0xF8, 0x1F,
  0x8F, 0x07, 0x8F, 0xC0, 0xFC, 0xF8, 0x3E, 0x7E, 0x03, 0xE7, 0xC1, 0xF3,
  0xE0, 0x1F, 0x3E, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x7C, 0xF8, 0x07, 0xCF,
  0x81, 0xE7, 0xC0, 0x3E, 0x78, 0x0F, 0x3E, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x0F, 0xFE, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3E, 0x00,
  0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x07,
  0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0x83,
  0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0x1F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0x03,
  0xF7, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x7F, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0xC0, 0xF8, 0xFF, 0xFE, 0x03,
  0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xFE,
  0x3F, 0x03, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xE0, 0x7F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0xF8,
  0xF8, 0x07, 0xFF, 0x87, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x10,
  0x1F, 0xC0, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x7E, 0x0F, 0xF8, 0x01, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7E,
  0x00, 0x1F, 0xF0, 0x01, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0xC0,
  0xFF, 0xFF, 0x3E, 0x0F, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8,
  0x1F, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFE, 0x7E, 0x01,
  0xFF, 0xE3, 0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x03, 0xF8, 0xE0, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC3, 0xFE, 0x07, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0x1F, 0x87, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0x87, 0xE7, 0xFF, 0xFE, 0x3F,
  0x7F, 0xFF, 0xF9, 0xFF, 0xE0, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x7E, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x07, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFE, 0x0F,
  0xC0, 0x01, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x3F, 0xF1, 0xFF, 0x8F, 0xDF, 0xFE,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC3,
  0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x07,
  0xF8, 0x07, 0xC1, 0xFF, 0xF0, 0x3E, 0x1F, 0xFF, 0xE1, 0xF1, 0xFF, 0xFF,
  0x8F, 0x9F, 0xFF, 0xFE, 0x7F, 0xF8, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xE1, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0xF0,
  0x3E, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xF7, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0xE0,
  0x3F, 0x0F, 0xFE, 0x00, 0xFC, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x87, 0xC0, 0xFF, 0xFF, 0x3E, 0x0F, 0xFF, 0xFD, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFE,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x3F, 0xE3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFE, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x02, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFD,
  0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0x9F, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xBF, 0x0F,
  0xFF, 0xF9, 0xF8, 0x3F, 0xFF, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x00, 0x78,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x7D, 0xF8, 0x03, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x1F, 0x3E, 0x00, 0xFE, 0x00, 0xF9, 0xF0,
  0x07, 0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0x80, 0x7C, 0x7E, 0x03, 0xFC, 0x03,
  0xE1, 0xF0, 0x1F, 0xF0, 0x1F, 0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x7C, 0x0F,
  0xBC, 0x07, 0x83, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x03, 0xCF, 0x83, 0xE0,
  0x7C, 0x1E, 0x7C, 0x1F, 0x03, 0xE1, 0xF1, 0xE0, 0xF8, 0x1F, 0x0F, 0x8F,
  0x07, 0x80, 0xF8, 0x78, 0x7C, 0x7C, 0x03, 0xC3, 0xC3, 0xE3, 0xE0, 0x1F,
  0x3E, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0x78, 0xF8, 0x07, 0xCF, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x1F, 0x3C, 0x00, 0xF7, 0xC0, 0x7B, 0xE0, 0x07, 0xBE,
  0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x06, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x7F, 0xFF, 0xC0, 0x01,
  0xE7, 0xFF, 0xFF, 0x00, 0x1F, 0x3F, 0x87, 0xFC, 0x00, 0xFB, 0xF0, 0x0F,
  0xF8, 0x0F, 0xDF, 0x00, 0x3F, 0xFB, 0xFC, 0xF0, 0x00, 0x7F, 0xFF, 0xE7,
  0x80, 0x01, 0xFF, 0xFE, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
};

const GFXglyph RobotoMono_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 7, 48, 40, 16, -48 },
  { 43, 16, 15, 40, 12, -50 },
  { 73, 37, 48, 40, 2, -48 },
  { 295, 31, 62, 40, 5, -55 },
  { 536, 38, 49, 40, 1, -48 },
  { 769, 36, 49, 40, 3, -48 },
  { 990, 5, 15, 40, 16, -50 },
  { 1000, 17, 69, 40, 12, -54 },
  { 1147, 18, 69, 40, 10, -54 },
  { 1303, 32, 33, 40, 5, -48 },
  { 1435, 33, 34, 40, 4, -39 },
  { 1576, 9, 18, 40, 12, -7 },
  { 1597, 25, 5, 40, 7, -23 },
  { 1613, 10, 10, 40, 16, -9 },
  { 1626, 26, 52, 40, 8, -48 },
  { 1795, 31, 49, 40, 5, -48 },
  { 1985, 18, 48, 40, 7, -48 },
  { 2093, 32, 48, 40, 3, -48 },
  { 2285, 30, 49, 40, 3, -48 },
  { 2469, 35, 48, 40, 2, -48 },
  { 2679, 30, 49, 40, 6, -48 },
  { 2863, 30, 49, 40, 5, -48 },
  { 3047, 32, 48, 40, 4, -48 },
  { 3239, 30, 49, 40, 6, -48 },
  { 3423, 30, 48, 40, 5, -48 },
  { 3603, 9, 39, 40, 18, -38 },
  { 3647, 11, 49, 40, 16, -38 },
  { 3715, 27, 30, 40, 6, -36 },
  { 3817, 29, 19, 40, 6, -31 },
  { 3886, 29, 30, 40, 6, -36 },
  { 3995, 28, 48, 40, 6, -48 },
  { 4163, 36, 48, 40, 2, -48 },
  { 4379, 35, 48, 40, 3, -48 },
  { 4589, 31, 48, 40, 6, -48 },
  { 4775, 34, 49, 40, 3, -48 },
  { 4984, 32, 48, 40, 5, -48 },
  { 5176, 29, 48, 40, 6, -48 },
  { 5350, 30, 48, 40, 6, -48 },
  { 5530, 34, 49, 40, 3, -48 },
  { 5739, 31, 48, 40, 5, -48 },
  { 5925, 28, 48, 40, 6, -48 },
  { 6093, 31, 49, 40, 3, -48 },
  { 6283, 33, 48, 40, 6, -48 },
  { 6481, 30, 48, 40, 6, -48 },
  { 6661, 31, 48, 40, 5, -48 },
  { 6847, 31, 48, 40, 5, -48 },
  { 7033, 34, 49, 40, 3, -48 },
  { 7242, 31, 48, 40, 6, -48 },
  { 7428, 35, 56, 40, 3, -48 },
  { 7673, 31, 48, 40, 6, -48 },
  { 7859, 33, 49, 40, 4, -48 },
  { 8062, 36, 48, 40, 2, -48 },
  { 8278, 31, 49, 40, 5, -48 },
  { 8468, 36, 48, 40, 2, -48 },
  { 8684, 37, 48, 40, 2, -48 },
  { 8906, 35, 48, 40, 3, -48 },
  { 9116, 35, 48, 40, 2, -48 },
  { 9326, 31, 48, 40, 4, -48 },
  { 9512, 13, 64, 40, 14, -54 },
  { 9616, 25, 52, 40, 8, -48 },
  { 9779, 13, 64, 40, 13, -54 },
  { 9883, 25, 26, 40, 8, -48 },
  { 9965, 30, 5, 40, 5, 0 },
  { 9984, 13, 8, 40, 14, -48 },
  { 9997, 30, 37, 40, 5, -36 },
  { 10136, 30, 51, 40, 6, -50 },
  { 10328, 30, 37, 40, 5, -36 },
  { 10467, 29, 51, 40, 5, -50 },
  { 10652, 32, 37, 40, 4, -36 },
  { 10800, 32, 52, 40, 5, -52 },
  { 11008, 29, 50, 40, 5, -36 },
  { 11190, 29, 50, 40, 6, -50 },
  { 11372, 29, 48, 40, 7, -48 },
  { 11546, 21, 62, 40, 7, -48 },
  { 11709, 31, 50, 40, 6, -50 },
  { 11903, 29, 50, 40, 7, -50 },
  { 12085, 34, 36, 40, 3, -36 },
  { 12238, 29, 36, 40, 6, -36 },
  { 12369, 32, 37, 40, 4, -36 },
  { 12517, 30, 50, 40, 6, -36 },
  { 12705, 29, 50, 40, 5, -36 },
  { 12887, 24, 36, 40, 11, -36 },
  { 12995, 29, 37, 40, 6, -36 },
  { 13130, 30, 45, 40, 5, -44 },
  { 13299, 29, 36, 40, 6, -35 },
  { 13430, 34, 35, 40, 3, -35 },
  { 13579, 37, 35, 40, 2, -35 },
  { 13741, 33, 35, 40, 4, -35 },
  { 13886, 36, 49, 40, 2, -35 },
  { 14107, 31, 35, 40, 5, -35 },
  { 14243, 22, 64, 40, 11, -52 },
  { 14419, 5, 61, 40, 18, -48 },
  { 14458, 22, 64, 40, 11, -52 },
  { 14634, 37, 13, 40, 2, -26 },
};

const GFXfont RobotoMono_Regular67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular67pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_REGULAR67PT7B_H_
