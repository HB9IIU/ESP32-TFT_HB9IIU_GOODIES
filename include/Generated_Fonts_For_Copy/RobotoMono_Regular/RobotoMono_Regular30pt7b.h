#ifndef _ROBOTOMONO_REGULAR30PT7B_H_
#define _ROBOTOMONO_REGULAR30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC6, 0xC6, 0xC6, 0xC6, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03,
  0x0C, 0x07, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x06, 0x18, 0x0E,
  0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x18,
  0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x30, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0x83, 0x9C,
  0x0E, 0x70, 0x1D, 0xC0, 0x77, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xF8, 0x07, 0x60, 0x1D,
  0xC0, 0x77, 0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x10, 0x00, 0x7C, 0x00, 0xC6, 0x00, 0xC6, 0x10, 0xC7, 0x18, 0xC7, 0x30,
  0xC6, 0x30, 0xC6, 0x60, 0x7E, 0x60, 0x38, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x3E, 0x06, 0x7F, 0x06, 0x63, 0x0C, 0xE3, 0x0C, 0xC3,
  0x18, 0xC3, 0x00, 0x63, 0x00, 0x77, 0x00, 0x3E, 0x02, 0x00, 0x3F, 0x80,
  0xFF, 0x81, 0xC7, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x1C, 0xE0, 0x3B,
  0xC0, 0x3E, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xF0, 0xFE, 0x71, 0xF8, 0x73,
  0xE0, 0xF6, 0xC0, 0xFD, 0x80, 0xFB, 0x80, 0xE7, 0x87, 0xE7, 0xFF, 0xC7,
  0xF1, 0xC0, 0xFF, 0xED, 0xB6, 0x01, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x70, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x81, 0x83, 0x83, 0x83, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0xC3,
  0x8E, 0x18, 0x20, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x63,
  0x0F, 0xFD, 0xF3, 0xFF, 0xC1, 0xF0, 0x07, 0x80, 0x3B, 0x00, 0xCE, 0x07,
  0x1C, 0x38, 0x78, 0x20, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x77, 0x77, 0x77,
  0xE4, 0xFF, 0xFF, 0xFC, 0x77, 0xBE, 0xE0, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1C, 0x0E, 0x70, 0x39,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x3D, 0xF9, 0xE7,
  0xEE, 0x1F, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x67, 0x03,
  0x9E, 0x1E, 0x3F, 0xF0, 0x3F, 0x00, 0x03, 0x1F, 0x7F, 0xFB, 0xC3, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0x81, 0xC6, 0x03,
  0x9C, 0x03, 0xB8, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0x00, 0x7F,
  0x83, 0xFF, 0x1C, 0x0E, 0x70, 0x19, 0x80, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0x9E, 0x0E, 0x3F, 0xF0, 0x3F, 0x80,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0x38,
  0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x38, 0x38,
  0x70, 0x38, 0x60, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xFB, 0xFF, 0xDC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0D, 0xF0, 0x7F, 0xE3, 0xFF, 0x98, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xDC,
  0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x39, 0xF0, 0xFF, 0xE3, 0xF3, 0xCF, 0x03,
  0xB8, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0x60, 0x39, 0xC0,
  0xE3, 0x87, 0x0F, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x02, 0x01, 0xFE, 0x1F, 0xF8,
  0xE0, 0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x06, 0x60, 0x73, 0xC7, 0x8F,
  0xF0, 0x7F, 0x87, 0x8F, 0x70, 0x1B, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xE0, 0xE7, 0xFE, 0x0F, 0xE0, 0x07, 0x00, 0x7F, 0x03, 0xFF,
  0x1C, 0x1C, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80,
  0x76, 0x03, 0xDC, 0x0F, 0x3D, 0xF8, 0xFF, 0x60, 0xF1, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x03, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x6F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x33, 0xDE, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x9C, 0xEE, 0x20, 0x00, 0x08, 0x03,
  0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xE0, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x06, 0x03, 0xFC, 0x7F,
  0xEF, 0x07, 0xE0, 0x7E, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0F, 0x00, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x18, 0x0C, 0x30,
  0x06, 0x31, 0xE6, 0x63, 0xF3, 0x67, 0x33, 0xC6, 0x33, 0xC4, 0x23, 0xCC,
  0x23, 0xCC, 0x23, 0xCC, 0x23, 0xCC, 0x63, 0xCC, 0x62, 0xCF, 0xF6, 0xC7,
  0xBC, 0x60, 0x00, 0x70, 0x00, 0x38, 0x10, 0x1F, 0xF0, 0x07, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x06,
  0x70, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x38, 0x1C, 0x38, 0x1C,
  0x18, 0x1F, 0xFC, 0x3F, 0xFC, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x06, 0x60, 0x07, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x30, 0x3D, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0E, 0xC0, 0xF7, 0xFE, 0x3F, 0xF9, 0x80,
  0xEC, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x3D,
  0xFF, 0xCF, 0xF8, 0x00, 0x03, 0x80, 0x7F, 0x83, 0xFF, 0x1C, 0x0E, 0x70,
  0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80, 0x77,
  0x01, 0x9E, 0x1E, 0x3F, 0xF0, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0xC3, 0x83,
  0xC7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x06, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xB8, 0x07, 0x70,
  0x0E, 0xE0, 0x39, 0xC0, 0xF3, 0x87, 0xC7, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0xFF, 0x3F, 0xF9, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1F,
  0xE0, 0x7F, 0xE1, 0xE0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xB0, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xD8,
  0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0C, 0xE0, 0x18, 0xE0, 0xF0, 0xFF,
  0xC0, 0xFE, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xF8, 0x07, 0x70, 0x1D, 0xC0, 0x73, 0x87, 0x87, 0xFC, 0x0F,
  0xE0, 0xC0, 0x3F, 0x01, 0xCC, 0x0F, 0x30, 0x38, 0xC1, 0xC3, 0x0E, 0x0C,
  0x70, 0x33, 0xC0, 0xCE, 0x03, 0x78, 0x0F, 0xE0, 0x3D, 0xC0, 0xE3, 0x83,
  0x8E, 0x0C, 0x1C, 0x30, 0x38, 0xC0, 0xE3, 0x01, 0xCC, 0x07, 0xB0, 0x0E,
  0xC0, 0x1C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x6F, 0xE1, 0xBF,
  0xCE, 0xFB, 0x33, 0xEC, 0xCF, 0xBF, 0x3E, 0x78, 0xF9, 0xE3, 0xE7, 0x9F,
  0x8C, 0x7E, 0x31, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1C, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x7E, 0xC1, 0xFB, 0x87, 0xE6, 0x1F, 0x9C, 0x7E, 0x31, 0xF8, 0xE7, 0xE1,
  0xDF, 0x87, 0x7E, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1C, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03,
  0x8E, 0x1C, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xC3, 0xFF, 0xCE, 0x07, 0xB8,
  0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x81, 0xEF,
  0xFF, 0x3F, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0x60,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x06, 0x60, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x3C, 0x3C, 0x1F,
  0xF8, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x02, 0xFF,
  0xC3, 0xFF, 0x8C, 0x0F, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0xEC, 0x03, 0xB0,
  0x0E, 0xC0, 0x3B, 0x03, 0xCF, 0xFE, 0x3F, 0xF0, 0xC1, 0xC3, 0x07, 0x0C,
  0x0E, 0x30, 0x38, 0xC0, 0x73, 0x01, 0xCC, 0x03, 0xB0, 0x0E, 0xC0, 0x1C,
  0x03, 0x00, 0x3F, 0xC0, 0xFF, 0xE3, 0xC1, 0xC7, 0x01, 0xDC, 0x03, 0xB8,
  0x03, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x06, 0xE0, 0x0F, 0xC0, 0x1B, 0xC0, 0x73,
  0xC1, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xE7, 0x87, 0x8F, 0xFC, 0x0F,
  0xC0, 0xE0, 0x07, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x30, 0x0C, 0x38,
  0x1C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0C,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xE1, 0xC3, 0xE1, 0xC3, 0xE1,
  0xC7, 0x63, 0xC7, 0x63, 0xC7, 0x63, 0xC7, 0x63, 0xE6, 0x63, 0x66, 0x77,
  0x66, 0x76, 0x66, 0x76, 0x66, 0x76, 0x66, 0x36, 0x7E, 0x36, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x1C,
  0x1C, 0xF0, 0x0F, 0x78, 0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E,
  0x38, 0x0E, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x38,
  0x1C, 0x38, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x70,
  0x1C, 0x38, 0x1C, 0x38, 0x18, 0x1C, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E,
  0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0xFF,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0xFC, 0x06, 0x00, 0xF0,
  0x0F, 0x01, 0xF8, 0x1F, 0x81, 0x98, 0x39, 0xC3, 0x0C, 0x70, 0xE7, 0x0E,
  0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0xC0, 0xFF,
  0xC7, 0x87, 0x9C, 0x0E, 0x60, 0x38, 0x00, 0x60, 0x1F, 0x87, 0xFE, 0x7C,
  0x19, 0xC0, 0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x39, 0xC3, 0xE7, 0xFD, 0x87,
  0xE7, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x19, 0xF0, 0xDF, 0xE7, 0x87, 0xB8, 0x1D, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xEF, 0x0F, 0x7F,
  0xF3, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x0E, 0x60, 0x1F,
  0x80, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x07,
  0x70, 0x18, 0xE1, 0xE3, 0xFF, 0x03, 0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x61, 0xF3, 0x3F, 0xDB, 0xE3, 0xDC,
  0x0E, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x06, 0xE0, 0x77, 0x87, 0x9F, 0xFC, 0x7E, 0x60, 0x0F, 0xC0, 0x7F,
  0xC3, 0x87, 0x9C, 0x0E, 0x60, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x08, 0xE0, 0xF3, 0xFF, 0x83,
  0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x1E, 0x10, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0x99, 0xFF,
  0xDF, 0x1E, 0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x06, 0xC0, 0x37, 0x03, 0xBC, 0x3C, 0xFF, 0xE3, 0xFB, 0x00,
  0x18, 0x01, 0xC8, 0x0E, 0xE0, 0xE3, 0xFF, 0x0F, 0xE0, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x19, 0xF8, 0xDF, 0xE7,
  0xC7, 0xB8, 0x1D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x02,
  0x00, 0x38, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0x00, 0xF0, 0x38, 0x04, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x7F, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x81, 0xEF, 0xF3, 0xF8, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x1E,
  0xC0, 0xE3, 0x07, 0x0C, 0x38, 0x31, 0xC0, 0xCE, 0x03, 0x70, 0x0F, 0xE0,
  0x3F, 0xC0, 0xE7, 0x03, 0x0E, 0x0C, 0x1C, 0x30, 0x78, 0xC0, 0xF3, 0x01,
  0xCC, 0x03, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x7F, 0xFF, 0xFF, 0xE0, 0xEF, 0x3C, 0xFF, 0xFE, 0xF3, 0xCE, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xCF, 0xC6, 0xFF, 0x3E, 0x3D, 0xC0, 0xEC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0x70, 0x39, 0xE1, 0xE3, 0xFF, 0x03, 0xF0, 0xCF, 0x87, 0xFF, 0x3C, 0x7D,
  0xC0, 0xEC, 0x07, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x6E, 0x07, 0x78, 0x7B, 0xFF, 0x9B, 0xF8, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x0F, 0x99, 0xFF, 0xDE, 0x1E,
  0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x37, 0x03, 0xBC, 0x3C, 0xFF, 0xE3, 0xF3, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xC7, 0xF9, 0xFF, 0xFF, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0xC3, 0xFF, 0x1C, 0x3D, 0xC0, 0xEE,
  0x03, 0xF0, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x7E, 0x03, 0xF8, 0x39, 0xFF, 0xC3, 0xF8, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x7F, 0x0F, 0x7F, 0xB3, 0xF3, 0xE0, 0x06, 0xE0, 0x1D, 0xC0, 0x39,
  0xC0, 0xE3, 0x81, 0xC3, 0x03, 0x07, 0x0E, 0x0E, 0x18, 0x0C, 0x30, 0x1C,
  0xE0, 0x19, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0,
  0xC1, 0x83, 0xC1, 0x83, 0xE1, 0xC3, 0xE3, 0xC7, 0x63, 0xC7, 0x63, 0xC6,
  0x63, 0x66, 0x66, 0x66, 0x76, 0x66, 0x36, 0x6C, 0x36, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0xE0, 0x1E, 0xE0, 0x78,
  0xE0, 0xE1, 0xC3, 0x81, 0xCE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x3B, 0x80, 0xE7, 0x03, 0x87, 0x0F, 0x07, 0x1C, 0x0F,
  0x70, 0x0F, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x38, 0x1C,
  0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x06, 0x60,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFB,
  0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xC1, 0xE0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x3C, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x3C, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xF0, 0x7C, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x7F, 0x03, 0xFF,
  0x83, 0xC3, 0xE7, 0xC0, 0xFE, 0x00, 0x7C,
};

const GFXglyph RobotoMono_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 3, 21, 18, 7, -21 },
  { 9, 8, 8, 18, 5, -23 },
  { 17, 16, 21, 18, 1, -21 },
  { 59, 14, 28, 18, 2, -25 },
  { 108, 16, 22, 18, 1, -22 },
  { 152, 15, 22, 18, 2, -22 },
  { 194, 3, 8, 18, 7, -23 },
  { 197, 8, 31, 18, 5, -24 },
  { 228, 7, 31, 18, 5, -24 },
  { 256, 14, 14, 18, 2, -21 },
  { 281, 14, 16, 18, 2, -18 },
  { 309, 4, 8, 18, 5, -3 },
  { 313, 11, 2, 18, 3, -10 },
  { 316, 5, 4, 18, 7, -4 },
  { 319, 11, 23, 18, 4, -21 },
  { 351, 14, 22, 18, 2, -22 },
  { 390, 8, 21, 18, 3, -21 },
  { 411, 15, 22, 18, 1, -22 },
  { 453, 14, 22, 18, 1, -22 },
  { 492, 16, 21, 18, 1, -21 },
  { 534, 13, 21, 18, 3, -21 },
  { 569, 14, 21, 18, 2, -21 },
  { 606, 14, 21, 18, 2, -21 },
  { 643, 13, 22, 18, 3, -22 },
  { 679, 14, 22, 18, 2, -22 },
  { 718, 4, 17, 18, 8, -17 },
  { 727, 5, 22, 18, 7, -17 },
  { 741, 13, 13, 18, 2, -16 },
  { 763, 13, 9, 18, 3, -14 },
  { 778, 13, 13, 18, 3, -16 },
  { 800, 12, 22, 18, 3, -22 },
  { 833, 16, 21, 18, 1, -21 },
  { 875, 16, 21, 18, 1, -21 },
  { 917, 13, 21, 18, 3, -21 },
  { 952, 14, 22, 18, 2, -22 },
  { 991, 15, 21, 18, 2, -21 },
  { 1031, 13, 21, 18, 3, -21 },
  { 1066, 13, 21, 18, 3, -21 },
  { 1101, 15, 22, 18, 1, -22 },
  { 1143, 14, 21, 18, 2, -21 },
  { 1180, 12, 21, 18, 3, -21 },
  { 1212, 14, 21, 18, 1, -21 },
  { 1249, 14, 21, 18, 3, -21 },
  { 1286, 13, 21, 18, 3, -21 },
  { 1321, 14, 21, 18, 2, -21 },
  { 1358, 14, 21, 18, 2, -21 },
  { 1395, 14, 22, 18, 2, -22 },
  { 1434, 14, 21, 18, 3, -21 },
  { 1471, 16, 26, 18, 1, -22 },
  { 1523, 14, 21, 18, 3, -21 },
  { 1560, 15, 22, 18, 2, -22 },
  { 1602, 16, 21, 18, 1, -21 },
  { 1644, 14, 21, 18, 2, -21 },
  { 1681, 16, 21, 18, 1, -21 },
  { 1723, 16, 21, 18, 1, -21 },
  { 1765, 16, 21, 18, 1, -21 },
  { 1807, 16, 21, 18, 1, -21 },
  { 1849, 14, 21, 18, 2, -21 },
  { 1886, 6, 29, 18, 6, -24 },
  { 1908, 12, 23, 18, 3, -21 },
  { 1943, 6, 29, 18, 6, -24 },
  { 1965, 12, 11, 18, 3, -21 },
  { 1982, 14, 2, 18, 2, 0 },
  { 1986, 6, 4, 18, 6, -22 },
  { 1989, 14, 16, 18, 2, -16 },
  { 2017, 13, 23, 18, 3, -23 },
  { 2055, 14, 16, 18, 2, -16 },
  { 2083, 13, 23, 18, 2, -23 },
  { 2121, 14, 16, 18, 2, -16 },
  { 2149, 15, 23, 18, 2, -23 },
  { 2193, 13, 22, 18, 2, -16 },
  { 2229, 13, 23, 18, 3, -23 },
  { 2267, 13, 22, 18, 3, -22 },
  { 2303, 10, 28, 18, 3, -22 },
  { 2338, 14, 23, 18, 3, -23 },
  { 2379, 13, 23, 18, 3, -23 },
  { 2417, 16, 16, 18, 1, -16 },
  { 2449, 13, 16, 18, 3, -16 },
  { 2475, 14, 16, 18, 2, -16 },
  { 2503, 13, 22, 18, 3, -16 },
  { 2539, 13, 22, 18, 2, -16 },
  { 2575, 11, 16, 18, 5, -16 },
  { 2597, 13, 16, 18, 3, -16 },
  { 2623, 14, 20, 18, 2, -20 },
  { 2658, 12, 16, 18, 3, -16 },
  { 2682, 15, 16, 18, 1, -16 },
  { 2712, 16, 16, 18, 1, -16 },
  { 2744, 15, 16, 18, 2, -16 },
  { 2774, 16, 22, 18, 1, -16 },
  { 2818, 14, 16, 18, 2, -16 },
  { 2846, 10, 28, 18, 5, -23 },
  { 2881, 2, 27, 18, 8, -21 },
  { 2888, 10, 28, 18, 5, -23 },
  { 2923, 16, 6, 18, 1, -12 },
};

const GFXfont RobotoMono_Regular30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular30pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_REGULAR30PT7B_H_
