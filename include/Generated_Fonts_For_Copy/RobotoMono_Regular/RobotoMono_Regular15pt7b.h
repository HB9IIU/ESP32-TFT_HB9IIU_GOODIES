#ifndef _ROBOTOMONO_REGULAR15PT7B_H_
#define _ROBOTOMONO_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x60, 0xB6, 0x80, 0x09, 0x0D, 0x04, 0x8F, 0xF1, 0x20, 0x90,
  0xD9, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x10, 0x71, 0xB2, 0x34, 0x2C, 0x0E,
  0x06, 0x07, 0x85, 0x1B, 0xE1, 0x02, 0x00, 0x60, 0x68, 0x24, 0x92, 0x86,
  0x40, 0x40, 0x28, 0x2A, 0x34, 0x92, 0x41, 0xC0, 0x38, 0x68, 0x4C, 0x48,
  0x70, 0x70, 0xD2, 0x9A, 0x8E, 0xC6, 0x7B, 0xE0, 0x25, 0x69, 0x24, 0x92,
  0x64, 0x88, 0x84, 0x22, 0x31, 0x11, 0x11, 0x13, 0x26, 0xC0, 0x10, 0x22,
  0x4F, 0xF1, 0x85, 0x19, 0x02, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08,
  0xFE, 0xF8, 0xF0, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x41, 0x0C, 0x20,
  0x38, 0xDB, 0x1C, 0x18, 0xF3, 0x68, 0xE1, 0xC6, 0x89, 0xF0, 0x17, 0xB3,
  0x33, 0x33, 0x33, 0x30, 0x39, 0x9A, 0x10, 0x20, 0x41, 0x06, 0x18, 0x61,
  0x83, 0xF8, 0x3B, 0x38, 0x41, 0x0C, 0xE0, 0xC1, 0x87, 0x17, 0x80, 0x0C,
  0x18, 0x71, 0xE2, 0xC9, 0xB3, 0x7F, 0xFE, 0x18, 0x30, 0x7E, 0xFD, 0x02,
  0x07, 0xC8, 0xC0, 0x81, 0xC2, 0x8C, 0xF0, 0x08, 0x71, 0x06, 0x0B, 0x98,
  0xA1, 0xC3, 0xC6, 0x88, 0xE0, 0xFF, 0xFC, 0x10, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0x41, 0x80, 0x38, 0xC9, 0x1A, 0x34, 0x47, 0x11, 0xE1, 0xC2, 0x8D,
  0xF0, 0x38, 0xDB, 0x14, 0x38, 0x78, 0xDF, 0x83, 0x04, 0x18, 0xC0, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x04, 0x77, 0x30, 0x38, 0x30, 0x40, 0xFE, 0x00,
  0x07, 0xF0, 0xC0, 0xE0, 0x70, 0x33, 0x9C, 0x20, 0x00, 0x38, 0xDB, 0x18,
  0x30, 0x41, 0x84, 0x08, 0x00, 0x20, 0x40, 0x0C, 0x19, 0x10, 0x4B, 0xA5,
  0x4C, 0xA6, 0x94, 0xAA, 0x5A, 0x30, 0x0F, 0x00, 0x10, 0x18, 0x38, 0x28,
  0x28, 0x64, 0x44, 0x7C, 0xC6, 0x82, 0x83, 0xF9, 0xFB, 0x1E, 0x1C, 0x5F,
  0xB1, 0xE1, 0xC3, 0x8F, 0xF0, 0x38, 0xCB, 0x0C, 0x18, 0x10, 0x20, 0x40,
  0x82, 0x8C, 0xF0, 0xF1, 0xBB, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x9B,
  0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83, 0xF8, 0xFF,
  0xFF, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x38, 0xDB, 0x0C,
  0x08, 0x10, 0x23, 0xC1, 0xC2, 0x84, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xE0, 0xC1, 0x83, 0x06, 0x08, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x23, 0xF8, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x89,
  0xE0, 0xC2, 0xC6, 0xCC, 0xD8, 0xF0, 0xF0, 0xD8, 0xC8, 0xCC, 0xC6, 0xC3,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xF8, 0xC7, 0x8F,
  0x1D, 0x5A, 0xB5, 0x64, 0xC9, 0x83, 0x06, 0x08, 0xC3, 0x87, 0x8D, 0x1B,
  0x32, 0x66, 0xC5, 0x8F, 0x0E, 0x18, 0x38, 0xDB, 0x1C, 0x18, 0x30, 0x60,
  0xC1, 0xC6, 0x88, 0xF0, 0xF9, 0x9F, 0x0E, 0x1C, 0x38, 0xFE, 0x60, 0xC1,
  0x83, 0x00, 0x38, 0x6C, 0xC6, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x44,
  0x7C, 0x07, 0x02, 0xF9, 0x9B, 0x1E, 0x1C, 0x79, 0xBE, 0x66, 0xC5, 0x8F,
  0x08, 0x38, 0xCF, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x83, 0x8D, 0xF0, 0xFF,
  0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xC6, 0x89, 0xF0, 0x83, 0x07, 0x1A, 0x24, 0x49,
  0x9A, 0x14, 0x28, 0x70, 0x40, 0x93, 0x93, 0x9A, 0xBA, 0xAA, 0xAA, 0xAA,
  0xEA, 0x66, 0x46, 0x44, 0x82, 0xC6, 0x44, 0x2C, 0x38, 0x10, 0x38, 0x28,
  0x64, 0x46, 0xC3, 0xC1, 0x63, 0x22, 0x26, 0x14, 0x14, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0xFC, 0x10, 0x41, 0x82, 0x08, 0x30, 0x41, 0x83, 0xF8,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x84, 0x10, 0x86, 0x10, 0x86, 0x10,
  0x82, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x93, 0xC0, 0x21, 0x14, 0xAD, 0xC4,
  0xFE, 0xCC, 0x7D, 0x88, 0x19, 0xFC, 0x78, 0xF1, 0xBF, 0xC1, 0x83, 0x07,
  0xEC, 0x58, 0xF0, 0xE1, 0xC7, 0x8B, 0xF0, 0x3C, 0x8F, 0x0C, 0x08, 0x18,
  0x51, 0x9E, 0x06, 0x0C, 0x1B, 0xF4, 0x78, 0xE1, 0xC3, 0xC6, 0x8D, 0xF8,
  0x3C, 0x8B, 0x0F, 0xF8, 0x18, 0x10, 0x9E, 0x04, 0x3C, 0xC1, 0x8F, 0xE6,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x7E, 0x8F, 0x1C, 0x38, 0x78, 0xD1,
  0xBF, 0x07, 0x89, 0xE0, 0xC1, 0x83, 0x07, 0xEC, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x18, 0x18, 0x20, 0x07, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xF8,
  0x11, 0x0F, 0x11, 0x11, 0x11, 0x11, 0x3E, 0xC1, 0x83, 0x06, 0x3C, 0x9A,
  0x3C, 0x68, 0xC9, 0x9B, 0x18, 0xF8, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x33, 0xF8, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xFD, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x38, 0x8B, 0x1C, 0x18, 0x30, 0x51, 0x3E,
  0xFD, 0x8B, 0x1E, 0x1C, 0x38, 0xF1, 0x7E, 0xC1, 0x83, 0x00, 0x7E, 0x8F,
  0x1C, 0x38, 0x78, 0xD1, 0xBF, 0x06, 0x0C, 0x18, 0xDF, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0x3C, 0x8D, 0x03, 0x81, 0xC0, 0xF1, 0xBE, 0x20, 0x43, 0xF9,
  0x02, 0x04, 0x08, 0x10, 0x30, 0x3C, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xD1,
  0xBF, 0x83, 0x8D, 0x12, 0x22, 0x85, 0x0A, 0x08, 0xC9, 0xA4, 0x95, 0x4A,
  0xA5, 0x51, 0xA8, 0x88, 0x44, 0xC6, 0x88, 0xA1, 0xC3, 0x85, 0x11, 0x63,
  0xC1, 0x63, 0x22, 0x22, 0x36, 0x14, 0x1C, 0x08, 0x18, 0x10, 0x70, 0xFE,
  0x08, 0x20, 0xC3, 0x0C, 0x10, 0x7F, 0x08, 0x84, 0x63, 0x18, 0x98, 0x21,
  0x8C, 0x61, 0x08, 0x20, 0xFF, 0xFC, 0xC3, 0x08, 0x42, 0x10, 0xC1, 0x31,
  0x08, 0x42, 0x32, 0x00, 0x71, 0x2C, 0xE1, 0xC0,
};

const GFXglyph RobotoMono_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 11, 9, 4, -11 },
  { 3, 3, 3, 9, 3, -11 },
  { 5, 9, 11, 9, 0, -11 },
  { 18, 7, 14, 9, 1, -12 },
  { 31, 9, 11, 9, 0, -11 },
  { 44, 8, 11, 9, 1, -11 },
  { 55, 1, 3, 9, 4, -11 },
  { 56, 3, 15, 9, 3, -12 },
  { 62, 4, 15, 9, 2, -12 },
  { 70, 7, 8, 9, 1, -11 },
  { 77, 7, 8, 9, 1, -9 },
  { 84, 2, 4, 9, 3, -2 },
  { 85, 5, 1, 9, 2, -5 },
  { 86, 2, 2, 9, 4, -2 },
  { 87, 6, 12, 9, 2, -11 },
  { 96, 7, 11, 9, 1, -11 },
  { 106, 4, 11, 9, 2, -11 },
  { 112, 7, 11, 9, 1, -11 },
  { 122, 6, 11, 9, 1, -11 },
  { 131, 7, 11, 9, 1, -11 },
  { 141, 7, 11, 9, 1, -11 },
  { 151, 7, 11, 9, 1, -11 },
  { 161, 7, 11, 9, 1, -11 },
  { 171, 7, 11, 9, 1, -11 },
  { 181, 7, 11, 9, 1, -11 },
  { 191, 2, 8, 9, 4, -8 },
  { 193, 2, 10, 9, 4, -8 },
  { 196, 6, 7, 9, 1, -8 },
  { 202, 7, 4, 9, 1, -7 },
  { 206, 7, 7, 9, 1, -8 },
  { 213, 7, 11, 9, 1, -11 },
  { 223, 9, 11, 9, 0, -11 },
  { 236, 8, 11, 9, 1, -11 },
  { 247, 7, 11, 9, 1, -11 },
  { 257, 7, 11, 9, 1, -11 },
  { 267, 7, 11, 9, 1, -11 },
  { 277, 7, 11, 9, 1, -11 },
  { 287, 7, 11, 9, 1, -11 },
  { 297, 7, 11, 9, 1, -11 },
  { 307, 7, 11, 9, 1, -11 },
  { 317, 7, 11, 9, 1, -11 },
  { 327, 7, 11, 9, 1, -11 },
  { 337, 8, 11, 9, 1, -11 },
  { 348, 7, 11, 9, 1, -11 },
  { 358, 7, 11, 9, 1, -11 },
  { 368, 7, 11, 9, 1, -11 },
  { 378, 7, 11, 9, 1, -11 },
  { 388, 7, 11, 9, 1, -11 },
  { 398, 8, 13, 9, 1, -11 },
  { 411, 7, 11, 9, 1, -11 },
  { 421, 7, 11, 9, 1, -11 },
  { 431, 7, 11, 9, 1, -11 },
  { 441, 7, 11, 9, 1, -11 },
  { 451, 7, 11, 9, 1, -11 },
  { 461, 8, 11, 9, 1, -11 },
  { 472, 8, 11, 9, 1, -11 },
  { 483, 8, 11, 9, 0, -11 },
  { 494, 7, 11, 9, 1, -11 },
  { 504, 3, 14, 9, 3, -12 },
  { 510, 5, 12, 9, 2, -11 },
  { 518, 3, 14, 9, 3, -12 },
  { 524, 5, 6, 9, 2, -11 },
  { 528, 7, 1, 9, 1, 0 },
  { 529, 3, 2, 9, 3, -11 },
  { 530, 7, 8, 9, 1, -8 },
  { 537, 7, 11, 9, 1, -11 },
  { 547, 7, 8, 9, 1, -8 },
  { 554, 7, 11, 9, 1, -11 },
  { 564, 7, 8, 9, 1, -8 },
  { 571, 7, 12, 9, 1, -12 },
  { 582, 7, 11, 9, 1, -8 },
  { 592, 7, 11, 9, 1, -11 },
  { 602, 7, 11, 9, 1, -11 },
  { 612, 4, 14, 9, 2, -11 },
  { 619, 7, 11, 9, 1, -11 },
  { 629, 7, 11, 9, 1, -11 },
  { 639, 7, 8, 9, 1, -8 },
  { 646, 7, 8, 9, 1, -8 },
  { 653, 7, 8, 9, 1, -8 },
  { 660, 7, 11, 9, 1, -8 },
  { 670, 7, 11, 9, 1, -8 },
  { 680, 6, 8, 9, 2, -8 },
  { 686, 7, 8, 9, 1, -8 },
  { 693, 7, 10, 9, 1, -10 },
  { 702, 7, 8, 9, 1, -8 },
  { 709, 7, 8, 9, 1, -8 },
  { 716, 9, 8, 9, 0, -8 },
  { 725, 7, 8, 9, 1, -8 },
  { 732, 8, 11, 9, 0, -8 },
  { 743, 7, 8, 9, 1, -8 },
  { 750, 5, 15, 9, 2, -12 },
  { 760, 1, 14, 9, 4, -11 },
  { 762, 5, 15, 9, 2, -12 },
  { 772, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_Regular15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular15pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_REGULAR15PT7B_H_
