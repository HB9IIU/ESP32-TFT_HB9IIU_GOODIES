#ifndef _ROBOTOMONO_REGULAR18PT7B_H_
#define _ROBOTOMONO_REGULAR18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC3, 0xC0, 0x9C, 0xE7, 0x29, 0x00, 0x19, 0x08, 0x84,
  0x42, 0x6F, 0xF9, 0x90, 0x88, 0x44, 0xFF, 0x92, 0x19, 0x08, 0x84, 0x40,
  0x08, 0x04, 0x07, 0x8E, 0xE6, 0x33, 0x09, 0x82, 0x60, 0x1E, 0x03, 0x80,
  0x58, 0x34, 0x1B, 0x18, 0xF8, 0x10, 0x08, 0x00, 0x70, 0x12, 0x0C, 0x93,
  0x24, 0x5A, 0x0D, 0x80, 0x40, 0x30, 0x0B, 0xC6, 0x91, 0x24, 0x09, 0x03,
  0xC0, 0x3C, 0x3B, 0x19, 0x8C, 0xC6, 0xC1, 0xC0, 0xE0, 0xF1, 0xCC, 0xE3,
  0xF0, 0xD8, 0xE7, 0xD8, 0xFF, 0xC0, 0x19, 0x88, 0xC4, 0x23, 0x18, 0xC6,
  0x31, 0x84, 0x21, 0x84, 0x10, 0x40, 0x84, 0x62, 0x33, 0x11, 0x11, 0x11,
  0x33, 0x26, 0xC8, 0x08, 0x04, 0x02, 0x1D, 0x73, 0xF0, 0xE0, 0xD8, 0xC6,
  0x22, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10, 0x08,
  0x04, 0x00, 0x6D, 0xAC, 0xFE, 0xFC, 0x06, 0x0C, 0x10, 0x60, 0x81, 0x06,
  0x08, 0x30, 0x40, 0x83, 0x04, 0x18, 0x00, 0x3C, 0x33, 0x90, 0xD8, 0x2C,
  0x3E, 0x3F, 0x37, 0xE3, 0xE1, 0xE0, 0x90, 0x4C, 0x63, 0xE0, 0x0B, 0xFF,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x3C, 0x66, 0xC3, 0x83, 0x03,
  0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFF, 0x3C, 0x66, 0xC3, 0xC3,
  0x03, 0x06, 0x3C, 0x06, 0x03, 0x03, 0xC3, 0xC6, 0x7C, 0x06, 0x03, 0x03,
  0x83, 0xC1, 0x61, 0xB1, 0x98, 0x8C, 0xC6, 0x7F, 0xC1, 0x80, 0xC0, 0x60,
  0x7E, 0x7E, 0x40, 0xC0, 0xC0, 0xFC, 0xC6, 0x03, 0x03, 0x03, 0x82, 0xC6,
  0x7C, 0x0E, 0x3E, 0x60, 0x60, 0x40, 0xFE, 0xE3, 0xC3, 0xC1, 0xC1, 0x43,
  0x63, 0x3E, 0xFF, 0xFF, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x03, 0x00, 0x3C, 0xEE, 0xC2, 0x82, 0xC2, 0x66, 0x3C,
  0xC6, 0x83, 0x83, 0x83, 0xC6, 0x7C, 0x3C, 0x76, 0x43, 0xC1, 0xC1, 0xC1,
  0x63, 0x7F, 0x19, 0x03, 0x02, 0x1E, 0x38, 0xF0, 0x00, 0xF0, 0x6C, 0x00,
  0x00, 0x6D, 0xAC, 0x01, 0x07, 0x1E, 0x70, 0xE0, 0x38, 0x0F, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x81, 0x81, 0xE0, 0x70, 0x67, 0xBC, 0x40, 0x7D,
  0xDE, 0x18, 0x10, 0x60, 0xC3, 0x0C, 0x10, 0x40, 0x00, 0x83, 0x00, 0x1C,
  0x19, 0x90, 0x73, 0xD9, 0x2D, 0x26, 0x93, 0x49, 0xA4, 0xDD, 0xA0, 0x08,
  0x43, 0xE0, 0x08, 0x0E, 0x07, 0x02, 0x83, 0x61, 0xB0, 0x88, 0xC6, 0x7F,
  0x3F, 0x90, 0x58, 0x38, 0x08, 0xF8, 0xFE, 0x82, 0x83, 0x82, 0x8E, 0xFC,
  0x86, 0x83, 0x83, 0x83, 0x8E, 0xFC, 0x3E, 0x3B, 0x90, 0x58, 0x3C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0xD0, 0x4C, 0x63, 0xE0, 0xF8, 0x7F, 0x30,
  0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xD8, 0xCF, 0xC0,
  0xFF, 0xFE, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0,
  0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1E, 0x3B, 0x90, 0x58, 0x3C, 0x06, 0x03, 0x01, 0x8F, 0xC1, 0xE0,
  0xD0, 0x6C, 0x73, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF, 0xFC, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0xC3, 0xC3, 0x66, 0x3C, 0x83, 0x86, 0x8C, 0x8C,
  0x98, 0xB0, 0xF0, 0xD8, 0x88, 0x8C, 0x86, 0x86, 0x83, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC1, 0xF1,
  0xF8, 0xFC, 0xFF, 0x7E, 0xAF, 0x77, 0xBB, 0xC9, 0xE0, 0xF0, 0x78, 0x3C,
  0x18, 0xC1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1E, 0xCF, 0x27, 0x9B, 0xC5, 0xE3,
  0xF0, 0xF8, 0x7C, 0x18, 0x3C, 0x3B, 0x90, 0xD8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xD0, 0x4C, 0x63, 0xE0, 0xFC, 0xFE, 0x83, 0x83, 0x83,
  0x83, 0x8E, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C, 0x3B, 0x90, 0xD8,
  0x3C, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xD0, 0x4C, 0x63, 0xE0, 0x1C,
  0x06, 0xF8, 0xFE, 0x82, 0x83, 0x83, 0x82, 0xFE, 0xF8, 0x8C, 0x84, 0x86,
  0x82, 0x83, 0x3E, 0x3B, 0x90, 0x78, 0x34, 0x03, 0x80, 0xF8, 0x0E, 0x01,
  0xE0, 0xF0, 0x6C, 0x63, 0xE0, 0xFF, 0xFF, 0xC2, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xD0, 0x4C, 0x63, 0xE0, 0x81,
  0xE0, 0xF0, 0x48, 0x66, 0x33, 0x10, 0x88, 0x6C, 0x34, 0x0A, 0x07, 0x03,
  0x80, 0x80, 0x88, 0xC4, 0x67, 0x3B, 0xBD, 0x5E, 0xAF, 0x56, 0xAE, 0x77,
  0x31, 0x98, 0xCC, 0x66, 0x30, 0xC1, 0xA0, 0x98, 0xC6, 0xC3, 0x60, 0xE0,
  0x20, 0x38, 0x36, 0x1B, 0x18, 0xCC, 0x2C, 0x18, 0xC1, 0xE0, 0x90, 0xCC,
  0x42, 0x61, 0xA0, 0x70, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFF,
  0xFF, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0xFF,
  0xFE, 0x49, 0x24, 0x92, 0x49, 0x24, 0xFC, 0xC0, 0x81, 0x03, 0x02, 0x06,
  0x0C, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0xC0, 0xFC, 0x92, 0x49, 0x24,
  0x92, 0x49, 0xFC, 0x10, 0x60, 0xE3, 0x46, 0xC8, 0xB1, 0x80, 0xFF, 0xCC,
  0x1C, 0x7E, 0x43, 0x01, 0x1F, 0x71, 0xC1, 0xC3, 0x67, 0x7D, 0x80, 0x80,
  0x80, 0x80, 0x98, 0xFC, 0xC6, 0x82, 0x83, 0x83, 0x83, 0x82, 0xC6, 0xBC,
  0x1C, 0x3F, 0x63, 0xC1, 0xC0, 0xC0, 0xC0, 0x41, 0x63, 0x3E, 0x01, 0x01,
  0x01, 0x01, 0x19, 0x7F, 0x63, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x63, 0x3D,
  0x1C, 0x1F, 0x18, 0xD8, 0x2F, 0xFF, 0xFF, 0x00, 0x80, 0x63, 0x1F, 0x00,
  0x07, 0x87, 0xC6, 0x03, 0x0F, 0xF7, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x19, 0x7F, 0x63, 0xC1, 0xC1, 0xC1, 0xC1, 0x41,
  0x63, 0x3D, 0x01, 0x43, 0x7E, 0x1C, 0x81, 0x02, 0x04, 0x09, 0x9F, 0xF1,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x18, 0x18, 0x00, 0xF8, 0xF8,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x0C, 0x20, 0x1E, 0x78,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0xBE, 0xF0, 0x80, 0x80, 0x80,
  0x80, 0x86, 0x8C, 0x98, 0xB0, 0xF0, 0xF0, 0x98, 0x8C, 0x86, 0x87, 0xF8,
  0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xB3, 0x7F, 0xE2, 0x71, 0x38, 0x9C, 0x4E, 0x27, 0x13, 0x89, 0xC4,
  0xC0, 0x99, 0xFF, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x1C, 0x3F,
  0x18, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x82, 0x63, 0x1F, 0x00, 0x98, 0xFC,
  0x86, 0x82, 0x83, 0x83, 0x82, 0x86, 0xC6, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x19, 0x7F, 0x63, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x63, 0x3D, 0x01, 0x01,
  0x01, 0x01, 0x8E, 0xFE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x38, 0xFF,
  0x1E, 0x0F, 0x07, 0x81, 0xC1, 0xC6, 0xF8, 0x10, 0x10, 0xFF, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xC6, 0xF4, 0xC1, 0xE0, 0x90, 0xCC, 0x62, 0x21, 0x30, 0xD0,
  0x28, 0x1C, 0x04, 0x00, 0xC4, 0x51, 0x14, 0xC5, 0x29, 0x6A, 0xDA, 0xA3,
  0xA8, 0xC6, 0x31, 0x8C, 0x60, 0xC1, 0xB1, 0x88, 0x86, 0xC1, 0xC0, 0xE0,
  0x50, 0x6C, 0x63, 0x60, 0xC0, 0x81, 0xE0, 0xD0, 0x4C, 0x66, 0x21, 0xB0,
  0xD8, 0x28, 0x1C, 0x04, 0x06, 0x02, 0x07, 0x07, 0x00, 0xFF, 0x7F, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x7F, 0xC0, 0x0C, 0x63, 0x0C,
  0x30, 0xC3, 0x08, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x04, 0x0C, 0xFF, 0xFF,
  0x80, 0xC1, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x1C, 0xC3, 0x08, 0x20, 0x82,
  0x18, 0xC0, 0x78, 0x5B, 0x1C, 0x7C,
};

const GFXglyph RobotoMono_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 13, 11, 4, -13 },
  { 5, 5, 5, 11, 3, -14 },
  { 9, 9, 13, 11, 1, -13 },
  { 24, 9, 17, 11, 1, -15 },
  { 44, 10, 13, 11, 0, -13 },
  { 61, 9, 13, 11, 1, -13 },
  { 76, 2, 5, 11, 4, -14 },
  { 78, 5, 18, 11, 3, -14 },
  { 90, 4, 18, 11, 3, -14 },
  { 99, 9, 9, 11, 1, -13 },
  { 110, 9, 10, 11, 1, -11 },
  { 122, 3, 5, 11, 3, -2 },
  { 124, 7, 1, 11, 2, -6 },
  { 125, 3, 2, 11, 4, -2 },
  { 126, 7, 14, 11, 2, -13 },
  { 139, 9, 13, 11, 1, -13 },
  { 154, 5, 13, 11, 2, -13 },
  { 163, 8, 13, 11, 1, -13 },
  { 176, 8, 13, 11, 1, -13 },
  { 189, 9, 13, 11, 1, -13 },
  { 204, 8, 13, 11, 2, -13 },
  { 217, 8, 13, 11, 1, -13 },
  { 230, 9, 13, 11, 1, -13 },
  { 245, 8, 13, 11, 2, -13 },
  { 258, 8, 13, 11, 1, -13 },
  { 271, 2, 10, 11, 5, -10 },
  { 274, 3, 13, 11, 4, -10 },
  { 279, 8, 8, 11, 1, -10 },
  { 287, 7, 5, 11, 2, -8 },
  { 292, 7, 8, 11, 2, -10 },
  { 299, 7, 13, 11, 2, -13 },
  { 311, 9, 13, 11, 1, -13 },
  { 326, 9, 13, 11, 1, -13 },
  { 341, 8, 13, 11, 2, -13 },
  { 354, 9, 13, 11, 1, -13 },
  { 369, 9, 13, 11, 1, -13 },
  { 384, 7, 13, 11, 2, -13 },
  { 396, 8, 13, 11, 2, -13 },
  { 409, 9, 13, 11, 1, -13 },
  { 424, 9, 13, 11, 1, -13 },
  { 439, 7, 13, 11, 2, -13 },
  { 451, 8, 13, 11, 1, -13 },
  { 464, 8, 13, 11, 2, -13 },
  { 477, 8, 13, 11, 2, -13 },
  { 490, 9, 13, 11, 1, -13 },
  { 505, 9, 13, 11, 1, -13 },
  { 520, 9, 13, 11, 1, -13 },
  { 535, 8, 13, 11, 2, -13 },
  { 548, 9, 15, 11, 1, -13 },
  { 565, 8, 13, 11, 2, -13 },
  { 578, 9, 13, 11, 1, -13 },
  { 593, 9, 13, 11, 1, -13 },
  { 608, 9, 13, 11, 1, -13 },
  { 623, 9, 13, 11, 1, -13 },
  { 638, 9, 13, 11, 1, -13 },
  { 653, 9, 13, 11, 1, -13 },
  { 668, 9, 13, 11, 1, -13 },
  { 683, 8, 13, 11, 1, -13 },
  { 696, 3, 18, 11, 4, -15 },
  { 703, 7, 14, 11, 2, -13 },
  { 716, 3, 18, 11, 4, -15 },
  { 723, 7, 7, 11, 2, -13 },
  { 730, 8, 1, 11, 1, 0 },
  { 731, 3, 2, 11, 4, -13 },
  { 732, 8, 10, 11, 1, -10 },
  { 742, 8, 14, 11, 2, -14 },
  { 756, 8, 10, 11, 1, -10 },
  { 766, 8, 14, 11, 1, -14 },
  { 780, 9, 10, 11, 1, -10 },
  { 792, 9, 14, 11, 1, -14 },
  { 808, 8, 14, 11, 1, -10 },
  { 822, 7, 14, 11, 2, -14 },
  { 835, 8, 13, 11, 2, -13 },
  { 848, 6, 17, 11, 2, -13 },
  { 861, 8, 14, 11, 2, -14 },
  { 875, 8, 14, 11, 2, -14 },
  { 889, 9, 10, 11, 1, -10 },
  { 901, 7, 10, 11, 2, -10 },
  { 910, 9, 10, 11, 1, -10 },
  { 922, 8, 14, 11, 2, -10 },
  { 936, 8, 14, 11, 1, -10 },
  { 950, 6, 10, 11, 3, -10 },
  { 958, 7, 10, 11, 2, -10 },
  { 967, 8, 12, 11, 1, -12 },
  { 979, 7, 10, 11, 2, -10 },
  { 988, 9, 10, 11, 1, -10 },
  { 1000, 10, 10, 11, 0, -10 },
  { 1013, 9, 10, 11, 1, -10 },
  { 1025, 9, 14, 11, 1, -10 },
  { 1041, 9, 10, 11, 1, -10 },
  { 1053, 6, 17, 11, 3, -14 },
  { 1066, 1, 17, 11, 5, -13 },
  { 1069, 6, 17, 11, 3, -14 },
  { 1082, 10, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_Regular18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular18pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_REGULAR18PT7B_H_
