#ifndef _ROBOTOMONO_REGULAR43PT7B_H_
#define _ROBOTOMONO_REGULAR43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xC0, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xDF, 0xC3, 0xE0, 0x3E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x00, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x01, 0xF7, 0xC0, 0x1E, 0x3E, 0x07, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0xE0, 0xE0, 0x40, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0,
  0xE0, 0xE3, 0xC0, 0xE0, 0xE3, 0x80, 0x71, 0xE7, 0x00, 0x7F, 0xC7, 0x00,
  0x3F, 0x8E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0xF8, 0x00, 0xF3, 0xFC,
  0x00, 0xE7, 0xFE, 0x01, 0xC7, 0x0E, 0x01, 0xC7, 0x07, 0x03, 0x86, 0x07,
  0x03, 0x86, 0x07, 0x07, 0x06, 0x07, 0x03, 0x07, 0x07, 0x00, 0x07, 0x0F,
  0x00, 0x07, 0x8E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x78, 0x01, 0xF0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x79, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x38, 0xF1, 0xF0, 0x73, 0xE1, 0xE1, 0xE7, 0x81, 0xE3, 0xDE, 0x03, 0xE7,
  0xBC, 0x03, 0xEE, 0x78, 0x03, 0xFC, 0xF0, 0x03, 0xF0, 0xF0, 0x07, 0xE1,
  0xE0, 0x0F, 0xC3, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0x81,
  0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x00, 0x20, 0x06, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xF0, 0x06, 0x00, 0x20, 0x80, 0x18, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0x81, 0xC0,
  0x4F, 0x0E, 0x1E, 0x7E, 0x73, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xC0,
  0x07, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x81, 0xF0, 0x1C, 0x07, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x38, 0xF3, 0xC1, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xF9, 0xF7, 0xF7, 0xCF, 0x80, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x3C, 0x03,
  0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xEF, 0xF0,
  0x7C, 0xFF, 0x0F, 0x8F, 0xF1, 0xF0, 0xFF, 0x7C, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xF1, 0xF8, 0x7C, 0x07, 0xC7, 0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x87, 0xC7, 0xC0, 0x3C, 0xF0,
  0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3D, 0xE0, 0x0F, 0xBE, 0x03, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00,
  0xF3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x83,
  0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0x80,
  0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x07, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x7E, 0x0F, 0x3F, 0xF1,
  0xFF, 0xFF, 0x3F, 0xC3, 0xE7, 0xE0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0x1F, 0x03, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x01, 0xDE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x78,
  0x7E, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xC1, 0xF1,
  0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0x3E, 0x03, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0x8F, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x3C, 0x07, 0xE7,
  0xF7, 0xFC, 0x7F, 0xFF, 0x87, 0xFE, 0xF0, 0x3E, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x10, 0xF9, 0xF7,
  0xF7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x43, 0xE7, 0xDF, 0xDF, 0x3E, 0x08, 0x7D, 0xFB, 0xF7, 0xE7, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x81, 0xFF, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFE, 0x78, 0x07,
  0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3E, 0x07, 0x80, 0x70,
  0x07, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x0F, 0x86, 0x38, 0x7F,
  0x8E, 0x60, 0xE3, 0x0D, 0xC3, 0x86, 0x1B, 0x8E, 0x0C, 0x36, 0x1C, 0x18,
  0x6C, 0x30, 0x30, 0xD8, 0x60, 0xE1, 0xF1, 0xC1, 0xC3, 0xE3, 0x83, 0x87,
  0xC7, 0x07, 0x0F, 0x8E, 0x0C, 0x1F, 0x1C, 0x18, 0x76, 0x38, 0x70, 0xCC,
  0x3F, 0xF3, 0x9C, 0x7F, 0xFE, 0x38, 0x7C, 0xF8, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x04, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x38, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xE0,
  0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x80, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x0F, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x01, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0x0F, 0xC1, 0xE0, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0,
  0x07, 0x8F, 0x80, 0x3C, 0x3E, 0x07, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x3C,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C,
  0x03, 0xF1, 0xE0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0x9F, 0xC1, 0xF0, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x3C, 0x00, 0x39, 0xE0,
  0x01, 0xC7, 0x80, 0x1E, 0x3F, 0x03, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1E,
  0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F,
  0x00, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x7C,
  0x07, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x7B,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80,
  0x3F, 0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xF1,
  0xE0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xE0, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x7F, 0xE0, 0x77, 0xFF, 0x0F, 0x7F,
  0x70, 0xE7, 0xF7, 0x0E, 0x7F, 0x79, 0xEF, 0xF3, 0x9C, 0xFF, 0x39, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0E, 0x0F, 0xF0, 0x60, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x78, 0x0F, 0xF7, 0x80, 0xFF, 0x3C,
  0x0F, 0xF3, 0xC0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x07, 0x8F, 0xF0, 0x78, 0xFF, 0x03, 0xCF, 0xF0, 0x3C, 0xFF,
  0x01, 0xEF, 0xF0, 0x1E, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00,
  0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC1, 0xE0, 0x1E, 0x07, 0xC1, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xF0, 0x07, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x03, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1E, 0x03, 0xE0, 0xF0,
  0x07, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xC0, 0x01,
  0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x07,
  0xC1, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x04,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x0F,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0,
  0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xF3, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x7D, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7C, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0xFB, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x0E,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x77,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x78,
  0x1F, 0xC0, 0xF0, 0x3F, 0x81, 0xE0, 0x7F, 0x83, 0xC0, 0xEF, 0x07, 0xC1,
  0xDE, 0x0F, 0x83, 0xBC, 0x3F, 0x0F, 0x78, 0x7E, 0x1E, 0x70, 0xFC, 0x3C,
  0xE1, 0xF8, 0x79, 0xC3, 0xB8, 0xF3, 0x87, 0x71, 0xC7, 0x9C, 0xE3, 0x8F,
  0x39, 0xC7, 0x1E, 0x73, 0x8E, 0x3C, 0xE7, 0x9C, 0x79, 0xC7, 0x78, 0x77,
  0x8E, 0xF0, 0xEE, 0x1D, 0xE1, 0xDC, 0x3B, 0x83, 0xB8, 0x77, 0x07, 0x70,
  0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x00, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF8,
  0x07, 0x81, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC1,
  0xE0, 0x0F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x07,
  0x87, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07,
  0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x78,
  0x3C, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78,
  0x3C, 0x1E, 0x0F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0,
  0xFC, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3E, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E,
  0xF8, 0x07, 0xE7, 0xC0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xDE, 0x0F, 0xF1,
  0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x7F,
  0x03, 0xDF, 0xF8, 0x7F, 0xFF, 0x8F, 0xE1, 0xF9, 0xF0, 0x0F, 0x3C, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x03, 0xEF, 0xC0, 0xF9, 0xFF, 0xFE,
  0x3B, 0xFF, 0x87, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x83, 0xF0, 0x7C, 0x3C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF7,
  0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x7E, 0x3C, 0x3F, 0xF7, 0x8F, 0xFF, 0xF3, 0xF0, 0xFE, 0xF8, 0x07,
  0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xF3, 0xE0, 0x7E,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xCF, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xF0, 0xFC, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x04, 0x7C, 0x00, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xF0, 0x20, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0xE1, 0xFF,
  0xBC, 0x7F, 0xFF, 0x9F, 0x87, 0xF7, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x9F, 0x03, 0xF1, 0xFF, 0xFE, 0x1F, 0xFB,
  0xC1, 0xFE, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0xC0, 0x0F,
  0x1C, 0x03, 0xE7, 0xE1, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x7F, 0x0F, 0x3F,
  0xF3, 0xFF, 0xFE, 0xFE, 0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x7C, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0,
  0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDE, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x80,
  0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F,
  0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xE3, 0xE3, 0xFF, 0xDF, 0xEF, 0xFF, 0xFF, 0xBE, 0x3F, 0x1F, 0xF0,
  0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78,
  0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xC0, 0xE1, 0xFC, 0x39, 0xFF, 0xCE, 0xFF, 0xFB, 0xB8,
  0x3E, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xE3, 0xF8, 0x1C, 0xFF, 0xC3, 0xBF,
  0xFC, 0x7F, 0x0F, 0xCF, 0x80, 0xF9, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x1E, 0x7E, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3C, 0xFF,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF9,
  0xE1, 0xFF, 0xBC, 0x7F, 0xFF, 0x9F, 0x87, 0xF7, 0xC0, 0x3E, 0xF0, 0x03,
  0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x9F, 0x03, 0xF1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFE, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xF0, 0xFF, 0xF3, 0xFE, 0xF7, 0xFE, 0xFF, 0xFE, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0x07, 0xC7, 0x80, 0x7C,
  0xE0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0x3E, 0x03, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x20, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xF0, 0x7F, 0x7F,
  0xFF, 0xCF, 0xFE, 0xF0, 0xFF, 0x1C, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0,
  0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x38,
  0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x38, 0xF0, 0x00,
  0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x18,
  0x07, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x70, 0x3C, 0x0E, 0x70, 0x3C,
  0x0E, 0x70, 0x7E, 0x0E, 0x78, 0x7E, 0x1E, 0x38, 0x7E, 0x1C, 0x38, 0x7E,
  0x1C, 0x38, 0xE7, 0x1C, 0x38, 0xE7, 0x1C, 0x3C, 0xE7, 0x1C, 0x1C, 0xE7,
  0x38, 0x1D, 0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x1D, 0xC3,
  0xB8, 0x0D, 0x81, 0xB0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x78, 0x00, 0x7D, 0xF0, 0x03,
  0xE3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x0F, 0x03, 0xC0, 0x3E, 0x1F, 0x00,
  0x78, 0x78, 0x00, 0xF3, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x3E, 0x1F, 0x00, 0xF0, 0x3E, 0x07,
  0x80, 0x78, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x70, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x03,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0x3F, 0xF0, 0x07, 0x7F, 0xFC, 0x0F,
  0xF0, 0x7E, 0x1E, 0xE0, 0x1F, 0xFE, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x60,
};

const GFXglyph RobotoMono_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 5, 31, 26, 10, -31 },
  { 21, 11, 10, 26, 7, -32 },
  { 35, 24, 31, 26, 1, -31 },
  { 128, 20, 40, 26, 3, -36 },
  { 228, 24, 31, 26, 1, -31 },
  { 321, 23, 31, 26, 2, -31 },
  { 411, 4, 10, 26, 10, -32 },
  { 416, 12, 45, 26, 7, -35 },
  { 484, 11, 45, 26, 7, -35 },
  { 546, 21, 21, 26, 3, -31 },
  { 602, 21, 22, 26, 2, -25 },
  { 660, 7, 12, 26, 7, -5 },
  { 671, 16, 3, 26, 5, -15 },
  { 677, 7, 6, 26, 10, -6 },
  { 683, 17, 34, 26, 5, -31 },
  { 756, 20, 31, 26, 3, -31 },
  { 834, 12, 31, 26, 4, -31 },
  { 881, 20, 31, 26, 2, -31 },
  { 959, 19, 31, 26, 2, -31 },
  { 1033, 22, 31, 26, 2, -31 },
  { 1119, 19, 31, 26, 4, -31 },
  { 1193, 19, 31, 26, 3, -31 },
  { 1267, 21, 31, 26, 2, -31 },
  { 1349, 19, 31, 26, 4, -31 },
  { 1423, 19, 31, 26, 3, -31 },
  { 1497, 7, 24, 26, 11, -24 },
  { 1518, 7, 31, 26, 10, -24 },
  { 1546, 17, 19, 26, 4, -23 },
  { 1587, 18, 12, 26, 4, -20 },
  { 1614, 18, 19, 26, 4, -23 },
  { 1657, 18, 31, 26, 4, -31 },
  { 1727, 23, 31, 26, 1, -31 },
  { 1817, 23, 31, 26, 2, -31 },
  { 1907, 20, 31, 26, 4, -31 },
  { 1985, 21, 31, 26, 2, -31 },
  { 2067, 21, 31, 26, 3, -31 },
  { 2149, 19, 31, 26, 4, -31 },
  { 2223, 19, 31, 26, 4, -31 },
  { 2297, 21, 31, 26, 2, -31 },
  { 2379, 20, 31, 26, 3, -31 },
  { 2457, 18, 31, 26, 4, -31 },
  { 2527, 20, 31, 26, 2, -31 },
  { 2605, 21, 31, 26, 4, -31 },
  { 2687, 19, 31, 26, 4, -31 },
  { 2761, 20, 31, 26, 3, -31 },
  { 2839, 20, 31, 26, 3, -31 },
  { 2917, 22, 31, 26, 2, -31 },
  { 3003, 20, 31, 26, 4, -31 },
  { 3081, 22, 36, 26, 2, -31 },
  { 3180, 20, 31, 26, 4, -31 },
  { 3258, 22, 31, 26, 2, -31 },
  { 3344, 22, 31, 26, 2, -31 },
  { 3430, 20, 31, 26, 3, -31 },
  { 3508, 23, 31, 26, 1, -31 },
  { 3598, 23, 31, 26, 2, -31 },
  { 3688, 23, 31, 26, 2, -31 },
  { 3778, 23, 31, 26, 1, -31 },
  { 3868, 21, 31, 26, 2, -31 },
  { 3950, 8, 42, 26, 9, -35 },
  { 3992, 16, 34, 26, 5, -31 },
  { 4060, 9, 42, 26, 8, -35 },
  { 4108, 16, 17, 26, 5, -31 },
  { 4142, 20, 3, 26, 3, 0 },
  { 4150, 8, 5, 26, 9, -31 },
  { 4155, 20, 23, 26, 3, -23 },
  { 4213, 19, 32, 26, 4, -32 },
  { 4289, 20, 23, 26, 3, -23 },
  { 4347, 19, 32, 26, 3, -32 },
  { 4423, 20, 23, 26, 3, -23 },
  { 4481, 21, 33, 26, 3, -33 },
  { 4568, 19, 32, 26, 3, -23 },
  { 4644, 18, 32, 26, 4, -32 },
  { 4716, 19, 31, 26, 4, -31 },
  { 4790, 14, 40, 26, 4, -31 },
  { 4860, 20, 32, 26, 4, -32 },
  { 4940, 19, 32, 26, 4, -32 },
  { 5016, 22, 23, 26, 2, -23 },
  { 5080, 18, 23, 26, 4, -23 },
  { 5132, 20, 23, 26, 3, -23 },
  { 5190, 19, 32, 26, 4, -23 },
  { 5266, 19, 32, 26, 3, -23 },
  { 5342, 16, 23, 26, 7, -23 },
  { 5388, 19, 23, 26, 4, -23 },
  { 5443, 19, 28, 26, 3, -28 },
  { 5510, 18, 23, 26, 4, -23 },
  { 5562, 22, 23, 26, 2, -23 },
  { 5626, 24, 23, 26, 1, -23 },
  { 5695, 22, 23, 26, 2, -23 },
  { 5759, 23, 32, 26, 1, -23 },
  { 5851, 20, 23, 26, 3, -23 },
  { 5909, 14, 42, 26, 7, -34 },
  { 5983, 3, 39, 26, 11, -31 },
  { 5998, 14, 42, 26, 7, -34 },
  { 6072, 24, 9, 26, 1, -17 },
};

const GFXfont RobotoMono_Regular43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular43pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_REGULAR43PT7B_H_
