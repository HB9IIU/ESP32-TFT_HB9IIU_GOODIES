#ifndef _ROBOTOMONO_REGULAR37PT7B_H_
#define _ROBOTOMONO_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00,
  0x6F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xB8, 0x6E, 0x1B, 0x86,
  0xE1, 0x80, 0x00, 0xE1, 0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x1C, 0x18,
  0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0x83, 0x87, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x03, 0x87, 0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x70,
  0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x0C, 0x1C, 0x01,
  0xC1, 0x80, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7C, 0x7C,
  0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x7B, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xCF, 0x01, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0E, 0x38, 0x00, 0xC1, 0x83, 0x0C, 0x18,
  0x70, 0xC1, 0x87, 0x0C, 0x18, 0xE0, 0xE1, 0x8C, 0x0F, 0x39, 0xC0, 0x7F,
  0x18, 0x01, 0xE3, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC7, 0xC0, 0x1C, 0xFE, 0x03, 0x9C, 0x70, 0x31, 0x83,
  0x07, 0x18, 0x30, 0x61, 0x83, 0x0E, 0x18, 0x30, 0x21, 0x83, 0x00, 0x1C,
  0x70, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x1F,
  0xF8, 0x01, 0xE3, 0xC0, 0x3C, 0x1C, 0x03, 0xC1, 0xC0, 0x3C, 0x1C, 0x03,
  0xC1, 0xC0, 0x3C, 0x3C, 0x01, 0xC7, 0x80, 0x1E, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xDE, 0x0E, 0x78, 0xF0,
  0xEF, 0x0F, 0x0E, 0xF0, 0x79, 0xCE, 0x03, 0xDC, 0xE0, 0x1F, 0xCE, 0x01,
  0xF8, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x7E, 0x7F, 0xC3, 0xFF, 0xBC, 0x0F,
  0xF1, 0xF0, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x40, 0x30, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03,
  0x0E, 0x1F, 0xF7, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xEE, 0x00, 0xE7, 0x80, 0xF1, 0xC0, 0x70, 0x70, 0x78, 0x3C, 0x08,
  0x0C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xCF,
  0x38, 0xE3, 0x9C, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77,
  0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0x87,
  0xC7, 0x80, 0xE7, 0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x7F, 0x0F, 0x3F, 0x9F, 0x1F,
  0xDE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xEE, 0x00,
  0x77, 0x80, 0x39, 0xC0, 0x3C, 0xF0, 0x3C, 0x3E, 0x7E, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0xC1, 0xF3, 0xFF, 0xFF, 0xF9, 0xF8, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x03,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xCF, 0x00, 0xE7, 0x80, 0x7B,
  0x80, 0x1D, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x07, 0xFC, 0x07,
  0xF0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x0E, 0x7E, 0x7E, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0E, 0x78, 0x03, 0xCF,
  0x00, 0x71, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1D, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0x81, 0xF0, 0x40, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x39, 0xE0, 0x3C, 0x7E, 0xFC, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE7, 0xF0, 0xEF, 0xF8, 0xFF,
  0xFC, 0xF8, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xC7,
  0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x3C,
  0x03, 0x8E, 0x03, 0xC7, 0x83, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF0,
  0x78, 0x3C, 0x78, 0x0F, 0x38, 0x03, 0xBC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3D, 0xC0, 0x1C, 0xF0, 0x1E, 0x3F, 0x7E, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0x78, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x3F, 0xFF, 0x3F, 0xF7,
  0x0F, 0xC7, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0x00, 0x77, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0x80, 0x39, 0xF7,
  0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0x9E, 0x79, 0xE7, 0x9C, 0x73, 0x84, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0x03, 0x80, 0xE0, 0x1C, 0x18, 0x00, 0xE3,
  0x83, 0x86, 0x30, 0xFE, 0x67, 0x1E, 0xE3, 0x61, 0x86, 0x36, 0x38, 0xC3,
  0x63, 0x0C, 0x3E, 0x30, 0xC3, 0xC7, 0x0C, 0x3C, 0x70, 0xC3, 0xC6, 0x0C,
  0x3C, 0x70, 0xC6, 0xE7, 0x1C, 0x6E, 0x33, 0xC6, 0x63, 0xFF, 0xC6, 0x1E,
  0x78, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x3D, 0xC0,
  0x03, 0x9E, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xF0, 0x07, 0x07,
  0x00, 0xF0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x1E, 0x38,
  0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9C, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xF3, 0x80, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7D, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xE0,
  0x78, 0x7C, 0x3C, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x38, 0xF0, 0x1E, 0x1F,
  0x3F, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xFE, 0x0E, 0x3F,
  0xC3, 0x80, 0xF8, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0x7B, 0x80, 0x1E,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x7B, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x07, 0x8E, 0x03, 0xE3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xE7, 0xFF, 0xF3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xE0,
  0x7C, 0x7C, 0x3C, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x07, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x1C, 0xF0, 0x0F, 0x1F,
  0xDF, 0x83, 0xFF, 0xC0, 0x3F, 0xC0, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x79, 0xE0, 0x7C, 0x7E, 0xFC, 0x1F, 0xFC, 0x07,
  0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0,
  0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0,
  0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xDE, 0x03,
  0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x1E, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00,
  0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0xEF, 0xF8, 0x77, 0xEE, 0x3B,
  0xF7, 0x39, 0xFB, 0x9C, 0xFC, 0xEE, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F,
  0x0F, 0xC7, 0x87, 0xE3, 0xC3, 0xF0, 0xC1, 0xF8, 0x60, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xC0, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xDC, 0x0F, 0xEF, 0x07, 0xF3, 0x83, 0xF9, 0xE1,
  0xFC, 0x70, 0xFE, 0x3C, 0x7F, 0x0E, 0x3F, 0x87, 0x9F, 0xC1, 0xCF, 0xE0,
  0xF7, 0xF0, 0x3B, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xFE, 0x01, 0xFF, 0xE0, 0x7C, 0xFC, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x00,
  0x39, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x70, 0x03, 0x9E, 0x00, 0xE3, 0x80,
  0x78, 0xF0, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0x07, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x00, 0xEF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B, 0xC0,
  0x1E, 0xF0, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0x9F, 0x83, 0xC0, 0xF0, 0xF0, 0x0F, 0x1C,
  0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x00, 0xE7, 0x00, 0x3C, 0xE0,
  0x07, 0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0x0F, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x3C, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x73,
  0xC0, 0x3C, 0xF0, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xC1, 0xC0, 0xF0,
  0x78, 0x3C, 0x0E, 0x0F, 0x03, 0xC3, 0xC0, 0x70, 0xF0, 0x1E, 0x3C, 0x03,
  0x8F, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xBC, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFC, 0x7E, 0x3C, 0x07, 0x9E, 0x00, 0xF7,
  0x00, 0x3D, 0xC0, 0x07, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77,
  0x80, 0x3D, 0xF0, 0x1F, 0x3F, 0xBF, 0x87, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00,
  0x77, 0x80, 0x79, 0xE0, 0x78, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x00,
  0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38, 0x01,
  0xC3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xE0,
  0x78, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x78, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x70, 0x77, 0x07, 0x07, 0x70, 0xF0,
  0x77, 0x0F, 0x07, 0x70, 0xF8, 0x77, 0x0F, 0x87, 0x70, 0xF8, 0xF7, 0x0D,
  0x8E, 0x71, 0xD8, 0xE7, 0x9D, 0xCE, 0x39, 0xDC, 0xE3, 0x99, 0xCE, 0x39,
  0x9C, 0xE3, 0xB8, 0xCE, 0x3B, 0x8C, 0xE3, 0xB8, 0xEC, 0x3B, 0x8F, 0xC3,
  0xB0, 0xFC, 0x1B, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0xF0, 0x01,
  0xEF, 0x00, 0x79, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xC0, 0xF0, 0x3C, 0x1E,
  0x03, 0x87, 0x80, 0x78, 0xE0, 0x07, 0x3C, 0x00, 0xF7, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xB8, 0x00, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x07, 0x01, 0xE0, 0xF0,
  0x78, 0x0E, 0x0E, 0x01, 0xE3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3C,
  0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0x71,
  0xE0, 0x07, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xFF, 0xF0,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3B, 0x81, 0xCE, 0x07, 0x38, 0x38,
  0x70, 0xE1, 0xC3, 0x83, 0x9C, 0x0E, 0x70, 0x3F, 0x80, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x03, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0x78, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x7F, 0xFF, 0x7F, 0xF7, 0x1F,
  0xC7, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xE0, 0x7B, 0xFC, 0x3F, 0xFF,
  0x1F, 0x83, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3B,
  0xC0, 0x1D, 0xE0, 0x1E, 0xF8, 0x1E, 0x7F, 0xFF, 0x3B, 0xFF, 0x1C, 0xFE,
  0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x3E,
  0x7E, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0xC7, 0x1F,
  0xF7, 0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x1F, 0x3F, 0xFF, 0x1F, 0xF7, 0x0F,
  0xE7, 0x01, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x3C, 0x3C, 0x07,
  0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x04, 0x3C, 0x03, 0xC7, 0xE7, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x0C,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7E, 0x30, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x07, 0xC7, 0x1F, 0xF7, 0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x1F, 0x3F, 0xFF,
  0x3F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x0F, 0x20, 0x0F, 0x60, 0x1E,
  0xF8, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE1, 0xF0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40,
  0x1C, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x1E, 0xFF, 0xDF, 0xF3, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F,
  0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0x7C, 0x0F, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE1,
  0xE0, 0x78, 0xF0, 0x3E, 0x78, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x8F, 0x1F, 0xFB, 0xF3,
  0xFF, 0xFF, 0x78, 0xF0, 0xEE, 0x1E, 0x1F, 0xC1, 0xC3, 0xF8, 0x38, 0x7F,
  0x07, 0x0F, 0xE0, 0xE1, 0xFC, 0x1C, 0x3F, 0x83, 0x87, 0xF0, 0x70, 0xFE,
  0x0E, 0x1F, 0xC1, 0xC3, 0xF8, 0x38, 0x7F, 0x07, 0x0F, 0xE0, 0xE1, 0xFC,
  0x1C, 0x3F, 0x83, 0x87, 0xF0, 0x70, 0xF0, 0xE1, 0xF0, 0xE7, 0xFC, 0xEF,
  0xFE, 0xFC, 0x1E, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x3C, 0x38, 0x07, 0x9E, 0x00,
  0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x3C,
  0x0F, 0x07, 0xCF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0xE3, 0xE0, 0x77, 0xFC,
  0x3F, 0xFF, 0x1F, 0x87, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0x80, 0x1D, 0xC0,
  0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1E, 0xF8, 0x1E, 0x7F, 0x3F, 0x3B, 0xFF,
  0x1C, 0xFE, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC7, 0x1F, 0xF7,
  0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x1F, 0x3E, 0x7F, 0x3F, 0xF7, 0x0F, 0xE7,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0xFF, 0x3F, 0x80,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F, 0x70,
  0x07, 0x70, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x0F, 0x7E,
  0x3F, 0x3F, 0xFE, 0x0F, 0xF8, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0xEF, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70,
  0x0F, 0x78, 0x1F, 0x7E, 0xFF, 0x3F, 0xF7, 0x1F, 0xC7, 0xE0, 0x01, 0xFC,
  0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x07, 0x8E, 0x01, 0xC3, 0xC0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x60, 0x3F, 0x03, 0x83, 0xB8,
  0x1C, 0x1C, 0xC1, 0xE0, 0xE7, 0x0F, 0x07, 0x38, 0x7C, 0x31, 0xC3, 0xE3,
  0x8E, 0x3B, 0x1C, 0x31, 0xD8, 0xE1, 0x8C, 0xE7, 0x0E, 0x67, 0x30, 0x77,
  0x19, 0x83, 0xB8, 0xDC, 0x0D, 0x86, 0xE0, 0x6C, 0x3F, 0x03, 0x60, 0xF0,
  0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0x81, 0xE0, 0x1C, 0x06, 0x00, 0xF0,
  0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x81, 0xE0, 0xE0, 0x1E,
  0x3C, 0x01, 0xCF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xC7, 0x00, 0xF0,
  0xF0, 0x1C, 0x0F, 0x07, 0x80, 0xF1, 0xE0, 0x0E, 0x78, 0x01, 0xF0, 0xF0,
  0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC3,
  0xC0, 0x3C, 0x1E, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0x70,
  0x07, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0, 0x01, 0xDC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x0F, 0x01, 0xE0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x08,
  0x00, 0x3F, 0x80, 0x27, 0xFC, 0x03, 0x7B, 0xF0, 0x7E, 0x0F, 0x8F, 0xE0,
  0x7F, 0xEC, 0x01, 0xFC, 0x00, 0x07, 0x00,
};

const GFXglyph RobotoMono_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 26, 22, 9, -26 },
  { 14, 10, 9, 22, 6, -28 },
  { 26, 20, 26, 22, 1, -26 },
  { 91, 17, 35, 22, 3, -31 },
  { 166, 20, 27, 22, 1, -27 },
  { 234, 20, 27, 22, 2, -27 },
  { 302, 3, 9, 22, 9, -28 },
  { 306, 10, 38, 22, 6, -30 },
  { 354, 9, 38, 22, 6, -30 },
  { 397, 17, 17, 22, 3, -26 },
  { 434, 18, 19, 22, 2, -22 },
  { 477, 6, 10, 22, 6, -4 },
  { 485, 14, 3, 22, 4, -13 },
  { 491, 5, 5, 22, 9, -5 },
  { 495, 14, 28, 22, 5, -26 },
  { 544, 17, 27, 22, 3, -27 },
  { 602, 10, 26, 22, 4, -26 },
  { 635, 17, 27, 22, 2, -27 },
  { 693, 16, 27, 22, 2, -27 },
  { 747, 19, 26, 22, 1, -26 },
  { 809, 17, 26, 22, 3, -26 },
  { 865, 16, 26, 22, 3, -26 },
  { 917, 18, 26, 22, 2, -26 },
  { 976, 17, 27, 22, 3, -27 },
  { 1034, 16, 27, 22, 3, -27 },
  { 1088, 5, 21, 22, 10, -21 },
  { 1102, 6, 27, 22, 9, -21 },
  { 1123, 15, 16, 22, 3, -20 },
  { 1153, 16, 10, 22, 3, -17 },
  { 1173, 16, 16, 22, 3, -20 },
  { 1205, 16, 27, 22, 3, -27 },
  { 1259, 20, 26, 22, 1, -26 },
  { 1324, 20, 26, 22, 1, -26 },
  { 1389, 17, 26, 22, 3, -26 },
  { 1445, 18, 27, 22, 2, -27 },
  { 1506, 18, 26, 22, 3, -26 },
  { 1565, 16, 26, 22, 3, -26 },
  { 1617, 17, 26, 22, 3, -26 },
  { 1673, 18, 27, 22, 2, -27 },
  { 1734, 17, 26, 22, 3, -26 },
  { 1790, 16, 26, 22, 3, -26 },
  { 1842, 17, 26, 22, 2, -26 },
  { 1898, 18, 26, 22, 3, -26 },
  { 1957, 16, 26, 22, 4, -26 },
  { 2009, 17, 26, 22, 3, -26 },
  { 2065, 17, 26, 22, 3, -26 },
  { 2121, 18, 27, 22, 2, -27 },
  { 2182, 18, 26, 22, 3, -26 },
  { 2241, 19, 31, 22, 2, -27 },
  { 2315, 18, 26, 22, 3, -26 },
  { 2374, 18, 27, 22, 2, -27 },
  { 2435, 20, 26, 22, 1, -26 },
  { 2500, 17, 26, 22, 3, -26 },
  { 2556, 20, 26, 22, 1, -26 },
  { 2621, 20, 26, 22, 1, -26 },
  { 2686, 19, 26, 22, 2, -26 },
  { 2748, 20, 26, 22, 1, -26 },
  { 2813, 18, 26, 22, 2, -26 },
  { 2872, 7, 36, 22, 8, -30 },
  { 2904, 14, 28, 22, 4, -26 },
  { 2953, 7, 36, 22, 7, -30 },
  { 2985, 14, 14, 22, 4, -26 },
  { 3010, 16, 3, 22, 3, 0 },
  { 3016, 8, 5, 22, 7, -27 },
  { 3021, 16, 20, 22, 3, -20 },
  { 3061, 17, 28, 22, 3, -28 },
  { 3121, 16, 20, 22, 3, -20 },
  { 3161, 16, 28, 22, 3, -28 },
  { 3217, 18, 20, 22, 2, -20 },
  { 3262, 17, 29, 22, 3, -29 },
  { 3324, 16, 28, 22, 3, -20 },
  { 3380, 16, 28, 22, 3, -28 },
  { 3436, 16, 27, 22, 4, -27 },
  { 3490, 11, 35, 22, 4, -27 },
  { 3539, 17, 28, 22, 3, -28 },
  { 3599, 16, 28, 22, 4, -28 },
  { 3655, 19, 20, 22, 2, -20 },
  { 3703, 16, 20, 22, 3, -20 },
  { 3743, 18, 20, 22, 2, -20 },
  { 3788, 17, 28, 22, 3, -20 },
  { 3848, 16, 28, 22, 3, -20 },
  { 3904, 13, 20, 22, 6, -20 },
  { 3937, 16, 20, 22, 3, -20 },
  { 3977, 16, 24, 22, 3, -24 },
  { 4025, 16, 20, 22, 3, -20 },
  { 4065, 18, 20, 22, 2, -20 },
  { 4110, 21, 20, 22, 1, -20 },
  { 4163, 19, 20, 22, 2, -20 },
  { 4211, 20, 28, 22, 1, -20 },
  { 4281, 17, 20, 22, 3, -20 },
  { 4324, 12, 36, 22, 6, -29 },
  { 4378, 2, 33, 22, 10, -26 },
  { 4387, 12, 36, 22, 6, -29 },
  { 4441, 20, 7, 22, 1, -14 },
};

const GFXfont RobotoMono_Regular37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular37pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_REGULAR37PT7B_H_
