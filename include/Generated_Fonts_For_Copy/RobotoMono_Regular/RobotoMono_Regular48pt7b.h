#ifndef _ROBOTOMONO_REGULAR48PT7B_H_
#define _ROBOTOMONO_REGULAR48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0xFF, 0xFD, 0xE0, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xE7, 0x80, 0x0F, 0x9F, 0x80, 0x7E, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x20, 0x38, 0x1E, 0x0F, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x78,
  0x70, 0x1C, 0x0F, 0x1E, 0x03, 0xC1, 0xC3, 0x80, 0x78, 0x38, 0xF0, 0x07,
  0xDF, 0x1C, 0x00, 0x7F, 0xC7, 0x80, 0x07, 0xF0, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x70, 0xFE, 0x00, 0x1E, 0x3F,
  0xE0, 0x03, 0x8F, 0xBE, 0x00, 0xF1, 0xC1, 0xC0, 0x1C, 0x78, 0x3C, 0x07,
  0x8E, 0x07, 0x80, 0xE1, 0xC0, 0xF0, 0x38, 0x38, 0x1E, 0x07, 0x07, 0x03,
  0xC0, 0x20, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x01, 0xE3,
  0xE7, 0xC0, 0xF3, 0xE1, 0xF0, 0x7B, 0xE0, 0xF8, 0x3D, 0xF0, 0x3E, 0x1E,
  0xF0, 0x0F, 0x9E, 0x78, 0x03, 0xEF, 0x3C, 0x01, 0xFF, 0x9E, 0x00, 0x7F,
  0x8F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x0F, 0xF0, 0xFC, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0x8F, 0x81, 0xFF, 0x87, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x01, 0x80, 0x1C, 0x01, 0xF0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30,
  0x00, 0x80, 0x40, 0x03, 0x00, 0x1C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x70, 0x02, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x80, 0x9C, 0x1E, 0x0E, 0xFE, 0x78,
  0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x1E,
  0x1E, 0x00, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x38, 0x07,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C,
  0xF9, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x0F,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x3F, 0xBE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x3F, 0xF0, 0xFC, 0x7F, 0xE3, 0xF0,
  0xFF, 0xCF, 0x81, 0xFF, 0xBE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0x7F, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x0F,
  0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x0F, 0x80, 0x3E,
  0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8,
  0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x7B, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xE0,
  0x0F, 0x8F, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF1,
  0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x81,
  0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3D, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3E, 0x03, 0xF0, 0x20, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E,
  0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0xFF, 0x01, 0xEF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFC, 0xFE, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x3E, 0x00,
  0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E,
  0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0xF3,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8,
  0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7D, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0xF8, 0x07, 0xC3, 0xC0,
  0x0F, 0x1F, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0xCF, 0xE1,
  0xFF, 0x1F, 0xFF, 0xBC, 0x3F, 0xFD, 0xF0, 0x3F, 0xE7, 0x80, 0x18, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x3F, 0x7F, 0xFF, 0xF9, 0xF0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x30, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E, 0x3E, 0x00, 0xF9, 0xE0, 0x03,
  0xCF, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x38, 0x70, 0x3F, 0x0E, 0x1C, 0x1F, 0xE1, 0x8E, 0x0F, 0xF8, 0x73, 0x87,
  0x86, 0x1C, 0xC1, 0xC1, 0x87, 0x70, 0xE0, 0xE1, 0xDC, 0x38, 0x38, 0x37,
  0x0E, 0x0E, 0x0D, 0xC7, 0x03, 0x83, 0x71, 0xC0, 0xE0, 0xD8, 0x70, 0x38,
  0x76, 0x1C, 0x0E, 0x1D, 0x87, 0x03, 0x87, 0x71, 0xC0, 0xC1, 0x9C, 0x70,
  0x70, 0x67, 0x1E, 0x3C, 0x39, 0xC3, 0xFF, 0x9C, 0x70, 0xFE, 0xFF, 0x1E,
  0x1F, 0x1F, 0x83, 0x81, 0x01, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB,
  0xC0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3E, 0x00,
  0x1E, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0,
  0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0x87, 0xFE, 0x0F, 0x00, 0xFE, 0x1E, 0x00, 0x7E,
  0x3C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0xE7, 0x80, 0x0F, 0x8F, 0x00, 0x3F, 0x1E, 0x01, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x87, 0xC0, 0x3F, 0x07, 0xF1, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x0F, 0xC0,
  0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7E, 0x00,
  0xF0, 0xFC, 0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00,
  0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFE, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xFC,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFB,
  0x80, 0xEF, 0xF7, 0x83, 0xDF, 0xEF, 0x07, 0xBF, 0xCE, 0x0E, 0x7F, 0x9E,
  0x3C, 0xFF, 0xBC, 0x79, 0xFF, 0x38, 0xE3, 0xFE, 0x7B, 0xC7, 0xFC, 0xF7,
  0x8F, 0xF8, 0xEE, 0x1F, 0xF1, 0xFC, 0x3F, 0xE3, 0xF8, 0x7F, 0xC7, 0xE0,
  0xFF, 0x87, 0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x1E, 0x07, 0xFC, 0x1C, 0x0F,
  0xF8, 0x38, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xBC, 0x03, 0xFE,
  0xF8, 0x0F, 0xF9, 0xE0, 0x3F, 0xE7, 0xC0, 0xFF, 0x8F, 0x03, 0xFE, 0x3E,
  0x0F, 0xF8, 0x78, 0x3F, 0xE1, 0xF0, 0xFF, 0x83, 0xC3, 0xFE, 0x07, 0x8F,
  0xF8, 0x1E, 0x3F, 0xE0, 0x3C, 0xFF, 0x80, 0xFB, 0xFE, 0x01, 0xEF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0xF8,
  0x0F, 0xE3, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xC0, 0x7F, 0x8F,
  0x80, 0x1F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x07,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x78, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xC0, 0xFF, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x01, 0xF8, 0xF8, 0x3F, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0x7C, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x81, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0,
  0x03, 0xE3, 0xC0, 0x0F, 0x87, 0xC0, 0x3F, 0x07, 0xE1, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0,
  0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x1F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x81,
  0xFF, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0, 0x3E, 0x07, 0xBC, 0x0F,
  0xC1, 0xE7, 0x83, 0xF0, 0x79, 0xE1, 0xFC, 0x1E, 0x78, 0x7F, 0x07, 0x9E,
  0x1F, 0xC1, 0xE7, 0x87, 0x70, 0xF1, 0xE1, 0xDE, 0x3C, 0x78, 0x77, 0x8F,
  0x1E, 0x3C, 0xE3, 0xC7, 0x8F, 0x38, 0xF0, 0xE3, 0xCE, 0x3C, 0x3C, 0xE3,
  0xCF, 0x0F, 0x38, 0xF3, 0xC3, 0xCE, 0x3C, 0xE0, 0xF7, 0x87, 0x38, 0x3D,
  0xE1, 0xDE, 0x0F, 0x70, 0x77, 0x83, 0xDC, 0x1F, 0xE0, 0x77, 0x07, 0xF8,
  0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0x7C, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF,
  0xFC, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xE3, 0xC0,
  0x79, 0xF0, 0x1E, 0x78, 0x03, 0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xE0, 0x3E, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xF8, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x03,
  0xF9, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFE, 0xF8, 0x7F, 0xC3, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x3C, 0xFF, 0xE0, 0xF7, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xF0, 0x7E, 0x3F, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xE0,
  0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0xC0,
  0x1F, 0x3F, 0x80, 0xFC, 0xFF, 0x0F, 0xE3, 0xDF, 0xFF, 0x0F, 0x3F, 0xF8,
  0x3C, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0x81, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x07, 0xDF, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x3E, 0x00,
  0x7C, 0xFC, 0x03, 0xE1, 0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0xFF, 0x9F,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF8, 0x3F, 0xCF, 0x80, 0x3F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x1F, 0x83, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xF3, 0xC0, 0xFF, 0x8F, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x83, 0xE0, 0x01, 0x87, 0xE0, 0x0F, 0x87, 0xF0, 0x7F,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFA,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xF8, 0xF0, 0xFF, 0xFB, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFC, 0xF8, 0x03,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0x3E, 0x00, 0xFC, 0xFC, 0x07, 0xF1, 0xF8, 0x7F, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0x7C, 0x0F, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x40, 0x03, 0xE3, 0x80, 0x0F, 0x8F, 0x80, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x81, 0xE3, 0xFF, 0x0F, 0x3F, 0xFE, 0x7B, 0xFF, 0xF3,
  0xFC, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x20,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFD, 0xCF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xBC, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8,
  0x3C, 0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x3C,
  0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFE, 0xF8, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x3C, 0x0F, 0xC0,
  0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF8, 0xF0,
  0x03, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x78,
  0x7B, 0xFC, 0xFF, 0x3D, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0x83, 0xF0,
  0xF7, 0x81, 0xF0, 0x7F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C,
  0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03,
  0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0,
  0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF,
  0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F,
  0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x8F, 0xFC,
  0x3C, 0xFF, 0xF9, 0xEF, 0xFF, 0xCF, 0xF0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1F,
  0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x07, 0xE0, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0x9F, 0xF8,
  0x3D, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xE0, 0x7E, 0x7E, 0x00, 0xFB, 0xE0,
  0x07, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0x7E, 0x01, 0xFB, 0xFC, 0x1F, 0x9F, 0xFF, 0xF8, 0xF7, 0xFF,
  0x87, 0x8F, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0xF0,
  0xFF, 0xFB, 0xC7, 0xFF, 0xFF, 0x3F, 0x81, 0xFC, 0xF8, 0x03, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00,
  0x1F, 0x3E, 0x00, 0x7C, 0xFC, 0x03, 0xF1, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0x7C, 0x0F, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x78,
  0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x3F, 0x3E, 0x00, 0xFD, 0xE0, 0x03, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xBE, 0x00, 0x7C, 0xFC, 0x0F, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x18, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xF7, 0xC0,
  0x3F, 0x9F, 0x87, 0xFC, 0xFF, 0xFD, 0xE3, 0xFF, 0xCF, 0x07, 0xF8, 0x78,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0,
  0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0,
  0x01, 0xE3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x0E, 0x01, 0xEE, 0x01, 0xC0, 0x3D, 0xE0, 0x7C,
  0x07, 0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0x8E,
  0x0E, 0xE0, 0xE1, 0xC1, 0xDC, 0x1C, 0x3C, 0x3B, 0x83, 0x87, 0x87, 0x70,
  0xF0, 0xF1, 0xEF, 0x1E, 0x0E, 0x38, 0xE3, 0x81, 0xC7, 0x1C, 0x70, 0x3C,
  0xE3, 0x8E, 0x07, 0xBC, 0x7B, 0xC0, 0xF7, 0x07, 0x78, 0x0E, 0xE0, 0xEE,
  0x01, 0xDC, 0x1D, 0xC0, 0x3B, 0x83, 0xB8, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC7,
  0xC0, 0x03, 0xC7, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xF3, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x38, 0xFF, 0xE0, 0x07,
  0xBF, 0xFF, 0x00, 0xE7, 0x87, 0xF0, 0x3D, 0xE0, 0x3F, 0x8F, 0xBC, 0x03,
  0xFF, 0xE7, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x02, 0x00,
};

const GFXglyph RobotoMono_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 6, 34, 29, 11, -34 },
  { 27, 12, 11, 29, 8, -36 },
  { 44, 27, 34, 29, 1, -34 },
  { 159, 22, 45, 29, 4, -40 },
  { 283, 27, 36, 29, 1, -35 },
  { 405, 25, 35, 29, 3, -35 },
  { 515, 3, 11, 29, 12, -36 },
  { 520, 13, 50, 29, 8, -39 },
  { 602, 13, 50, 29, 7, -39 },
  { 684, 22, 23, 29, 4, -34 },
  { 748, 23, 25, 29, 3, -28 },
  { 820, 7, 13, 29, 8, -5 },
  { 832, 18, 4, 29, 5, -17 },
  { 841, 6, 6, 29, 12, -6 },
  { 846, 18, 37, 29, 6, -34 },
  { 930, 23, 35, 29, 3, -35 },
  { 1031, 13, 34, 29, 5, -34 },
  { 1087, 23, 35, 29, 2, -35 },
  { 1188, 22, 35, 29, 2, -35 },
  { 1285, 24, 34, 29, 2, -34 },
  { 1387, 22, 34, 29, 4, -34 },
  { 1481, 22, 34, 29, 3, -34 },
  { 1575, 23, 34, 29, 3, -34 },
  { 1673, 22, 35, 29, 4, -35 },
  { 1770, 22, 35, 29, 3, -35 },
  { 1867, 7, 27, 29, 13, -27 },
  { 1891, 8, 35, 29, 11, -27 },
  { 1926, 20, 21, 29, 4, -26 },
  { 1979, 21, 13, 29, 4, -22 },
  { 2014, 21, 21, 29, 4, -26 },
  { 2070, 21, 35, 29, 4, -35 },
  { 2162, 26, 34, 29, 1, -34 },
  { 2273, 25, 34, 29, 2, -34 },
  { 2380, 22, 34, 29, 4, -34 },
  { 2474, 23, 35, 29, 3, -35 },
  { 2575, 23, 34, 29, 4, -34 },
  { 2673, 21, 34, 29, 4, -34 },
  { 2763, 21, 34, 29, 4, -34 },
  { 2853, 24, 36, 29, 2, -35 },
  { 2961, 22, 34, 29, 3, -34 },
  { 3055, 21, 34, 29, 4, -34 },
  { 3145, 23, 34, 29, 2, -34 },
  { 3243, 24, 34, 29, 4, -34 },
  { 3345, 21, 34, 29, 5, -34 },
  { 3435, 23, 34, 29, 3, -34 },
  { 3533, 22, 34, 29, 3, -34 },
  { 3627, 24, 35, 29, 2, -35 },
  { 3732, 23, 34, 29, 4, -34 },
  { 3830, 25, 41, 29, 2, -35 },
  { 3959, 23, 34, 29, 4, -34 },
  { 4057, 23, 35, 29, 3, -35 },
  { 4158, 25, 34, 29, 2, -34 },
  { 4265, 23, 34, 29, 3, -34 },
  { 4363, 25, 34, 29, 2, -34 },
  { 4470, 26, 34, 29, 2, -34 },
  { 4581, 25, 34, 29, 2, -34 },
  { 4688, 26, 34, 29, 1, -34 },
  { 4799, 22, 34, 29, 3, -34 },
  { 4893, 9, 46, 29, 10, -39 },
  { 4945, 19, 37, 29, 5, -34 },
  { 5033, 10, 46, 29, 9, -39 },
  { 5091, 18, 18, 29, 5, -34 },
  { 5132, 21, 4, 29, 4, 0 },
  { 5143, 9, 7, 29, 10, -35 },
  { 5151, 21, 26, 29, 4, -26 },
  { 5220, 22, 36, 29, 4, -36 },
  { 5319, 22, 26, 29, 3, -26 },
  { 5391, 22, 36, 29, 3, -36 },
  { 5490, 23, 26, 29, 3, -26 },
  { 5565, 23, 37, 29, 4, -37 },
  { 5672, 22, 36, 29, 3, -26 },
  { 5771, 21, 36, 29, 4, -36 },
  { 5866, 21, 35, 29, 5, -35 },
  { 5958, 15, 45, 29, 5, -35 },
  { 6043, 22, 36, 29, 4, -36 },
  { 6142, 21, 36, 29, 5, -36 },
  { 6237, 25, 26, 29, 2, -26 },
  { 6319, 21, 26, 29, 4, -26 },
  { 6388, 23, 26, 29, 3, -26 },
  { 6463, 21, 36, 29, 4, -26 },
  { 6558, 22, 36, 29, 3, -26 },
  { 6657, 17, 26, 29, 8, -26 },
  { 6713, 21, 26, 29, 4, -26 },
  { 6782, 22, 32, 29, 3, -32 },
  { 6870, 21, 25, 29, 4, -25 },
  { 6936, 24, 25, 29, 2, -25 },
  { 7011, 27, 25, 29, 1, -25 },
  { 7096, 24, 25, 29, 3, -25 },
  { 7171, 25, 35, 29, 2, -25 },
  { 7281, 21, 25, 29, 4, -25 },
  { 7347, 15, 46, 29, 8, -37 },
  { 7434, 3, 43, 29, 13, -34 },
  { 7451, 15, 46, 29, 8, -37 },
  { 7538, 27, 10, 29, 1, -19 },
};

const GFXfont RobotoMono_Regular48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular48pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_REGULAR48PT7B_H_
