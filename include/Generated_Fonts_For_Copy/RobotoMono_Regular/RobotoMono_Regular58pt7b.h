#ifndef _ROBOTOMONO_REGULAR58PT7B_H_
#define _ROBOTOMONO_REGULAR58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0x03, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0E, 0x03, 0xC0, 0xF0, 0x0E, 0x07, 0x80,
  0xF0, 0x0E, 0x0F, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x1F, 0x00,
  0x78, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x3C, 0x00, 0x3F, 0xFC, 0x3C, 0x00,
  0x1F, 0xF8, 0x78, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0xC0,
  0x00, 0x0F, 0x07, 0xF8, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x1E, 0x1F, 0xFE,
  0x00, 0x1E, 0x3E, 0x1F, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x3C, 0x78, 0x0F,
  0x00, 0x78, 0x78, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x00, 0xF0, 0x78, 0x07,
  0x01, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x78, 0x0F, 0x00, 0x20, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xC0, 0x3E, 0x3F, 0x9F, 0x80,
  0x7C, 0x7E, 0x1F, 0x80, 0xF9, 0xF8, 0x1F, 0x81, 0xE3, 0xE0, 0x1F, 0x87,
  0xCF, 0xC0, 0x3F, 0x0F, 0x9F, 0x80, 0x3F, 0x1F, 0x3E, 0x00, 0x3F, 0x7C,
  0x7C, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x7F, 0xE1, 0xF8, 0x00, 0x7F, 0xC3,
  0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFE, 0x07,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0xFC, 0x07,
  0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0x81, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x20, 0x40, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x02, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x01,
  0x9F, 0x83, 0xC0, 0xFB, 0xFE, 0x78, 0xFF, 0x7F, 0xFF, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xE0, 0x07, 0x80, 0x08, 0x00,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x70, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xBF, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C,
  0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFC, 0x03, 0xF1, 0xFF, 0x81, 0xFC, 0x3F, 0xF0, 0x7F, 0x07, 0xFE,
  0x1F, 0xC0, 0xFF, 0xC7, 0xE0, 0x1F, 0xFB, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFC, 0x3E,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x01,
  0xF3, 0xFF, 0xC0, 0x7D, 0xFF, 0xFC, 0x3E, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F,
  0xE3, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x1F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3E, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3,
  0xF8, 0x07, 0xFC, 0x7F, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFD,
  0xF0, 0x3F, 0xFC, 0x78, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xF7, 0xFB, 0xF8,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xCF,
  0xFF, 0xFB, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x3F, 0x1F, 0xDF, 0xEF, 0xF7,
  0xF9, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7,
  0xE3, 0xE3, 0xF1, 0xF0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x38, 0x38, 0x0F,
  0xF0, 0x78, 0xF0, 0x3F, 0xF0, 0x71, 0xC0, 0xFF, 0xF0, 0xE3, 0x81, 0xE1,
  0xE1, 0xCF, 0x07, 0x83, 0x83, 0xDC, 0x1E, 0x07, 0x03, 0xB8, 0x3C, 0x0E,
  0x07, 0xF0, 0x70, 0x1C, 0x0F, 0xE0, 0xE0, 0x38, 0x1F, 0xC3, 0xC0, 0x70,
  0x3F, 0x87, 0x80, 0xE0, 0x7E, 0x0E, 0x01, 0xC0, 0xFC, 0x1C, 0x03, 0x81,
  0xF8, 0x38, 0x0F, 0x07, 0x70, 0x70, 0x1E, 0x0E, 0xE0, 0xE0, 0x38, 0x1D,
  0xE1, 0xE0, 0x70, 0x3B, 0xC3, 0xC1, 0xE0, 0xE7, 0x87, 0x87, 0xE1, 0xCF,
  0x0F, 0xFF, 0xCF, 0x0E, 0x0F, 0xFB, 0xFE, 0x1E, 0x0F, 0xE3, 0xF8, 0x3C,
  0x0F, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x40, 0x00, 0xFF,
  0x8F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xF1, 0xF0, 0x00,
  0xFE, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x1F, 0xC7, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0xCF, 0x80, 0x3F, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x83, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xF1,
  0xF0, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x80, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xFC, 0x00,
  0x7C, 0x1F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x3E, 0xFF, 0x00, 0x01, 0xF7, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0xFC, 0x00,
  0x1F, 0xE3, 0xF0, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x01, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xEF, 0x01, 0xEF, 0xFD, 0xF0, 0x3D, 0xFF, 0xBE, 0x0F, 0xBF, 0xF3,
  0xC1, 0xE7, 0xFE, 0x78, 0x7C, 0xFF, 0xCF, 0x8F, 0x9F, 0xF8, 0xF1, 0xE3,
  0xFF, 0x1E, 0x7C, 0x7F, 0xE3, 0xEF, 0x8F, 0xFC, 0x3D, 0xE1, 0xFF, 0x87,
  0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x1F,
  0xF8, 0x3F, 0x83, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F,
  0x81, 0xFF, 0x80, 0xE0, 0x3F, 0xF0, 0x1C, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0x80, 0x1F, 0xFD,
  0xF0, 0x03, 0xFF, 0x9F, 0x00, 0x7F, 0xF3, 0xF0, 0x0F, 0xFE, 0x3E, 0x01,
  0xFF, 0xC7, 0xE0, 0x3F, 0xF8, 0x7C, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xE0,
  0xF8, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x81, 0xF0, 0x7F, 0xF0, 0x3F, 0x0F,
  0xFE, 0x03, 0xE1, 0xFF, 0xC0, 0x7E, 0x3F, 0xF8, 0x07, 0xC7, 0xFF, 0x00,
  0xFC, 0xFF, 0xE0, 0x0F, 0x9F, 0xFC, 0x01, 0xFB, 0xFF, 0x80, 0x1F, 0x7F,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xF9, 0xF8, 0x00,
  0x3F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x01, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x21, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0xF1, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x01, 0xFC, 0x7C, 0x00, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0,
  0x1F, 0x80, 0xFB, 0xC0, 0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x03, 0xEF, 0x81,
  0xFC, 0x07, 0xDF, 0x03, 0xF8, 0x0F, 0xBE, 0x07, 0xF0, 0x1F, 0x7C, 0x0F,
  0xF0, 0x3C, 0xF8, 0x1F, 0xE0, 0xF9, 0xF0, 0x3F, 0xC1, 0xF3, 0xE0, 0xFF,
  0x83, 0xE3, 0xC1, 0xEF, 0x07, 0xC7, 0x83, 0xDE, 0x0F, 0x8F, 0x87, 0x9E,
  0x1F, 0x1F, 0x0F, 0x3C, 0x3E, 0x3E, 0x1E, 0x78, 0x78, 0x7C, 0x78, 0xF0,
  0xF0, 0xF8, 0xF1, 0xE1, 0xE1, 0xF1, 0xE3, 0xE7, 0xC1, 0xE3, 0xC3, 0xCF,
  0x83, 0xC7, 0x87, 0x9F, 0x07, 0x9F, 0x0F, 0x3E, 0x0F, 0xBC, 0x1E, 0x7C,
  0x1F, 0x78, 0x3C, 0xF0, 0x3E, 0xF0, 0x7D, 0xE0, 0x7D, 0xE0, 0x7B, 0xC0,
  0xFB, 0xC0, 0xF7, 0x80, 0xFF, 0x81, 0xEF, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x3C,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xE0,
  0x78, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC,
  0x0F, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0xFC, 0x1F,
  0xFF, 0x8F, 0x80, 0xFF, 0xC1, 0xF8, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x1F, 0xF0, 0x0F, 0x8F, 0xFF, 0x03, 0xEF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0x8F, 0xF0, 0x07, 0xF3, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x0F,
  0xCF, 0xF0, 0x07, 0xF3, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x3E, 0xFF,
  0xFF, 0x0F, 0x9F, 0xFF, 0x03, 0xE1, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x07,
  0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xF0, 0x3F, 0xFC, 0x7C, 0x1F, 0xFF, 0xDF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0xF3, 0xF8, 0x03, 0xFC, 0xFC, 0x00,
  0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3,
  0xF8, 0x03, 0xFC, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFD,
  0xF0, 0x3F, 0xFE, 0x7C, 0x07, 0xFE, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x3F, 0x00, 0x03, 0x87,
  0xF0, 0x00, 0xFC, 0x7F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0xC0, 0xFF, 0xF1, 0xF0, 0x7F, 0xFF, 0x7C, 0x3F,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0xCF, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0,
  0x0F, 0xF1, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xC0,
  0xFF, 0xF9, 0xF0, 0x1F, 0xF8, 0x7C, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x60, 0x00, 0x7E, 0x1C, 0x00,
  0x1F, 0x9F, 0xC0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0xFF, 0x03, 0xE1, 0xFF, 0xE1, 0xF3, 0xFF, 0xF8, 0xFB,
  0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xBF, 0xE0, 0x0F, 0xDF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xCF,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x03,
  0xF8, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xF3, 0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x07, 0xF0, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xFC, 0x1F, 0xC7, 0x9F, 0xF1, 0xFF, 0x3D,
  0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xFE, 0x3F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F,
  0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0,
  0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8,
  0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0xE0,
  0x7C, 0x3F, 0xFC, 0x3E, 0x7F, 0xFF, 0x1F, 0x7F, 0xFF, 0xCF, 0xFE, 0x1F,
  0xF7, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0xF8, 0x7F, 0xC0, 0x3E, 0x7F, 0xFC, 0x0F, 0xBF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x1F, 0xCF, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8,
  0x3E, 0x7F, 0xFC, 0x0F, 0x8F, 0xFE, 0x03, 0xE0, 0x10, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x87, 0xC0, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF, 0xFF, 0x1F,
  0xE0, 0xFF, 0xCF, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xC0, 0xFF, 0xF9, 0xF0,
  0x1F, 0xF8, 0x7C, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x20, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xBF, 0x00, 0x3F, 0xCF, 0xC0, 0x7F, 0xE7, 0xFF, 0xFD, 0xF1, 0xFF,
  0xFC, 0xF8, 0x7F, 0xFC, 0x7C, 0x0F, 0xFC, 0x3E, 0x00, 0x40, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0xBC, 0x00, 0xF0, 0x07,
  0x9E, 0x00, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x80, 0xF8, 0xF0, 0x1F, 0xC0, 0x78, 0x78, 0x0F, 0xE0,
  0x3C, 0x3E, 0x07, 0x70, 0x1E, 0x1F, 0x03, 0xBC, 0x1F, 0x07, 0x83, 0xDE,
  0x0F, 0x83, 0xC1, 0xEF, 0x07, 0x81, 0xE0, 0xF7, 0x83, 0xC0, 0xF0, 0x71,
  0xE1, 0xE0, 0x7C, 0x78, 0xF0, 0xF0, 0x1E, 0x3C, 0x78, 0xF8, 0x0F, 0x1E,
  0x3C, 0x78, 0x07, 0x8E, 0x0F, 0x3C, 0x03, 0xCF, 0x07, 0x9E, 0x01, 0xF7,
  0x83, 0xCF, 0x00, 0x7B, 0xC1, 0xE7, 0x00, 0x3D, 0xC0, 0x77, 0x80, 0x1E,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0x3F, 0xFF, 0x80, 0x0F, 0x3F, 0xFF, 0xC0, 0x0F,
  0x7E, 0x0F, 0xF0, 0x1F, 0x78, 0x07, 0xF8, 0x3E, 0x78, 0x01, 0xFF, 0xFE,
  0xF0, 0x00, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0x80,
};

const GFXglyph RobotoMono_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 6, 41, 35, 14, -41 },
  { 32, 14, 14, 35, 10, -44 },
  { 57, 31, 41, 35, 2, -41 },
  { 216, 26, 54, 35, 5, -48 },
  { 392, 32, 43, 35, 1, -42 },
  { 564, 31, 43, 35, 3, -42 },
  { 731, 5, 14, 35, 14, -44 },
  { 740, 15, 60, 35, 10, -47 },
  { 853, 15, 60, 35, 9, -47 },
  { 966, 27, 28, 35, 5, -41 },
  { 1061, 29, 30, 35, 3, -34 },
  { 1170, 8, 16, 35, 10, -6 },
  { 1186, 22, 4, 35, 6, -20 },
  { 1197, 8, 8, 35, 14, -7 },
  { 1205, 22, 45, 35, 7, -41 },
  { 1329, 27, 43, 35, 4, -42 },
  { 1475, 16, 41, 35, 6, -41 },
  { 1557, 28, 42, 35, 2, -42 },
  { 1704, 26, 43, 35, 3, -42 },
  { 1844, 30, 41, 35, 2, -41 },
  { 1998, 26, 42, 35, 5, -41 },
  { 2135, 26, 42, 35, 4, -41 },
  { 2272, 28, 41, 35, 3, -41 },
  { 2416, 26, 43, 35, 5, -42 },
  { 2556, 26, 42, 35, 4, -42 },
  { 2693, 9, 33, 35, 15, -32 },
  { 2731, 9, 42, 35, 14, -32 },
  { 2779, 24, 25, 35, 5, -31 },
  { 2854, 25, 17, 35, 5, -27 },
  { 2908, 25, 25, 35, 5, -31 },
  { 2987, 25, 42, 35, 5, -42 },
  { 3119, 31, 41, 35, 2, -41 },
  { 3278, 31, 41, 35, 2, -41 },
  { 3437, 27, 41, 35, 5, -41 },
  { 3576, 29, 43, 35, 3, -42 },
  { 3732, 28, 41, 35, 4, -41 },
  { 3876, 25, 41, 35, 5, -41 },
  { 4005, 26, 41, 35, 5, -41 },
  { 4139, 29, 43, 35, 3, -42 },
  { 4295, 27, 41, 35, 4, -41 },
  { 4434, 25, 41, 35, 5, -41 },
  { 4563, 27, 42, 35, 3, -41 },
  { 4705, 29, 41, 35, 5, -41 },
  { 4854, 25, 41, 35, 6, -41 },
  { 4983, 27, 41, 35, 4, -41 },
  { 5122, 27, 41, 35, 4, -41 },
  { 5261, 29, 43, 35, 3, -42 },
  { 5417, 27, 41, 35, 5, -41 },
  { 5556, 30, 49, 35, 3, -42 },
  { 5740, 27, 41, 35, 5, -41 },
  { 5879, 29, 43, 35, 3, -42 },
  { 6035, 31, 41, 35, 2, -41 },
  { 6194, 27, 42, 35, 4, -41 },
  { 6336, 31, 41, 35, 2, -41 },
  { 6495, 31, 41, 35, 2, -41 },
  { 6654, 31, 41, 35, 2, -41 },
  { 6813, 30, 41, 35, 2, -41 },
  { 6967, 28, 41, 35, 3, -41 },
  { 7111, 11, 56, 35, 12, -47 },
  { 7188, 21, 45, 35, 7, -41 },
  { 7307, 12, 56, 35, 11, -47 },
  { 7391, 21, 22, 35, 7, -41 },
  { 7449, 26, 4, 35, 4, 0 },
  { 7462, 11, 8, 35, 12, -42 },
  { 7473, 27, 32, 35, 4, -31 },
  { 7581, 26, 45, 35, 5, -44 },
  { 7728, 26, 32, 35, 4, -31 },
  { 7832, 26, 45, 35, 4, -44 },
  { 7979, 27, 32, 35, 4, -31 },
  { 8087, 28, 45, 35, 4, -45 },
  { 8245, 26, 43, 35, 4, -31 },
  { 8385, 25, 44, 35, 5, -44 },
  { 8523, 25, 42, 35, 6, -42 },
  { 8655, 18, 54, 35, 6, -42 },
  { 8777, 27, 44, 35, 5, -44 },
  { 8926, 25, 44, 35, 6, -44 },
  { 9064, 29, 31, 35, 3, -31 },
  { 9177, 25, 31, 35, 5, -31 },
  { 9274, 28, 32, 35, 3, -31 },
  { 9386, 26, 43, 35, 5, -31 },
  { 9526, 26, 43, 35, 4, -31 },
  { 9666, 21, 31, 35, 9, -31 },
  { 9748, 26, 32, 35, 5, -31 },
  { 9852, 26, 39, 35, 4, -38 },
  { 9979, 25, 32, 35, 5, -31 },
  { 10079, 29, 31, 35, 3, -31 },
  { 10192, 33, 31, 35, 1, -31 },
  { 10320, 29, 31, 35, 3, -31 },
  { 10433, 31, 43, 35, 2, -31 },
  { 10600, 26, 31, 35, 5, -31 },
  { 10701, 19, 55, 35, 9, -45 },
  { 10832, 5, 52, 35, 15, -41 },
  { 10865, 19, 55, 35, 9, -45 },
  { 10996, 32, 12, 35, 1, -23 },
};

const GFXfont RobotoMono_Regular58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular58pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_REGULAR58PT7B_H_
