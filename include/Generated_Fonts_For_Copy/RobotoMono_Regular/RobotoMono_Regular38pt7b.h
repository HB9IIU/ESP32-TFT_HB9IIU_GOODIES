#ifndef _ROBOTOMONO_REGULAR38PT7B_H_
#define _ROBOTOMONO_REGULAR38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0xFF, 0xF0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x01, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x70,
  0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x07, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00,
  0x38, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x80,
  0xFF, 0xF0, 0xFF, 0xF8, 0x78, 0x1E, 0x78, 0x07, 0x3C, 0x03, 0xDC, 0x01,
  0xEF, 0x00, 0x77, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xDC, 0x01, 0xEF, 0x01,
  0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x38, 0xE0, 0x01,
  0xC3, 0x82, 0x0C, 0x1C, 0x38, 0x60, 0xE1, 0x83, 0x07, 0x1C, 0x1C, 0x39,
  0xC0, 0xE3, 0x8E, 0x03, 0xFC, 0xE0, 0x0F, 0xC7, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x20, 0x00, 0xC7,
  0xE0, 0x0E, 0x7F, 0x80, 0xE7, 0x0E, 0x07, 0x38, 0x70, 0x71, 0xC3, 0x83,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x43, 0x87, 0x00, 0x1C, 0x30, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xE1,
  0xE0, 0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xC0, 0x1C,
  0x3C, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x0E, 0x78, 0xF0, 0xEF, 0x07, 0x8E,
  0xF0, 0x3C, 0xEE, 0x03, 0xDE, 0xE0, 0x1F, 0xCF, 0x00, 0xFC, 0xF0, 0x07,
  0x87, 0x80, 0xF8, 0x7E, 0x7F, 0xC3, 0xFF, 0xDE, 0x0F, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x81, 0xC1, 0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x02, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x08, 0x00,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x10,
  0x30, 0x27, 0x8C, 0x7B, 0xFB, 0x7F, 0x7F, 0xFF, 0xC1, 0xFE, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x07, 0x78, 0x03, 0xCE, 0x01, 0xE1, 0xC0, 0xF0, 0x78,
  0x1C, 0x0E, 0x02, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xDE, 0xE6, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x73, 0xEF, 0xFF, 0x78, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xDF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x0F,
  0x7E, 0x0F, 0x3F, 0x1F, 0x1F, 0x9E, 0x0F, 0xDE, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1C,
  0xF0, 0x1E, 0x3F, 0x7E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x40, 0xF1,
  0xFD, 0xFF, 0xFF, 0xFC, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0xF8, 0x07, 0xFF, 0x07,
  0xF7, 0xE1, 0xE0, 0x7C, 0xF0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7B, 0x80,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xDF, 0x8F, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1C, 0xF0, 0x1E, 0x7F,
  0x7E, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00,
  0x0E, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x70, 0x70,
  0x0F, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x70, 0x38, 0x07,
  0x07, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x70, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xF7, 0xF3, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x1D, 0xE0, 0x1E, 0x78, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xF0, 0x39, 0xFE, 0x1D,
  0xFF, 0x8F, 0xE3, 0xE7, 0xC0, 0x7B, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x77, 0x80, 0x39, 0xE0,
  0x3C, 0xF8, 0x3C, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x07,
  0xF8, 0x0F, 0xFE, 0x0F, 0xDF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0xC0, 0x3D,
  0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0x8F, 0x03, 0xC3, 0xE7,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x78, 0x1E, 0x78, 0x07, 0xB8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x1E,
  0xF0, 0x1F, 0x3F, 0x7F, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0x03, 0xC7, 0x00, 0xF7, 0x80, 0x7B, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7B, 0xC0, 0x7D, 0xF0, 0xFE, 0x7F, 0xFF, 0x1F, 0xF7, 0x03, 0xE3, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x73, 0xEF, 0xFE, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xEF, 0xFE, 0x78, 0x39,
  0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE3, 0x8E, 0x38, 0xE7, 0x9E, 0x73, 0xC6, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0x80, 0x00,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0xE1, 0xF0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xC1, 0xF0,
  0xC6, 0x1F, 0xC6, 0x71, 0xC6, 0x33, 0x0C, 0x31, 0x98, 0xE1, 0x8C, 0xC6,
  0x0C, 0x7E, 0x30, 0x63, 0x71, 0x83, 0x1B, 0x9C, 0x38, 0xDC, 0xE1, 0x86,
  0xE7, 0x0C, 0x37, 0x18, 0x63, 0x98, 0xFF, 0x98, 0xC7, 0xEF, 0x86, 0x1E,
  0x38, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x06, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x03, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1E, 0x01, 0xE0, 0x70, 0x0E,
  0x03, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xC0, 0x1E,
  0x1E, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0x80,
  0x03, 0xBC, 0x00, 0x1E, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0,
  0x7C, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0x03, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x7C, 0xFF, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7E, 0xFC,
  0x1E, 0x03, 0xC3, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0x77, 0x80, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0xF7, 0x00, 0x1C, 0xF0, 0x03, 0x8E, 0x00, 0xF1,
  0xE0, 0x3C, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0x80, 0xF8, 0xE0, 0x1F, 0x38, 0x03, 0xCE,
  0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x03, 0xCE,
  0x01, 0xF3, 0x80, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x03,
  0xC3, 0x80, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1F,
  0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x1E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F,
  0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E,
  0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xEF, 0x00, 0xF8, 0xF0, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xD8, 0x77, 0xEE, 0x3B, 0xF7, 0x1D, 0xFB, 0x9C,
  0xFC, 0xEE, 0x7E, 0x77, 0x3F, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3,
  0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xDC, 0x07, 0xEF, 0x03, 0xF3, 0x81, 0xF9, 0xE0, 0xFC, 0x70,
  0x7E, 0x3C, 0x3F, 0x0E, 0x1F, 0x87, 0x8F, 0xC1, 0xC7, 0xE0, 0xF3, 0xF0,
  0x39, 0xF8, 0x1E, 0xFC, 0x07, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0x80, 0x78, 0xF0, 0x07, 0x9C,
  0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0xF0,
  0x07, 0x8E, 0x01, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x03, 0xEE, 0x00,
  0xF7, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF8, 0x38, 0x07,
  0x87, 0x80, 0x3C, 0x70, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x01, 0xEE, 0x00,
  0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x80, 0x3C, 0x38, 0x07, 0x83, 0xC0, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x04, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B,
  0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x1C, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3C, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1E, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xE0,
  0x03, 0xDE, 0x00, 0x79, 0xE0, 0x3E, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x3C, 0xF0,
  0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x77, 0x00,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xC1, 0xC0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x78, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0, 0x01, 0xDC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x70, 0x3B, 0x83, 0x81, 0xDC, 0x1E, 0x1E,
  0xE0, 0xF0, 0xF7, 0x0F, 0x87, 0x38, 0x7C, 0x39, 0xC3, 0xE1, 0xCE, 0x1F,
  0x0E, 0x78, 0xDC, 0x73, 0xCE, 0xE3, 0x8E, 0x77, 0x1C, 0x73, 0xB9, 0xE3,
  0x9C, 0xCE, 0x1C, 0xC7, 0x70, 0xE6, 0x3B, 0x87, 0x71, 0xDC, 0x3B, 0x8E,
  0xE1, 0xDC, 0x37, 0x07, 0xE1, 0xB8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC3, 0xC0,
  0x78, 0x3C, 0x07, 0x81, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xF1, 0xE0, 0x07,
  0x1C, 0x00, 0x7B, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0,
  0x07, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x70, 0x3C, 0x07,
  0x83, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x1E, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1,
  0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0x70, 0xF0,
  0x07, 0x8E, 0x00, 0x39, 0xE0, 0x03, 0xDC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x78,
  0x1C, 0x70, 0x70, 0xE0, 0xE0, 0xE3, 0xC1, 0xC7, 0x01, 0xDE, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x70, 0xF0, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFE, 0x1F, 0x9F, 0x8F, 0x01, 0xEF, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x0F, 0xFF, 0x1F, 0xFF, 0x9F, 0x81, 0xCE, 0x00,
  0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1E, 0xF0, 0x1F, 0x3F,
  0xFF, 0x8F, 0xFD, 0xE3, 0xFC, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7B, 0xFC, 0x3F, 0xFF, 0x1F, 0xEF, 0xCF, 0x80, 0xF7, 0x80, 0x7B,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0x7C,
  0x0F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8E, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xFE,
  0x0F, 0xDF, 0x8F, 0x01, 0xE7, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x0E, 0xF0, 0x0F, 0x78, 0x0F, 0x1F, 0xBF, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xF3,
  0xC7, 0xFF, 0xE7, 0xEF, 0xF7, 0x80, 0xFB, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x0F, 0xBC, 0x07, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFE, 0x78, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFB, 0xF0,
  0xF0, 0x1E, 0x38, 0x03, 0x9E, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x06, 0x3E, 0x03, 0xC7, 0xF7, 0xE0, 0xFF, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE7, 0x8F, 0xFF,
  0xCF, 0xDF, 0xEF, 0x01, 0xF7, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1E, 0xE0, 0x1F, 0x78, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFC, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x80, 0x1C, 0xC0, 0x1E, 0x78,
  0x1E, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC0, 0xF7,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF3, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0xFF, 0xCF, 0xF8, 0xFE,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xEF,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xCF,
  0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF9, 0xE0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x3C, 0x07, 0x8F,
  0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF, 0xCF, 0xDF,
  0xFF, 0xFB, 0xEF, 0xEF, 0xF0, 0xF0, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8,
  0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0,
  0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0,
  0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x70, 0xE3, 0xFC, 0x73,
  0xFF, 0x3F, 0xFF, 0xDF, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1E,
  0x03, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xF0,
  0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x1C, 0xE0,
  0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x3C, 0x07, 0x83, 0xF7, 0xE0, 0x3F,
  0xF8, 0x03, 0xFC, 0x00, 0xE7, 0xF8, 0x77, 0xFE, 0x3F, 0xFF, 0x9F, 0x03,
  0xEF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1E, 0xF8, 0x1F, 0x7F, 0xBF, 0x3F, 0xFF, 0x1E, 0xFF, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF7, 0x8F, 0xFF, 0xCF, 0x9F, 0xEF, 0x01,
  0xF7, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1E,
  0xE0, 0x0F, 0x78, 0x0F, 0x9F, 0xBF, 0xC7, 0xFF, 0xE1, 0xFC, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0xE3, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xCF, 0xCF, 0x01, 0xE7,
  0x80, 0x7B, 0x80, 0x3D, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x0F, 0x78, 0x07, 0x9F, 0x9F, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x07, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1E,
  0xE0, 0x1F, 0x78, 0x1F, 0x9F, 0xFF, 0xCF, 0xFD, 0xE1, 0xFC, 0xF0, 0xF0,
  0x01, 0xFE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0F, 0x70, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0xE0,
  0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0E, 0xE1, 0xE0, 0xE7, 0x0F, 0x87,
  0x38, 0x6C, 0x39, 0xC3, 0x61, 0xCE, 0x3B, 0x0C, 0x39, 0xDC, 0x61, 0xCE,
  0xE7, 0x0E, 0x63, 0x38, 0x77, 0x19, 0xC1, 0xB8, 0xEC, 0x0D, 0xC7, 0x60,
  0x7C, 0x1B, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xF8, 0x03, 0xEF, 0x00, 0x78, 0xF0, 0x1E, 0x0F,
  0x07, 0x80, 0xE0, 0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0x78, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x07, 0x80, 0xF1, 0xE0,
  0x0F, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xC1, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xE0, 0x38,
  0x0F, 0x07, 0x80, 0x70, 0x70, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x03, 0x8E,
  0x00, 0x3D, 0xE0, 0x01, 0xDC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x07,
  0x80, 0x7E, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1E,
  0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x07, 0x80, 0x3E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFE, 0x01, 0xDF, 0xF8, 0x0F, 0xE3, 0xE0, 0xFE, 0x07,
  0xFF, 0x70, 0x1F, 0xF0, 0x80, 0x7F, 0x00, 0x00, 0x20,
};

const GFXglyph RobotoMono_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 4, 27, 23, 9, -27 },
  { 15, 9, 9, 23, 7, -29 },
  { 26, 21, 27, 23, 1, -27 },
  { 97, 17, 35, 23, 3, -31 },
  { 172, 21, 27, 23, 1, -27 },
  { 243, 20, 27, 23, 2, -27 },
  { 311, 3, 9, 23, 9, -29 },
  { 315, 9, 39, 23, 7, -30 },
  { 359, 10, 39, 23, 6, -30 },
  { 408, 18, 18, 23, 3, -27 },
  { 449, 19, 19, 23, 2, -22 },
  { 495, 5, 10, 23, 7, -4 },
  { 502, 14, 3, 23, 4, -13 },
  { 508, 6, 5, 23, 9, -5 },
  { 512, 14, 29, 23, 5, -27 },
  { 563, 17, 27, 23, 3, -27 },
  { 621, 10, 27, 23, 4, -27 },
  { 655, 18, 27, 23, 2, -27 },
  { 716, 17, 27, 23, 2, -27 },
  { 774, 20, 27, 23, 1, -27 },
  { 842, 17, 27, 23, 3, -27 },
  { 900, 17, 27, 23, 3, -27 },
  { 958, 18, 27, 23, 2, -27 },
  { 1019, 17, 27, 23, 3, -27 },
  { 1077, 17, 27, 23, 3, -27 },
  { 1135, 6, 21, 23, 10, -21 },
  { 1151, 6, 27, 23, 9, -21 },
  { 1172, 16, 16, 23, 3, -20 },
  { 1204, 17, 10, 23, 3, -17 },
  { 1226, 17, 16, 23, 3, -20 },
  { 1260, 16, 27, 23, 4, -27 },
  { 1314, 21, 27, 23, 1, -27 },
  { 1385, 21, 27, 23, 1, -27 },
  { 1456, 18, 27, 23, 3, -27 },
  { 1517, 19, 27, 23, 2, -27 },
  { 1582, 18, 27, 23, 3, -27 },
  { 1643, 17, 27, 23, 3, -27 },
  { 1701, 16, 27, 23, 4, -27 },
  { 1755, 19, 27, 23, 2, -27 },
  { 1820, 17, 27, 23, 3, -27 },
  { 1878, 17, 27, 23, 3, -27 },
  { 1936, 17, 27, 23, 2, -27 },
  { 1994, 19, 27, 23, 3, -27 },
  { 2059, 16, 27, 23, 4, -27 },
  { 2113, 17, 27, 23, 3, -27 },
  { 2171, 17, 27, 23, 3, -27 },
  { 2229, 19, 27, 23, 2, -27 },
  { 2294, 17, 27, 23, 4, -27 },
  { 2352, 20, 32, 23, 2, -27 },
  { 2432, 18, 27, 23, 3, -27 },
  { 2493, 19, 27, 23, 2, -27 },
  { 2558, 20, 27, 23, 1, -27 },
  { 2626, 17, 27, 23, 3, -27 },
  { 2684, 20, 27, 23, 1, -27 },
  { 2752, 21, 27, 23, 1, -27 },
  { 2823, 20, 27, 23, 2, -27 },
  { 2891, 20, 27, 23, 1, -27 },
  { 2959, 18, 27, 23, 2, -27 },
  { 3020, 7, 37, 23, 8, -31 },
  { 3053, 15, 29, 23, 4, -27 },
  { 3108, 7, 37, 23, 8, -31 },
  { 3141, 15, 14, 23, 4, -27 },
  { 3168, 17, 3, 23, 3, 0 },
  { 3175, 7, 4, 23, 8, -27 },
  { 3179, 17, 20, 23, 3, -20 },
  { 3222, 17, 29, 23, 3, -29 },
  { 3284, 17, 20, 23, 3, -20 },
  { 3327, 17, 29, 23, 3, -29 },
  { 3389, 18, 20, 23, 2, -20 },
  { 3434, 18, 29, 23, 3, -29 },
  { 3500, 17, 28, 23, 3, -20 },
  { 3560, 17, 29, 23, 3, -29 },
  { 3622, 17, 27, 23, 4, -27 },
  { 3680, 12, 35, 23, 4, -27 },
  { 3733, 18, 29, 23, 3, -29 },
  { 3799, 17, 29, 23, 4, -29 },
  { 3861, 19, 20, 23, 2, -20 },
  { 3909, 17, 20, 23, 3, -20 },
  { 3952, 19, 20, 23, 2, -20 },
  { 4000, 17, 28, 23, 3, -20 },
  { 4060, 17, 28, 23, 3, -20 },
  { 4120, 14, 20, 23, 6, -20 },
  { 4155, 17, 20, 23, 3, -20 },
  { 4198, 17, 25, 23, 3, -25 },
  { 4252, 17, 20, 23, 3, -20 },
  { 4295, 19, 20, 23, 2, -20 },
  { 4343, 21, 20, 23, 1, -20 },
  { 4396, 19, 20, 23, 2, -20 },
  { 4444, 20, 28, 23, 1, -20 },
  { 4514, 17, 20, 23, 3, -20 },
  { 4557, 13, 37, 23, 6, -30 },
  { 4618, 3, 34, 23, 10, -27 },
  { 4631, 13, 37, 23, 6, -30 },
  { 4692, 21, 8, 23, 1, -15 },
};

const GFXfont RobotoMono_Regular38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular38pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_REGULAR38PT7B_H_
