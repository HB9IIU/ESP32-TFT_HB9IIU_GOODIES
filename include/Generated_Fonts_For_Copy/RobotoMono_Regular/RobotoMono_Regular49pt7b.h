#ifndef _ROBOTOMONO_REGULAR49PT7B_H_
#define _ROBOTOMONO_REGULAR49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xFC, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3B, 0xC1, 0xDE, 0x0E,
  0xF0, 0x77, 0x83, 0xBC, 0x1D, 0xE0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x0F,
  0x8F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x7E, 0x3F, 0xCF, 0xF8,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x07, 0x81, 0x01, 0xC0, 0xF0, 0x38, 0x38, 0x0E, 0x0F, 0x07, 0x01, 0xC1,
  0xC0, 0xE0, 0x38, 0x78, 0x1C, 0x0F, 0x0E, 0x03, 0xC1, 0xE3, 0x80, 0x3C,
  0x78, 0xF0, 0x07, 0xFF, 0x1C, 0x00, 0x7F, 0xC7, 0x80, 0x03, 0xE0, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0xFF,
  0x00, 0x1E, 0x3F, 0xF0, 0x03, 0x8F, 0x1E, 0x00, 0xF1, 0xC1, 0xE0, 0x1C,
  0x38, 0x1C, 0x07, 0x8F, 0x03, 0x80, 0xE1, 0xE0, 0x70, 0x3C, 0x3C, 0x0E,
  0x03, 0x07, 0x81, 0xC0, 0x20, 0x70, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFD, 0xF0, 0x1E, 0x7E, 0x7C, 0x07, 0x9F, 0x0F, 0x83, 0xCF,
  0x81, 0xF0, 0xF3, 0xE0, 0x3E, 0x3C, 0xF0, 0x0F, 0xCF, 0x3C, 0x01, 0xF7,
  0x8F, 0x00, 0x3F, 0xE3, 0xC0, 0x07, 0xF0, 0xF0, 0x01, 0xFC, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0xC1, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xE7, 0xC0, 0x7F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE,
  0x00, 0x30, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x30, 0x1C, 0x06, 0x7C, 0x38, 0x7D, 0xFE, 0x73, 0xFB, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xCF, 0x00, 0x0F, 0x8F, 0x00, 0x1E, 0x1F,
  0x00, 0x78, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xCF, 0x9F, 0x3C, 0x79, 0xE7, 0xC3, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xF0, 0x0F, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xCF, 0xF8, 0x1F, 0x1F, 0xF0, 0xFC, 0x3F,
  0xE3, 0xE0, 0x7F, 0xCF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x07, 0xBF, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0xFB, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0xC0,
  0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFE, 0x1F, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3E, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF3, 0xFC, 0x3E,
  0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0,
  0x0F, 0x8F, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0x87, 0xF0, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0,
  0x03, 0xE3, 0xE0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x3E, 0x01, 0xE7, 0xFF, 0x07, 0xBF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7F, 0x83, 0xFB, 0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x1F, 0x3C, 0x00, 0x7C,
  0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF3, 0xFC, 0x3F, 0x01, 0xF0,
  0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF8, 0x03,
  0xC1, 0xF0, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x87, 0xE0, 0x3E,
  0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x80,
  0xFE, 0x7F, 0x3F, 0xF1, 0xFF, 0xF7, 0x87, 0xFF, 0x3C, 0x1F, 0xF1, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0x3E, 0x7E, 0x7F, 0x7F, 0x7F,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0x60, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFC, 0x03, 0xEF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0x83, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00,
  0x70, 0xF0, 0x1C, 0x1C, 0x38, 0x1F, 0xC3, 0x8E, 0x0F, 0xF8, 0xE7, 0x07,
  0x8E, 0x19, 0xC3, 0xC3, 0x86, 0x60, 0xE0, 0xE1, 0xF8, 0x70, 0x30, 0x7E,
  0x1C, 0x0C, 0x1F, 0x87, 0x03, 0x07, 0xE1, 0xC0, 0xC1, 0xF8, 0xE0, 0x70,
  0x7E, 0x38, 0x1C, 0x1F, 0x8E, 0x07, 0x06, 0xE3, 0x81, 0xC1, 0xB8, 0xE0,
  0x70, 0xEE, 0x3C, 0x3C, 0x3B, 0x87, 0x1F, 0x1C, 0xE1, 0xFF, 0xEF, 0x38,
  0x7F, 0xBF, 0x87, 0x0F, 0x87, 0xC1, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xE0, 0x01, 0xE0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0xF9, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x7C, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x3E, 0x01, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xC0, 0x0F, 0xCF,
  0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x7E, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0x00, 0xFE, 0x1E, 0x00, 0x7E, 0x3C, 0x00, 0x7E,
  0x78, 0x00, 0x7C, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x07,
  0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x7E, 0x3C, 0x03, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0xE1, 0xFE, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0xC0, 0x3E, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF9,
  0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0E, 0xFF, 0x70, 0x7B, 0xFD, 0xE1, 0xEF, 0xF7, 0x8F, 0x3F, 0xCE, 0x3C,
  0xFF, 0x3C, 0xF3, 0xFC, 0xF7, 0x8F, 0xF1, 0xDE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F,
  0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x70, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xEF, 0x00, 0xFF, 0xDF, 0x01, 0xFF, 0x9E, 0x03,
  0xFF, 0x3E, 0x07, 0xFE, 0x3C, 0x0F, 0xFC, 0x7C, 0x1F, 0xF8, 0x78, 0x3F,
  0xF0, 0xF8, 0x7F, 0xE0, 0xF0, 0xFF, 0xC1, 0xF1, 0xFF, 0x81, 0xF3, 0xFF,
  0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xFC, 0x03, 0xDF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x01,
  0xF8, 0x1F, 0xE7, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x01, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1E,
  0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x3F, 0xCF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C,
  0x00, 0x7C, 0xF8, 0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xF7, 0xF8, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0xC0, 0x3E, 0x0F, 0xE3, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x07, 0x80,
  0x0F, 0x81, 0xE0, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x7C, 0x0F,
  0xF0, 0x3F, 0x03, 0xFE, 0x0F, 0xC0, 0xF7, 0x83, 0xF0, 0x7D, 0xE0, 0xFC,
  0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x1F, 0xE1, 0xE7, 0x87, 0xF8, 0x79, 0xE1,
  0xFE, 0x1E, 0x78, 0x73, 0x87, 0x9E, 0x1C, 0xE1, 0xE7, 0x87, 0x38, 0x78,
  0xF3, 0xCF, 0x3C, 0x3C, 0xF3, 0xCF, 0x0F, 0x3C, 0x73, 0xC3, 0xCE, 0x1C,
  0xF0, 0xF3, 0x87, 0x3C, 0x3C, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE,
  0x1E, 0xF0, 0x77, 0x03, 0xB8, 0x1F, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x80, 0x3D, 0xE0, 0x0F, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3E, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xC3, 0xFC, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xC3, 0xE7, 0xE0, 0x0F, 0xBE, 0x00,
  0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E,
  0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xE7, 0xF3, 0xFF, 0x9F, 0xFF, 0xDE, 0x3F,
  0xFE, 0x78, 0x3F, 0xE1, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x3F, 0xC0, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0x3F, 0x80,
  0x7C, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x3E, 0xFE, 0x01, 0xF3,
  0xFE, 0x3F, 0xCF, 0x7F, 0xFE, 0x3C, 0xFF, 0xF0, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x3F, 0xC1, 0xF0,
  0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xE0, 0x03, 0xC3,
  0xE0, 0x1F, 0x87, 0xF0, 0x7E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0x8F, 0x07,
  0xFF, 0xBC, 0x3F, 0xFF, 0xF1, 0xFE, 0x7F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00,
  0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0x7F, 0x0F, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x03, 0xFE, 0x3C, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7E, 0x1F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0,
  0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x43, 0xE0, 0x01, 0xC7, 0xE0, 0x07, 0xC7,
  0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xC0, 0x60, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xFE, 0x3C, 0x1F, 0xFE, 0xF0, 0xFF, 0xFF, 0xC7, 0xF9, 0xFF,
  0x3F, 0x00, 0xFC, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xFC,
  0x03, 0xF1, 0xFC, 0x7F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xBC, 0x0F, 0xF8,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x40, 0x01, 0xF1,
  0x80, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0xE0, 0xF9, 0xFF, 0xE3, 0xEF, 0xFF, 0xCF, 0xFE, 0x7F, 0x3F, 0x80, 0x7E,
  0xFC, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7D, 0x07, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFD, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xEF, 0x80, 0x07, 0xE0, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xF8, 0xFE, 0x7B, 0xFE, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xDF, 0xF3, 0xFF, 0x83, 0xE0, 0x7F, 0x81, 0xF0, 0x3F,
  0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x0F, 0x03,
  0xFC, 0x07, 0x81, 0xFE, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x7F, 0x80, 0xF0,
  0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x0F,
  0x03, 0xFC, 0x07, 0x81, 0xFE, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x7F, 0x80,
  0xF0, 0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E, 0x07, 0xF8,
  0x0F, 0x03, 0xC0, 0xF0, 0x7F, 0x87, 0x8F, 0xFF, 0x3C, 0xFF, 0xF9, 0xEF,
  0x9F, 0xEF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x1F, 0x83,
  0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xE3, 0xE0, 0x07,
  0xC7, 0xE0, 0x1F, 0x07, 0xE0, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xF1, 0xFF, 0x03, 0xCF, 0xFF, 0x0F, 0x7F, 0xFE, 0x3F,
  0xF7, 0xF8, 0xFE, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x01,
  0xFB, 0xF0, 0x0F, 0xCF, 0xF0, 0x7F, 0x3F, 0xFF, 0xF8, 0xFB, 0xFF, 0xC3,
  0xE7, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x3C, 0x1F, 0xFE, 0xF0,
  0xFF, 0xFF, 0xC7, 0xF0, 0xFF, 0x3F, 0x00, 0xFC, 0xF8, 0x01, 0xF7, 0xC0,
  0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x3E, 0x00, 0x7C, 0xFC, 0x03, 0xF1, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xBC, 0x0F, 0xF8, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFB, 0xDF, 0xFE, 0xFF, 0x80, 0xBF, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3E, 0x01, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xF8, 0x3F, 0x87,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x1C, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFC, 0xFC, 0x3F,
  0xE7, 0xFF, 0xEF, 0x1F, 0xFE, 0x78, 0x3F, 0xE3, 0xC0, 0xF8, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x00,
  0x7C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x7C,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xFF, 0x00,
  0xF0, 0x1E, 0x78, 0x0F, 0x01, 0xE7, 0x80, 0xF0, 0x1E, 0x78, 0x1F, 0x01,
  0xE7, 0x81, 0xF8, 0x1C, 0x78, 0x1F, 0x83, 0xC3, 0x81, 0xF8, 0x3C, 0x3C,
  0x3B, 0x83, 0xC3, 0xC3, 0xBC, 0x3C, 0x3C, 0x39, 0xC3, 0x81, 0xC3, 0x9C,
  0x38, 0x1C, 0x79, 0xC7, 0x81, 0xE7, 0x1E, 0x78, 0x1E, 0x70, 0xE7, 0x01,
  0xE7, 0x0E, 0x70, 0x0E, 0xF0, 0xE7, 0x00, 0xEE, 0x0F, 0x70, 0x0E, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x38,
  0x03, 0xC0, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x27, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x1C, 0xFF, 0xF0, 0x03, 0xBF, 0xFF, 0x00, 0xF7, 0x83, 0xF8, 0x3F, 0xE0,
  0x1F, 0xFF, 0xBC, 0x01, 0xFF, 0xF7, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE,
  0x00,
};

const GFXglyph RobotoMono_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 5, 35, 29, 12, -35 },
  { 23, 13, 12, 29, 8, -37 },
  { 43, 27, 35, 29, 1, -35 },
  { 162, 22, 45, 29, 4, -40 },
  { 286, 27, 36, 29, 1, -35 },
  { 408, 26, 35, 29, 3, -35 },
  { 522, 4, 12, 29, 12, -37 },
  { 528, 12, 50, 29, 9, -39 },
  { 603, 12, 50, 29, 8, -39 },
  { 678, 23, 24, 29, 4, -35 },
  { 747, 24, 26, 29, 3, -29 },
  { 825, 7, 13, 29, 8, -5 },
  { 837, 19, 4, 29, 5, -17 },
  { 847, 7, 6, 29, 12, -6 },
  { 853, 19, 38, 29, 6, -35 },
  { 944, 23, 35, 29, 3, -35 },
  { 1045, 14, 35, 29, 5, -35 },
  { 1107, 24, 35, 29, 2, -35 },
  { 1212, 22, 35, 29, 2, -35 },
  { 1309, 25, 35, 29, 2, -35 },
  { 1419, 22, 35, 29, 4, -35 },
  { 1516, 22, 35, 29, 3, -35 },
  { 1613, 23, 35, 29, 3, -35 },
  { 1714, 22, 35, 29, 4, -35 },
  { 1811, 21, 35, 29, 4, -35 },
  { 1903, 7, 27, 29, 13, -27 },
  { 1927, 8, 35, 29, 12, -27 },
  { 1962, 20, 21, 29, 4, -26 },
  { 2015, 22, 14, 29, 4, -23 },
  { 2054, 21, 21, 29, 4, -26 },
  { 2110, 20, 35, 29, 5, -35 },
  { 2198, 26, 35, 29, 2, -35 },
  { 2312, 26, 35, 29, 2, -35 },
  { 2426, 23, 35, 29, 4, -35 },
  { 2527, 24, 35, 29, 3, -35 },
  { 2632, 23, 35, 29, 4, -35 },
  { 2733, 22, 35, 29, 4, -35 },
  { 2830, 21, 35, 29, 5, -35 },
  { 2922, 25, 36, 29, 2, -35 },
  { 3035, 23, 35, 29, 3, -35 },
  { 3136, 21, 35, 29, 4, -35 },
  { 3228, 23, 35, 29, 2, -35 },
  { 3329, 24, 35, 29, 4, -35 },
  { 3434, 21, 35, 29, 5, -35 },
  { 3526, 22, 35, 29, 4, -35 },
  { 3623, 23, 35, 29, 3, -35 },
  { 3724, 24, 35, 29, 3, -35 },
  { 3829, 22, 35, 29, 5, -35 },
  { 3926, 26, 41, 29, 2, -35 },
  { 4060, 23, 35, 29, 4, -35 },
  { 4161, 24, 35, 29, 3, -35 },
  { 4266, 26, 35, 29, 2, -35 },
  { 4380, 23, 35, 29, 3, -35 },
  { 4481, 26, 35, 29, 2, -35 },
  { 4595, 26, 35, 29, 2, -35 },
  { 4709, 26, 35, 29, 2, -35 },
  { 4823, 26, 35, 29, 1, -35 },
  { 4937, 23, 35, 29, 3, -35 },
  { 5038, 10, 47, 29, 10, -40 },
  { 5097, 18, 38, 29, 6, -35 },
  { 5183, 9, 47, 29, 10, -40 },
  { 5236, 18, 19, 29, 6, -35 },
  { 5279, 22, 4, 29, 4, 0 },
  { 5290, 9, 6, 29, 10, -35 },
  { 5297, 22, 26, 29, 4, -26 },
  { 5369, 22, 37, 29, 4, -37 },
  { 5471, 23, 26, 29, 3, -26 },
  { 5546, 22, 37, 29, 3, -37 },
  { 5648, 23, 26, 29, 3, -26 },
  { 5723, 23, 38, 29, 4, -38 },
  { 5833, 22, 36, 29, 3, -26 },
  { 5932, 22, 37, 29, 4, -37 },
  { 6034, 22, 35, 29, 5, -35 },
  { 6131, 15, 45, 29, 5, -35 },
  { 6216, 23, 37, 29, 4, -37 },
  { 6323, 22, 37, 29, 5, -37 },
  { 6425, 25, 26, 29, 2, -26 },
  { 6507, 21, 26, 29, 4, -26 },
  { 6576, 23, 26, 29, 3, -26 },
  { 6651, 22, 36, 29, 4, -26 },
  { 6750, 22, 36, 29, 3, -26 },
  { 6849, 18, 26, 29, 8, -26 },
  { 6908, 22, 26, 29, 4, -26 },
  { 6980, 22, 32, 29, 3, -32 },
  { 7068, 21, 26, 29, 4, -26 },
  { 7137, 25, 26, 29, 2, -26 },
  { 7219, 28, 26, 29, 1, -26 },
  { 7310, 24, 26, 29, 3, -26 },
  { 7388, 26, 36, 29, 2, -26 },
  { 7505, 22, 26, 29, 4, -26 },
  { 7577, 16, 47, 29, 8, -38 },
  { 7671, 3, 45, 29, 13, -35 },
  { 7688, 16, 47, 29, 8, -38 },
  { 7782, 27, 9, 29, 1, -19 },
};

const GFXfont RobotoMono_Regular49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular49pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_REGULAR49PT7B_H_
