#ifndef _ROBOTOMONO_REGULAR55PT7B_H_
#define _ROBOTOMONO_REGULAR55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC7, 0xFF, 0xFF, 0xF7, 0x80, 0x78, 0x3D, 0xE0, 0xF7, 0x83,
  0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x3D, 0xC0,
  0xF7, 0x03, 0xDC, 0x0F, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0x83, 0xE0, 0x07, 0xE3, 0xF0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x80,
  0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x78, 0x07, 0x80, 0xE0, 0xF0, 0x07,
  0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x87, 0x00, 0x1F, 0xFE, 0x1E, 0x00, 0x1F,
  0xFC, 0x78, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E,
  0x1F, 0xF0, 0x00, 0x3C, 0x7F, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0x01, 0xE3,
  0xC1, 0xE0, 0x07, 0x87, 0x81, 0xC0, 0x0F, 0x1E, 0x03, 0xC0, 0x3C, 0x3C,
  0x07, 0x80, 0x78, 0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x03, 0x81, 0xE0,
  0x3C, 0x01, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF9,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7E, 0xFC, 0x03, 0xC7, 0xE3, 0xE0, 0x3E, 0x7E, 0x1F, 0x81, 0xF3, 0xF0,
  0x7E, 0x0F, 0xBF, 0x01, 0xF8, 0x7D, 0xF0, 0x07, 0xE3, 0xCF, 0x80, 0x3F,
  0x3E, 0x7C, 0x00, 0xFD, 0xF3, 0xE0, 0x03, 0xFF, 0x1F, 0x00, 0x0F, 0xF8,
  0xF8, 0x00, 0x7F, 0x87, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xE0, 0xFE,
  0x01, 0xFF, 0x83, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF,
  0x8F, 0xC0, 0x7F, 0xF0, 0x3F, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x08, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x80, 0x78, 0x02, 0x78, 0x1E, 0x03, 0x9F, 0x87, 0x87, 0xE7, 0xFD,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0x00, 0x38, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3C, 0x7C, 0xF8, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0x3F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xF3, 0xFF, 0x03, 0xF1, 0xFF, 0x87, 0xF0, 0xFF, 0xC7, 0xF0, 0x7F, 0xE7,
  0xE0, 0x3F, 0xF7, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x0F,
  0x8F, 0x80, 0x0F, 0x87, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x7C, 0x03, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x1F, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x40, 0x00, 0xFB, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x7F, 0x8F,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x3F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x70,
  0x01, 0xE3, 0xFF, 0x01, 0xF3, 0xFF, 0xE0, 0xFB, 0xFF, 0xF8, 0x7F, 0xFB,
  0xFE, 0x3F, 0xE0, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xC1, 0xF8, 0x07, 0xE0,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xE1,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xDF, 0x00,
  0x07, 0xEF, 0x80, 0x07, 0xF7, 0xE0, 0x07, 0xF9, 0xF8, 0x07, 0xF8, 0xFF,
  0x0F, 0xFC, 0x3F, 0xFF, 0xDE, 0x0F, 0xFF, 0xDF, 0x01, 0xFF, 0xCF, 0x80,
  0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE,
  0xFE, 0x7C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE,
  0xFE, 0x7C, 0x10, 0x1F, 0x1F, 0xCF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFC, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE0, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xE0, 0x3F, 0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x03, 0xE0,
  0xF1, 0xE0, 0x7F, 0xC3, 0x8E, 0x07, 0xFE, 0x1C, 0x70, 0x7C, 0x70, 0x77,
  0x03, 0xC3, 0x83, 0xB8, 0x3C, 0x1C, 0x1D, 0xC1, 0xC0, 0xE0, 0xFE, 0x1E,
  0x07, 0x07, 0xE0, 0xE0, 0x38, 0x3F, 0x07, 0x01, 0xC1, 0xF8, 0x38, 0x0E,
  0x0F, 0xC3, 0xC0, 0x70, 0x7E, 0x1E, 0x07, 0x03, 0xF0, 0xF0, 0x38, 0x1F,
  0x87, 0x81, 0xC0, 0xFC, 0x3C, 0x0E, 0x0E, 0xE1, 0xE0, 0x70, 0x77, 0x0F,
  0x07, 0x83, 0xBC, 0x3C, 0xFE, 0x39, 0xE1, 0xFF, 0x7F, 0xC7, 0x07, 0xF3,
  0xFC, 0x38, 0x1F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x1F,
  0xE0, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE0,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0x80, 0x3F, 0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0,
  0x01, 0xF8, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xC0, 0x07, 0xF3, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0x80,
  0x7F, 0x81, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0x83, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x07,
  0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x87, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x00,
  0x1F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xCF, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x01,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xCF,
  0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0x80, 0xFF,
  0xFD, 0xE0, 0x3D, 0xFF, 0xFC, 0x0F, 0x7F, 0xEF, 0x07, 0xDF, 0xFB, 0xC1,
  0xE7, 0xFE, 0xF8, 0x79, 0xFF, 0x9E, 0x3E, 0x7F, 0xE7, 0x8F, 0x1F, 0xF9,
  0xF3, 0xC7, 0xFE, 0x3D, 0xF1, 0xFF, 0x8F, 0x78, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xC1, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0xF8,
  0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x81, 0xC0, 0x7F, 0xE0,
  0x70, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0x7C, 0x01, 0xFF, 0xBE, 0x00, 0xFF, 0xCF, 0x80, 0x7F, 0xE7, 0xE0,
  0x3F, 0xF1, 0xF0, 0x1F, 0xF8, 0xFC, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F,
  0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xF0, 0xFF, 0xC0, 0xF8, 0x7F, 0xE0,
  0x3E, 0x3F, 0xF0, 0x1F, 0x1F, 0xF8, 0x07, 0xCF, 0xFC, 0x03, 0xE7, 0xFE,
  0x00, 0xFB, 0xFF, 0x00, 0x7D, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x8F, 0xC0,
  0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x0F,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0C, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x3F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x3E,
  0x01, 0xFF, 0x80, 0xF8, 0x07, 0xBE, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0,
  0x79, 0xE0, 0x3F, 0x03, 0xE7, 0x80, 0xFC, 0x0F, 0x9F, 0x07, 0xF0, 0x3E,
  0x7C, 0x1F, 0xE0, 0xF9, 0xF0, 0x7F, 0x83, 0xE7, 0xC1, 0xFE, 0x0F, 0x1F,
  0x07, 0xF8, 0x3C, 0x7C, 0x3D, 0xE0, 0xF0, 0xF0, 0xF3, 0x83, 0xC3, 0xC3,
  0xCF, 0x0F, 0x0F, 0x0F, 0x3C, 0x7C, 0x3C, 0x3C, 0xF1, 0xF0, 0xF8, 0xF3,
  0xC7, 0xC3, 0xE7, 0x8F, 0x1E, 0x0F, 0x9E, 0x1C, 0x78, 0x3E, 0x78, 0x79,
  0xE0, 0x79, 0xE1, 0xE7, 0x81, 0xE7, 0x87, 0x9E, 0x07, 0x9C, 0x1E, 0x78,
  0x1E, 0xF0, 0x7B, 0xE0, 0x7B, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFB, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x07, 0xDF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x01, 0xEF, 0x80, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x03, 0xFE, 0x7F, 0xC1, 0xF8, 0x07, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFB, 0xE1, 0xFF, 0xF9, 0xF8, 0x3F, 0xF0, 0x7C, 0x00, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0C,
  0x00, 0xF8, 0xFF, 0xC0, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xF7, 0xFF, 0xF0, 0xF3, 0xFF,
  0xE0, 0xF0, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x1F, 0x01, 0xFF, 0x1F, 0x07,
  0xFF, 0xDF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0x3F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0x07, 0xFF, 0xCF, 0x01, 0xFF, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x0C, 0x3F, 0x00, 0x0F, 0x0F, 0xE0, 0x1F, 0xC7,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0x0F, 0x07, 0xFF, 0xCF, 0x0F, 0xFF, 0xEF, 0x1F, 0xFF, 0xFF, 0x3F,
  0x80, 0xFF, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F,
  0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x01,
  0xFF, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x10,
  0x00, 0x1F, 0x18, 0x00, 0x3E, 0x3C, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0xF8,
  0x7F, 0xE0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x07, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF9, 0xEF,
  0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x2F,
  0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xE0,
  0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x1F, 0xC7, 0xC0, 0x07, 0xF3, 0xE0, 0x01, 0xF9,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x04, 0x07, 0xCF, 0xF1, 0xFE, 0x3E,
  0xFF, 0xDF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0x0F,
  0xE0, 0xFB, 0xE0, 0x3E, 0x03, 0xDF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F,
  0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0,
  0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8,
  0x0F, 0xFC, 0x07, 0xC0, 0x7C, 0x00, 0x0E, 0x00, 0xF0, 0x7F, 0xE0, 0xF1,
  0xFF, 0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0xFF, 0xFC, 0xFF, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x9F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0,
  0xFF, 0xC0, 0xF3, 0xFF, 0xE0, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFB, 0xFF, 0xE0, 0xF8,
  0xFF, 0x80, 0xF8, 0x08, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0x8F, 0x07, 0xFF, 0xCF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3F,
  0x00, 0x3F, 0x3F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xDF, 0x01, 0xFF, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0x8F, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFE,
  0xFB, 0xFF, 0xEF, 0xFF, 0x8E, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x02, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0x7F, 0xFF,
  0xBC, 0xFF, 0xFE, 0x78, 0xFF, 0xF8, 0xF0, 0x7F, 0xE1, 0xE0, 0x08, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0xF0, 0x07, 0x80, 0x7D, 0xE0,
  0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0x03, 0xCF, 0x80,
  0xFC, 0x07, 0x8F, 0x03, 0xF8, 0x1F, 0x1E, 0x07, 0x70, 0x3C, 0x3C, 0x0E,
  0xE0, 0x78, 0x78, 0x1D, 0xE0, 0xF0, 0x78, 0x7B, 0xC1, 0xE0, 0xF0, 0xF7,
  0x83, 0xC1, 0xE1, 0xE7, 0x0F, 0x03, 0xC3, 0x8F, 0x1E, 0x07, 0x8F, 0x1E,
  0x3C, 0x07, 0x9E, 0x3C, 0x78, 0x0F, 0x3C, 0x38, 0xE0, 0x1E, 0x70, 0x79,
  0xC0, 0x3D, 0xE0, 0xF7, 0x80, 0x7B, 0xC1, 0xEF, 0x00, 0x77, 0x81, 0xDE,
  0x00, 0xFE, 0x03, 0xB8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x01,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x79, 0xFF, 0xF8,
  0x00, 0xF3, 0xFF, 0xF8, 0x03, 0xCF, 0x83, 0xFC, 0x07, 0x9E, 0x01, 0xFE,
  0x3F, 0x78, 0x01, 0xFF, 0xFC, 0xF0, 0x01, 0xFF, 0xF0, 0x60, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 6, 39, 33, 13, -39 },
  { 31, 14, 13, 33, 9, -41 },
  { 54, 30, 39, 33, 2, -39 },
  { 201, 25, 51, 33, 4, -45 },
  { 361, 31, 41, 33, 1, -40 },
  { 520, 29, 41, 33, 3, -40 },
  { 669, 5, 13, 33, 13, -41 },
  { 678, 14, 57, 33, 10, -44 },
  { 778, 14, 57, 33, 9, -44 },
  { 878, 26, 26, 33, 4, -39 },
  { 963, 27, 28, 33, 3, -32 },
  { 1058, 8, 15, 33, 9, -6 },
  { 1073, 20, 4, 33, 6, -19 },
  { 1083, 8, 8, 33, 13, -7 },
  { 1091, 21, 42, 33, 7, -39 },
  { 1202, 25, 41, 33, 4, -40 },
  { 1331, 15, 39, 33, 6, -39 },
  { 1405, 27, 40, 33, 2, -40 },
  { 1540, 24, 41, 33, 3, -40 },
  { 1663, 28, 39, 33, 2, -39 },
  { 1800, 25, 40, 33, 5, -39 },
  { 1925, 25, 40, 33, 4, -39 },
  { 2050, 26, 39, 33, 3, -39 },
  { 2177, 25, 41, 33, 5, -40 },
  { 2306, 25, 40, 33, 4, -40 },
  { 2431, 8, 32, 33, 15, -31 },
  { 2463, 9, 40, 33, 13, -31 },
  { 2508, 22, 25, 33, 5, -30 },
  { 2577, 24, 15, 33, 5, -25 },
  { 2622, 24, 25, 33, 5, -30 },
  { 2697, 23, 40, 33, 5, -40 },
  { 2812, 29, 39, 33, 2, -39 },
  { 2954, 29, 39, 33, 2, -39 },
  { 3096, 25, 39, 33, 5, -39 },
  { 3218, 27, 41, 33, 3, -40 },
  { 3357, 27, 39, 33, 4, -39 },
  { 3489, 24, 39, 33, 5, -39 },
  { 3606, 24, 39, 33, 5, -39 },
  { 3723, 27, 41, 33, 3, -40 },
  { 3862, 25, 39, 33, 4, -39 },
  { 3984, 23, 39, 33, 5, -39 },
  { 4097, 25, 40, 33, 3, -39 },
  { 4222, 27, 39, 33, 5, -39 },
  { 4354, 24, 39, 33, 5, -39 },
  { 4471, 26, 39, 33, 4, -39 },
  { 4598, 25, 39, 33, 4, -39 },
  { 4720, 27, 41, 33, 3, -40 },
  { 4859, 26, 39, 33, 5, -39 },
  { 4986, 28, 47, 33, 3, -40 },
  { 5151, 26, 39, 33, 5, -39 },
  { 5278, 27, 41, 33, 3, -40 },
  { 5417, 29, 39, 33, 2, -39 },
  { 5559, 25, 40, 33, 4, -39 },
  { 5684, 29, 39, 33, 2, -39 },
  { 5826, 30, 39, 33, 2, -39 },
  { 5973, 29, 39, 33, 2, -39 },
  { 6115, 29, 39, 33, 2, -39 },
  { 6257, 26, 39, 33, 3, -39 },
  { 6384, 11, 53, 33, 11, -45 },
  { 6457, 21, 42, 33, 6, -39 },
  { 6568, 11, 53, 33, 11, -45 },
  { 6641, 21, 21, 33, 6, -39 },
  { 6697, 25, 4, 33, 4, 0 },
  { 6710, 11, 7, 33, 11, -40 },
  { 6720, 25, 31, 33, 4, -30 },
  { 6817, 24, 42, 33, 5, -41 },
  { 6943, 25, 31, 33, 4, -30 },
  { 7040, 24, 42, 33, 4, -41 },
  { 7166, 25, 31, 33, 4, -30 },
  { 7263, 26, 42, 33, 4, -42 },
  { 7400, 24, 41, 33, 4, -30 },
  { 7523, 24, 41, 33, 5, -41 },
  { 7646, 25, 40, 33, 5, -40 },
  { 7771, 17, 52, 33, 6, -40 },
  { 7882, 25, 41, 33, 5, -41 },
  { 8011, 25, 41, 33, 5, -41 },
  { 8140, 29, 30, 33, 2, -30 },
  { 8249, 24, 30, 33, 5, -30 },
  { 8339, 27, 31, 33, 3, -30 },
  { 8444, 24, 41, 33, 5, -30 },
  { 8567, 24, 41, 33, 4, -30 },
  { 8690, 20, 30, 33, 9, -30 },
  { 8765, 24, 31, 33, 5, -30 },
  { 8858, 25, 37, 33, 4, -36 },
  { 8974, 23, 30, 33, 5, -29 },
  { 9061, 27, 29, 33, 3, -29 },
  { 9159, 31, 29, 33, 1, -29 },
  { 9272, 28, 29, 33, 3, -29 },
  { 9374, 29, 41, 33, 2, -29 },
  { 9523, 25, 29, 33, 4, -29 },
  { 9614, 18, 53, 33, 9, -43 },
  { 9734, 5, 50, 33, 14, -39 },
  { 9766, 18, 53, 33, 9, -43 },
  { 9886, 31, 11, 33, 1, -22 },
};

const GFXfont RobotoMono_Regular55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular55pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_REGULAR55PT7B_H_
