#ifndef _ROBOTOMONO_REGULAR12PT7B_H_
#define _ROBOTOMONO_REGULAR12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xB6, 0x80, 0x14, 0x28, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x48, 0x21, 0x93, 0x1C, 0x38, 0x71, 0x8B, 0xC8, 0x61, 0x4A, 0xA3, 0x41,
  0x02, 0x8A, 0x95, 0x0E, 0x21, 0x49, 0x1C, 0x62, 0x99, 0x62, 0xFC, 0xE0,
  0x25, 0x29, 0x24, 0x89, 0x12, 0x91, 0x22, 0x49, 0x29, 0x48, 0x20, 0x8A,
  0x9D, 0x51, 0x20, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0x58, 0xF8, 0xB0, 0x08,
  0x44, 0x22, 0x10, 0x88, 0x46, 0x00, 0x36, 0x63, 0x1B, 0xE6, 0x31, 0x70,
  0x17, 0xB3, 0x33, 0x33, 0x30, 0x31, 0x3C, 0x41, 0x08, 0x42, 0x18, 0x7C,
  0x64, 0xE2, 0x17, 0x0C, 0x31, 0xF0, 0x08, 0x10, 0x61, 0x42, 0x89, 0x3F,
  0x84, 0x08, 0x7B, 0xD0, 0xED, 0x84, 0x31, 0x78, 0x13, 0x31, 0x4D, 0xC6,
  0x31, 0x70, 0xF8, 0x42, 0x21, 0x10, 0x8C, 0x40, 0x32, 0x63, 0x97, 0x66,
  0x31, 0x78, 0x26, 0xE3, 0x18, 0xBC, 0x22, 0x60, 0x70, 0x1C, 0xB0, 0x0E,
  0x80, 0x1B, 0x30, 0x60, 0x80, 0xF8, 0x01, 0xF0, 0xC1, 0xC6, 0xC8, 0x00,
  0x36, 0x42, 0x11, 0x10, 0x80, 0x20, 0x18, 0x49, 0x6D, 0x5A, 0xB5, 0x6F,
  0x20, 0x38, 0x10, 0x20, 0x61, 0x42, 0x84, 0x9F, 0x22, 0xC2, 0xE2, 0x68,
  0xA2, 0xF2, 0x28, 0xE2, 0xF8, 0x33, 0x28, 0xE0, 0x82, 0x08, 0xE2, 0x70,
  0xE2, 0x68, 0xA3, 0x86, 0x18, 0xA2, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10,
  0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x33, 0x28, 0xE0, 0x82, 0x78,
  0xE3, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0xF8, 0x08, 0x42, 0x10, 0x84, 0x31, 0x70, 0x8E, 0x29, 0x28, 0xE3,
  0xC9, 0x22, 0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x8E, 0x77, 0xBB,
  0xD6, 0xB1, 0x88, 0x8C, 0x73, 0xDA, 0xDE, 0x73, 0x88, 0x33, 0x68, 0xA3,
  0x8E, 0x38, 0xA2, 0x70, 0xF2, 0x28, 0x61, 0x8B, 0xC8, 0x20, 0x80, 0x33,
  0x68, 0xA1, 0x86, 0x18, 0xA2, 0x70, 0x30, 0xE2, 0x68, 0xA2, 0x9B, 0xC9,
  0x22, 0x8C, 0x33, 0x28, 0xE0, 0x70, 0x60, 0xE3, 0x78, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xC2,
  0x89, 0x12, 0x22, 0x85, 0x0A, 0x0C, 0x10, 0x92, 0xA5, 0x6A, 0xD6, 0xCD,
  0x9B, 0x32, 0x64, 0x8E, 0x25, 0x94, 0x20, 0xC5, 0x32, 0x8C, 0xC6, 0x89,
  0x91, 0x42, 0x82, 0x04, 0x08, 0x10, 0xF8, 0x44, 0x22, 0x31, 0x10, 0xF8,
  0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0x82, 0x10, 0x42, 0x10, 0x42, 0x10, 0x40,
  0xE4, 0x92, 0x49, 0x24, 0xF0, 0x21, 0x14, 0xAC, 0x80, 0xF8, 0xC4, 0xF8,
  0x5F, 0x18, 0xFC, 0x84, 0x21, 0xF8, 0xC6, 0x31, 0xF0, 0x7C, 0x61, 0x08,
  0xB8, 0x08, 0x43, 0xF8, 0xC6, 0x31, 0x78, 0x7C, 0x7F, 0x08, 0xBC, 0x3C,
  0x82, 0x3E, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x63, 0x18, 0xBC, 0x3B, 0x20,
  0x84, 0x21, 0xF8, 0xC6, 0x31, 0x88, 0x20, 0xC0, 0x38, 0x20, 0x82, 0x08,
  0xFC, 0x11, 0x07, 0x11, 0x11, 0x11, 0x3C, 0x82, 0x08, 0x26, 0xA3, 0x8B,
  0x24, 0x8C, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0xFC, 0xFE, 0x9A, 0x69,
  0xA6, 0x90, 0xFC, 0x63, 0x18, 0xC4, 0xFC, 0x63, 0x18, 0xB8, 0xFC, 0x63,
  0x18, 0xFA, 0x10, 0xFC, 0x63, 0x18, 0xBC, 0x21, 0xF8, 0x88, 0x88, 0x7C,
  0x58, 0x38, 0xBC, 0x63, 0x3E, 0xC6, 0x30, 0x87, 0x8C, 0x63, 0x18, 0xBC,
  0x8E, 0x25, 0x14, 0x30, 0x80, 0x92, 0xA5, 0xB3, 0x66, 0xC4, 0x80, 0xCD,
  0x42, 0x0C, 0x5A, 0x30, 0xC6, 0x88, 0xB1, 0x41, 0x82, 0x04, 0x10, 0x40,
  0xF8, 0x88, 0xC4, 0x7C, 0x32, 0x22, 0x48, 0x42, 0x22, 0x30, 0xFF, 0xE0,
  0xC4, 0x44, 0x63, 0x44, 0x44, 0x80, 0x61, 0x24, 0x30,
};

const GFXglyph RobotoMono_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 3, 7, 2, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 7, 0, -9 },
  { 28, 6, 9, 7, 1, -9 },
  { 35, 1, 3, 7, 3, -9 },
  { 36, 3, 13, 7, 2, -10 },
  { 41, 3, 13, 7, 2, -10 },
  { 46, 6, 6, 7, 1, -9 },
  { 51, 6, 6, 7, 1, -7 },
  { 56, 2, 3, 7, 2, -1 },
  { 57, 5, 1, 7, 1, -4 },
  { 58, 2, 2, 7, 3, -2 },
  { 59, 5, 10, 7, 1, -9 },
  { 66, 5, 9, 7, 1, -9 },
  { 72, 4, 9, 7, 1, -9 },
  { 77, 6, 9, 7, 0, -9 },
  { 84, 5, 9, 7, 1, -9 },
  { 90, 7, 9, 7, 0, -9 },
  { 98, 5, 9, 7, 1, -9 },
  { 104, 5, 9, 7, 1, -9 },
  { 110, 5, 9, 7, 1, -9 },
  { 116, 5, 9, 7, 1, -9 },
  { 122, 5, 9, 7, 1, -9 },
  { 128, 2, 7, 7, 3, -7 },
  { 130, 2, 9, 7, 3, -7 },
  { 133, 5, 5, 7, 1, -6 },
  { 137, 5, 4, 7, 1, -6 },
  { 140, 5, 5, 7, 1, -6 },
  { 144, 5, 9, 7, 1, -9 },
  { 150, 7, 9, 7, 0, -9 },
  { 158, 7, 9, 7, 0, -9 },
  { 166, 6, 9, 7, 1, -9 },
  { 173, 6, 9, 7, 1, -9 },
  { 180, 6, 9, 7, 1, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 5, 9, 7, 1, -9 },
  { 199, 6, 9, 7, 1, -9 },
  { 206, 5, 9, 7, 1, -9 },
  { 212, 5, 9, 7, 1, -9 },
  { 218, 5, 9, 7, 1, -9 },
  { 224, 6, 9, 7, 1, -9 },
  { 231, 5, 9, 7, 1, -9 },
  { 237, 5, 9, 7, 1, -9 },
  { 243, 5, 9, 7, 1, -9 },
  { 249, 6, 9, 7, 1, -9 },
  { 256, 6, 9, 7, 1, -9 },
  { 263, 6, 10, 7, 1, -9 },
  { 271, 6, 9, 7, 1, -9 },
  { 278, 6, 9, 7, 1, -9 },
  { 285, 7, 9, 7, 0, -9 },
  { 293, 5, 9, 7, 1, -9 },
  { 299, 7, 9, 7, 0, -9 },
  { 307, 7, 9, 7, 0, -9 },
  { 315, 6, 9, 7, 1, -9 },
  { 322, 7, 9, 7, 0, -9 },
  { 330, 5, 9, 7, 1, -9 },
  { 336, 3, 12, 7, 2, -10 },
  { 341, 5, 10, 7, 1, -9 },
  { 348, 3, 12, 7, 2, -10 },
  { 353, 5, 5, 7, 1, -9 },
  { 357, 5, 1, 7, 1, 0 },
  { 358, 3, 2, 7, 2, -9 },
  { 359, 5, 6, 7, 1, -6 },
  { 363, 5, 9, 7, 1, -9 },
  { 369, 5, 6, 7, 1, -6 },
  { 373, 5, 9, 7, 1, -9 },
  { 379, 5, 6, 7, 1, -6 },
  { 383, 6, 9, 7, 1, -9 },
  { 390, 5, 9, 7, 1, -6 },
  { 396, 5, 9, 7, 1, -9 },
  { 402, 6, 9, 7, 1, -9 },
  { 409, 4, 12, 7, 1, -9 },
  { 415, 6, 9, 7, 1, -9 },
  { 422, 6, 9, 7, 1, -9 },
  { 429, 6, 6, 7, 1, -6 },
  { 434, 5, 6, 7, 1, -6 },
  { 438, 5, 6, 7, 1, -6 },
  { 442, 5, 8, 7, 1, -6 },
  { 447, 5, 8, 7, 1, -6 },
  { 452, 4, 6, 7, 2, -6 },
  { 455, 5, 6, 7, 1, -6 },
  { 459, 5, 8, 7, 1, -8 },
  { 464, 5, 6, 7, 1, -6 },
  { 468, 6, 6, 7, 1, -6 },
  { 473, 7, 6, 7, 0, -6 },
  { 479, 6, 6, 7, 1, -6 },
  { 484, 7, 9, 7, 0, -6 },
  { 492, 5, 6, 7, 1, -6 },
  { 496, 4, 11, 7, 2, -9 },
  { 502, 1, 11, 7, 3, -9 },
  { 504, 4, 11, 7, 2, -9 },
  { 510, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_Regular12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular12pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_REGULAR12PT7B_H_
