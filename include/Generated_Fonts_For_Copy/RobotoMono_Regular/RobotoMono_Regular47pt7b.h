#ifndef _ROBOTOMONO_REGULAR47PT7B_H_
#define _ROBOTOMONO_REGULAR47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBC, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x78, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70,
  0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xF8, 0x1F, 0x0F, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xFE,
  0x1F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0xF0, 0x70, 0x20, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC1,
  0xC0, 0xE0, 0x70, 0xF0, 0x38, 0x1C, 0x38, 0x0F, 0x07, 0x1E, 0x01, 0xC3,
  0xC7, 0x00, 0x7F, 0xE3, 0xC0, 0x0F, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x7E, 0x00, 0x1E, 0x3F, 0xC0, 0x07,
  0x1F, 0xF8, 0x03, 0xCF, 0x0F, 0x00, 0xE3, 0x81, 0xC0, 0x70, 0xE0, 0x70,
  0x1C, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x20, 0xE0,
  0x70, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x07, 0x80,
  0x3E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0xF0,
  0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x23, 0xEF, 0x80, 0xE3, 0xE3, 0xE0, 0x73, 0xE0, 0xF8, 0x79, 0xF0,
  0x3E, 0x3C, 0xF0, 0x1F, 0x1E, 0xF8, 0x07, 0xDE, 0x7C, 0x01, 0xFF, 0x3E,
  0x00, 0x7F, 0x8F, 0x00, 0x3F, 0x87, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0xE0,
  0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x9F, 0x01, 0xFF, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x03, 0x00, 0x70,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0x00, 0x10, 0x40, 0x06, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x06, 0x07, 0x01, 0xBE, 0x1C, 0x1E, 0xFE, 0x73, 0xFB,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1E,
  0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x0E, 0x03, 0xC0, 0x10, 0x04, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF1, 0xE7, 0x82, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF,
  0x80, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x01, 0xF0,
  0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xCF, 0xF8, 0x3E, 0x3F, 0xE3, 0xF0, 0xFF,
  0x9F, 0x03, 0xFE, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x3F, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x0F, 0xC1,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xE1, 0xF8, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3E, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xE0,
  0x3F, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0xF8, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0,
  0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x87, 0xC0, 0xFE, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xE3, 0xC0,
  0x1F, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xFC, 0x07, 0x9F, 0xF8, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x9F, 0xE0, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3E, 0x78,
  0x01, 0xE3, 0xE0, 0x1F, 0x0F, 0xC3, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3E, 0x1E,
  0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0x7C,
  0x1F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7C, 0x07, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF7,
  0x80, 0x0F, 0xBE, 0x00, 0xF8, 0xFC, 0x1F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xF0, 0x3E, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x7C, 0x00,
  0xF9, 0xF0, 0x0F, 0xCF, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xF7, 0x83,
  0xFF, 0x3C, 0x07, 0xE1, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x78, 0x78, 0xF0, 0x20, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x30, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x1F, 0x78, 0x01,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC1, 0xE0, 0x20, 0x70, 0x70, 0x7F, 0x0E, 0x38, 0x3F,
  0xE3, 0x8E, 0x1F, 0x38, 0x63, 0x87, 0x0E, 0x19, 0xC3, 0x83, 0x86, 0x70,
  0xE0, 0xE1, 0xDC, 0x38, 0x38, 0x77, 0x1C, 0x0C, 0x1D, 0x87, 0x03, 0x07,
  0x61, 0xC0, 0xC1, 0x98, 0x70, 0x30, 0x66, 0x1C, 0x0C, 0x19, 0x87, 0x07,
  0x06, 0x61, 0xC1, 0xC3, 0x9C, 0x70, 0xF0, 0xC7, 0x1F, 0xFC, 0x71, 0xC3,
  0xFB, 0xF8, 0x70, 0xFC, 0xFC, 0x0E, 0x0C, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x18, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7,
  0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3C, 0x03, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xBC,
  0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00,
  0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xC0, 0x3F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x03, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0x80, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3C, 0x0F, 0xF0, 0xF0, 0x07, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F,
  0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF0, 0x0F,
  0xC3, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x3F,
  0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3E,
  0x01, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x1F,
  0x0F, 0x00, 0x7E, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80,
  0xF0, 0x3E, 0x01, 0xE0, 0xFC, 0x03, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F,
  0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3D, 0xF8, 0x00, 0x7B, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x83,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x8F, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFD, 0xC0, 0xFF, 0xF7, 0x83, 0xFF,
  0xDE, 0x1E, 0xFF, 0x38, 0x7B, 0xFC, 0xF1, 0xCF, 0xF3, 0xCF, 0x3F, 0xC7,
  0x3C, 0xFF, 0x1E, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC3, 0xF0,
  0xFF, 0x8F, 0xC3, 0xFE, 0x3F, 0x0F, 0xF8, 0x78, 0x3F, 0xE1, 0xE0, 0xFF,
  0x87, 0x83, 0xFE, 0x0C, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xBC, 0x03,
  0xFE, 0xF8, 0x0F, 0xF9, 0xE0, 0x3F, 0xE7, 0xC0, 0xFF, 0x8F, 0x03, 0xFE,
  0x1E, 0x0F, 0xF8, 0x78, 0x3F, 0xE0, 0xF0, 0xFF, 0x83, 0xC3, 0xFE, 0x07,
  0x8F, 0xF8, 0x1E, 0x3F, 0xE0, 0x3C, 0xFF, 0x80, 0xFB, 0xFE, 0x01, 0xEF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3E, 0x00, 0xFC, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x78, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF,
  0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x00, 0x1F,
  0x3C, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3C,
  0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0xC0,
  0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x7E, 0x1F, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE7,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x3C,
  0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xFF, 0x03,
  0xE0, 0x7F, 0x81, 0xF0, 0x7B, 0xC1, 0xF8, 0x3C, 0xF0, 0xFE, 0x1E, 0x78,
  0x77, 0x0F, 0x3C, 0x3B, 0x87, 0x9E, 0x1D, 0xC3, 0xCF, 0x1E, 0xE1, 0xE7,
  0x8F, 0x78, 0xF3, 0xC7, 0x3C, 0x71, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x3C,
  0x38, 0xE3, 0x9E, 0x1E, 0xF1, 0xCF, 0x0F, 0x78, 0xF7, 0x87, 0xB8, 0x7B,
  0xC3, 0xDC, 0x1D, 0xE1, 0xEE, 0x0E, 0xE0, 0xF7, 0x07, 0x70, 0x3F, 0x83,
  0xB8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x3C, 0x01, 0xF0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x7C,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x38, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0x80, 0x79, 0xE0, 0x1E, 0xF8, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFC, 0x1F,
  0xC7, 0xC0, 0x3E, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x3F, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x07, 0xEF, 0x80, 0x7F, 0x7F, 0x0F, 0xF9,
  0xFF, 0xFB, 0xC7, 0xFF, 0x9E, 0x0F, 0xF8, 0xF8, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x7F,
  0x81, 0xE7, 0xFF, 0x0F, 0x7F, 0xFC, 0x7F, 0xC7, 0xF3, 0xF0, 0x0F, 0x9F,
  0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x80, 0x0F,
  0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0x9F, 0xE1, 0xFC, 0xFF, 0xFF, 0xC7, 0xBF,
  0xFC, 0x3C, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xE1, 0xFC, 0x3F, 0x01, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E,
  0x00, 0x1F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0xCF, 0x00, 0x1E, 0x3E,
  0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0xFF, 0x1E, 0x0F, 0xFE, 0xF0, 0xFF, 0xFF, 0x8F,
  0xE3, 0xFC, 0xF8, 0x07, 0xE7, 0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x07, 0xE3, 0xF0,
  0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFB, 0xC0, 0xFF, 0x1E, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF1, 0xFC, 0x3F, 0x01, 0xF0, 0xF8,
  0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x0C, 0x3F, 0x00, 0x7C, 0x7E, 0x07, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFC, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFC, 0x78, 0x3F, 0xFB, 0xC3, 0xFF, 0xFE, 0x3F, 0x8F,
  0xF3, 0xE0, 0x1F, 0x9E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0,
  0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x8F, 0xC3, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x03, 0xFE, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF1, 0x00, 0x0F, 0x9C, 0x00, 0xF9, 0xF8, 0x0F, 0xC7,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x3F, 0xC1, 0xE7, 0xFF, 0x8F, 0x7F, 0xFE, 0x7F, 0xC7, 0xF3, 0xF8,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x87, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1F,
  0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C,
  0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xC3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0xF8,
  0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFC, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0,
  0x1F, 0x83, 0xC0, 0x3F, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF0, 0x01,
  0xF3, 0xC0, 0x07, 0xEF, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3,
  0xF1, 0xFC, 0xF7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x7F, 0x3F, 0xF8,
  0x3E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0xFF, 0x0F, 0x3F, 0xFC, 0xF7, 0xFF, 0xEF, 0xF8, 0xFE,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFE, 0x07, 0xE1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E,
  0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0xF1, 0xFE, 0x07, 0xBF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F,
  0xCF, 0xC0, 0x3E, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x3E, 0x7F, 0x07, 0xF3,
  0xFF, 0xFF, 0x1E, 0xFF, 0xF0, 0xF1, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC,
  0x78, 0x3F, 0xFB, 0xC7, 0xFF, 0xFE, 0x3F, 0x0F, 0xF3, 0xE0, 0x1F, 0xBE,
  0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x1E,
  0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF,
  0xEF, 0x03, 0xFE, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0xF0, 0xFF, 0xF9, 0xFF, 0xBD, 0xFF,
  0xDF, 0xFF, 0xEF, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x1F, 0xC7, 0xC0,
  0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x3F, 0x81, 0xF8, 0xFF, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x30, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0xFF, 0x3F,
  0xFE, 0xF1, 0xFF, 0xCF, 0x0F, 0xF8, 0xF0, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xF7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x0E,
  0x03, 0xFC, 0x03, 0x80, 0xF7, 0x01, 0xE0, 0x3D, 0xC0, 0x78, 0x0F, 0x78,
  0x1F, 0x03, 0x9E, 0x07, 0xC0, 0xE7, 0x83, 0xF0, 0x78, 0xE0, 0xFC, 0x1E,
  0x38, 0x3B, 0x87, 0x8F, 0x0E, 0xE1, 0xC3, 0xC7, 0x38, 0x70, 0xF1, 0xCE,
  0x1C, 0x1C, 0x71, 0xCF, 0x07, 0x3C, 0x73, 0x81, 0xCE, 0x1C, 0xE0, 0x7B,
  0x87, 0x38, 0x0E, 0xE0, 0xEE, 0x03, 0xB8, 0x3B, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x07,
  0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x00, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0xF8, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xE3, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x00,
  0x3E, 0x1F, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xFB, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x77, 0xFF, 0xC0, 0x1D, 0xF3,
  0xF8, 0x0F, 0x70, 0x3F, 0x87, 0xBC, 0x03, 0xFF, 0xEE, 0x00, 0x7F, 0xF0,
  0x40, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoMono_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 5, 33, 28, 11, -33 },
  { 22, 12, 11, 28, 8, -35 },
  { 39, 26, 33, 28, 1, -33 },
  { 147, 21, 44, 28, 4, -39 },
  { 263, 26, 34, 28, 1, -34 },
  { 374, 25, 34, 28, 2, -34 },
  { 481, 4, 11, 28, 11, -35 },
  { 487, 12, 49, 28, 8, -38 },
  { 561, 12, 49, 28, 7, -38 },
  { 635, 22, 22, 28, 4, -33 },
  { 696, 23, 25, 28, 3, -28 },
  { 768, 7, 13, 28, 8, -5 },
  { 780, 18, 3, 28, 5, -16 },
  { 787, 7, 6, 28, 11, -6 },
  { 793, 18, 36, 28, 6, -33 },
  { 874, 22, 34, 28, 3, -34 },
  { 968, 13, 33, 28, 5, -33 },
  { 1022, 22, 34, 28, 2, -34 },
  { 1116, 21, 34, 28, 2, -34 },
  { 1206, 24, 33, 28, 2, -33 },
  { 1305, 21, 33, 28, 4, -33 },
  { 1392, 21, 33, 28, 3, -33 },
  { 1479, 22, 33, 28, 3, -33 },
  { 1570, 21, 34, 28, 4, -34 },
  { 1660, 21, 34, 28, 3, -34 },
  { 1750, 6, 26, 28, 13, -26 },
  { 1770, 8, 34, 28, 11, -26 },
  { 1804, 19, 21, 28, 4, -25 },
  { 1854, 20, 14, 28, 4, -22 },
  { 1889, 20, 20, 28, 4, -25 },
  { 1939, 20, 34, 28, 4, -34 },
  { 2024, 26, 33, 28, 1, -33 },
  { 2132, 25, 33, 28, 2, -33 },
  { 2236, 22, 33, 28, 4, -33 },
  { 2327, 24, 34, 28, 2, -34 },
  { 2429, 22, 33, 28, 4, -33 },
  { 2520, 21, 33, 28, 4, -33 },
  { 2607, 21, 33, 28, 4, -33 },
  { 2694, 24, 34, 28, 2, -34 },
  { 2796, 22, 33, 28, 3, -33 },
  { 2887, 20, 33, 28, 4, -33 },
  { 2970, 22, 33, 28, 2, -33 },
  { 3061, 23, 33, 28, 4, -33 },
  { 3156, 20, 33, 28, 5, -33 },
  { 3239, 22, 33, 28, 3, -33 },
  { 3330, 22, 33, 28, 3, -33 },
  { 3421, 24, 34, 28, 2, -34 },
  { 3523, 22, 33, 28, 4, -33 },
  { 3614, 25, 40, 28, 2, -34 },
  { 3739, 22, 33, 28, 4, -33 },
  { 3830, 23, 34, 28, 3, -34 },
  { 3928, 25, 33, 28, 2, -33 },
  { 4032, 22, 33, 28, 3, -33 },
  { 4123, 24, 33, 28, 2, -33 },
  { 4222, 25, 33, 28, 2, -33 },
  { 4326, 25, 33, 28, 2, -33 },
  { 4430, 25, 33, 28, 1, -33 },
  { 4534, 22, 33, 28, 3, -33 },
  { 4625, 9, 45, 28, 10, -38 },
  { 4676, 18, 36, 28, 5, -33 },
  { 4757, 9, 45, 28, 9, -38 },
  { 4808, 18, 17, 28, 5, -33 },
  { 4847, 21, 3, 28, 4, 0 },
  { 4855, 9, 6, 28, 10, -34 },
  { 4862, 21, 25, 28, 4, -25 },
  { 4928, 21, 35, 28, 4, -35 },
  { 5020, 22, 25, 28, 3, -25 },
  { 5089, 21, 35, 28, 3, -35 },
  { 5181, 22, 25, 28, 3, -25 },
  { 5250, 23, 36, 28, 3, -36 },
  { 5354, 21, 35, 28, 3, -25 },
  { 5446, 21, 35, 28, 4, -35 },
  { 5538, 20, 34, 28, 5, -34 },
  { 5623, 15, 44, 28, 5, -34 },
  { 5706, 22, 35, 28, 4, -35 },
  { 5803, 20, 35, 28, 5, -35 },
  { 5891, 24, 25, 28, 2, -25 },
  { 5966, 20, 25, 28, 4, -25 },
  { 6029, 22, 25, 28, 3, -25 },
  { 6098, 21, 35, 28, 4, -25 },
  { 6190, 21, 35, 28, 3, -25 },
  { 6282, 17, 25, 28, 8, -25 },
  { 6336, 21, 25, 28, 4, -25 },
  { 6402, 21, 31, 28, 3, -31 },
  { 6484, 20, 25, 28, 4, -25 },
  { 6547, 24, 25, 28, 2, -25 },
  { 6622, 26, 25, 28, 1, -25 },
  { 6704, 23, 25, 28, 3, -25 },
  { 6776, 25, 35, 28, 2, -25 },
  { 6886, 21, 25, 28, 4, -25 },
  { 6952, 16, 45, 28, 7, -37 },
  { 7042, 4, 42, 28, 12, -33 },
  { 7063, 16, 45, 28, 7, -37 },
  { 7153, 26, 9, 28, 1, -18 },
};

const GFXfont RobotoMono_Regular47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular47pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_REGULAR47PT7B_H_
