#ifndef _ROBOTOMONO_REGULAR50PT7B_H_
#define _ROBOTOMONO_REGULAR50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xF0,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xFD,
  0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1E, 0x0E, 0x03, 0x83, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x03, 0x87, 0x80,
  0xF0, 0x38, 0x70, 0x07, 0x07, 0x8F, 0x00, 0x7D, 0xF0, 0xE0, 0x03, 0xFF,
  0x1E, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x3C, 0x7F, 0xC0, 0x07, 0x8F,
  0xFE, 0x00, 0x79, 0xE1, 0xE0, 0x0F, 0x1E, 0x0F, 0x00, 0xE1, 0xC0, 0xF0,
  0x1E, 0x1C, 0x0F, 0x01, 0xC1, 0xC0, 0xF0, 0x3C, 0x1C, 0x0F, 0x01, 0x81,
  0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x07, 0x9F, 0x8F, 0x81, 0xE7, 0xC1,
  0xF0, 0x7B, 0xE0, 0x7E, 0x1E, 0xF8, 0x0F, 0x8F, 0xBC, 0x01, 0xF3, 0xCF,
  0x00, 0x3E, 0xF3, 0xC0, 0x0F, 0xF8, 0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x07, 0xF8, 0x7F, 0x0F, 0xFE, 0x0F, 0xFF,
  0xF7, 0xC1, 0xFF, 0xF8, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x10, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x80,
  0x0C, 0x40, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x20, 0x1C, 0x02, 0x78,
  0x38, 0x1D, 0xFC, 0x71, 0xFF, 0xFF, 0xEF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xEF,
  0x00, 0x07, 0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF3, 0xE7, 0x86, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0,
  0x1F, 0x0F, 0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0x3F,
  0xE0, 0xFC, 0x7F, 0xC3, 0xF0, 0xFF, 0x8F, 0x81, 0xFF, 0x7E, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3D, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0xCF, 0x00,
  0x0F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F,
  0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x01,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF8, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F,
  0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07,
  0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x3F, 0xC3, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xF8, 0x1F, 0xC3, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xE0,
  0x03, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x3F, 0x87, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0xF0, 0x1E, 0x7F,
  0xF8, 0x3D, 0xFF, 0xF8, 0x7F, 0xF7, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x01,
  0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x0F,
  0x80, 0x7C, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xE0, 0x03,
  0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0xE1, 0xF8,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x83,
  0xF0, 0x1F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x7E, 0x3F, 0xC3,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xE1,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xF7,
  0xC0, 0x1F, 0xDF, 0x80, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xE7, 0x80, 0xFE, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0xFF, 0xFE, 0xFD,
  0xF8, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xE0, 0x7F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x1F, 0xF0,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x3C, 0x0F, 0xC3, 0x8E, 0x0F, 0xF8, 0x67, 0x07, 0xFE,
  0x1D, 0xC1, 0xE3, 0x87, 0x70, 0xF0, 0xE1, 0xF8, 0x38, 0x38, 0x7E, 0x1E,
  0x0E, 0x0F, 0x87, 0x03, 0x83, 0xE1, 0xC0, 0xE0, 0xF8, 0x70, 0x38, 0x3E,
  0x1C, 0x0E, 0x0F, 0x8E, 0x03, 0x07, 0xE3, 0x80, 0xC1, 0xF8, 0xE0, 0x30,
  0x7E, 0x3C, 0x1C, 0x1B, 0x87, 0x0F, 0x0E, 0xE1, 0xE7, 0xC3, 0xB8, 0x7F,
  0xBF, 0xCF, 0x0F, 0xEF, 0xE1, 0xC1, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x80, 0x0F, 0x80, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F,
  0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF0,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F,
  0x80, 0xFF, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7C, 0x07, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xC0, 0x3F, 0xCF, 0x80, 0x0F,
  0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0xC1, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0xE0, 0xF0,
  0x03, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0xF8, 0xF0, 0x03, 0xF0, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFC,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFD, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x3F, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xC7, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x1F,
  0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xF7, 0xE0, 0x07, 0xF1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xDF, 0xFE, 0x07, 0xBF, 0xDC, 0x0F,
  0x7F, 0xBC, 0x3C, 0xFF, 0x78, 0x79, 0xFE, 0x70, 0xF3, 0xFC, 0xF3, 0xC7,
  0xF9, 0xE7, 0x8F, 0xF1, 0xCF, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x87, 0xF0, 0xFF, 0x0F, 0xC3, 0xFE, 0x1F, 0x87, 0xFC, 0x3E, 0x0F, 0xF8,
  0x3C, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFB, 0xC0, 0x1F, 0xFB, 0xE0,
  0x1F, 0xF9, 0xE0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF8, 0xF0, 0x1F, 0xF8, 0xF8,
  0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x0F, 0x9F, 0xF8, 0x0F,
  0x9F, 0xF8, 0x07, 0xDF, 0xF8, 0x07, 0xDF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x8F, 0x00, 0x7F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0,
  0x00, 0xFD, 0xE0, 0x07, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3C,
  0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0xF8, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x40, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x01, 0xF8, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8,
  0x0F, 0x81, 0xEF, 0x81, 0xF0, 0x3D, 0xF0, 0x7E, 0x07, 0xBE, 0x0F, 0xC0,
  0xF3, 0xC1, 0xFC, 0x1E, 0x78, 0x3F, 0x83, 0xCF, 0x07, 0xF0, 0x79, 0xE0,
  0xEE, 0x0F, 0x3C, 0x3D, 0xC3, 0xE7, 0x87, 0xB8, 0x78, 0xF0, 0xF7, 0x8F,
  0x1F, 0x1C, 0xF1, 0xE1, 0xE3, 0x9E, 0x3C, 0x3C, 0x71, 0xC7, 0x87, 0x9E,
  0x38, 0xF0, 0xF3, 0xC7, 0x1E, 0x1E, 0x78, 0xF3, 0xC3, 0xCE, 0x1E, 0xF0,
  0x79, 0xC3, 0xDE, 0x0F, 0x78, 0x3B, 0xC0, 0xFF, 0x07, 0x78, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x7C,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xE0,
  0x78, 0x78, 0x3E, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x1E, 0x78,
  0x07, 0xBE, 0x01, 0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7E, 0x03, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x07, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x7B,
  0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0,
  0x07, 0xEF, 0xC0, 0x3F, 0x9F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF9,
  0xF0, 0xFF, 0xC7, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC3, 0xF0, 0x0F, 0x9F, 0xF8, 0x1F, 0x7F, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F,
  0x81, 0xF8, 0xFE, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0xF9, 0xFC, 0x03, 0xF3, 0xFF, 0x3F, 0xC7, 0xFF, 0xFF, 0x0F,
  0xBF, 0xFC, 0x1E, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F,
  0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F,
  0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE1, 0xF0, 0x3F,
  0xF3, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0x3F, 0x00,
  0xFE, 0x7C, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0x80, 0x03,
  0xEF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7E,
  0x01, 0xFC, 0x7F, 0x9F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB, 0xE0, 0x3F,
  0xC7, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x08, 0x3E, 0x00, 0x1C, 0x1F, 0x80, 0x3E, 0x1F,
  0xE0, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x0E, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFE, 0x3C, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xF8, 0x1F, 0xE7, 0xE0,
  0x1F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x8F, 0xF3, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7C, 0x07,
  0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x82, 0x00,
  0x1F, 0x0C, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0xC0, 0xF8, 0xFF, 0xC3, 0xE7, 0xFF, 0xCF, 0xBF, 0xFF,
  0x3F, 0xE0, 0x7E, 0xFE, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x04, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8,
  0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3C, 0x3C,
  0xFF, 0x3F, 0xCF, 0x7F, 0xDF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFC, 0x3F, 0x0F,
  0xBE, 0x07, 0xC1, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8, 0x1E,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8,
  0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78,
  0x1F, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0,
  0x78, 0x1F, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7C,
  0x00, 0x3F, 0x03, 0xC3, 0xFF, 0x0F, 0x3F, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0x81, 0xFB, 0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x7E, 0x01, 0xE3, 0xFF, 0x03, 0xDF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xF0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F,
  0x9F, 0x80, 0x1F, 0x3F, 0x80, 0x7E, 0x7F, 0xC3, 0xF8, 0xFF, 0xFF, 0xE1,
  0xF7, 0xFF, 0x83, 0xE7, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFE, 0x7C, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF8,
  0x1F, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xE7,
  0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0x8F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0x7C, 0x07, 0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xBC, 0x3F, 0xFF, 0x1F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x01,
  0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x01, 0xF7,
  0xE0, 0x0F, 0xCF, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xE3, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF8,
  0x07, 0xF3, 0xF8, 0xFF, 0xC7, 0xFF, 0xDF, 0x0F, 0xFE, 0x3C, 0x1F, 0xF0,
  0xF0, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0xF7, 0x80, 0xF0, 0x0F, 0x78, 0x0F, 0x00, 0xE7, 0x80, 0xF8,
  0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x38, 0x1F, 0x81, 0xE3,
  0xC1, 0xFC, 0x1C, 0x3C, 0x3D, 0xC1, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x39,
  0xC3, 0xC1, 0xC3, 0x9E, 0x3C, 0x1E, 0x79, 0xE3, 0x81, 0xE7, 0x0E, 0x38,
  0x1E, 0x70, 0xE7, 0x80, 0xE7, 0x0F, 0x78, 0x0E, 0xF0, 0xF7, 0x00, 0xEE,
  0x07, 0x70, 0x0F, 0xE0, 0x77, 0x00, 0xFE, 0x07, 0x70, 0x07, 0xE0, 0x7F,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x38, 0x01, 0xE0, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01,
  0xF3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x08, 0x3F,
  0xFC, 0x00, 0xF3, 0xFF, 0xE0, 0x0F, 0x7E, 0x7F, 0x00, 0xE7, 0x81, 0xFC,
  0x1E, 0xF0, 0x0F, 0xFF, 0xEF, 0x00, 0x3F, 0xFC, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xE0,
};

const GFXglyph RobotoMono_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 5, 36, 30, 12, -36 },
  { 24, 12, 12, 30, 9, -38 },
  { 42, 28, 36, 30, 1, -36 },
  { 168, 23, 46, 30, 4, -41 },
  { 301, 28, 37, 30, 1, -36 },
  { 431, 26, 36, 30, 3, -36 },
  { 548, 4, 12, 30, 12, -38 },
  { 554, 13, 51, 30, 9, -40 },
  { 637, 13, 51, 30, 8, -40 },
  { 720, 23, 24, 30, 4, -36 },
  { 789, 24, 25, 30, 3, -29 },
  { 864, 7, 13, 30, 9, -5 },
  { 876, 19, 3, 30, 5, -17 },
  { 884, 7, 6, 30, 12, -6 },
  { 890, 19, 39, 30, 6, -36 },
  { 983, 23, 36, 30, 4, -36 },
  { 1087, 14, 36, 30, 5, -36 },
  { 1150, 24, 36, 30, 2, -36 },
  { 1258, 23, 36, 30, 2, -36 },
  { 1362, 26, 36, 30, 2, -36 },
  { 1479, 22, 36, 30, 5, -36 },
  { 1578, 23, 36, 30, 3, -36 },
  { 1682, 24, 36, 30, 3, -36 },
  { 1790, 23, 36, 30, 4, -36 },
  { 1894, 22, 36, 30, 4, -36 },
  { 1993, 7, 27, 30, 13, -27 },
  { 2017, 8, 35, 30, 12, -27 },
  { 2052, 21, 22, 30, 4, -27 },
  { 2110, 22, 14, 30, 4, -23 },
  { 2149, 22, 22, 30, 4, -27 },
  { 2210, 21, 36, 30, 5, -36 },
  { 2305, 26, 36, 30, 2, -36 },
  { 2422, 27, 36, 30, 2, -36 },
  { 2544, 23, 36, 30, 4, -36 },
  { 2648, 24, 36, 30, 3, -36 },
  { 2756, 24, 36, 30, 4, -36 },
  { 2864, 22, 36, 30, 4, -36 },
  { 2963, 21, 36, 30, 5, -36 },
  { 3058, 25, 37, 30, 2, -36 },
  { 3174, 24, 36, 30, 3, -36 },
  { 3282, 22, 36, 30, 4, -36 },
  { 3381, 24, 36, 30, 2, -36 },
  { 3489, 25, 36, 30, 4, -36 },
  { 3602, 22, 36, 30, 5, -36 },
  { 3701, 23, 36, 30, 4, -36 },
  { 3805, 24, 36, 30, 3, -36 },
  { 3913, 24, 36, 30, 3, -36 },
  { 4021, 23, 36, 30, 5, -36 },
  { 4125, 26, 42, 30, 2, -36 },
  { 4262, 24, 36, 30, 4, -36 },
  { 4370, 25, 36, 30, 3, -36 },
  { 4483, 26, 36, 30, 2, -36 },
  { 4600, 24, 36, 30, 3, -36 },
  { 4708, 26, 36, 30, 2, -36 },
  { 4825, 27, 36, 30, 2, -36 },
  { 4947, 26, 36, 30, 2, -36 },
  { 5064, 27, 36, 30, 1, -36 },
  { 5186, 23, 36, 30, 3, -36 },
  { 5290, 10, 49, 30, 10, -41 },
  { 5352, 19, 39, 30, 6, -36 },
  { 5445, 10, 49, 30, 10, -41 },
  { 5507, 18, 19, 30, 6, -36 },
  { 5550, 22, 4, 30, 4, 0 },
  { 5561, 10, 6, 30, 10, -36 },
  { 5569, 22, 27, 30, 4, -27 },
  { 5644, 23, 38, 30, 4, -38 },
  { 5754, 23, 27, 30, 3, -27 },
  { 5832, 23, 38, 30, 3, -38 },
  { 5942, 24, 27, 30, 3, -27 },
  { 6023, 24, 39, 30, 4, -39 },
  { 6140, 23, 37, 30, 3, -27 },
  { 6247, 22, 38, 30, 4, -38 },
  { 6352, 22, 36, 30, 5, -36 },
  { 6451, 16, 47, 30, 5, -36 },
  { 6545, 24, 38, 30, 4, -38 },
  { 6659, 22, 38, 30, 5, -38 },
  { 6764, 26, 27, 30, 2, -27 },
  { 6852, 22, 27, 30, 4, -27 },
  { 6927, 24, 27, 30, 3, -27 },
  { 7008, 23, 37, 30, 4, -27 },
  { 7115, 23, 37, 30, 3, -27 },
  { 7222, 18, 27, 30, 8, -27 },
  { 7283, 22, 27, 30, 4, -27 },
  { 7358, 23, 33, 30, 3, -33 },
  { 7453, 22, 26, 30, 4, -26 },
  { 7525, 25, 26, 30, 2, -26 },
  { 7607, 28, 26, 30, 1, -26 },
  { 7698, 25, 26, 30, 3, -26 },
  { 7780, 26, 37, 30, 2, -26 },
  { 7901, 22, 26, 30, 4, -26 },
  { 7973, 16, 48, 30, 8, -39 },
  { 8069, 4, 46, 30, 13, -36 },
  { 8092, 16, 48, 30, 8, -39 },
  { 8188, 28, 10, 30, 1, -20 },
};

const GFXfont RobotoMono_Regular50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular50pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_REGULAR50PT7B_H_
