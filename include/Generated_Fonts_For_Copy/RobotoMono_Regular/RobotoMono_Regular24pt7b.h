#ifndef _ROBOTOMONO_REGULAR24PT7B_H_
#define _ROBOTOMONO_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x06,
  0x20, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC4, 0x3F, 0xFC, 0x23, 0x03, 0x18,
  0x18, 0xC0, 0xC4, 0x06, 0x21, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x20, 0x23, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0xC7, 0xFC, 0xC1, 0x98,
  0x33, 0x07, 0x60, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0x80, 0x3E,
  0x03, 0xC0, 0xFC, 0x19, 0xFF, 0x1F, 0xC0, 0x40, 0x08, 0x00, 0xF8, 0x06,
  0x60, 0x23, 0x11, 0x19, 0x88, 0xC8, 0x6C, 0xC1, 0xEC, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x3C, 0x13, 0x31, 0x91, 0x98, 0x8C, 0x44, 0x60, 0x33,
  0x00, 0xF0, 0x1F, 0x01, 0xFC, 0x0C, 0x70, 0x61, 0x83, 0x18, 0x19, 0xC0,
  0x7C, 0x03, 0xC0, 0x1E, 0x03, 0xB0, 0xD9, 0xCD, 0xC7, 0x6C, 0x1F, 0x70,
  0x71, 0x83, 0x8F, 0xFE, 0x3F, 0x38, 0xFF, 0xA0, 0x04, 0x31, 0x8C, 0x31,
  0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x61, 0x86, 0x0C, 0x30,
  0x60, 0xC1, 0x04, 0x83, 0x06, 0x0C, 0x30, 0x61, 0x86, 0x1C, 0x30, 0xC3,
  0x0C, 0x30, 0xC7, 0x18, 0x61, 0x8C, 0x31, 0x86, 0x30, 0x80, 0x0E, 0x00,
  0x80, 0x10, 0x62, 0x1F, 0x5E, 0xFF, 0x83, 0x80, 0xD8, 0x1B, 0x06, 0x31,
  0x87, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x77, 0x76, 0x6E, 0x40,
  0xFF, 0x80, 0xFF, 0x80, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60,
  0x00, 0x3F, 0x0F, 0xF3, 0x83, 0x60, 0x6C, 0x0F, 0x81, 0xF0, 0xFE, 0x3B,
  0xCE, 0x7B, 0x0F, 0xC1, 0xF0, 0x3C, 0x0F, 0x81, 0x98, 0x33, 0xFC, 0x3F,
  0x00, 0x06, 0x3F, 0xFF, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x3F, 0x87, 0xFC, 0x60, 0xCC, 0x0E, 0xC0, 0x60,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0x8F, 0x79, 0x83, 0x70, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x7C, 0x0F, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x07,
  0x80, 0xD8, 0x33, 0xFE, 0x3F, 0x80, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x6C,
  0x06, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0xC6, 0x0C, 0x60, 0xCF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3F, 0xC7, 0xF9, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1F, 0xC3, 0xFE, 0x61, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x07, 0x81, 0xD8, 0x33, 0xFE, 0x1F, 0x80, 0x0F, 0x07, 0xC3, 0x81,
  0x80, 0xE0, 0x30, 0x0D, 0xF3, 0xFE, 0xE1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x36, 0x1D, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x00, 0x3F, 0x8F, 0x79, 0x83,
  0x30, 0x6E, 0x0E, 0xC1, 0x98, 0x31, 0xFC, 0x3F, 0x8E, 0x3B, 0x83, 0xE0,
  0x3C, 0x07, 0x80, 0xD8, 0x33, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0xEE, 0x1F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xDF, 0xF3, 0xEC, 0x03, 0x00,
  0xC0, 0x60, 0x78, 0xFC, 0x3C, 0x00, 0x6F, 0x70, 0x00, 0x00, 0x00, 0x6F,
  0x70, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x66, 0x66, 0xEC, 0xC0, 0x00, 0x40,
  0x70, 0x7C, 0xF8, 0xF8, 0x30, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x70, 0x04,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x38,
  0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x30, 0x7C, 0x7C, 0xF8, 0x38, 0x08, 0x00,
  0x3F, 0x1F, 0xFE, 0x0F, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x0F, 0x80,
  0xEF, 0x0C, 0x08, 0xC2, 0x64, 0x79, 0x66, 0x4B, 0x22, 0x73, 0x13, 0x98,
  0x9C, 0xCC, 0xA6, 0x65, 0x37, 0x6C, 0xEE, 0x60, 0x01, 0x80, 0x07, 0xB0,
  0x1F, 0x80, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xD8, 0x06, 0xC0,
  0x66, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x18, 0x7F, 0xC7, 0xFE, 0x30,
  0x39, 0x80, 0xDC, 0x06, 0xC0, 0x38, 0xFF, 0x1F, 0xFB, 0x03, 0x60, 0x7C,
  0x0F, 0x81, 0xB0, 0x77, 0xFC, 0xFF, 0x98, 0x3B, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x37, 0xFE, 0xFF, 0x00, 0x1F, 0x83, 0xFE, 0x70, 0x66, 0x07,
  0x60, 0x3E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x36, 0x07, 0x70, 0x63, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xF3, 0x07,
  0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xB0, 0x77, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFC, 0xFF, 0x98, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xD8, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x83, 0xFE, 0x70,
  0x66, 0x07, 0x60, 0x3E, 0x00, 0xC0, 0x0C, 0x00, 0xC1, 0xFC, 0x1F, 0xC0,
  0x3E, 0x03, 0x60, 0x36, 0x03, 0x30, 0x33, 0xFE, 0x0F, 0xC0, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3C, 0x07, 0xC0, 0xD8, 0x39, 0xFE, 0x1F, 0x80, 0xC0, 0xFC, 0x0C, 0xC1,
  0x8C, 0x38, 0xC7, 0x0C, 0xE0, 0xCC, 0x0D, 0xC0, 0xFC, 0x0F, 0xE0, 0xE7,
  0x0C, 0x30, 0xC3, 0x8C, 0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x70, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xE0, 0xE0, 0xFC,
  0x1F, 0x87, 0xF8, 0xFF, 0x17, 0xE6, 0xF6, 0xDE, 0xD3, 0xDE, 0x79, 0xCF,
  0x31, 0xE6, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0xC0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xB0, 0xF6, 0x1E, 0x63, 0xCC, 0x78, 0xCF,
  0x19, 0xE1, 0xBC, 0x37, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xE0, 0x1F, 0x83,
  0xFC, 0x70, 0xE6, 0x06, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0x60, 0x36, 0x06, 0x30, 0xE3, 0xFC, 0x1F, 0x80,
  0xFF, 0x1F, 0xFB, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF,
  0xDF, 0xF3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00,
  0x1F, 0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xC6, 0x03, 0x70, 0x1B, 0x00, 0xD8,
  0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x66, 0x03, 0x30, 0x31, 0xC3,
  0x87, 0xF8, 0x1F, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x20, 0xFF, 0x1F, 0xFB,
  0x03, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x3E, 0x06, 0xFF, 0x9F, 0xE3, 0x0C,
  0x61, 0xCC, 0x19, 0x83, 0xB0, 0x36, 0x07, 0xC0, 0x60, 0x1F, 0xC3, 0xFE,
  0x70, 0x76, 0x03, 0x60, 0x36, 0x00, 0x38, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x70, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x73, 0xFE, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xB8, 0x73,
  0xFC, 0x3F, 0x00, 0xC0, 0x3E, 0x03, 0x60, 0x76, 0x06, 0x70, 0x63, 0x06,
  0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x98, 0x19, 0x81, 0xD8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0x70, 0x06, 0x00, 0xC6, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x6C,
  0x73, 0x36, 0x99, 0xB4, 0xCD, 0xB6, 0x6D, 0xB3, 0x4D, 0x9A, 0x6C, 0xF1,
  0x47, 0x8E, 0x3C, 0x70, 0xE3, 0x86, 0x1C, 0x30, 0xE0, 0xE0, 0x3B, 0x83,
  0x8C, 0x18, 0x71, 0x81, 0x9C, 0x0E, 0xC0, 0x3E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x60, 0x3B, 0x01, 0x8C, 0x1C, 0x71, 0xC1, 0x8C, 0x0E, 0xE0,
  0x38, 0xC0, 0x3E, 0x07, 0x60, 0x67, 0x0E, 0x30, 0xC3, 0x9C, 0x19, 0x81,
  0xD8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x60, 0x18, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x01, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x0E, 0x0F, 0x07, 0x83, 0x63, 0x31,
  0x8D, 0x86, 0xC3, 0x80, 0xFF, 0xFF, 0xFC, 0xE1, 0x86, 0x1F, 0x0F, 0xF3,
  0x87, 0x60, 0x60, 0x0C, 0x1F, 0x9F, 0xF7, 0x06, 0xC0, 0xD8, 0x1B, 0x07,
  0x7F, 0xE3, 0xEE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x9E, 0x3F,
  0xE7, 0x0E, 0xC0, 0xD8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x37,
  0x0E, 0xFF, 0x9B, 0xE0, 0x1F, 0x07, 0xF1, 0x87, 0x70, 0x6C, 0x07, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x1D, 0x83, 0x3F, 0xE3, 0xF0, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC7, 0xB7, 0xFD, 0x87, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0x7F, 0xCF, 0xB0, 0x1E, 0x07, 0xF1,
  0x87, 0x70, 0x6C, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x81,
  0xBF, 0xE1, 0xF8, 0x00, 0x80, 0xFC, 0x38, 0x86, 0x01, 0xC0, 0x30, 0x3F,
  0xF7, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x1E, 0xDF, 0xF6, 0x1F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFF, 0x3E, 0xC0, 0x34,
  0x0F, 0x07, 0x7F, 0x87, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x9E, 0x37, 0xF7, 0x8E, 0xC0, 0xD8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1C, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x87, 0xFF, 0xFF, 0xE0, 0x07, 0x03, 0x00, 0x00, 0x7F, 0x7F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0x7E, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81,
  0xB0, 0x66, 0x18, 0xC6, 0x19, 0x83, 0x60, 0x7E, 0x0E, 0xE1, 0x8E, 0x30,
  0xC6, 0x0C, 0xC1, 0xD8, 0x1C, 0xFE, 0x1F, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0xDC, 0xEF, 0xFF, 0xC7, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x30, 0xCF, 0x37, 0xEF, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x0F, 0x03, 0xFC, 0x30, 0xE6,
  0x06, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x07, 0x70, 0x63,
  0xFC, 0x1F, 0x80, 0xCF, 0x1F, 0xF3, 0x87, 0x60, 0x6C, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x87, 0x7F, 0xCD, 0xF1, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x1E, 0xDF, 0xF6, 0x1F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0D, 0xFF, 0x3E, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xCF, 0xEF, 0xBC, 0x3C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0x0F, 0xF1, 0x87, 0x70, 0x66,
  0x02, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xD8, 0x1F, 0x83, 0x3F, 0xE3, 0xF8,
  0x18, 0x06, 0x01, 0x83, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xFC, 0x3F, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFF, 0x3E,
  0xC0, 0xC0, 0x36, 0x03, 0x60, 0x67, 0x06, 0x30, 0xC3, 0x0C, 0x18, 0xC1,
  0x98, 0x1D, 0x80, 0xD0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xC2, 0x1E, 0x30,
  0xF1, 0xC5, 0x8E, 0x6C, 0x73, 0x26, 0x99, 0xB6, 0xCD, 0x34, 0x69, 0xA1,
  0xC7, 0x0E, 0x38, 0x61, 0xC3, 0x0C, 0x00, 0xE0, 0x37, 0x06, 0x30, 0xE1,
  0x9C, 0x0D, 0x80, 0xF0, 0x07, 0x00, 0xF0, 0x0D, 0x81, 0x9C, 0x38, 0xC7,
  0x06, 0xE0, 0x70, 0xC0, 0x3F, 0x01, 0x98, 0x1C, 0xE0, 0xC3, 0x0E, 0x18,
  0x60, 0x63, 0x03, 0x30, 0x1D, 0x80, 0x7C, 0x03, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x78, 0x03, 0x80, 0x00, 0xFF, 0xDF, 0xF8,
  0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x7F, 0xFF, 0xFE, 0x03, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x30, 0xE0, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C,
  0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0xE0, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0F, 0x0F, 0x18, 0x38, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0xC0, 0x7C, 0x1F, 0xF0, 0xE1, 0xFD,
  0x03, 0xC0,
};

const GFXglyph RobotoMono_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 17, 14, 6, -17 },
  { 6, 6, 6, 14, 4, -18 },
  { 11, 13, 17, 14, 1, -17 },
  { 39, 11, 22, 14, 2, -20 },
  { 70, 13, 17, 14, 1, -17 },
  { 98, 13, 17, 14, 1, -17 },
  { 126, 2, 6, 14, 6, -18 },
  { 128, 6, 25, 14, 4, -19 },
  { 147, 6, 25, 14, 4, -19 },
  { 166, 11, 11, 14, 2, -17 },
  { 182, 12, 12, 14, 1, -14 },
  { 200, 4, 7, 14, 4, -3 },
  { 204, 9, 1, 14, 3, -8 },
  { 206, 3, 3, 14, 6, -3 },
  { 208, 9, 18, 14, 3, -17 },
  { 229, 11, 17, 14, 2, -17 },
  { 253, 7, 17, 14, 2, -17 },
  { 268, 12, 17, 14, 1, -17 },
  { 294, 11, 17, 14, 1, -17 },
  { 318, 12, 17, 14, 1, -17 },
  { 344, 11, 17, 14, 2, -17 },
  { 368, 10, 17, 14, 2, -17 },
  { 390, 12, 17, 14, 1, -17 },
  { 416, 11, 17, 14, 2, -17 },
  { 440, 10, 17, 14, 2, -17 },
  { 462, 4, 13, 14, 6, -13 },
  { 469, 4, 17, 14, 6, -13 },
  { 478, 10, 11, 14, 2, -13 },
  { 492, 11, 7, 14, 2, -11 },
  { 502, 10, 11, 14, 2, -13 },
  { 516, 10, 17, 14, 2, -17 },
  { 538, 13, 17, 14, 1, -17 },
  { 566, 13, 17, 14, 1, -17 },
  { 594, 11, 17, 14, 2, -17 },
  { 618, 12, 17, 14, 1, -17 },
  { 644, 11, 17, 14, 2, -17 },
  { 668, 11, 17, 14, 2, -17 },
  { 692, 11, 17, 14, 2, -17 },
  { 716, 12, 17, 14, 1, -17 },
  { 742, 11, 17, 14, 2, -17 },
  { 766, 10, 17, 14, 2, -17 },
  { 788, 11, 17, 14, 1, -17 },
  { 812, 12, 17, 14, 2, -17 },
  { 838, 11, 17, 14, 2, -17 },
  { 862, 11, 17, 14, 2, -17 },
  { 886, 11, 17, 14, 2, -17 },
  { 910, 12, 17, 14, 1, -17 },
  { 936, 11, 17, 14, 2, -17 },
  { 960, 13, 20, 14, 1, -17 },
  { 993, 11, 17, 14, 2, -17 },
  { 1017, 12, 17, 14, 1, -17 },
  { 1043, 13, 17, 14, 1, -17 },
  { 1071, 11, 17, 14, 2, -17 },
  { 1095, 12, 17, 14, 1, -17 },
  { 1121, 13, 17, 14, 1, -17 },
  { 1149, 13, 17, 14, 1, -17 },
  { 1177, 12, 17, 14, 1, -17 },
  { 1203, 12, 17, 14, 1, -17 },
  { 1229, 5, 24, 14, 5, -20 },
  { 1244, 9, 18, 14, 3, -17 },
  { 1265, 4, 24, 14, 5, -20 },
  { 1277, 9, 9, 14, 3, -17 },
  { 1288, 11, 2, 14, 2, 0 },
  { 1291, 5, 3, 14, 5, -17 },
  { 1293, 11, 13, 14, 2, -13 },
  { 1311, 11, 18, 14, 2, -18 },
  { 1336, 11, 13, 14, 2, -13 },
  { 1354, 10, 18, 14, 2, -18 },
  { 1377, 11, 13, 14, 2, -13 },
  { 1395, 11, 19, 14, 2, -19 },
  { 1422, 10, 18, 14, 2, -13 },
  { 1445, 11, 18, 14, 2, -18 },
  { 1470, 11, 17, 14, 2, -17 },
  { 1494, 8, 22, 14, 2, -17 },
  { 1516, 11, 18, 14, 2, -18 },
  { 1541, 11, 18, 14, 2, -18 },
  { 1566, 12, 13, 14, 1, -13 },
  { 1586, 10, 13, 14, 2, -13 },
  { 1603, 12, 13, 14, 1, -13 },
  { 1623, 11, 18, 14, 2, -13 },
  { 1648, 10, 18, 14, 2, -13 },
  { 1671, 9, 13, 14, 4, -13 },
  { 1686, 11, 13, 14, 2, -13 },
  { 1704, 10, 16, 14, 2, -16 },
  { 1724, 10, 13, 14, 2, -13 },
  { 1741, 12, 13, 14, 1, -13 },
  { 1761, 13, 13, 14, 1, -13 },
  { 1783, 12, 13, 14, 1, -13 },
  { 1803, 13, 18, 14, 1, -13 },
  { 1833, 11, 13, 14, 2, -13 },
  { 1851, 8, 23, 14, 4, -19 },
  { 1874, 2, 22, 14, 6, -17 },
  { 1880, 8, 23, 14, 4, -19 },
  { 1903, 13, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_Regular24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Regular24pt7bBitmaps,
  (GFXglyph *)RobotoMono_Regular24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_REGULAR24PT7B_H_
