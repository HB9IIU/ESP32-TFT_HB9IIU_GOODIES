#ifndef _UBUNTUSANSMONO_BOLD45PT7B_H_
#define _UBUNTUSANSMONO_BOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0x87, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x3F, 0x3F, 0xBF, 0xFF, 0xF7, 0xFB, 0xF8, 0xF8,
  0x10, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFB,
  0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x01, 0xF8, 0xFC, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F,
  0x00, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8, 0x0E, 0x1F, 0xC0, 0x04, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xD0, 0x00, 0x7E, 0x78, 0x03, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xCF, 0xF8, 0x07,
  0xCF, 0xFC, 0x03, 0xC7, 0x9E, 0x03, 0xE3, 0xCF, 0x81, 0xE1, 0xE3, 0xC1,
  0xE1, 0xF1, 0xE1, 0xF0, 0x78, 0xF0, 0xF0, 0x3C, 0x78, 0xF0, 0x1E, 0x7C,
  0xF8, 0x0F, 0x3C, 0x78, 0x07, 0xFE, 0x78, 0x01, 0xFE, 0x7C, 0x00, 0x7F,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x7F, 0x80, 0x1F, 0x3F, 0xC0, 0x0F, 0x3F, 0xF0, 0x0F, 0x9E, 0x78,
  0x0F, 0x8F, 0x3E, 0x07, 0x8F, 0x0F, 0x07, 0xC7, 0x87, 0x87, 0xC3, 0xC3,
  0xC3, 0xC1, 0xE1, 0xE3, 0xE0, 0x79, 0xE3, 0xE0, 0x3D, 0xF1, 0xE0, 0x1F,
  0xF9, 0xF0, 0x07, 0xF9, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x3E, 0x0F, 0xF0, 0x7C,
  0x7F, 0xF0, 0xF8, 0xFF, 0xF1, 0xF3, 0xF7, 0xF3, 0xE7, 0xC7, 0xFF, 0x9F,
  0x87, 0xFF, 0x3E, 0x07, 0xFE, 0x7C, 0x07, 0xF8, 0xF8, 0x07, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0xE3, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x87, 0xFF, 0x9F, 0x83, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xC7, 0x8F, 0x00, 0x00, 0x08, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x08, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x03, 0x0F, 0x82, 0x1E, 0x3C, 0x79, 0xFD, 0xEF, 0xCF, 0xFE, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x7F, 0x03, 0xF9, 0xFC, 0x3F, 0x8F, 0xC0,
  0x7C, 0x3C, 0x00, 0xC1, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xFE, 0x1F, 0xE3, 0xFE,
  0x3F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x3C, 0x07, 0xC7, 0xF8,
  0xFF, 0x07, 0xE0, 0x78, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7E, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF, 0xF1,
  0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC2, 0x0F, 0xFC, 0x3C, 0x7F, 0xE3, 0xE3, 0xFF,
  0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x1C, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xF3,
  0xF0, 0x0E, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xF0, 0x3F, 0xC6, 0x00, 0xFE, 0x10, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x03, 0xF8, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0x9F,
  0xF0, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x98, 0x03, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3E, 0x3F, 0x80, 0xFC,
  0x7F, 0x01, 0xF0, 0xFE, 0x07, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3E, 0x07,
  0xF0, 0xFC, 0x0F, 0xE1, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF3,
  0x00, 0x7F, 0x9F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0xFF, 0x0F, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7F, 0x03, 0xF3,
  0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xC7, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0xFE, 0x07, 0xE7,
  0xF8, 0x7E, 0x1F, 0xF7, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xCF, 0xF8, 0xFC, 0x1F, 0xE7, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xFC, 0x07, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x02, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x0F, 0x83,
  0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x7E, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xC7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x3F, 0xC3, 0xF8, 0x1E, 0x07, 0xC1, 0xF9, 0xFE, 0x7F,
  0x8F, 0xE0, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x7F, 0x8C, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0x7F, 0x83, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x7F, 0xFB, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7E, 0x3F, 0xF8, 0xF8,
  0x7F, 0xF3, 0xF0, 0xFF, 0xC7, 0xE1, 0xFF, 0x8F, 0xC3, 0xFF, 0x1F, 0x87,
  0xFF, 0x3F, 0x0F, 0xFE, 0x3E, 0x1F, 0xFC, 0x7C, 0x3F, 0xF8, 0xFC, 0x7F,
  0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xC1, 0xFF, 0xF7, 0xC3, 0xFF, 0xEF,
  0x81, 0xFF, 0x8F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x01, 0xF9, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F,
  0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0x01, 0xC0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8,
  0x1F, 0xCF, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x0F, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0,
  0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xBF, 0x03, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xF8, 0x06, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x60,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xF0, 0x7F, 0x9F,
  0x81, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0,
  0x7F, 0x3F, 0x0F, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFE, 0x01, 0x8F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x03,
  0xF3, 0xFC, 0x0F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x20, 0x07, 0xF3, 0x80, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xFD, 0xF8,
  0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F, 0x83,
  0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFE,
  0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xFC, 0x03,
  0xF3, 0xFC, 0x07, 0xE3, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x3F,
  0x07, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0,
  0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF,
  0x3F, 0xE3, 0xDE, 0x7F, 0xC7, 0xBC, 0xFF, 0x8F, 0x79, 0xF7, 0x9E, 0xF3,
  0xEF, 0x79, 0xE7, 0xDE, 0xF3, 0xCF, 0xBD, 0xE7, 0x9F, 0x3F, 0x8F, 0x3E,
  0x7F, 0x1E, 0x7C, 0xFE, 0x7C, 0xF8, 0xFC, 0xFD, 0xF1, 0xF1, 0xFB, 0xE3,
  0xE3, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFB, 0xE3, 0xFF, 0xDF, 0x1F, 0xFE, 0x7C, 0xFF, 0xF3,
  0xE7, 0xFF, 0x8F, 0xBF, 0xFC, 0x7D, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF0,
  0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0x81,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x04, 0x03, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xC1, 0xFE,
  0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xE1,
  0xF1, 0xFC, 0x01, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF9, 0x00, 0x1F, 0xDE, 0x00, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFB,
  0xF8, 0x3F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xE7, 0xC0,
  0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE3,
  0xE3, 0xF7, 0xC7, 0xC7, 0xEF, 0x8F, 0xCF, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F,
  0x3E, 0x7C, 0xFE, 0x3C, 0xFB, 0xFE, 0x79, 0xF7, 0xBC, 0xF3, 0xEF, 0x79,
  0xE7, 0xDE, 0x7B, 0xCF, 0xF8, 0xF7, 0x9F, 0xF1, 0xEF, 0x3F, 0xE1, 0xDE,
  0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x00, 0x7E,
  0x7F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xEF, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xE0,
  0x0F, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8,
  0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x3C, 0x00, 0x7C, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x20, 0x07, 0x01, 0xF0, 0x3F, 0x8F, 0xF8, 0xFF, 0xC7, 0xF0, 0x3E, 0x01,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x0F, 0xBF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xF7, 0xFC, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0xA8, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x0F,
  0xF7, 0xE0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x07, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF0, 0x19, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x02, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0x87, 0xFB, 0xF8, 0x1F, 0xDF, 0x80, 0xFE, 0xFC,
  0x07, 0xF7, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x18, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xCF, 0x81, 0xFC, 0x01, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x70, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x0C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x20, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x20, 0x1F, 0xCF, 0x07, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFE, 0xFC, 0x0F, 0xF3, 0xF0, 0x3F, 0x8F,
  0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF,
  0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F,
  0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x03,
  0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xC0, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x60, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x80, 0x0F, 0xC3, 0xE1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0x1F, 0x8F, 0xBE, 0x1F, 0x1F, 0xFC, 0x3E, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF,
  0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x1F, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF,
  0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFE,
  0x0F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x0F, 0xF3, 0xF0,
  0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x83, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFC, 0x10,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0x3F, 0x7F, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xBF, 0x00, 0x83, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x80, 0x17, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD,
  0xFC, 0x03, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x60,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x03, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xFC,
  0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x50, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F,
  0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7E,
  0x3E, 0xF8, 0x7E, 0x3E, 0x78, 0xFE, 0x3E, 0x78, 0xFE, 0x3E, 0x78, 0xFE,
  0x3C, 0x7C, 0xFF, 0x3C, 0x7D, 0xEF, 0x3C, 0x7D, 0xEF, 0x7C, 0x7D, 0xEF,
  0xFC, 0x3F, 0xC7, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x0F,
  0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xEF, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0,
  0x1F, 0x8F, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0xFE, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x3E, 0x00,
  0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x01, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x10, 0x1F, 0xF0, 0x1F, 0x3F, 0xF8, 0x3E, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFC, 0x7F, 0xFC, 0xF8,
  0x1F, 0xF8, 0x38, 0x07, 0xF0,
};

const GFXglyph UbuntuSansMono_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 32, 25, 8, -31 },
  { 37, 17, 14, 25, 4, -34 },
  { 67, 23, 31, 25, 1, -31 },
  { 157, 22, 40, 25, 2, -35 },
  { 267, 25, 33, 25, 0, -32 },
  { 371, 23, 32, 25, 1, -32 },
  { 463, 7, 15, 25, 9, -34 },
  { 477, 16, 45, 25, 5, -36 },
  { 567, 17, 45, 25, 4, -36 },
  { 663, 21, 19, 25, 2, -31 },
  { 713, 21, 23, 25, 2, -25 },
  { 774, 12, 16, 25, 6, -8 },
  { 798, 13, 6, 25, 6, -16 },
  { 808, 9, 9, 25, 8, -8 },
  { 819, 21, 43, 25, 2, -35 },
  { 932, 21, 33, 25, 2, -32 },
  { 1019, 21, 31, 25, 2, -31 },
  { 1101, 21, 32, 25, 2, -32 },
  { 1185, 21, 33, 25, 2, -32 },
  { 1272, 23, 31, 25, 1, -31 },
  { 1362, 21, 32, 25, 2, -31 },
  { 1446, 21, 32, 25, 2, -31 },
  { 1530, 21, 31, 25, 2, -31 },
  { 1612, 21, 33, 25, 2, -32 },
  { 1699, 21, 32, 25, 2, -32 },
  { 1783, 9, 24, 25, 8, -23 },
  { 1810, 11, 31, 25, 6, -23 },
  { 1853, 21, 22, 25, 2, -24 },
  { 1911, 21, 15, 25, 2, -21 },
  { 1951, 21, 22, 25, 2, -24 },
  { 2009, 19, 33, 25, 3, -32 },
  { 2088, 23, 39, 25, 1, -32 },
  { 2201, 25, 31, 25, 0, -31 },
  { 2298, 21, 32, 25, 3, -32 },
  { 2382, 23, 33, 25, 1, -32 },
  { 2477, 21, 32, 25, 3, -32 },
  { 2561, 20, 31, 25, 3, -31 },
  { 2639, 19, 31, 25, 3, -31 },
  { 2713, 22, 33, 25, 1, -32 },
  { 2804, 21, 31, 25, 2, -31 },
  { 2886, 20, 31, 25, 3, -31 },
  { 2964, 20, 32, 25, 2, -31 },
  { 3044, 23, 31, 25, 2, -31 },
  { 3134, 19, 31, 25, 4, -31 },
  { 3208, 23, 31, 25, 1, -31 },
  { 3298, 21, 31, 25, 2, -31 },
  { 3380, 23, 33, 25, 1, -32 },
  { 3475, 21, 32, 25, 3, -32 },
  { 3559, 23, 41, 25, 1, -32 },
  { 3677, 22, 32, 25, 3, -32 },
  { 3765, 21, 33, 25, 2, -32 },
  { 3852, 23, 31, 25, 1, -31 },
  { 3942, 21, 32, 25, 2, -31 },
  { 4026, 24, 31, 25, 1, -31 },
  { 4119, 23, 31, 25, 1, -31 },
  { 4209, 24, 31, 25, 1, -31 },
  { 4302, 24, 31, 25, 1, -31 },
  { 4395, 21, 31, 25, 2, -31 },
  { 4477, 14, 43, 25, 6, -35 },
  { 4553, 21, 43, 25, 2, -35 },
  { 4666, 14, 43, 25, 5, -35 },
  { 4742, 24, 18, 25, 1, -31 },
  { 4796, 25, 5, 25, 0, 3 },
  { 4812, 11, 9, 25, 8, -35 },
  { 4825, 20, 25, 25, 2, -24 },
  { 4888, 21, 36, 25, 3, -35 },
  { 4983, 21, 25, 25, 2, -24 },
  { 5049, 21, 36, 25, 1, -35 },
  { 5144, 21, 25, 25, 2, -24 },
  { 5210, 23, 35, 25, 2, -35 },
  { 5311, 20, 32, 25, 2, -24 },
  { 5391, 19, 35, 25, 3, -35 },
  { 5475, 22, 36, 25, 2, -35 },
  { 5574, 18, 44, 25, 2, -35 },
  { 5673, 22, 35, 25, 3, -35 },
  { 5770, 22, 36, 25, 2, -35 },
  { 5869, 23, 24, 25, 1, -24 },
  { 5938, 19, 24, 25, 3, -24 },
  { 5995, 23, 25, 25, 1, -24 },
  { 6067, 21, 32, 25, 3, -24 },
  { 6151, 20, 32, 25, 2, -24 },
  { 6231, 19, 24, 25, 4, -24 },
  { 6288, 19, 25, 25, 3, -24 },
  { 6348, 22, 32, 25, 2, -31 },
  { 6436, 19, 25, 25, 3, -24 },
  { 6496, 23, 24, 25, 1, -24 },
  { 6565, 24, 24, 25, 1, -24 },
  { 6637, 23, 24, 25, 1, -24 },
  { 6706, 23, 32, 25, 1, -24 },
  { 6798, 19, 24, 25, 3, -24 },
  { 6855, 19, 43, 25, 3, -35 },
  { 6958, 6, 43, 25, 10, -35 },
  { 6991, 19, 43, 25, 3, -35 },
  { 7094, 24, 9, 25, 1, -18 },
};

const GFXfont UbuntuSansMono_Bold45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_BOLD45PT7B_H_
