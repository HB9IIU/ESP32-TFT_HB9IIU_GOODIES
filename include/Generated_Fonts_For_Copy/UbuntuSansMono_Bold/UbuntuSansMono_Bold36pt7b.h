#ifndef _UBUNTUSANSMONO_BOLD36PT7B_H_
#define _UBUNTUSANSMONO_BOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7,
  0x9E, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xFC, 0xFF, 0xF3, 0xFF,
  0xCF, 0xDF, 0x1F, 0x7C, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xE3, 0x83, 0x80, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E,
  0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x81,
  0xE3, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xFE,
  0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x7E, 0x03, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF2, 0x00, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3,
  0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x0C, 0x00, 0x03, 0xF0, 0x0F, 0x7F, 0x80, 0xE7, 0xF8, 0x1C, 0x73,
  0x83, 0xCF, 0x38, 0x38, 0xF3, 0x87, 0x8F, 0x38, 0xF0, 0xF3, 0x8E, 0x07,
  0x79, 0xE0, 0x7F, 0xBC, 0x03, 0xF3, 0x80, 0x1E, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE7, 0x80, 0x1E, 0xFC, 0x03, 0xDF, 0xE0, 0x39, 0xCE, 0x07, 0x9C,
  0xF0, 0xF1, 0xCF, 0x0E, 0x1C, 0x71, 0xE1, 0xCF, 0x3C, 0x1C, 0xF3, 0x81,
  0xFE, 0x78, 0x0F, 0xEF, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x7C, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xC7, 0x47, 0xF1, 0xE3, 0xFE, 0x79, 0xFF, 0x9E, 0xF9, 0xF7, 0xBC,
  0x3F, 0xEF, 0x07, 0xF3, 0xC0, 0xFC, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xEF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xF7, 0xC7, 0xF0, 0xF0, 0xFF, 0xFF, 0xDF, 0x7D,
  0xF7, 0x9E, 0x79, 0xE7, 0x8E, 0x00, 0x20, 0x03, 0x00, 0x7C, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0x80, 0x38, 0x00, 0x40, 0x20, 0x01, 0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x0E,
  0x00, 0x20, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43, 0xC2, 0x73,
  0xCE, 0x7D, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0x7C, 0x3E, 0x7E, 0x3E, 0x7C, 0x0C, 0x38, 0x04, 0x10, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x0E, 0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x0E, 0x0F,
  0x1F, 0x3F, 0x9F, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x18, 0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x87, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x8C, 0x7F, 0xE7, 0x9F, 0xF9, 0xE7, 0xFE, 0x79,
  0xFF, 0x9E, 0x7F, 0xE3, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79,
  0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x87, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFB, 0xE0, 0x71,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80,
  0x01, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0x83,
  0xF0, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x3F, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x60, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0,
  0x02, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xCF,
  0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF4, 0x01, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7F, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C,
  0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x01, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF7,
  0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0x8F,
  0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xF9, 0xFC, 0xF8,
  0x3F, 0x78, 0x0F, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xDF, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0x7C, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x3E, 0x0C, 0x1F,
  0x8F, 0xCF, 0xF3, 0xF9, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC1, 0xF8, 0xFC, 0xFF, 0x7F, 0x9F, 0xC7, 0xC0, 0xE0, 0xF1, 0xF3, 0xF1,
  0xF0, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x03,
  0xFC, 0x01, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xC3, 0xFF,
  0xE7, 0xFF, 0xE7, 0xFF, 0xCC, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x0F, 0x8F, 0x01, 0xE7, 0x80, 0x7D,
  0xE0, 0x0F, 0x70, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xE3, 0xF8, 0xF0, 0xFE, 0x3C, 0x3F, 0x8F, 0x0F, 0xE3, 0xC3, 0xF8, 0xF0,
  0xFE, 0x3C, 0x3F, 0xCF, 0x8F, 0xF3, 0xF7, 0xFC, 0x7F, 0xFF, 0x1F, 0xFD,
  0xE1, 0xFF, 0x78, 0x1E, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x02, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x3E, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xE0, 0xFD, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xE0, 0x63, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x63, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x87, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0x87,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC0,
  0x67, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0xC1,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x02, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x40, 0x3E, 0x70, 0x7E, 0x7F, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0x02, 0x00, 0xF8, 0x1F, 0xBE, 0x07,
  0xCF, 0x83, 0xF3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0x83,
  0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xBF, 0x03, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x3F,
  0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0x73, 0xF9, 0xDC,
  0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0xE7, 0x3F, 0x3D, 0xCF, 0xCF, 0xF3, 0xF3,
  0xFC, 0xFC, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xF7, 0x8F,
  0xF7, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80,
  0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xF7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F,
  0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xF8, 0x00,
  0x06, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7E,
  0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x83, 0xF3, 0xE7, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x3F,
  0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0, 0x00, 0xC0,
  0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x23, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF3, 0x00, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xEF,
  0xC3, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0x40,
  0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7C, 0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0x81,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0xC7,
  0x80, 0xF9, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x78, 0xFF,
  0x1E, 0x3F, 0xC7, 0xCF, 0xF3, 0xF3, 0xFC, 0xFC, 0xF7, 0x3F, 0x3D, 0xDE,
  0xEF, 0x77, 0x3B, 0xDD, 0xCE, 0xE7, 0x71, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x07, 0x80, 0x7C, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF9,
  0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xDF, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03,
  0xF0, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x3E, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0x80,
  0xF9, 0xF8, 0x3F, 0x1F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x7E, 0x07, 0xEF,
  0x80, 0x7E, 0x70, 0x07, 0x04, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x1C, 0x1F, 0x1F,
  0xC7, 0xF8, 0xF8, 0x1C, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE1, 0xFB,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x7E, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE7, 0xF0, 0x17, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x04, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x10, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0x1C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x0F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xF7, 0xC0,
  0xFB, 0xF9, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x81, 0xE7, 0xC0,
  0x03, 0xE0, 0x03, 0xE4, 0x01, 0xF3, 0xF7, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8,
  0x7F, 0xF8, 0x03, 0xE0, 0x00, 0x30, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xC3,
  0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDE, 0x0F, 0xBC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xF0, 0x03, 0x80,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC2, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7D, 0x81, 0xF7, 0xFF, 0xDF, 0xFE, 0xFF, 0xF9, 0xFF,
  0xC0, 0xF8, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F,
  0xBE, 0x1F, 0x9F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0x81, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x07,
  0xCF, 0x83, 0xE7, 0xE1, 0xF1, 0xF8, 0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x0F,
  0xDF, 0x03, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC2, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x7F, 0xBF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF1, 0xE7, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F,
  0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3C, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0x03, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xE7, 0xE1, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3E, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0x3E, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xF7, 0xDF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0x7C, 0x04, 0x7C, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x60, 0x1F, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8,
  0x00, 0x40, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x81,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x78, 0xF9, 0xE7, 0x8F, 0x9E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x39, 0xFD,
  0xE3, 0xBF, 0xDC, 0x3F, 0x9D, 0xC3, 0xF9, 0xDC, 0x3F, 0x9F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x80, 0xF8, 0x07, 0xDF,
  0x03, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFE, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F,
  0x03, 0xFF, 0x80, 0x7C, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x1B, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xF0,
  0x00, 0x1F, 0x01, 0xE7, 0xF8, 0x79, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xBF,
  0xF9, 0xE0, 0xFF, 0x0C, 0x0F, 0x80,
};

const GFXglyph UbuntuSansMono_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 14, 11, 20, 3, -27 },
  { 40, 18, 25, 20, 1, -25 },
  { 97, 18, 32, 20, 1, -28 },
  { 169, 20, 27, 20, 0, -26 },
  { 237, 18, 26, 20, 1, -26 },
  { 296, 6, 12, 20, 7, -27 },
  { 305, 13, 36, 20, 4, -29 },
  { 364, 13, 36, 20, 3, -29 },
  { 423, 16, 16, 20, 2, -25 },
  { 455, 17, 18, 20, 2, -20 },
  { 494, 9, 13, 20, 5, -7 },
  { 509, 11, 5, 20, 5, -13 },
  { 516, 8, 7, 20, 6, -7 },
  { 523, 16, 35, 20, 2, -28 },
  { 593, 18, 27, 20, 1, -26 },
  { 654, 17, 25, 20, 2, -25 },
  { 708, 17, 26, 20, 2, -26 },
  { 764, 16, 27, 20, 2, -26 },
  { 818, 18, 25, 20, 1, -25 },
  { 875, 17, 26, 20, 1, -25 },
  { 931, 16, 26, 20, 2, -25 },
  { 983, 16, 25, 20, 2, -25 },
  { 1033, 17, 27, 20, 2, -26 },
  { 1091, 16, 26, 20, 2, -26 },
  { 1143, 8, 19, 20, 6, -19 },
  { 1162, 9, 25, 20, 5, -19 },
  { 1191, 17, 17, 20, 2, -19 },
  { 1228, 17, 12, 20, 2, -17 },
  { 1254, 17, 17, 20, 2, -19 },
  { 1291, 15, 26, 20, 3, -26 },
  { 1340, 18, 31, 20, 1, -26 },
  { 1410, 20, 25, 20, 0, -25 },
  { 1473, 17, 25, 20, 2, -25 },
  { 1527, 18, 27, 20, 1, -26 },
  { 1588, 17, 25, 20, 2, -25 },
  { 1642, 16, 25, 20, 3, -25 },
  { 1692, 15, 25, 20, 3, -25 },
  { 1739, 18, 27, 20, 1, -26 },
  { 1800, 16, 25, 20, 2, -25 },
  { 1850, 16, 25, 20, 2, -25 },
  { 1900, 16, 26, 20, 2, -25 },
  { 1952, 18, 25, 20, 2, -25 },
  { 2009, 16, 25, 20, 3, -25 },
  { 2059, 18, 25, 20, 1, -25 },
  { 2116, 16, 25, 20, 2, -25 },
  { 2166, 18, 27, 20, 1, -26 },
  { 2227, 17, 25, 20, 2, -25 },
  { 2281, 18, 32, 20, 1, -25 },
  { 2353, 18, 25, 20, 2, -25 },
  { 2410, 17, 27, 20, 2, -26 },
  { 2468, 18, 25, 20, 1, -25 },
  { 2525, 17, 26, 20, 2, -25 },
  { 2581, 19, 25, 20, 1, -25 },
  { 2641, 18, 25, 20, 1, -25 },
  { 2698, 20, 25, 20, 0, -25 },
  { 2761, 19, 25, 20, 1, -25 },
  { 2821, 16, 25, 20, 2, -25 },
  { 2871, 11, 35, 20, 5, -28 },
  { 2920, 16, 35, 20, 2, -28 },
  { 2990, 12, 35, 20, 4, -28 },
  { 3043, 19, 15, 20, 1, -25 },
  { 3079, 20, 5, 20, 0, 2 },
  { 3092, 9, 7, 20, 6, -28 },
  { 3100, 16, 19, 20, 2, -19 },
  { 3138, 17, 28, 20, 2, -28 },
  { 3198, 17, 19, 20, 2, -19 },
  { 3239, 16, 28, 20, 1, -28 },
  { 3295, 18, 19, 20, 1, -19 },
  { 3338, 19, 28, 20, 1, -28 },
  { 3405, 17, 26, 20, 1, -19 },
  { 3461, 15, 28, 20, 3, -28 },
  { 3514, 18, 28, 20, 1, -28 },
  { 3577, 14, 35, 20, 2, -28 },
  { 3639, 17, 28, 20, 3, -28 },
  { 3699, 18, 28, 20, 1, -28 },
  { 3762, 18, 19, 20, 1, -19 },
  { 3805, 15, 19, 20, 3, -19 },
  { 3841, 18, 20, 20, 1, -19 },
  { 3886, 16, 26, 20, 3, -19 },
  { 3938, 17, 26, 20, 1, -19 },
  { 3994, 15, 19, 20, 4, -19 },
  { 4030, 16, 19, 20, 2, -19 },
  { 4068, 18, 25, 20, 1, -25 },
  { 4125, 16, 19, 20, 2, -19 },
  { 4163, 19, 19, 20, 1, -19 },
  { 4209, 20, 19, 20, 0, -19 },
  { 4257, 18, 19, 20, 1, -19 },
  { 4300, 18, 26, 20, 1, -19 },
  { 4359, 15, 19, 20, 3, -19 },
  { 4395, 15, 35, 20, 3, -28 },
  { 4461, 5, 35, 20, 8, -28 },
  { 4483, 15, 35, 20, 3, -28 },
  { 4549, 19, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_Bold36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_BOLD36PT7B_H_
