#ifndef _UBUNTUSANSMONO_BOLD22PT7B_H_
#define _UBUNTUSANSMONO_BOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x70, 0x06, 0xFF, 0x70, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x67, 0x63, 0x0E, 0xE0, 0xCE, 0x0C, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x19, 0xC1, 0x9C, 0x39, 0x8F, 0xFF, 0xFF, 0xF3, 0x38, 0x33, 0x87,
  0x30, 0x73, 0x00, 0x0E, 0x01, 0xC0, 0x7E, 0x3F, 0xE7, 0xFD, 0xE0, 0xBC,
  0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xE0, 0x1E, 0x83, 0xBF, 0xF7,
  0xFC, 0x3F, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x07, 0x83, 0xFC, 0x6C, 0xCC,
  0xCC, 0xCC, 0xD8, 0x7B, 0x07, 0xB0, 0x06, 0x00, 0xFE, 0x0D, 0xF1, 0x9B,
  0x39, 0x33, 0x1B, 0x61, 0xFE, 0x1E, 0x08, 0x07, 0xC1, 0xFC, 0x31, 0x86,
  0x30, 0xCE, 0x1F, 0x81, 0xE0, 0x7C, 0xDF, 0x9B, 0x3F, 0x63, 0xEC, 0x39,
  0xCF, 0xBF, 0xF3, 0xE7, 0xFF, 0xFF, 0xB6, 0x07, 0x0F, 0x1E, 0x3C, 0x38,
  0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38,
  0x3C, 0x1E, 0x0F, 0x02, 0x60, 0xF0, 0x38, 0x1C, 0x1E, 0x0E, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1E, 0x1C, 0x78, 0xF0,
  0x60, 0x0E, 0x03, 0x86, 0xCF, 0xFF, 0xFF, 0xC7, 0x83, 0xF1, 0xEE, 0x33,
  0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x39, 0xE7, 0xCE, 0x18, 0xEF, 0x30, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x0F, 0xC7, 0xF9, 0xCF, 0xE1, 0xF8,
  0x7E, 0x4F, 0xB3, 0xEE, 0xFB, 0x3E, 0x0F, 0x87, 0xE1, 0xDC, 0xF7, 0xF8,
  0xFC, 0x0E, 0x07, 0x87, 0xE3, 0xF8, 0x6E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x7F, 0xDF, 0xF7, 0xFC, 0x0C, 0x1F, 0xCF, 0xF9,
  0x8F, 0x41, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1C, 0x3F, 0xC7, 0xF9, 0x0E, 0x03, 0xC0, 0xE0,
  0x78, 0x7C, 0x1F, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xF0, 0xFF, 0xFB, 0xFC,
  0x03, 0x80, 0xF0, 0x3E, 0x0F, 0xC3, 0xB8, 0x77, 0x1C, 0xE3, 0x1C, 0xE3,
  0x9F, 0xFF, 0xFF, 0x81, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3F, 0x8F, 0xE3,
  0x01, 0xC0, 0x70, 0x1F, 0x07, 0xF1, 0xFE, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0xC3, 0xFF, 0xEF, 0xF0, 0x07, 0x87, 0xE3, 0xE5, 0xE0, 0x70, 0x1F, 0x8F,
  0xFB, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0x73, 0xDF, 0xE3, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x0E, 0x0F, 0xE7, 0xFF, 0xC7, 0xE1,
  0xF8, 0x77, 0x39, 0xFE, 0x3F, 0x1D, 0xFE, 0x1F, 0x83, 0xE1, 0xFC, 0x77,
  0xFC, 0xFE, 0x0C, 0x0F, 0xC7, 0xF9, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7,
  0x7F, 0xCF, 0xF0, 0x1C, 0x0E, 0x07, 0x9F, 0xC7, 0xE1, 0xE0, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x3B, 0xDE, 0xF0, 0x00, 0x07, 0x7B, 0xDE, 0x37,
  0x73, 0x00, 0x00, 0x40, 0x70, 0xFC, 0xFE, 0xFE, 0x3C, 0x0F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x80, 0x3C, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF0, 0x7C, 0xFE, 0xFE,
  0x3C, 0x04, 0x00, 0x18, 0x7F, 0xBF, 0xD0, 0xF0, 0x78, 0x38, 0x3C, 0x3C,
  0x3C, 0x1C, 0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x70, 0x03, 0x01, 0xFC,
  0x3F, 0xE3, 0x06, 0x70, 0x66, 0x3F, 0x67, 0xF6, 0xFF, 0xEE, 0x7E, 0xE7,
  0xEE, 0x7E, 0xE7, 0x6F, 0x76, 0x7F, 0x63, 0xF7, 0x00, 0x38, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0x81, 0x9C, 0x19,
  0xC3, 0x9C, 0x38, 0xC3, 0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xE7, 0x07, 0xE0,
  0x70, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC7, 0x3F, 0xC7, 0xFC,
  0xE3, 0xDC, 0x3B, 0x83, 0xF0, 0xEF, 0x3D, 0xFF, 0xBF, 0xC0, 0x07, 0x03,
  0xFC, 0xFF, 0x3C, 0x2F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xF1, 0x8F, 0xF0, 0xFF, 0xFF, 0x1F, 0xF3, 0x8F,
  0x70, 0xEE, 0x1D, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x71,
  0xEE, 0x79, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0x07, 0x07, 0xF3, 0xFD, 0xE1, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xDE, 0x73, 0xFC, 0x7F, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xCF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x67, 0xBF, 0xE7, 0xF0, 0xE1, 0xFC, 0x7B, 0x8E,
  0x73, 0x8E, 0xF1, 0xDC, 0x3F, 0x07, 0xF0, 0xEE, 0x1C, 0xE3, 0x9E, 0x71,
  0xCE, 0x1D, 0xC3, 0xB8, 0x78, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xE1, 0xDE,
  0x3B, 0xCF, 0x79, 0xED, 0x3D, 0xBD, 0xB7, 0xB6, 0xF6, 0xCE, 0xF9, 0x9F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x38, 0xE1, 0xFC, 0x7F, 0x1F, 0xE7,
  0xF9, 0xFF, 0x7E, 0xDF, 0xBF, 0xE7, 0xF9, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8,
  0x7E, 0x0C, 0x0C, 0x07, 0xE1, 0xFE, 0x38, 0xEE, 0x1D, 0xC3, 0xB8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xEE, 0x1C, 0xE7, 0x9F, 0xE1, 0xF8,
  0xFF, 0x9F, 0xFB, 0x8F, 0x70, 0xFE, 0x0F, 0xC3, 0xF8, 0x77, 0xFE, 0xFF,
  0x9F, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x04, 0x07, 0xE1,
  0xFE, 0x39, 0xEE, 0x1D, 0xC3, 0xB8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0xEE, 0x1C, 0xE7, 0x9F, 0xE1, 0xF8, 0x0C, 0x01, 0xE0, 0x1F, 0x80,
  0xE0, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0xFC,
  0xFF, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0x38, 0x0E, 0x0F,
  0xF7, 0xFB, 0xC2, 0xE0, 0x3C, 0x0F, 0x81, 0xF8, 0x3F, 0x81, 0xF0, 0x1C,
  0x07, 0x01, 0xD8, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0xF0, 0x77,
  0x07, 0x70, 0xE7, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xC3, 0x9C, 0x19, 0xC1,
  0x9C, 0x1D, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x99, 0xF3, 0xB6, 0xF6, 0xDE, 0xDB, 0x7B, 0x4F,
  0x79, 0xEF, 0x1D, 0xC3, 0xB8, 0x70, 0x70, 0xF7, 0x8E, 0x39, 0xC1, 0xDC,
  0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0xC3, 0x9E,
  0x78, 0xE7, 0x0E, 0xF0, 0x70, 0xF0, 0x77, 0x0E, 0x78, 0xE3, 0x8E, 0x39,
  0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0x3C, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0xFF, 0xFC, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x3F, 0xFF, 0xE0, 0x07, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x3D, 0xC3,
  0x8E, 0x70, 0xFF, 0x07, 0x20, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x47,
  0x3E, 0x70, 0x3E, 0x1F, 0xE7, 0xF8, 0x07, 0x01, 0xCF, 0xF7, 0xFF, 0x87,
  0xE1, 0xFC, 0x77, 0xFC, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0x8F, 0xF3, 0xFE, 0xE3, 0xB8, 0xEE, 0x3F, 0x8F, 0xE3, 0xB8, 0xEE, 0x7B,
  0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xF7, 0xFD, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF0, 0x1F, 0x13, 0xFC, 0x7F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xCF, 0x77, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0x1D, 0xFF, 0x3F, 0xC0, 0x1E, 0x0F, 0xE7, 0xFF, 0x87, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x3E, 0x27, 0xFC, 0x7F, 0x07, 0xE3, 0xFC, 0x7F, 0x8E,
  0x03, 0x81, 0xFF, 0xBF, 0xF7, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0x9F, 0xF7, 0xFF, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xFC, 0x07, 0x03, 0xF9,
  0xEF, 0xFB, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE3, 0xFD, 0xFE,
  0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x1C,
  0x07, 0x80, 0xF0, 0x0C, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x90, 0x7E, 0x07, 0xE0, 0x07,
  0x03, 0xC1, 0xC0, 0x60, 0x03, 0xFD, 0xFE, 0xFF, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xDF, 0xFF, 0xE7, 0xE0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x7B, 0x9C, 0xEE, 0x3F, 0x0F,
  0x83, 0xF0, 0xEE, 0x3B, 0xCE, 0x73, 0x8E, 0xE3, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x90, 0x7E, 0x07, 0xE0, 0x7B, 0x9F, 0xFB,
  0xFF, 0x66, 0x7C, 0xCF, 0x99, 0xF3, 0x3E, 0x67, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x70, 0x7C, 0x7F, 0xBF, 0xDC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x70, 0x1E, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x1D, 0xC3,
  0xF8, 0x3F, 0x0F, 0xE1, 0xDE, 0x79, 0xFE, 0x1F, 0x80, 0x7C, 0x3F, 0xCF,
  0xFB, 0x8E, 0xE3, 0xB8, 0xFE, 0x3F, 0x8E, 0xE3, 0xB9, 0xEF, 0xF3, 0xF8,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0x8F, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xFC, 0xFF, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x1F, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x00, 0x1F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1F, 0x83, 0xF8,
  0x1F, 0x01, 0xD8, 0xFF, 0xF9, 0xFC, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0xEF,
  0xFD, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC4,
  0x3F, 0x83, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0xC7, 0x71, 0xDE, 0x77, 0xFC, 0xFF, 0xF0, 0x77, 0x07, 0x70, 0xE7, 0x0E,
  0x38, 0xE3, 0x9C, 0x39, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x70,
  0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x67, 0x67, 0x76, 0xF7, 0x6F, 0x66, 0xF6,
  0x6D, 0xE7, 0x9E, 0x39, 0xE3, 0x8C, 0x70, 0x77, 0x0E, 0x39, 0xC1, 0xDC,
  0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1D, 0xC3, 0x9C, 0x70, 0xEF, 0x0F,
  0x70, 0x77, 0x0E, 0x78, 0xE3, 0x8E, 0x38, 0xC3, 0xDC, 0x1D, 0xC1, 0xDC,
  0x0F, 0x80, 0xF8, 0x07, 0x00, 0x70, 0x07, 0x05, 0xE0, 0x7C, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x8F, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x78, 0x38, 0x1E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03,
  0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0xC1, 0xE1, 0xF1,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0x8F, 0x80, 0x30, 0x4F,
  0x9F, 0xFF, 0xE7, 0xE4, 0x38,
};

const GFXglyph UbuntuSansMono_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 8, 7, 12, 2, -17 },
  { 16, 12, 15, 12, 0, -15 },
  { 39, 11, 19, 12, 1, -17 },
  { 66, 12, 16, 12, 0, -16 },
  { 90, 11, 16, 12, 1, -16 },
  { 112, 3, 8, 12, 5, -17 },
  { 115, 8, 21, 12, 2, -17 },
  { 136, 8, 21, 12, 2, -17 },
  { 157, 10, 9, 12, 1, -15 },
  { 169, 10, 11, 12, 1, -12 },
  { 183, 6, 8, 12, 3, -4 },
  { 189, 7, 3, 12, 3, -8 },
  { 192, 4, 4, 12, 4, -4 },
  { 194, 10, 21, 12, 1, -17 },
  { 221, 10, 16, 12, 1, -16 },
  { 241, 10, 15, 12, 1, -15 },
  { 260, 10, 16, 12, 1, -16 },
  { 280, 10, 16, 12, 1, -16 },
  { 300, 11, 15, 12, 1, -15 },
  { 321, 10, 15, 12, 1, -15 },
  { 340, 10, 15, 12, 1, -15 },
  { 359, 10, 15, 12, 1, -15 },
  { 378, 10, 16, 12, 1, -16 },
  { 398, 10, 16, 12, 1, -16 },
  { 418, 4, 11, 12, 4, -11 },
  { 424, 5, 15, 12, 3, -11 },
  { 434, 10, 11, 12, 1, -12 },
  { 448, 10, 7, 12, 1, -10 },
  { 457, 10, 11, 12, 1, -12 },
  { 471, 9, 16, 12, 2, -16 },
  { 489, 12, 19, 12, 0, -16 },
  { 518, 12, 15, 12, 0, -15 },
  { 541, 11, 15, 12, 1, -15 },
  { 562, 11, 16, 12, 1, -16 },
  { 584, 11, 15, 12, 1, -15 },
  { 605, 9, 15, 12, 2, -15 },
  { 622, 9, 15, 12, 2, -15 },
  { 639, 10, 16, 12, 1, -16 },
  { 659, 10, 15, 12, 1, -15 },
  { 678, 10, 15, 12, 1, -15 },
  { 697, 10, 15, 12, 1, -15 },
  { 716, 11, 15, 12, 1, -15 },
  { 737, 9, 15, 12, 2, -15 },
  { 754, 11, 15, 12, 1, -15 },
  { 775, 10, 15, 12, 1, -15 },
  { 794, 11, 16, 12, 1, -16 },
  { 816, 11, 15, 12, 1, -15 },
  { 837, 11, 20, 12, 1, -16 },
  { 865, 11, 15, 12, 1, -15 },
  { 886, 10, 16, 12, 1, -16 },
  { 906, 11, 15, 12, 1, -15 },
  { 927, 10, 15, 12, 1, -15 },
  { 946, 12, 15, 12, 0, -15 },
  { 969, 11, 15, 12, 1, -15 },
  { 990, 12, 15, 12, 0, -15 },
  { 1013, 12, 15, 12, 0, -15 },
  { 1036, 10, 15, 12, 1, -15 },
  { 1055, 7, 21, 12, 3, -17 },
  { 1074, 10, 21, 12, 1, -17 },
  { 1101, 7, 21, 12, 3, -17 },
  { 1120, 12, 9, 12, 0, -15 },
  { 1134, 12, 3, 12, 0, 1 },
  { 1139, 5, 4, 12, 4, -17 },
  { 1142, 10, 12, 12, 1, -12 },
  { 1157, 10, 17, 12, 2, -17 },
  { 1179, 10, 12, 12, 1, -12 },
  { 1194, 10, 17, 12, 1, -17 },
  { 1216, 10, 12, 12, 1, -12 },
  { 1231, 11, 17, 12, 1, -17 },
  { 1255, 10, 16, 12, 1, -12 },
  { 1275, 9, 17, 12, 2, -17 },
  { 1295, 11, 17, 12, 1, -17 },
  { 1319, 9, 21, 12, 1, -17 },
  { 1343, 10, 17, 12, 2, -17 },
  { 1365, 11, 17, 12, 1, -17 },
  { 1389, 11, 12, 12, 1, -12 },
  { 1406, 9, 12, 12, 2, -12 },
  { 1420, 11, 12, 12, 1, -12 },
  { 1437, 10, 16, 12, 2, -12 },
  { 1457, 10, 16, 12, 1, -12 },
  { 1477, 9, 12, 12, 2, -12 },
  { 1491, 10, 12, 12, 1, -12 },
  { 1506, 11, 15, 12, 1, -15 },
  { 1527, 10, 12, 12, 1, -12 },
  { 1542, 12, 12, 12, 0, -12 },
  { 1560, 12, 12, 12, 0, -12 },
  { 1578, 12, 12, 12, 0, -12 },
  { 1596, 12, 16, 12, 0, -12 },
  { 1620, 9, 12, 12, 2, -12 },
  { 1634, 9, 21, 12, 2, -17 },
  { 1658, 3, 21, 12, 5, -17 },
  { 1666, 9, 21, 12, 2, -17 },
  { 1690, 11, 5, 12, 1, -9 },
};

const GFXfont UbuntuSansMono_Bold22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_BOLD22PT7B_H_
