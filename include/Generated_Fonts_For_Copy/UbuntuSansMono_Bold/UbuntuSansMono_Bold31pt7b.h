#ifndef _UBUNTUSANSMONO_BOLD31PT7B_H_
#define _UBUNTUSANSMONO_BOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x78, 0x00,
  0x00, 0x7B, 0xEF, 0xFE, 0x78, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7B, 0x8F, 0x70, 0xEE, 0x1C, 0x07, 0x1E, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x38, 0xE0, 0x78, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x71,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x81, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFF, 0x3E, 0x02, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7B, 0x81, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFE, 0x07, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3F, 0x01, 0xDF, 0xC1, 0xDC, 0xE1,
  0xCE, 0x70, 0xE7, 0x38, 0xE3, 0x9C, 0xE0, 0xCE, 0x70, 0x7F, 0x70, 0x3F,
  0x70, 0x07, 0x38, 0x00, 0x38, 0x00, 0x39, 0xE0, 0x1D, 0xF8, 0x1C, 0xFE,
  0x1C, 0xE7, 0x0E, 0x73, 0x8E, 0x39, 0xCE, 0x1C, 0xE7, 0x0F, 0x77, 0x03,
  0xF7, 0x80, 0xF8, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F,
  0x1C, 0x3F, 0x1E, 0x7F, 0x9E, 0xFF, 0xDE, 0xF3, 0xFC, 0xE1, 0xFC, 0xE0,
  0xFC, 0xF0, 0x78, 0xF0, 0xFC, 0x7F, 0xFE, 0x7F, 0xDE, 0x1F, 0x9F, 0xFF,
  0xFF, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0x00, 0x40, 0x18, 0x0F, 0x83, 0xF0,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x80,
  0x10, 0x40, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x3F, 0x0F, 0xC0, 0xE0, 0x08, 0x00, 0x07, 0x80, 0x1E, 0x04,
  0x70, 0xBD, 0xCE, 0xFB, 0xFB, 0xFF, 0xF7, 0xFF, 0x83, 0xE0, 0x1F, 0xC0,
  0xF7, 0xC7, 0xCF, 0x0E, 0x38, 0x08, 0x40, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x0C, 0x3E, 0x3F, 0x3F, 0x3F, 0x1F, 0x07, 0x0E, 0xFC, 0x78, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3,
  0xCF, 0x07, 0x9E, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE7, 0x3F, 0xCF, 0x7F,
  0x9E, 0xFF, 0x39, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0,
  0x79, 0xF9, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xC0, 0x3F,
  0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0x7C, 0x11, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC1, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x0F, 0xC0,
  0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE3, 0x07, 0xC4, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE1, 0xFF, 0xC2,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x79, 0xC3, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xEF, 0x03, 0xDE, 0x0F,
  0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0xC1, 0xF9,
  0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x18, 0x0F, 0xE0, 0x7F, 0x87,
  0xFE, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFB, 0x83, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xE1, 0xEF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0x83, 0xCF, 0x07, 0xDE, 0x0F, 0x3C,
  0x1E, 0x7C, 0x3C, 0x7E, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xCF, 0x0F,
  0x9E, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xF0, 0xFB, 0xFF, 0xE3,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xF8,
  0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xCF, 0xDF,
  0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x87,
  0xFE, 0x1F, 0xE0, 0x7F, 0x01, 0xF0, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0xFB, 0xFF, 0xFF, 0xF8, 0x1C, 0x3E, 0x3F, 0x3F,
  0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3E, 0x3F, 0x3F, 0x3F,
  0x3F, 0x0E, 0x1E, 0xFC, 0xF8, 0xF0, 0x00, 0x18, 0x03, 0xF0, 0x3F, 0xC7,
  0xFF, 0x7F, 0xE3, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xFE, 0x1F, 0xF9, 0xFF,
  0x87, 0xFC, 0x07, 0xE0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC7, 0xFF,
  0x1F, 0xFC, 0xFF, 0xF4, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xE1, 0xE7, 0x81, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0x9E, 0x3F, 0x3C, 0x7E, 0x78, 0xFC, 0xE1, 0xF9,
  0xC3, 0xF3, 0xC7, 0xE7, 0x8F, 0xCF, 0xFF, 0x8F, 0xFF, 0x8F, 0xF7, 0x07,
  0xCF, 0x00, 0x0F, 0x00, 0x1F, 0xC6, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xE0,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x80, 0x3B,
  0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC3, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7C, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xFF, 0x80, 0xF8, 0x3F, 0x03, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00,
  0x01, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE0, 0x4F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x39,
  0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0x80, 0x3E, 0x03, 0xFF, 0x0F, 0xFF, 0x3F,
  0xFC, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC3, 0xEF, 0x7F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0x78, 0x1E, 0xF8, 0x3C, 0xFC, 0x79, 0xFF, 0xF1, 0xFF,
  0xE0, 0xFF, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x20, 0x7D, 0xE3,
  0xF7, 0xFF, 0xBF, 0xFC, 0x3F, 0xE0, 0xF0, 0x7D, 0xE1, 0xF3, 0xC3, 0xE7,
  0x8F, 0x8F, 0x1E, 0x1E, 0x7C, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x7C, 0x1E, 0x7C, 0x3C, 0x7C, 0x78, 0xF8,
  0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xF7, 0x81, 0xEF, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78,
  0x3C, 0x78, 0x3C, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x6E, 0xFE,
  0xEE, 0xFE, 0xEE, 0xF6, 0xEE, 0xF7, 0xCE, 0xF7, 0xCE, 0xF3, 0xCE, 0xF3,
  0x8E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFB, 0x8F, 0xEF, 0x3F, 0x9C, 0xFE, 0x7B,
  0xF8, 0xEF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0x78, 0x3E, 0xF0, 0x79, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00,
  0x3F, 0x83, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF,
  0x8F, 0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3,
  0xCF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x78, 0x3E, 0xF0,
  0x7D, 0xF1, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xE0, 0x01, 0xF0,
  0x01, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x60, 0x3E, 0x01, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0x9E, 0x0F, 0x3C, 0x1F, 0x78, 0x3E, 0xF0,
  0x79, 0xE1, 0xF3, 0xDF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3C, 0x78,
  0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xDE,
  0x07, 0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xC7, 0xC0, 0x8F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x80, 0x7D,
  0xC1, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xFC, 0xF9, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0,
  0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF3, 0x8E, 0xF3, 0xCE, 0xF7, 0xCE, 0xF7, 0xCE, 0xF7,
  0xCE, 0xF6, 0xEE, 0xFE, 0xEE, 0xFE, 0x6E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C,
  0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x1C, 0x7C, 0x0F, 0x9E, 0x0F, 0x8F,
  0x87, 0x83, 0xC7, 0x81, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7B,
  0xC0, 0x3C, 0xF0, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x0F, 0x0F, 0x07, 0xCF,
  0x81, 0xEF, 0x80, 0xF8, 0xF8, 0x0F, 0xBE, 0x07, 0x8F, 0x07, 0xC7, 0x83,
  0xC3, 0xE1, 0xE0, 0xF1, 0xF0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x3E, 0xF8, 0x1F, 0xF0, 0x1F, 0x30, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x78, 0x7C, 0xFF, 0x1E, 0x06, 0x1F, 0x83,
  0xFF, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE3, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF8, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0xE0, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xBE, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x03, 0xF0, 0x7F, 0xF3,
  0xFF, 0xDF, 0xFE, 0x7C, 0x0B, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFC, 0x37, 0xFF, 0xCF, 0xFF,
  0x0F, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC1, 0xCF, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF, 0xDF, 0x1F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE,
  0x0F, 0x7E, 0x3D, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xC0, 0x1F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0xE3, 0x8F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xDE,
  0x0F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xEF, 0x00, 0x3C, 0x00, 0xF4,
  0x07, 0xDF, 0xFE, 0x7F, 0xFB, 0xFF, 0xC1, 0xF8, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x70, 0xFF, 0xE7,
  0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7E, 0x60, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF6, 0x1F,
  0xFF, 0xEF, 0xFE, 0xFF, 0xC1, 0xF0, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7D, 0xE1,
  0xF3, 0xC7, 0xC7, 0x8F, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0,
  0xF7, 0xC1, 0xE7, 0x83, 0xCF, 0x87, 0x8F, 0x8F, 0x0F, 0x9E, 0x0F, 0x3C,
  0x1F, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7E, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFE, 0x38, 0xFC, 0x71, 0xF8,
  0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x0F, 0x07, 0xFF, 0x3F, 0xFD, 0xFF,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x78, 0x03, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xFF, 0x07, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x8F,
  0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0x03, 0xFF, 0x8F, 0xFF, 0x3F,
  0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xF3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x3D, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0x78, 0x3D, 0xF1, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x05, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xEF,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC1, 0xFF, 0xDF,
  0xFC, 0xFF, 0xEF, 0x81, 0x7C, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x8C, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7,
  0xC7, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x03,
  0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1F,
  0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x07, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x38,
  0xF7, 0x1E, 0x7B, 0x8F, 0x39, 0xCF, 0x9C, 0xE7, 0xCE, 0x7B, 0xF7, 0x1D,
  0xBB, 0x8F, 0xDD, 0xC7, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78,
  0x38, 0x3C, 0xF8, 0x1E, 0x78, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3E, 0xF8, 0x3C, 0x7C, 0x78, 0x3C, 0x78, 0x3E, 0xF0, 0x1F, 0xF8, 0x1E,
  0xF0, 0x3D, 0xE0, 0xFB, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x3E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x7F, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0x7F, 0x8F, 0x7F, 0xFE, 0xFF, 0xFE, 0xE1, 0xFC, 0x60, 0x78,
};

const GFXglyph UbuntuSansMono_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 21, 17, 6, -21 },
  { 17, 11, 10, 17, 3, -24 },
  { 31, 16, 21, 17, 1, -21 },
  { 73, 15, 27, 17, 1, -24 },
  { 124, 17, 22, 17, 0, -22 },
  { 171, 16, 22, 17, 1, -22 },
  { 215, 5, 11, 17, 6, -24 },
  { 222, 11, 31, 17, 3, -25 },
  { 265, 11, 31, 17, 3, -25 },
  { 308, 14, 13, 17, 2, -21 },
  { 331, 15, 16, 17, 1, -17 },
  { 361, 8, 11, 17, 4, -6 },
  { 372, 9, 4, 17, 4, -11 },
  { 377, 6, 6, 17, 6, -6 },
  { 382, 14, 30, 17, 2, -24 },
  { 435, 15, 22, 17, 1, -22 },
  { 477, 14, 21, 17, 2, -21 },
  { 514, 15, 22, 17, 1, -22 },
  { 556, 15, 22, 17, 1, -22 },
  { 598, 15, 21, 17, 1, -21 },
  { 638, 15, 21, 17, 1, -21 },
  { 678, 14, 22, 17, 2, -22 },
  { 717, 14, 21, 17, 2, -21 },
  { 754, 15, 22, 17, 1, -22 },
  { 796, 14, 22, 17, 2, -22 },
  { 835, 6, 17, 17, 6, -17 },
  { 848, 8, 22, 17, 4, -17 },
  { 870, 14, 15, 17, 2, -16 },
  { 897, 15, 10, 17, 1, -14 },
  { 916, 15, 15, 17, 1, -16 },
  { 945, 13, 22, 17, 2, -22 },
  { 981, 15, 27, 17, 1, -22 },
  { 1032, 17, 21, 17, 0, -21 },
  { 1077, 14, 22, 17, 2, -22 },
  { 1116, 15, 22, 17, 1, -22 },
  { 1158, 14, 22, 17, 2, -22 },
  { 1197, 14, 21, 17, 2, -21 },
  { 1234, 13, 21, 17, 2, -21 },
  { 1269, 15, 22, 17, 1, -22 },
  { 1311, 14, 21, 17, 2, -21 },
  { 1348, 14, 21, 17, 2, -21 },
  { 1385, 14, 21, 17, 1, -21 },
  { 1422, 15, 21, 17, 2, -21 },
  { 1462, 14, 21, 17, 2, -21 },
  { 1499, 16, 21, 17, 1, -21 },
  { 1541, 14, 21, 17, 2, -21 },
  { 1578, 15, 22, 17, 1, -22 },
  { 1620, 14, 22, 17, 2, -22 },
  { 1659, 15, 28, 17, 1, -22 },
  { 1712, 15, 22, 17, 2, -22 },
  { 1754, 15, 22, 17, 1, -22 },
  { 1796, 15, 21, 17, 1, -21 },
  { 1836, 15, 21, 17, 1, -21 },
  { 1876, 17, 21, 17, 0, -21 },
  { 1921, 16, 21, 17, 1, -21 },
  { 1963, 17, 21, 17, 0, -21 },
  { 2008, 17, 21, 17, 0, -21 },
  { 2053, 14, 21, 17, 2, -21 },
  { 2090, 10, 30, 17, 4, -24 },
  { 2128, 14, 30, 17, 2, -24 },
  { 2181, 9, 30, 17, 4, -24 },
  { 2215, 16, 12, 17, 1, -21 },
  { 2239, 17, 4, 17, 0, 2 },
  { 2248, 8, 6, 17, 5, -24 },
  { 2254, 13, 17, 17, 2, -17 },
  { 2282, 14, 24, 17, 2, -24 },
  { 2324, 14, 17, 17, 2, -17 },
  { 2354, 14, 24, 17, 1, -24 },
  { 2396, 15, 17, 17, 1, -17 },
  { 2428, 16, 24, 17, 1, -24 },
  { 2476, 14, 23, 17, 1, -17 },
  { 2517, 13, 24, 17, 2, -24 },
  { 2556, 15, 24, 17, 1, -24 },
  { 2601, 12, 30, 17, 2, -24 },
  { 2646, 15, 24, 17, 2, -24 },
  { 2691, 15, 24, 17, 1, -24 },
  { 2736, 15, 16, 17, 1, -16 },
  { 2766, 13, 17, 17, 2, -17 },
  { 2794, 15, 17, 17, 1, -17 },
  { 2826, 14, 23, 17, 2, -17 },
  { 2867, 14, 23, 17, 1, -17 },
  { 2908, 13, 17, 17, 3, -17 },
  { 2936, 13, 17, 17, 2, -17 },
  { 2964, 15, 21, 17, 1, -21 },
  { 3004, 13, 16, 17, 2, -16 },
  { 3030, 17, 16, 17, 0, -16 },
  { 3064, 17, 16, 17, 0, -16 },
  { 3098, 16, 16, 17, 1, -16 },
  { 3130, 15, 22, 17, 1, -16 },
  { 3172, 13, 16, 17, 2, -16 },
  { 3198, 13, 30, 17, 2, -24 },
  { 3247, 4, 30, 17, 7, -24 },
  { 3262, 13, 30, 17, 2, -24 },
  { 3311, 16, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_Bold31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_BOLD31PT7B_H_
