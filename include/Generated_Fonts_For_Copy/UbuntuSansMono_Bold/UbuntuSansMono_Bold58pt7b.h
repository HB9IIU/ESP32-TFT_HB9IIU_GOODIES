#ifndef _UBUNTUSANSMONO_BOLD58PT7B_H_
#define _UBUNTUSANSMONO_BOLD58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xFC, 0x7F, 0xDF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF1, 0xFC, 0x0E, 0x00, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xBF, 0xC1, 0xFD, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFE, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x83, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0x00, 0x00, 0xFF, 0x3C, 0x00,
  0x1F, 0xF3, 0xFC, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x1F,
  0xF8, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0xFC, 0x7E,
  0x7E, 0x01, 0xF8, 0x7C, 0x7E, 0x01, 0xF8, 0x7C, 0x3E, 0x03, 0xF0, 0x7C,
  0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x0F, 0xC0, 0x7C,
  0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x1F, 0x80, 0x7C, 0x7E, 0x3F, 0x00, 0x7E,
  0x7E, 0x3E, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x1F,
  0xF8, 0xF8, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x0F, 0x8F, 0xF8, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x3F, 0x3F, 0xFE, 0x00,
  0x3E, 0x3F, 0xFE, 0x00, 0x7E, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x3F, 0x01, 0xF8, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x03,
  0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x0F, 0xC0, 0x7E, 0x3F, 0x0F,
  0xC0, 0x3E, 0x3E, 0x1F, 0x80, 0x3F, 0x7E, 0x3F, 0x00, 0x3F, 0xFE, 0x3F,
  0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFC, 0x03, 0xFF, 0x03, 0xF8, 0x3F, 0xFE,
  0x0F, 0xE1, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xF0, 0xFC, 0x3F, 0xDF, 0xE3,
  0xF1, 0xFE, 0x7F, 0xDF, 0xC7, 0xF0, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0xFC,
  0x7E, 0x03, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0x8F, 0xE0, 0x0F, 0xFC, 0x3F,
  0x80, 0x1F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0x87, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0x81,
  0xFC, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x7F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x3E,
  0x1F, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x60, 0x7F, 0x03, 0x0F,
  0x0F, 0xC1, 0xE1, 0xF8, 0xF8, 0xFC, 0x7F, 0x9F, 0x7F, 0xCF, 0xFF, 0xDF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xC3, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x3F,
  0x01, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x03, 0xFC, 0x7F,
  0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF3, 0xFE, 0x1F,
  0xC0, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0xFF, 0x0F, 0x07, 0xFF, 0xF1, 0xF8, 0x7F, 0xFF, 0x1F, 0xC7, 0xFF, 0xF1,
  0xFC, 0x7F, 0xFF, 0x1F, 0xC7, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF, 0x1F, 0x87,
  0xFF, 0xF0, 0xF8, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x03,
  0xF1, 0xFE, 0x00, 0x78, 0x3F, 0xC0, 0x04, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F,
  0xFC, 0x3C, 0x00, 0xFF, 0x83, 0x00, 0x0F, 0xF0, 0x40, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xFC, 0x18, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xD8, 0x00, 0x3F, 0xF7, 0xC0, 0x3F, 0xF9, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F,
  0xC0, 0x0F, 0xE3, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x81, 0xFF, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x20,
  0x00, 0x7F, 0xC7, 0x80, 0x3F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x9F,
  0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xC3,
  0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0x81, 0xFF,
  0xEF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0xF8, 0x3F,
  0xC1, 0xFF, 0xC3, 0xF8, 0x07, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xE0,
  0x3F, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xFC,
  0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF3, 0xFE,
  0x1F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0x7F, 0xF3, 0xFE, 0x1F, 0xC0, 0x60, 0x03, 0xC0, 0x3F,
  0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC1,
  0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x3C, 0x03, 0xFF, 0x30, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x07, 0xFF, 0xBF, 0x01, 0xFF, 0xFD,
  0xF8, 0x1F, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xFB, 0xF0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xC3, 0xFC,
  0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x87, 0xF0, 0x3F,
  0xFC, 0x3F, 0x81, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8,
  0x7F, 0x03, 0xFF, 0xC3, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0, 0xFF,
  0x07, 0xEF, 0x83, 0xFC, 0x3F, 0x7E, 0x1F, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF,
  0xDF, 0x83, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0x9F,
  0x80, 0xFF, 0xFC, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x60, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F,
  0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xFB, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x1E,
  0x1F, 0xF0, 0x00, 0x63, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x06, 0x1F, 0xFE, 0x03, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0x7F, 0xF8, 0xFF, 0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xFC, 0xFF, 0x00,
  0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x1F, 0xF8, 0xFF, 0xBF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x3E, 0x3F, 0xF0, 0x00,
  0x43, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF3, 0xFF, 0x00, 0xFF, 0x1F, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x60, 0x01,
  0xFF, 0x3C, 0x01, 0xFF, 0x9F, 0x83, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01,
  0xFF, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFD, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFD, 0xFF, 0x80, 0x1F, 0xE7, 0xFE, 0x00, 0xFF, 0x1F, 0xF0,
  0x07, 0xF8, 0xFF, 0xC0, 0x3F, 0xC3, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xFB,
  0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xF7, 0xE7, 0xEF, 0x0F, 0xBF, 0x3F,
  0x7C, 0xFD, 0xF9, 0xFB, 0xE7, 0xCF, 0xCF, 0xDF, 0x3E, 0x7E, 0x7E, 0x7F,
  0xF3, 0xF7, 0xF3, 0xFF, 0x1F, 0xBF, 0x9F, 0xF8, 0xFD, 0xFC, 0xFF, 0xC7,
  0xEF, 0xE3, 0xFE, 0x3F, 0x7F, 0x1F, 0xE1, 0xFB, 0xF8, 0xFF, 0x0F, 0xDF,
  0xC3, 0xF8, 0x7E, 0xFE, 0x1F, 0x83, 0xF7, 0xF0, 0xFC, 0x1F, 0xBF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xEF,
  0xE1, 0xFF, 0xFB, 0xF8, 0x7F, 0xFE, 0x7F, 0x1F, 0xFF, 0x9F, 0xC7, 0xFF,
  0xE3, 0xF1, 0xFF, 0xF8, 0x7E, 0x7F, 0xFE, 0x1F, 0x9F, 0xFF, 0x83, 0xF7,
  0xFF, 0xE0, 0xFD, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF,
  0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE,
  0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0xFF, 0x00,
  0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0,
  0x7F, 0xE1, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE, 0x00,
  0x70, 0x7F, 0x80, 0x02, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x20, 0x00,
  0x3F, 0xEE, 0x00, 0x07, 0xF9, 0xF8, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x7F,
  0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x7E, 0x0F, 0xDF, 0xC3, 0xF8,
  0x7E, 0xFE, 0x1F, 0xC3, 0xF7, 0xF1, 0xFE, 0x1F, 0xBF, 0x8F, 0xF0, 0xFD,
  0xFC, 0x7F, 0xC7, 0xEF, 0xE7, 0xFE, 0x3F, 0x7F, 0x3F, 0xF1, 0xFB, 0xF9,
  0xFF, 0xCF, 0xDF, 0xCF, 0xBE, 0x7E, 0x7C, 0xFD, 0xF3, 0xF3, 0xE7, 0xCF,
  0x9F, 0x9F, 0x3E, 0x3E, 0xFC, 0xFB, 0xF1, 0xF7, 0xE7, 0xDF, 0x0F, 0xBF,
  0x3E, 0xF8, 0x3F, 0xF9, 0xF7, 0xC1, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x70, 0x03, 0xE0,
  0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0x07, 0xF8, 0x07,
  0xE0, 0x07, 0x00, 0x04, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFC, 0x7F, 0xF8, 0x40, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xBF, 0xC1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF,
  0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xC0, 0x04, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x03,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF3,
  0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xF8, 0x1F, 0xF7,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F,
  0xDF, 0xF0, 0x0F, 0xF3, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x04, 0x3F, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1E, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xE0, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFD, 0xFF, 0x80,
  0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF8, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC8, 0x00,
  0x1F, 0xF3, 0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F,
  0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x01, 0x00, 0x7F, 0xF0, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x9C, 0x01, 0xFF,
  0x3F, 0x07, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xF7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x01, 0x00, 0x7F, 0xF0, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x3E, 0x07, 0xFF, 0xEF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x87, 0xF0, 0xFE, 0xFC,
  0x3F, 0x83, 0xF7, 0xE0, 0xFC, 0x1F, 0xBF, 0x07, 0xE0, 0xFF, 0xF8, 0x3F,
  0x07, 0xFF, 0xC1, 0xF8, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF0, 0x7E, 0x0F,
  0xFF, 0x83, 0xF0, 0x7F, 0xFC, 0x1F, 0x83, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF,
  0x07, 0xE0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFE, 0x03, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF,
  0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFC, 0x07, 0xFE, 0xFF, 0x00,
  0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF,
  0x03, 0xFC, 0x1E, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0xF0, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x70, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x02, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0x9F, 0xE1, 0xFF, 0x00, 0x18, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF4, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x10, 0x07,
  0xFE, 0x0F, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xE0, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x07, 0xF0, 0x7E,
  0xFE, 0x0F, 0xE0, 0xFC, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F, 0x87, 0xF3,
  0xF0, 0xFF, 0x0F, 0xE7, 0xE1, 0xFF, 0x1F, 0xCF, 0xC3, 0xFE, 0x3F, 0x1F,
  0x87, 0xFC, 0x7E, 0x3F, 0x1F, 0xF8, 0xFC, 0x7E, 0x3F, 0xF9, 0xF8, 0x7E,
  0x7F, 0xF3, 0xF0, 0xFD, 0xFB, 0xE7, 0xE1, 0xFB, 0xE7, 0xCF, 0x83, 0xF7,
  0xCF, 0xDF, 0x07, 0xEF, 0x8F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x02, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x60, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xFE,
  0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xF1, 0xFC, 0x03, 0xFF,
  0xC0, 0xF8, 0x01, 0xFF, 0x00, 0x20, 0x00, 0xF8, 0x00,
};

const GFXglyph UbuntuSansMono_Bold58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 11, 41, 32, 11, -40 },
  { 58, 21, 18, 32, 6, -44 },
  { 106, 30, 40, 32, 1, -40 },
  { 256, 28, 51, 32, 2, -45 },
  { 435, 32, 42, 32, 0, -41 },
  { 603, 30, 42, 32, 1, -41 },
  { 761, 9, 19, 32, 12, -44 },
  { 783, 21, 57, 32, 6, -46 },
  { 933, 21, 57, 32, 6, -46 },
  { 1083, 27, 25, 32, 3, -40 },
  { 1168, 27, 30, 32, 3, -32 },
  { 1270, 15, 21, 32, 8, -11 },
  { 1310, 18, 8, 32, 7, -21 },
  { 1328, 12, 12, 32, 10, -11 },
  { 1346, 26, 56, 32, 3, -45 },
  { 1528, 28, 42, 32, 2, -41 },
  { 1675, 27, 40, 32, 3, -40 },
  { 1810, 27, 41, 32, 3, -41 },
  { 1949, 26, 42, 32, 3, -41 },
  { 2086, 29, 40, 32, 2, -40 },
  { 2231, 27, 41, 32, 2, -40 },
  { 2370, 27, 41, 32, 3, -40 },
  { 2509, 26, 40, 32, 3, -40 },
  { 2639, 28, 42, 32, 2, -41 },
  { 2786, 27, 41, 32, 3, -41 },
  { 2925, 12, 32, 32, 10, -31 },
  { 2973, 14, 41, 32, 8, -31 },
  { 3045, 27, 28, 32, 3, -31 },
  { 3140, 27, 20, 32, 3, -27 },
  { 3208, 27, 28, 32, 3, -31 },
  { 3303, 24, 42, 32, 4, -41 },
  { 3429, 29, 50, 32, 1, -41 },
  { 3611, 31, 40, 32, 1, -40 },
  { 3766, 27, 42, 32, 3, -41 },
  { 3908, 28, 42, 32, 2, -41 },
  { 4055, 28, 42, 32, 3, -41 },
  { 4202, 26, 40, 32, 4, -40 },
  { 4332, 25, 40, 32, 4, -40 },
  { 4457, 28, 42, 32, 2, -41 },
  { 4604, 27, 40, 32, 3, -40 },
  { 4739, 26, 40, 32, 3, -40 },
  { 4869, 25, 41, 32, 3, -40 },
  { 4998, 29, 40, 32, 3, -40 },
  { 5143, 25, 40, 32, 5, -40 },
  { 5268, 29, 40, 32, 2, -40 },
  { 5413, 26, 40, 32, 3, -40 },
  { 5543, 29, 42, 32, 2, -41 },
  { 5696, 28, 41, 32, 3, -41 },
  { 5840, 29, 52, 32, 2, -41 },
  { 6029, 29, 41, 32, 3, -41 },
  { 6178, 27, 42, 32, 3, -41 },
  { 6320, 29, 40, 32, 2, -40 },
  { 6465, 27, 41, 32, 3, -40 },
  { 6604, 31, 40, 32, 1, -40 },
  { 6759, 29, 40, 32, 2, -40 },
  { 6904, 31, 40, 32, 1, -40 },
  { 7059, 31, 40, 32, 1, -40 },
  { 7214, 26, 40, 32, 3, -40 },
  { 7344, 18, 56, 32, 7, -45 },
  { 7470, 27, 56, 32, 3, -45 },
  { 7659, 18, 56, 32, 7, -45 },
  { 7785, 31, 23, 32, 1, -40 },
  { 7875, 31, 7, 32, 1, 4 },
  { 7903, 14, 12, 32, 10, -45 },
  { 7924, 26, 32, 32, 3, -31 },
  { 8028, 27, 46, 32, 4, -45 },
  { 8184, 27, 32, 32, 3, -31 },
  { 8292, 26, 46, 32, 2, -45 },
  { 8442, 28, 32, 32, 2, -31 },
  { 8554, 30, 45, 32, 2, -45 },
  { 8723, 26, 42, 32, 2, -31 },
  { 8860, 25, 45, 32, 4, -45 },
  { 9001, 28, 46, 32, 2, -45 },
  { 9162, 23, 56, 32, 3, -45 },
  { 9323, 28, 45, 32, 4, -45 },
  { 9481, 28, 46, 32, 2, -45 },
  { 9642, 29, 31, 32, 2, -31 },
  { 9755, 25, 31, 32, 4, -31 },
  { 9852, 29, 32, 32, 2, -31 },
  { 9968, 26, 42, 32, 4, -31 },
  { 10105, 26, 42, 32, 2, -31 },
  { 10242, 24, 31, 32, 6, -31 },
  { 10335, 26, 32, 32, 3, -31 },
  { 10439, 29, 41, 32, 2, -40 },
  { 10588, 24, 32, 32, 4, -31 },
  { 10684, 31, 31, 32, 1, -31 },
  { 10805, 31, 31, 32, 1, -31 },
  { 10926, 30, 31, 32, 1, -31 },
  { 11043, 30, 42, 32, 1, -31 },
  { 11201, 24, 31, 32, 4, -31 },
  { 11294, 24, 56, 32, 4, -45 },
  { 11462, 8, 56, 32, 12, -45 },
  { 11518, 24, 56, 32, 4, -45 },
  { 11686, 31, 12, 32, 1, -23 },
};

const GFXfont UbuntuSansMono_Bold58pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold58pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold58pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _UBUNTUSANSMONO_BOLD58PT7B_H_
