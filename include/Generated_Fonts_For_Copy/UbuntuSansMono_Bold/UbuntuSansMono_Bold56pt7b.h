#ifndef _UBUNTUSANSMONO_BOLD56PT7B_H_
#define _UBUNTUSANSMONO_BOLD56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0F, 0xE3, 0xFE, 0x7F, 0xEF, 0xFF,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x70, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFD,
  0xFE, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1,
  0xFC, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xC7,
  0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE,
  0x00, 0xF8, 0x7F, 0x80, 0x02, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE4, 0x00, 0x03,
  0xFC, 0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x3F, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x7F, 0xE0, 0x01, 0xF1, 0xFF, 0xC0, 0x07, 0xE3, 0xFF, 0xC0, 0x1F, 0x8F,
  0xDF, 0x80, 0x3E, 0x1F, 0x1F, 0x00, 0xFC, 0x3E, 0x3F, 0x03, 0xF0, 0x7C,
  0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x1F, 0x81, 0xF0, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0xF8, 0x07, 0xC7, 0xE3, 0xF0, 0x0F, 0x8F, 0x87, 0xC0, 0x1F, 0xBF,
  0x1F, 0x80, 0x3F, 0xFE, 0x7E, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x3F, 0xF3,
  0xF0, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x0F, 0xCF,
  0xFC, 0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x7C, 0x7F, 0xF8, 0x01, 0xF9, 0xFB,
  0xF0, 0x07, 0xE3, 0xE3, 0xE0, 0x0F, 0x87, 0xC7, 0xE0, 0x3F, 0x0F, 0x87,
  0xC0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x07, 0xE0, 0x7C, 0x3E,
  0x1F, 0x80, 0xF8, 0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0xFC, 0x03, 0xF7, 0xE3,
  0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0x1F, 0x80, 0x07, 0xFE, 0x7E,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x9F,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F, 0x07,
  0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0x9F,
  0xE7, 0xE3, 0xF8, 0xFF, 0xBF, 0x1F, 0xC3, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF,
  0x8F, 0xE0, 0x3F, 0xFC, 0x7F, 0x00, 0xFF, 0xE3, 0xF8, 0x03, 0xFE, 0x1F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xFE, 0x1F, 0xF9,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF3,
  0xF8, 0x1F, 0xFF, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x00, 0x10, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x0F,
  0xC0, 0x43, 0xC3, 0xF0, 0xF1, 0xF8, 0xF8, 0xFC, 0x7F, 0xBE, 0x7F, 0x9F,
  0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7C, 0x0F, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x07, 0x80,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0x0F, 0xFF, 0xC3, 0xF1,
  0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE3, 0xF8, 0xFF, 0xFC,
  0x7F, 0x1F, 0xFF, 0x87, 0xC3, 0xFF, 0xF0, 0x70, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0x3F,
  0xC0, 0x0E, 0x0F, 0xF0, 0x02, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFE, 0x0F, 0xFC, 0x3C, 0x01, 0xFF, 0x06, 0x00, 0x3F, 0xC1, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7C, 0x07,
  0xFC, 0x18, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x40, 0x00, 0xFF, 0xBC, 0x01, 0xFF, 0x9F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFD, 0x00, 0x01, 0xFE, 0x78, 0x01,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF,
  0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0xE1, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0x03, 0xFE, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x0F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x3F, 0xFC, 0x3F, 0x81, 0xFF,
  0xCF, 0xF0, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xE3, 0xF8, 0x0C, 0x00, 0x07,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3,
  0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xF3, 0xFF, 0x87, 0xFE,
  0x1F, 0xE0, 0x7F, 0x01, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9E, 0x03, 0xFF, 0x30, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x3E, 0x00, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0xF7,
  0xE0, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0xC3, 0xF0, 0x3F,
  0xFC, 0x7F, 0x03, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xC7,
  0xF0, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x3F, 0x83,
  0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x3F, 0xC3, 0xF7, 0xC3, 0xFF, 0x7F, 0x7C,
  0x1F, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F,
  0xFF, 0x3F, 0x01, 0xFF, 0xF3, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x60, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFE, 0xFF, 0xF3, 0xFC, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01,
  0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC,
  0x3F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F,
  0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3E, 0x1F,
  0xF0, 0x00, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x43,
  0xFF, 0x80, 0x78, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF7, 0xFF, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x0F,
  0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7,
  0xF8, 0x1F, 0xF8, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3E, 0x3F, 0xF0, 0x00, 0x87,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xFF, 0x03, 0xFC,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x80, 0x03, 0xFC, 0x70, 0x03,
  0xFE, 0x7E, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF,
  0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xEF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xBC, 0x1F,
  0xF8, 0x7D, 0xF1, 0xF7, 0xE3, 0xEF, 0x8F, 0xBF, 0x1F, 0x3C, 0x7D, 0xF8,
  0xF9, 0xF7, 0xEF, 0xCF, 0xCF, 0xBE, 0x7E, 0x7E, 0x7D, 0xF3, 0xF3, 0xF1,
  0xFF, 0x9F, 0x9F, 0x8F, 0xF8, 0xFC, 0xFC, 0x7F, 0xC7, 0xE7, 0xE3, 0xFE,
  0x3F, 0x3F, 0x0F, 0xF1, 0xF9, 0xF8, 0x7F, 0x0F, 0xCF, 0xC3, 0xF8, 0x7E,
  0x7E, 0x0F, 0xC3, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFB, 0xF0, 0xFF, 0xFD, 0xF8, 0x7F, 0xFE, 0x7E, 0x3F,
  0xFF, 0x3F, 0x1F, 0xFF, 0x8F, 0xCF, 0xFF, 0xC7, 0xE7, 0xFF, 0xE1, 0xFB,
  0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC7,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFB, 0xFF, 0xE7, 0xF8, 0x07, 0xFE,
  0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x07,
  0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F,
  0xF8, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0x00, 0x70, 0xFF, 0x80, 0x04, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x70, 0x00, 0x7F,
  0xDF, 0x00, 0x3F, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x3F, 0x0F, 0xCF, 0xC3, 0xF8, 0x7E,
  0x7E, 0x1F, 0xC3, 0xF3, 0xF0, 0xFF, 0x1F, 0x9F, 0x87, 0xF8, 0xFC, 0xFC,
  0x7F, 0xC7, 0xE7, 0xE3, 0xFE, 0x3F, 0x3F, 0x1F, 0xF9, 0xF9, 0xF9, 0xFF,
  0xCF, 0xCF, 0xCF, 0xBE, 0x7E, 0x7E, 0x7C, 0xFB, 0xF1, 0xF3, 0xE7, 0xDF,
  0x8F, 0xBE, 0x3E, 0xFC, 0x7D, 0xF0, 0xF7, 0xE3, 0xEF, 0x87, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3,
  0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x1F,
  0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFF, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x07,
  0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x01, 0xE0,
  0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE1, 0xFF, 0x03, 0xF0,
  0x07, 0x00, 0x08, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7C, 0x1F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F,
  0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF7,
  0xF8, 0x1F, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xC0, 0x04, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x06, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x03, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x07, 0xFB, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x21, 0xFF, 0xC0, 0x3C,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0xF4, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFE,
  0x07, 0xC0, 0x3F, 0xE0, 0x02, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xFD, 0xFF,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xFC, 0x7F, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x20, 0x00, 0xFF, 0x8F,
  0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x20, 0x03, 0xFC, 0xE0,
  0x1F, 0xF3, 0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFE, 0x00,
  0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87,
  0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x01,
  0xFF, 0x7F, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x7C, 0x0F, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xC3,
  0xF0, 0xFE, 0xFC, 0x3F, 0x87, 0xEF, 0xC3, 0xF8, 0x7E, 0xFC, 0x3F, 0x87,
  0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC,
  0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8,
  0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x0F,
  0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFE, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFC, 0x7C, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x3F,
  0xDF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFF, 0x83,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF, 0xF0, 0x03, 0x83, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xF0, 0x7E, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xF0, 0xFF, 0x00, 0x08, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFD, 0xC0, 0x01, 0xFE, 0xFC, 0x01, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x1F, 0xF8,
  0x1E, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFB, 0xF8, 0x3F, 0x07, 0xEF, 0xE0, 0xFC, 0x1F, 0xBF, 0x83, 0xF0, 0x7E,
  0x7E, 0x1F, 0xC1, 0xF9, 0xF8, 0x7F, 0x87, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F,
  0x87, 0xF8, 0xFC, 0x7E, 0x3F, 0xE3, 0xF1, 0xF8, 0xFF, 0x8F, 0xC7, 0xE3,
  0xFF, 0x3F, 0x1F, 0x8F, 0xFC, 0xFC, 0x3E, 0x7D, 0xF3, 0xF0, 0xF9, 0xF7,
  0xEF, 0x83, 0xF7, 0xCF, 0xBE, 0x0F, 0xFE, 0x3E, 0xF8, 0x3F, 0xF8, 0xFB,
  0xE0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x80, 0x0F, 0xF9, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F,
  0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x20, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0xC0, 0x3F, 0xF8, 0x07, 0xF1, 0xFF, 0xF0, 0x1F, 0x87,
  0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xC3, 0xF8, 0x07,
  0xFE, 0x00, 0xC0, 0x07, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Bold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 40, 31, 10, -39 },
  { 56, 21, 18, 31, 5, -43 },
  { 104, 29, 39, 31, 1, -39 },
  { 246, 27, 49, 31, 2, -43 },
  { 412, 31, 41, 31, 0, -40 },
  { 571, 29, 41, 31, 1, -40 },
  { 720, 8, 19, 31, 12, -43 },
  { 739, 20, 56, 31, 6, -45 },
  { 879, 21, 56, 31, 5, -45 },
  { 1026, 26, 25, 31, 3, -39 },
  { 1108, 26, 29, 31, 3, -31 },
  { 1203, 14, 20, 31, 8, -10 },
  { 1238, 17, 8, 31, 7, -20 },
  { 1255, 11, 11, 31, 10, -10 },
  { 1271, 25, 54, 31, 3, -44 },
  { 1440, 27, 41, 31, 2, -40 },
  { 1579, 26, 39, 31, 3, -39 },
  { 1706, 26, 40, 31, 3, -40 },
  { 1836, 25, 41, 31, 3, -40 },
  { 1965, 28, 39, 31, 2, -39 },
  { 2102, 26, 40, 31, 2, -39 },
  { 2232, 26, 40, 31, 3, -39 },
  { 2362, 25, 39, 31, 3, -39 },
  { 2484, 27, 41, 31, 2, -40 },
  { 2623, 26, 40, 31, 3, -40 },
  { 2753, 11, 30, 31, 10, -29 },
  { 2795, 14, 39, 31, 7, -29 },
  { 2864, 26, 27, 31, 3, -30 },
  { 2952, 26, 19, 31, 3, -26 },
  { 3014, 26, 28, 31, 3, -30 },
  { 3105, 23, 41, 31, 4, -40 },
  { 3223, 28, 48, 31, 1, -40 },
  { 3391, 30, 39, 31, 1, -39 },
  { 3538, 26, 40, 31, 3, -39 },
  { 3668, 27, 41, 31, 2, -40 },
  { 3807, 27, 40, 31, 3, -39 },
  { 3942, 25, 39, 31, 4, -39 },
  { 4064, 24, 39, 31, 4, -39 },
  { 4181, 27, 41, 31, 2, -40 },
  { 4320, 26, 39, 31, 3, -39 },
  { 4447, 25, 39, 31, 3, -39 },
  { 4569, 25, 40, 31, 3, -39 },
  { 4694, 28, 39, 31, 3, -39 },
  { 4831, 25, 39, 31, 4, -39 },
  { 4953, 29, 39, 31, 1, -39 },
  { 5095, 25, 39, 31, 3, -39 },
  { 5217, 28, 41, 31, 2, -40 },
  { 5361, 27, 39, 31, 3, -39 },
  { 5493, 28, 51, 31, 2, -40 },
  { 5672, 28, 39, 31, 3, -39 },
  { 5809, 26, 41, 31, 3, -40 },
  { 5943, 28, 39, 31, 2, -39 },
  { 6080, 27, 40, 31, 2, -39 },
  { 6215, 30, 39, 31, 1, -39 },
  { 6362, 29, 39, 31, 1, -39 },
  { 6504, 30, 39, 31, 1, -39 },
  { 6651, 30, 39, 31, 1, -39 },
  { 6798, 25, 39, 31, 3, -39 },
  { 6920, 17, 54, 31, 7, -44 },
  { 7035, 26, 54, 31, 3, -44 },
  { 7211, 17, 54, 31, 7, -44 },
  { 7326, 30, 23, 31, 1, -39 },
  { 7413, 31, 6, 31, 0, 4 },
  { 7437, 13, 11, 31, 10, -43 },
  { 7455, 25, 31, 31, 3, -30 },
  { 7552, 25, 45, 31, 4, -44 },
  { 7693, 26, 31, 31, 3, -30 },
  { 7794, 25, 45, 31, 2, -44 },
  { 7935, 27, 31, 31, 2, -30 },
  { 8040, 29, 43, 31, 2, -43 },
  { 8196, 26, 41, 31, 2, -30 },
  { 8330, 24, 44, 31, 4, -44 },
  { 8462, 27, 44, 31, 2, -43 },
  { 8611, 22, 54, 31, 3, -43 },
  { 8760, 27, 44, 31, 4, -44 },
  { 8909, 27, 44, 31, 2, -43 },
  { 9058, 28, 30, 31, 2, -30 },
  { 9163, 24, 30, 31, 4, -30 },
  { 9253, 28, 31, 31, 2, -30 },
  { 9362, 25, 40, 31, 4, -30 },
  { 9487, 26, 40, 31, 2, -30 },
  { 9617, 23, 30, 31, 6, -30 },
  { 9704, 25, 31, 31, 3, -30 },
  { 9801, 28, 39, 31, 2, -38 },
  { 9938, 24, 30, 31, 4, -29 },
  { 10028, 29, 29, 31, 1, -29 },
  { 10134, 30, 29, 31, 1, -29 },
  { 10243, 29, 29, 31, 1, -29 },
  { 10349, 29, 40, 31, 1, -29 },
  { 10494, 23, 29, 31, 4, -29 },
  { 10578, 23, 54, 31, 4, -44 },
  { 10734, 8, 54, 31, 12, -44 },
  { 10788, 23, 54, 31, 4, -44 },
  { 10944, 30, 11, 31, 1, -22 },
};

const GFXfont UbuntuSansMono_Bold56pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold56pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold56pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _UBUNTUSANSMONO_BOLD56PT7B_H_
