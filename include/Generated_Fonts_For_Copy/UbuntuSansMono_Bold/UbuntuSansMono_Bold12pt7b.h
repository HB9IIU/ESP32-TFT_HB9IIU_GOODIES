#ifndef _UBUNTUSANSMONO_BOLD12PT7B_H_
#define _UBUNTUSANSMONO_BOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x4F, 0xDE, 0xF4, 0xA0, 0x34, 0xBF, 0xCA, 0x6B, 0xF5, 0x96,
  0x11, 0xF6, 0x58, 0x78, 0x70, 0x5F, 0xF8, 0x40, 0x43, 0xCA, 0xB5, 0x45,
  0x07, 0x8B, 0xA7, 0xCC, 0x11, 0xE4, 0x9E, 0x35, 0xDD, 0xF3, 0x74, 0xD5,
  0x11, 0xD8, 0xC4, 0x63, 0x18, 0x43, 0x0C, 0x30, 0x8C, 0x63, 0x11, 0x11,
  0x13, 0x6C, 0x27, 0xDD, 0xA5, 0x80, 0x21, 0x09, 0xF2, 0x10, 0xFD, 0x40,
  0xE0, 0xF8, 0x18, 0x8C, 0x63, 0x31, 0x8C, 0x46, 0x30, 0x11, 0xE4, 0xD1,
  0xD7, 0x54, 0x5B, 0x38, 0x77, 0xAC, 0x63, 0x18, 0xDF, 0x27, 0xA6, 0x33,
  0x33, 0x18, 0xF8, 0x27, 0x86, 0x37, 0x0C, 0x73, 0xF0, 0x18, 0xE2, 0x9A,
  0x4B, 0xF0, 0x82, 0x7D, 0x86, 0x1E, 0x0C, 0x38, 0xFE, 0x3F, 0x31, 0xF9,
  0xCF, 0x6E, 0xF8, 0xCC, 0x62, 0x31, 0x8C, 0x27, 0xE7, 0xBF, 0x7E, 0x33,
  0xF8, 0x27, 0xA7, 0x1D, 0xBC, 0x6E, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x0D,
  0xD4, 0x1F, 0xB1, 0xE3, 0x80, 0xFF, 0xC1, 0xF0, 0xC3, 0x86, 0xFC, 0x00,
  0x27, 0xC6, 0x33, 0x30, 0x0C, 0x60, 0x11, 0xF4, 0x77, 0xF6, 0xDB, 0x77,
  0x49, 0x91, 0xC0, 0x38, 0x70, 0xA3, 0x46, 0xCF, 0x91, 0x63, 0xFC, 0xE7,
  0xE9, 0xC6, 0x7E, 0x08, 0xF6, 0x30, 0xC3, 0x04, 0x19, 0x3C, 0xF4, 0xE3,
  0x18, 0xCE, 0x7E, 0xFE, 0x31, 0xEC, 0x63, 0x1F, 0xFE, 0x31, 0xFC, 0x63,
  0x18, 0x11, 0xF6, 0x30, 0xC3, 0x14, 0x59, 0x3C, 0x9C, 0xE7, 0xF9, 0xCE,
  0x73, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0xF8, 0xC6, 0x31, 0x8E, 0x7E, 0x9A,
  0xCB, 0x38, 0xB2, 0xC9, 0xA3, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0x4D, 0xB6,
  0xDD, 0xD7, 0x1C, 0x71, 0x8E, 0x7B, 0x5A, 0xCE, 0x71, 0x11, 0xF4, 0xF1,
  0xC7, 0x14, 0x5B, 0x38, 0xFC, 0xE3, 0x3F, 0x42, 0x10, 0x79, 0x3C, 0x71,
  0xC5, 0x16, 0xDE, 0x10, 0x70, 0xF2, 0x69, 0xAE, 0xF2, 0x49, 0xA3, 0x27,
  0xE1, 0x8F, 0x1C, 0x33, 0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x8C,
  0x63, 0x18, 0xC7, 0x7E, 0xC6, 0x89, 0x33, 0x66, 0x85, 0x0E, 0x18, 0xC7,
  0x1C, 0x75, 0x7D, 0xB6, 0xD3, 0xCC, 0xD0, 0xE1, 0x83, 0x8D, 0x1B, 0x63,
  0xC6, 0xD9, 0xA1, 0xC3, 0x02, 0x04, 0x08, 0xF8, 0xCC, 0x46, 0x63, 0x1F,
  0xF2, 0x49, 0x24, 0x93, 0x80, 0xC6, 0x10, 0xC6, 0x10, 0xC6, 0x10, 0xC6,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x38, 0x71, 0xB6, 0x74, 0x40, 0xFE,
  0xCC, 0xF8, 0xFF, 0x39, 0xFC, 0x84, 0x21, 0xF9, 0xC6, 0x33, 0xF0, 0xFE,
  0x21, 0x0C, 0xBC, 0x0C, 0x30, 0xDF, 0x4F, 0x3C, 0xDB, 0x7C, 0x7D, 0x3F,
  0xF0, 0x64, 0xF0, 0x3E, 0x60, 0xC7, 0xE3, 0x06, 0x0C, 0x18, 0x30, 0x7D,
  0x3C, 0xD3, 0x7C, 0xF8, 0xDE, 0xC6, 0x31, 0xFD, 0xEF, 0x7B, 0xD8, 0x30,
  0xC0, 0x3C, 0x30, 0xC3, 0x0D, 0x1C, 0x33, 0x0F, 0x11, 0x11, 0x19, 0xF0,
  0xC3, 0x0C, 0x36, 0xF3, 0x8F, 0x36, 0xDC, 0xF0, 0xC3, 0x0C, 0x30, 0xC3,
  0x0D, 0x1C, 0xFF, 0x5D, 0x75, 0xC7, 0x10, 0xFE, 0xF7, 0xBD, 0xEC, 0x7D,
  0x3C, 0x71, 0x6D, 0xE0, 0xFE, 0xF3, 0x9D, 0xFB, 0x18, 0x7D, 0x3C, 0xF3,
  0x6D, 0xF0, 0xC3, 0xFE, 0x31, 0x8C, 0x60, 0xFE, 0x3C, 0x79, 0xF8, 0x30,
  0xCF, 0xCC, 0x30, 0xC3, 0x4F, 0x9C, 0xE7, 0x3D, 0xFC, 0xC6, 0x99, 0xB3,
  0x43, 0x86, 0x00, 0xC7, 0xAB, 0xD3, 0xE6, 0xCD, 0x80, 0xEC, 0xA3, 0x0E,
  0x6F, 0x30, 0xCD, 0xB6, 0xCA, 0x38, 0x63, 0x38, 0xF9, 0x88, 0xCC, 0x7C,
  0x3B, 0x18, 0xC6, 0x61, 0x8C, 0x63, 0x0E, 0xFF, 0xE0, 0xE1, 0x08, 0x43,
  0x0C, 0x84, 0x21, 0x38, 0x67, 0xF9, 0x20,
};

const GFXglyph UbuntuSansMono_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 5, 4, 7, 1, -9 },
  { 6, 6, 8, 7, 0, -8 },
  { 12, 6, 10, 7, 0, -9 },
  { 20, 7, 9, 7, 0, -9 },
  { 28, 6, 9, 7, 0, -9 },
  { 35, 2, 4, 7, 2, -9 },
  { 36, 5, 12, 7, 1, -10 },
  { 44, 4, 12, 7, 1, -10 },
  { 50, 5, 5, 7, 1, -8 },
  { 54, 5, 6, 7, 1, -7 },
  { 58, 3, 4, 7, 2, -2 },
  { 60, 3, 1, 7, 2, -4 },
  { 61, 3, 2, 7, 2, -2 },
  { 62, 5, 11, 7, 1, -9 },
  { 69, 6, 9, 7, 0, -9 },
  { 76, 5, 8, 7, 1, -8 },
  { 81, 5, 9, 7, 1, -9 },
  { 87, 5, 9, 7, 1, -9 },
  { 93, 6, 8, 7, 0, -8 },
  { 99, 6, 8, 7, 0, -8 },
  { 105, 5, 8, 7, 1, -8 },
  { 110, 5, 8, 7, 1, -8 },
  { 115, 5, 9, 7, 1, -9 },
  { 121, 5, 9, 7, 1, -9 },
  { 127, 3, 6, 7, 2, -6 },
  { 130, 3, 8, 7, 2, -6 },
  { 133, 5, 5, 7, 1, -6 },
  { 137, 5, 4, 7, 1, -6 },
  { 140, 5, 5, 7, 1, -6 },
  { 144, 5, 9, 7, 1, -9 },
  { 150, 6, 11, 7, 0, -9 },
  { 159, 7, 8, 7, 0, -8 },
  { 166, 5, 8, 7, 1, -8 },
  { 171, 6, 9, 7, 0, -9 },
  { 178, 5, 8, 7, 1, -8 },
  { 183, 5, 8, 7, 1, -8 },
  { 188, 5, 8, 7, 1, -8 },
  { 193, 6, 9, 7, 0, -9 },
  { 200, 5, 8, 7, 1, -8 },
  { 205, 5, 8, 7, 1, -8 },
  { 210, 5, 8, 7, 1, -8 },
  { 215, 6, 8, 7, 1, -8 },
  { 221, 5, 8, 7, 1, -8 },
  { 226, 6, 8, 7, 0, -8 },
  { 232, 5, 8, 7, 1, -8 },
  { 237, 6, 9, 7, 0, -9 },
  { 244, 5, 8, 7, 1, -8 },
  { 249, 6, 10, 7, 0, -8 },
  { 257, 6, 8, 7, 1, -8 },
  { 263, 5, 9, 7, 1, -9 },
  { 269, 6, 8, 7, 0, -8 },
  { 275, 5, 8, 7, 1, -8 },
  { 280, 7, 8, 7, 0, -8 },
  { 287, 6, 8, 7, 0, -8 },
  { 293, 7, 8, 7, 0, -8 },
  { 300, 7, 8, 7, 0, -8 },
  { 307, 5, 8, 7, 1, -8 },
  { 312, 3, 11, 7, 2, -9 },
  { 317, 5, 11, 7, 1, -9 },
  { 324, 4, 11, 7, 1, -9 },
  { 330, 7, 5, 7, 0, -8 },
  { 335, 7, 1, 7, 0, 1 },
  { 336, 3, 2, 7, 2, -9 },
  { 337, 5, 6, 7, 1, -6 },
  { 341, 5, 9, 7, 1, -9 },
  { 347, 5, 6, 7, 1, -6 },
  { 351, 6, 9, 7, 0, -9 },
  { 358, 6, 6, 7, 0, -6 },
  { 363, 7, 9, 7, 0, -9 },
  { 371, 6, 8, 7, 0, -6 },
  { 377, 5, 9, 7, 1, -9 },
  { 383, 6, 9, 7, 0, -9 },
  { 390, 4, 11, 7, 1, -9 },
  { 396, 6, 9, 7, 1, -9 },
  { 403, 6, 9, 7, 0, -9 },
  { 410, 6, 6, 7, 0, -6 },
  { 415, 5, 6, 7, 1, -6 },
  { 419, 6, 6, 7, 0, -6 },
  { 424, 5, 8, 7, 1, -6 },
  { 429, 6, 8, 7, 0, -6 },
  { 435, 5, 6, 7, 1, -6 },
  { 439, 5, 6, 7, 1, -6 },
  { 443, 6, 8, 7, 0, -8 },
  { 449, 5, 6, 7, 1, -6 },
  { 453, 7, 6, 7, 0, -6 },
  { 459, 7, 6, 7, 0, -6 },
  { 465, 6, 6, 7, 0, -6 },
  { 470, 6, 8, 7, 0, -6 },
  { 476, 5, 6, 7, 1, -6 },
  { 480, 5, 11, 7, 1, -9 },
  { 487, 1, 11, 7, 3, -9 },
  { 489, 5, 11, 7, 1, -9 },
  { 496, 7, 3, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_Bold12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_BOLD12PT7B_H_
