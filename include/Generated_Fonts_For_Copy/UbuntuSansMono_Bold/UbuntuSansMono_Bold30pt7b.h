#ifndef _UBUNTUSANSMONO_BOLD30PT7B_H_
#define _UBUNTUSANSMONO_BOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x77,
  0xFF, 0xFF, 0x00, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7B, 0x8E, 0x71, 0xCC, 0x18, 0x07, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x71,
  0xE0, 0xE3, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xE0,
  0x71, 0xC1, 0xE3, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8E, 0x07, 0x1C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x7F, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0x8E, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7D, 0x80, 0xFB, 0xFF, 0xEF, 0xFF,
  0xCF, 0xFF, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x03,
  0xBF, 0x03, 0x9F, 0xC3, 0x9C, 0xE1, 0xCE, 0x71, 0xC7, 0x39, 0xC3, 0x9C,
  0xE0, 0xFE, 0xE0, 0x7E, 0xE0, 0x1E, 0x70, 0x00, 0x70, 0x00, 0x73, 0x80,
  0x3B, 0xF0, 0x3B, 0xF8, 0x39, 0xCC, 0x1C, 0xE6, 0x1C, 0x73, 0x1C, 0x39,
  0x8E, 0x1D, 0xCE, 0x07, 0xEE, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0xFF,
  0x83, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x1E, 0xF0, 0x3F, 0xC0,
  0x3F, 0x00, 0xFC, 0x73, 0xFC, 0xEF, 0xFD, 0xDE, 0x7F, 0xB8, 0x7F, 0x70,
  0x7C, 0xE0, 0x79, 0xE1, 0xFB, 0xFF, 0xF3, 0xFE, 0xF3, 0xF9, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x80, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1C, 0x01, 0x00,
  0x40, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x07, 0x00, 0x40, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xCE,
  0x2F, 0x77, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x1F, 0xC1, 0xEF, 0x1F, 0x7C,
  0x71, 0xC1, 0x8C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x08, 0x3E, 0x3E, 0x3F, 0x3F,
  0x1E, 0x0E, 0x1E, 0xFC, 0xF8, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x11,
  0xFF, 0xFF, 0x7D, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xC7,
  0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF3, 0x9F, 0xE7, 0x3F, 0xCE,
  0x7F, 0x9C, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF8, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0x80, 0x3C, 0x03,
  0xE0, 0x7F, 0x0F, 0xF8, 0x7F, 0xC3, 0xDE, 0x08, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0xE3, 0xFF,
  0xE3, 0xE7, 0xC2, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F,
  0xC1, 0xFF, 0xC7, 0xFF, 0x8E, 0x3E, 0x20, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7D, 0x83, 0xF7, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xEF, 0x03,
  0xDE, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0x80,
  0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7D, 0x83, 0xE7,
  0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x00, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0xE3,
  0xF0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xE1,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xDF, 0xFC,
  0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x3E, 0x1E, 0x7E, 0x78, 0x7F, 0xE0, 0x7F, 0x81,
  0xFF, 0xC7, 0x8F, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x3C, 0xF0,
  0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x9F, 0x1E, 0x78, 0x7D, 0xE0, 0xFF, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xF0,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x03,
  0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3C, 0x00, 0x11, 0xFF, 0xFF, 0x7D,
  0xF0, 0x00, 0x00, 0x01, 0x1F, 0xFF, 0xF7, 0xDF, 0x08, 0x7D, 0xFB, 0xF3,
  0xE7, 0xC0, 0x00, 0x00, 0x00, 0x21, 0xF7, 0xEF, 0xCF, 0x9F, 0x0E, 0x3B,
  0xF7, 0xCE, 0x00, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0xF1, 0xFF,
  0x9F, 0xF8, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xC0, 0x03, 0x80, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x40, 0x01, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x7E,
  0x01, 0xC0, 0x04, 0x00, 0x00, 0x3F, 0xC7, 0xFF, 0x1F, 0xFC, 0xE3, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xC1, 0xE7,
  0x01, 0xCE, 0x03, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9E,
  0x7F, 0x38, 0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7, 0xF3, 0xCF, 0xE7, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFB, 0x87, 0xE7, 0x80, 0x07, 0x80, 0x0F, 0xE3, 0x0F,
  0xFE, 0x07, 0xFC, 0x00, 0x40, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1C, 0xF0, 0x0E, 0x78,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x78, 0x1E, 0x3C, 0x0F, 0x9E, 0x03, 0xCF, 0x01, 0xEF,
  0x80, 0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF0, 0xFB, 0xC1,
  0xEF, 0x07, 0xBC, 0x3C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFE, 0xF0,
  0x7B, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7, 0xEF, 0xFF, 0xBF,
  0xFC, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0xE7, 0xC0,
  0x4F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC,
  0x18, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0,
  0xFB, 0xCF, 0xCF, 0xFF, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1,
  0xF8, 0xE7, 0xC0, 0x4F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBE, 0x0F, 0x3C, 0x1E,
  0x7C, 0x3C, 0xFC, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x20, 0x79, 0xC3, 0xE7, 0xFF, 0xBF, 0xFC, 0x3F, 0xE0, 0xF8,
  0x3F, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x1F, 0x3E, 0x3E, 0xF8,
  0x7D, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xBE, 0x1F,
  0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0x79, 0xF0, 0xFB, 0xE0, 0xF7, 0xC1,
  0xFF, 0x81, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0xC7, 0xDD,
  0x8F, 0xBB, 0x3F, 0x77, 0x7E, 0xEE, 0xDD, 0xCF, 0xBF, 0x9F, 0x7F, 0x3E,
  0xFE, 0x39, 0xFC, 0x73, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xE0, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xEE, 0x3F, 0x39, 0xF9, 0xCF,
  0xC7, 0x7E, 0x3B, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7,
  0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x1E, 0x78,
  0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xE3, 0xFE, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xFC, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE1, 0xFF, 0x80,
  0xFE, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF8, 0x00,
  0x30, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC7, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3,
  0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xEF, 0x07, 0xBC, 0x1F,
  0xF0, 0x3C, 0x0F, 0xF0, 0xFF, 0xF3, 0xFF, 0x9F, 0x0E, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x40, 0x3D, 0xC1, 0xF7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0x78,
  0x3D, 0xF1, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0xF8, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78,
  0x0F, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE3, 0x9F, 0xCF, 0x3F, 0x9F, 0x7F, 0x3E,
  0xFE, 0xED, 0xFD, 0xDF, 0xBB, 0xBF, 0x36, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x78, 0x0F, 0x7C, 0x1E, 0x3C, 0x1E,
  0x1E, 0x3C, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF8, 0x7C, 0x7C, 0x7C, 0x3C, 0xF8, 0x3E, 0xF0, 0x1F, 0x70, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0xF3, 0xF3, 0xF1,
  0xE0, 0x80, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8C, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x7F, 0xCF, 0xFF, 0x7F, 0xFD, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0x78,
  0x3D, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xCF,
  0xDF, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xF8, 0xFF, 0xF1, 0xFC, 0xE7, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x47,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE3, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFF, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1E,
  0xF8, 0xF7, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xF7, 0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE1, 0x87, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x86, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xF8, 0x7F, 0xF3, 0xFF, 0xDF, 0x8F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xDF, 0xBF, 0x7F, 0xFC, 0xFF, 0xF0,
  0xFB, 0xC0, 0x0F, 0x00, 0x7D, 0x01, 0xE7, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0,
  0x18, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0xF8, 0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xE1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x20, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x61, 0xFF, 0xFF,
  0xFF, 0x7F, 0xC0, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xF0, 0xFB, 0xC7, 0xCF, 0x1E, 0x3C,
  0xF0, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0xC3, 0xCF, 0x8F,
  0x1E, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x20, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0x7E, 0x79, 0xFF, 0xFB, 0xFF, 0xF7, 0xBD,
  0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xE7, 0xF1, 0xCF, 0xE3, 0x9F, 0xC7, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x7F,
  0xC7, 0xFF, 0x3F, 0xFD, 0xF7, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xDF, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1, 0xE7,
  0xC7, 0xC7, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF,
  0x3C, 0x7E, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1E, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0xF8,
  0x7F, 0xF3, 0xFF, 0xDF, 0x9F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0x7C, 0x7D, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x1F, 0xF1, 0xFF, 0x9F, 0xFD, 0xF8, 0xEF, 0x00, 0x7C, 0x01, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0xFE, 0x0F, 0xFF, 0xFB,
  0xFF, 0xCF, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x84, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC7, 0xBF, 0xFD, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x1F, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x71, 0xC7, 0x71,
  0xC7, 0x73, 0xC7, 0x73, 0xE7, 0x73, 0xE7, 0x73, 0xEE, 0x77, 0x6E, 0x3F,
  0x7E, 0x3E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x1C, 0x1C, 0xF0,
  0x1E, 0xF0, 0x79, 0xF1, 0xE1, 0xE3, 0xC1, 0xEF, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC3, 0xC7, 0x8F,
  0x0F, 0xBE, 0x0F, 0x78, 0x0F, 0xF8, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1,
  0xE7, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x70, 0x3D, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x00, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x87, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0x00, 0x00, 0x1C, 0x0C, 0xFE, 0x1D,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xDC, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 11, 10, 17, 3, -23 },
  { 29, 15, 21, 17, 1, -21 },
  { 69, 15, 26, 17, 1, -23 },
  { 118, 17, 21, 17, 0, -21 },
  { 163, 15, 21, 17, 1, -21 },
  { 203, 5, 10, 17, 6, -23 },
  { 210, 11, 30, 17, 3, -24 },
  { 252, 11, 30, 17, 3, -24 },
  { 294, 13, 13, 17, 2, -21 },
  { 316, 14, 15, 17, 1, -16 },
  { 343, 8, 11, 17, 4, -6 },
  { 354, 9, 4, 17, 4, -11 },
  { 359, 6, 6, 17, 5, -6 },
  { 364, 13, 29, 17, 2, -23 },
  { 412, 15, 21, 17, 1, -21 },
  { 452, 13, 21, 17, 2, -21 },
  { 487, 15, 21, 17, 1, -21 },
  { 527, 14, 21, 17, 1, -21 },
  { 564, 15, 21, 17, 1, -21 },
  { 604, 14, 21, 17, 1, -21 },
  { 641, 13, 21, 17, 2, -21 },
  { 676, 13, 21, 17, 2, -21 },
  { 711, 15, 21, 17, 1, -21 },
  { 751, 14, 21, 17, 1, -21 },
  { 788, 6, 16, 17, 5, -16 },
  { 800, 7, 21, 17, 4, -16 },
  { 819, 15, 15, 17, 1, -16 },
  { 848, 14, 10, 17, 1, -14 },
  { 866, 14, 15, 17, 1, -16 },
  { 893, 13, 21, 17, 2, -21 },
  { 928, 15, 26, 17, 1, -21 },
  { 977, 17, 21, 17, 0, -21 },
  { 1022, 14, 21, 17, 2, -21 },
  { 1059, 15, 21, 17, 1, -21 },
  { 1099, 14, 21, 17, 2, -21 },
  { 1136, 13, 21, 17, 2, -21 },
  { 1171, 13, 21, 17, 2, -21 },
  { 1206, 15, 21, 17, 1, -21 },
  { 1246, 14, 21, 17, 1, -21 },
  { 1283, 13, 21, 17, 2, -21 },
  { 1318, 14, 21, 17, 1, -21 },
  { 1355, 15, 21, 17, 1, -21 },
  { 1395, 13, 21, 17, 2, -21 },
  { 1430, 15, 21, 17, 1, -21 },
  { 1470, 13, 21, 17, 2, -21 },
  { 1505, 15, 21, 17, 1, -21 },
  { 1545, 14, 21, 17, 2, -21 },
  { 1582, 15, 27, 17, 1, -21 },
  { 1633, 14, 21, 17, 2, -21 },
  { 1670, 14, 21, 17, 1, -21 },
  { 1707, 15, 21, 17, 1, -21 },
  { 1747, 14, 21, 17, 1, -21 },
  { 1784, 16, 21, 17, 0, -21 },
  { 1826, 15, 21, 17, 1, -21 },
  { 1866, 16, 21, 17, 0, -21 },
  { 1908, 16, 21, 17, 0, -21 },
  { 1950, 13, 21, 17, 2, -21 },
  { 1985, 9, 29, 17, 4, -23 },
  { 2018, 13, 29, 17, 2, -23 },
  { 2066, 9, 29, 17, 4, -23 },
  { 2099, 16, 12, 17, 1, -21 },
  { 2123, 17, 4, 17, 0, 2 },
  { 2132, 7, 6, 17, 5, -23 },
  { 2138, 14, 16, 17, 1, -16 },
  { 2166, 14, 23, 17, 2, -23 },
  { 2207, 15, 16, 17, 1, -16 },
  { 2237, 13, 23, 17, 1, -23 },
  { 2275, 15, 16, 17, 1, -16 },
  { 2305, 16, 23, 17, 1, -23 },
  { 2351, 14, 22, 17, 1, -16 },
  { 2390, 13, 23, 17, 2, -23 },
  { 2428, 15, 23, 17, 1, -23 },
  { 2472, 11, 29, 17, 2, -23 },
  { 2512, 14, 23, 17, 2, -23 },
  { 2553, 15, 23, 17, 1, -23 },
  { 2597, 15, 16, 17, 1, -16 },
  { 2627, 13, 16, 17, 2, -16 },
  { 2653, 15, 16, 17, 1, -16 },
  { 2683, 14, 22, 17, 2, -16 },
  { 2722, 14, 22, 17, 1, -16 },
  { 2761, 12, 16, 17, 3, -16 },
  { 2785, 13, 16, 17, 2, -16 },
  { 2811, 15, 20, 17, 1, -20 },
  { 2849, 13, 16, 17, 2, -16 },
  { 2875, 16, 16, 17, 0, -16 },
  { 2907, 16, 16, 17, 0, -16 },
  { 2939, 15, 16, 17, 1, -16 },
  { 2969, 15, 22, 17, 1, -16 },
  { 3011, 13, 16, 17, 2, -16 },
  { 3037, 13, 29, 17, 2, -23 },
  { 3085, 5, 29, 17, 6, -23 },
  { 3104, 13, 29, 17, 2, -23 },
  { 3152, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_Bold30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_BOLD30PT7B_H_
