#ifndef _UBUNTUSANSMONO_BOLD32PT7B_H_
#define _UBUNTUSANSMONO_BOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF9, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x07, 0x9E, 0x07,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xF0, 0x78, 0xF0, 0x78,
  0xE0, 0x78, 0xE0, 0x79, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7E, 0x1C, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x70, 0x3E, 0x7F,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x18, 0x00, 0x0F, 0x80, 0xF7, 0xF0, 0x39, 0xDC, 0x1C, 0xE7, 0x0E,
  0x39, 0xC3, 0x8E, 0x71, 0xC3, 0x9C, 0xE0, 0x77, 0x38, 0x1F, 0xDC, 0x03,
  0xEF, 0x00, 0x03, 0x80, 0x01, 0xC4, 0x00, 0xF7, 0xC0, 0x3B, 0xF8, 0x1C,
  0xEE, 0x0F, 0x31, 0x83, 0x9C, 0x71, 0xC3, 0x1C, 0xF0, 0xEE, 0x38, 0x3B,
  0x9C, 0x0F, 0xEF, 0x01, 0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x78, 0xF0, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x3D, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x0E, 0x3F, 0x8E, 0x7F, 0xCE, 0xF3, 0xFE, 0xF1,
  0xFE, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFF, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0xE0, 0x1E, 0x03,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1E, 0x00, 0x40, 0x70, 0x07, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x07,
  0xE0, 0xFC, 0x07, 0x80, 0x20, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x19,
  0xE6, 0xFB, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x7F, 0x83,
  0xCF, 0x1F, 0x3E, 0x1C, 0x60, 0x21, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0xC3, 0x8F, 0xFD, 0xF3, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3E, 0x7C, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF1, 0x8F,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0F, 0xF8, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x07, 0xBC, 0x18, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x07, 0x00, 0x7F, 0xC3, 0xFF, 0xC7, 0xFF,
  0xCF, 0x0F, 0x8C, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x80, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xE3, 0x87, 0xC4, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xFB, 0xC7, 0xF7, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7C, 0x0F,
  0x7C, 0x1E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7D, 0xC7, 0xF3, 0xFF, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00,
  0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xCF, 0x9F, 0xFE, 0x3F, 0xF0,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E,
  0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x3D, 0xFC, 0x78, 0x3E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF0, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0xF8, 0xFB,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7F,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0x80, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0x1E, 0x3F, 0x3F,
  0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3F, 0x3F, 0x3F,
  0x3F, 0x1F, 0x07, 0x0E, 0x7E, 0xFC, 0x70, 0x00, 0x0C, 0x00, 0x78, 0x07,
  0xF0, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x07, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0x00,
  0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x80,
  0x1F, 0x00, 0x7E, 0x07, 0xFC, 0x3F, 0xF7, 0xFF, 0x07, 0xF8, 0x0F, 0xC0,
  0x1C, 0x00, 0x20, 0x00, 0x07, 0x81, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x70,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3F, 0x7E, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7,
  0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0xCF, 0xE3, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0x70, 0x7C, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x82, 0x1F,
  0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x73, 0x80, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x03, 0xE7, 0xC0, 0xF9,
  0xE0, 0x3E, 0x78, 0x07, 0xBE, 0x01, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF,
  0xE7, 0xCF, 0xCF, 0x07, 0xDE, 0x0F, 0xBC, 0x1F, 0x78, 0x3C, 0xF1, 0xF9,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0xDE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC,
  0x00, 0x00, 0x70, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x0E, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x02, 0x3F, 0x9E, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x9F, 0xCF, 0x07, 0xDE, 0x0F, 0xBC, 0x0F,
  0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0, 0x7D, 0xE1, 0xFB, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x0E, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x3F, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x40,
  0xF9, 0xE7, 0xF3, 0xFF, 0xCF, 0xFF, 0x87, 0xFC, 0x00, 0xF0, 0x7E, 0xF0,
  0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF7, 0xC0, 0xF3,
  0xE0, 0xF3, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x3F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0xFE, 0x6E, 0xF7, 0xEE, 0xF7,
  0xEF, 0xF7, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xDC, 0xFF, 0x7B, 0xFC, 0xEF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x70, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7E, 0x7E, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x8F, 0xEF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7, 0xF7, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFC, 0x3F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7E, 0x7E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x0E, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xF3, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E,
  0xF0, 0x1F, 0x01, 0xC0, 0x1F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xC0, 0x8F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3D,
  0x00, 0x7B, 0xC3, 0xF7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF0, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x1C, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xEE, 0xFE, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x1F, 0x3E, 0x03,
  0xCF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFB, 0xC0, 0x3C, 0xF8,
  0x1F, 0x3E, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE,
  0x01, 0xF0, 0xF8, 0x07, 0xDF, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E,
  0x1F, 0x07, 0x87, 0x81, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C,
  0x7C, 0x7C, 0x3E, 0x7E, 0x0F, 0xBE, 0x07, 0xEE, 0x01, 0xC1, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x30, 0x7C,
  0xFE, 0x3F, 0x0E, 0x02, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x8E, 0xFE, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x38, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF,
  0x87, 0xDF, 0x3F, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFC, 0x3F,
  0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xF3, 0x8F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x78, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0x7C, 0x3D, 0xFC, 0xF3, 0xFF, 0xCF, 0xFF, 0x0F,
  0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7E, 0x7C, 0x1E, 0x78,
  0x1E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7F, 0xBC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0x7C, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x10, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB, 0xF1,
  0xF7, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFB, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x87, 0xDF, 0x00,
  0x3E, 0x00, 0x79, 0x01, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x0F, 0xF0,
  0x00, 0x38, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7B,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0x07, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x61, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0x80, 0x18, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x7F, 0xF0, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F, 0x9E, 0x1F, 0x78,
  0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x83, 0xEF, 0x87, 0xCF, 0x8F,
  0x8F, 0x9F, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0xF8, 0x3E, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x7F,
  0x7C, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x7F, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7C, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07,
  0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x87, 0xDF, 0x9F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x3F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0xCF, 0xDF,
  0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0x9F, 0xBE, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0xE3, 0xFF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xE0, 0x01, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xEE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xFB, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78,
  0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E,
  0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0x71, 0xE3, 0x9C, 0x78, 0xE7, 0x1E, 0x79, 0xEF, 0xDE, 0x7B, 0xF7, 0x9E,
  0xFD, 0xC3, 0xBF, 0x70, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE1,
  0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x00, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3C,
  0x3E, 0x7C, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E,
  0x78, 0x1E, 0xF0, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E,
  0x3C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78,
  0x0F, 0x78, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0xE0, 0x3E, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x01,
  0xFC, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F,
  0xE0, 0x00, 0x1C, 0x04, 0x3F, 0x07, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE0, 0xFE, 0x20, 0x38,
};

const GFXglyph UbuntuSansMono_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 12, 10, 18, 3, -24 },
  { 33, 16, 22, 18, 1, -22 },
  { 77, 16, 28, 18, 1, -25 },
  { 133, 18, 23, 18, 0, -23 },
  { 185, 16, 23, 18, 1, -23 },
  { 231, 4, 10, 18, 7, -24 },
  { 236, 12, 31, 18, 3, -25 },
  { 283, 12, 31, 18, 3, -25 },
  { 330, 14, 14, 18, 2, -22 },
  { 355, 15, 16, 18, 1, -17 },
  { 385, 7, 11, 18, 5, -6 },
  { 395, 10, 4, 18, 4, -11 },
  { 400, 6, 6, 18, 6, -6 },
  { 405, 14, 31, 18, 2, -25 },
  { 460, 16, 23, 18, 1, -23 },
  { 506, 14, 22, 18, 2, -22 },
  { 545, 15, 23, 18, 2, -23 },
  { 589, 15, 23, 18, 1, -23 },
  { 633, 16, 22, 18, 1, -22 },
  { 677, 15, 22, 18, 1, -22 },
  { 719, 14, 22, 18, 2, -22 },
  { 758, 14, 22, 18, 2, -22 },
  { 797, 16, 23, 18, 1, -23 },
  { 843, 14, 23, 18, 2, -23 },
  { 884, 6, 17, 18, 6, -17 },
  { 897, 8, 22, 18, 4, -17 },
  { 919, 15, 16, 18, 2, -17 },
  { 949, 15, 11, 18, 1, -15 },
  { 970, 15, 16, 18, 1, -17 },
  { 1000, 14, 23, 18, 2, -23 },
  { 1041, 16, 28, 18, 1, -23 },
  { 1097, 18, 22, 18, 0, -22 },
  { 1147, 15, 22, 18, 2, -22 },
  { 1189, 16, 23, 18, 1, -23 },
  { 1235, 15, 22, 18, 2, -22 },
  { 1277, 14, 22, 18, 2, -22 },
  { 1316, 14, 22, 18, 2, -22 },
  { 1355, 16, 23, 18, 1, -23 },
  { 1401, 14, 22, 18, 2, -22 },
  { 1440, 14, 22, 18, 2, -22 },
  { 1479, 15, 22, 18, 1, -22 },
  { 1521, 16, 22, 18, 2, -22 },
  { 1565, 13, 22, 18, 3, -22 },
  { 1601, 16, 22, 18, 1, -22 },
  { 1645, 14, 22, 18, 2, -22 },
  { 1684, 16, 23, 18, 1, -23 },
  { 1730, 15, 22, 18, 2, -22 },
  { 1772, 16, 29, 18, 1, -23 },
  { 1830, 16, 22, 18, 2, -22 },
  { 1874, 15, 23, 18, 1, -23 },
  { 1918, 16, 22, 18, 1, -22 },
  { 1962, 16, 22, 18, 1, -22 },
  { 2006, 18, 22, 18, 0, -22 },
  { 2056, 16, 22, 18, 1, -22 },
  { 2100, 18, 22, 18, 0, -22 },
  { 2150, 18, 22, 18, 0, -22 },
  { 2200, 14, 22, 18, 2, -22 },
  { 2239, 10, 31, 18, 4, -25 },
  { 2278, 14, 31, 18, 2, -25 },
  { 2333, 10, 31, 18, 4, -25 },
  { 2372, 17, 13, 18, 1, -22 },
  { 2400, 18, 4, 18, 0, 2 },
  { 2409, 8, 7, 18, 5, -25 },
  { 2416, 14, 17, 18, 2, -17 },
  { 2446, 15, 25, 18, 2, -25 },
  { 2493, 15, 17, 18, 2, -17 },
  { 2525, 14, 25, 18, 1, -25 },
  { 2569, 16, 17, 18, 1, -17 },
  { 2603, 17, 25, 18, 1, -25 },
  { 2657, 15, 23, 18, 1, -17 },
  { 2701, 14, 25, 18, 2, -25 },
  { 2745, 16, 25, 18, 1, -25 },
  { 2795, 12, 31, 18, 2, -25 },
  { 2842, 15, 25, 18, 2, -25 },
  { 2889, 16, 25, 18, 1, -25 },
  { 2939, 16, 17, 18, 1, -17 },
  { 2973, 14, 17, 18, 2, -17 },
  { 3003, 16, 17, 18, 1, -17 },
  { 3037, 15, 23, 18, 2, -17 },
  { 3081, 15, 23, 18, 1, -17 },
  { 3125, 13, 17, 18, 3, -17 },
  { 3153, 14, 17, 18, 2, -17 },
  { 3183, 16, 22, 18, 1, -22 },
  { 3227, 14, 17, 18, 2, -17 },
  { 3257, 16, 17, 18, 1, -17 },
  { 3291, 18, 17, 18, 0, -17 },
  { 3330, 16, 17, 18, 1, -17 },
  { 3364, 16, 23, 18, 1, -17 },
  { 3410, 14, 17, 18, 2, -17 },
  { 3440, 14, 31, 18, 2, -25 },
  { 3495, 4, 31, 18, 7, -25 },
  { 3511, 14, 31, 18, 2, -25 },
  { 3566, 16, 7, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_Bold32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_BOLD32PT7B_H_
