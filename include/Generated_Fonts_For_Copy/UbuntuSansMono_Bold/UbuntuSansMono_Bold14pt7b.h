#ifndef _UBUNTUSANSMONO_BOLD14PT7B_H_
#define _UBUNTUSANSMONO_BOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF0, 0xF0, 0xDF, 0x7C, 0x92, 0x48, 0x16, 0x36, 0x36, 0xFF,
  0x24, 0x2C, 0xFF, 0xFF, 0x68, 0x48, 0x30, 0xCF, 0xF1, 0xC3, 0xC7, 0xC3,
  0x0F, 0xFF, 0x8C, 0x30, 0x63, 0xF2, 0xB4, 0xFC, 0x68, 0x16, 0x3E, 0x2B,
  0x4B, 0xC6, 0x38, 0x6C, 0x6C, 0x6C, 0x38, 0x72, 0xDE, 0xCE, 0x4E, 0x7B,
  0xFF, 0xC0, 0x08, 0x73, 0x18, 0x61, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x18,
  0x20, 0x47, 0x0C, 0x31, 0x8C, 0x21, 0x18, 0xC6, 0x6E, 0x20, 0x30, 0xCE,
  0xDF, 0x7B, 0x70, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x00, 0x6D, 0x9C, 0xFF,
  0xFC, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x61, 0x86, 0x30, 0xC3, 0x00,
  0x7B, 0xFC, 0xE3, 0xB6, 0xD8, 0xF3, 0xFD, 0xE0, 0x11, 0xCF, 0x2C, 0x30,
  0xC3, 0x0C, 0xFF, 0xF0, 0x73, 0xE8, 0xC3, 0x18, 0xC6, 0x38, 0xFF, 0xF0,
  0x73, 0xE0, 0xC3, 0x79, 0xF0, 0xC3, 0x9F, 0xE0, 0x0C, 0x18, 0x71, 0xE6,
  0xCD, 0xBF, 0xFF, 0x0C, 0x18, 0x7D, 0xF4, 0x30, 0xF8, 0xF0, 0xC3, 0x9F,
  0xE0, 0x0C, 0xF6, 0x30, 0xFB, 0x7C, 0xF3, 0xFD, 0xE0, 0xFF, 0xF1, 0xC6,
  0x18, 0xC3, 0x18, 0x61, 0x80, 0x7B, 0xFC, 0xF3, 0xFB, 0xEC, 0xE3, 0xCD,
  0xE0, 0x7B, 0xFC, 0xF3, 0xCF, 0xF0, 0xC6, 0xFB, 0x80, 0xFC, 0x3F, 0x6D,
  0x80, 0xFB, 0x38, 0x1D, 0xFE, 0x38, 0x7C, 0x30, 0xFC, 0x00, 0x3F, 0xC3,
  0xE1, 0xC7, 0xFB, 0x00, 0x7B, 0xF0, 0xC7, 0x38, 0xC0, 0x00, 0x71, 0xC0,
  0x1C, 0xED, 0x0A, 0x7D, 0xFA, 0x74, 0xED, 0x5E, 0x81, 0xC0, 0xF0, 0x18,
  0x18, 0x3C, 0x3C, 0x24, 0x66, 0x7E, 0x7E, 0x46, 0xC3, 0xF3, 0xFC, 0xF3,
  0xFB, 0xFC, 0xF3, 0xFF, 0xE0, 0x1E, 0x7D, 0x83, 0x0C, 0x18, 0x18, 0x30,
  0x76, 0x7C, 0xF3, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xC0, 0xFF, 0xFC,
  0x30, 0xFB, 0xEC, 0x30, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30,
  0xC3, 0x00, 0x1E, 0x7D, 0x83, 0x0C, 0x18, 0xD1, 0xB3, 0x76, 0x7C, 0xCF,
  0x3C, 0xF3, 0xFF, 0xFC, 0xF3, 0xCF, 0x30, 0xFF, 0xF3, 0x0C, 0x30, 0xC3,
  0x0C, 0xFF, 0xF0, 0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0xDF, 0xE0, 0xCD,
  0x9B, 0x67, 0x8F, 0x1E, 0x36, 0x6C, 0xCD, 0x9C, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFF, 0xF0, 0x66, 0xCD, 0x9B, 0xD5, 0xAB, 0x56, 0xE1, 0xC3,
  0x84, 0x8F, 0x3E, 0xFB, 0xBE, 0xF9, 0xE7, 0x8E, 0x30, 0x3C, 0xFD, 0x9A,
  0x3C, 0x78, 0xD1, 0xB3, 0x7E, 0x78, 0xFB, 0xFC, 0xF3, 0xCF, 0xFF, 0x30,
  0xC3, 0x00, 0x3C, 0xFD, 0x9A, 0x3C, 0x78, 0xF1, 0xB3, 0x6E, 0x78, 0x60,
  0x70, 0x20, 0xF1, 0xFB, 0x36, 0x6C, 0xDF, 0x36, 0x6C, 0xCD, 0x9C, 0x7B,
  0xFC, 0x30, 0xF0, 0xF0, 0xC3, 0xDF, 0xE0, 0xFF, 0xFC, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0,
  0xC3, 0xC6, 0x66, 0x66, 0x66, 0x24, 0x3C, 0x3C, 0x38, 0x18, 0xC3, 0x87,
  0x0E, 0x15, 0xAB, 0x5E, 0xB3, 0x66, 0xCC, 0xE7, 0x66, 0x3C, 0x3C, 0x18,
  0x18, 0x3C, 0x66, 0x66, 0xC7, 0xC3, 0x66, 0x66, 0x24, 0x3C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xF1, 0x86, 0x30, 0xC6, 0x30, 0xFF, 0xF0, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x0C,
  0x30, 0x61, 0x86, 0x0C, 0x30, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF,
  0x18, 0x3C, 0x3C, 0x66, 0x66, 0xC3, 0xFF, 0xFF, 0x4E, 0x30, 0x33, 0xE0,
  0xCF, 0xFF, 0x3C, 0xFF, 0xC3, 0x0C, 0x34, 0xFF, 0x3C, 0xF3, 0xCF, 0xFF,
  0x80, 0x19, 0xFC, 0x30, 0xC3, 0x0F, 0xDF, 0x06, 0x0C, 0x18, 0xB7, 0xEC,
  0xF1, 0xE3, 0x66, 0xFC, 0xF8, 0x18, 0xFD, 0x9A, 0x3F, 0xEC, 0x1F, 0x9F,
  0x1C, 0x7D, 0x83, 0x0F, 0xCC, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x13, 0xFC,
  0xF3, 0xCF, 0x3F, 0xCB, 0x0F, 0xE7, 0x00, 0xC3, 0x0C, 0x34, 0xFB, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x61, 0xC2, 0x00, 0xF0, 0xC3, 0x0C, 0x30, 0xF3,
  0xC0, 0x18, 0xC4, 0x0F, 0x8C, 0x63, 0x18, 0xC7, 0x3F, 0xB8, 0xC1, 0x83,
  0x06, 0x0D, 0xDB, 0x3C, 0x78, 0xD9, 0x9B, 0x38, 0xF3, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xF3, 0xC0, 0xFF, 0xB7, 0x6E, 0xDC, 0x38, 0x70, 0x80,
  0x33, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0x18, 0xF9, 0x9A, 0x3C, 0x6C, 0xDF,
  0x9E, 0x23, 0xEC, 0xF3, 0xCF, 0x3F, 0xFE, 0xC3, 0x0C, 0x00, 0x18, 0xFD,
  0x9B, 0x3C, 0x6C, 0xDF, 0x9F, 0x06, 0x0C, 0x18, 0x13, 0xFC, 0x70, 0xC3,
  0x0C, 0x30, 0x33, 0xFC, 0x78, 0x78, 0x3D, 0xFE, 0x11, 0x86, 0x3F, 0x61,
  0x86, 0x18, 0x7C, 0xF0, 0xCF, 0x3C, 0xF3, 0xCF, 0xF7, 0xC0, 0xC7, 0x66,
  0x66, 0x2C, 0x3C, 0x38, 0x18, 0xC3, 0xDA, 0xDA, 0x5A, 0x7A, 0x66, 0x66,
  0xE6, 0x3C, 0x3C, 0x18, 0x3C, 0x66, 0xE7, 0x66, 0xCD, 0x99, 0xA3, 0xC3,
  0x86, 0x0C, 0xF0, 0xC0, 0xFC, 0x63, 0x0C, 0x63, 0xFF, 0xC0, 0x3C, 0xF3,
  0x0C, 0x30, 0x8E, 0x38, 0x20, 0xC3, 0x0C, 0x3C, 0x70, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE3, 0xC3, 0x0C, 0x30, 0xC1, 0xC7, 0x30, 0xC3, 0x0C, 0xF3, 0x80,
  0x22, 0x7F, 0xDE,
};

const GFXglyph UbuntuSansMono_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 6, 5, 8, 1, -11 },
  { 8, 8, 10, 8, 0, -10 },
  { 18, 6, 13, 8, 1, -11 },
  { 28, 8, 10, 8, 0, -10 },
  { 38, 8, 10, 8, 0, -10 },
  { 48, 2, 5, 8, 3, -11 },
  { 50, 6, 14, 8, 1, -11 },
  { 61, 5, 14, 8, 1, -11 },
  { 70, 6, 6, 8, 1, -10 },
  { 75, 6, 7, 8, 1, -8 },
  { 81, 3, 5, 8, 2, -3 },
  { 83, 4, 2, 8, 2, -5 },
  { 84, 2, 3, 8, 3, -3 },
  { 85, 6, 14, 8, 1, -11 },
  { 96, 6, 10, 8, 1, -10 },
  { 104, 6, 10, 8, 1, -10 },
  { 112, 6, 10, 8, 1, -10 },
  { 120, 6, 10, 8, 1, -10 },
  { 128, 7, 10, 8, 0, -10 },
  { 137, 6, 10, 8, 1, -10 },
  { 145, 6, 10, 8, 1, -10 },
  { 153, 6, 10, 8, 1, -10 },
  { 161, 6, 10, 8, 1, -10 },
  { 169, 6, 10, 8, 1, -10 },
  { 177, 2, 8, 8, 3, -8 },
  { 179, 3, 10, 8, 2, -8 },
  { 183, 6, 6, 8, 1, -7 },
  { 188, 6, 4, 8, 1, -6 },
  { 191, 6, 6, 8, 1, -7 },
  { 196, 6, 10, 8, 1, -10 },
  { 204, 7, 12, 8, 0, -10 },
  { 215, 8, 10, 8, 0, -10 },
  { 225, 6, 10, 8, 1, -10 },
  { 233, 7, 10, 8, 0, -10 },
  { 242, 6, 10, 8, 1, -10 },
  { 250, 6, 10, 8, 1, -10 },
  { 258, 6, 10, 8, 1, -10 },
  { 266, 7, 10, 8, 0, -10 },
  { 275, 6, 10, 8, 1, -10 },
  { 283, 6, 10, 8, 1, -10 },
  { 291, 6, 10, 8, 1, -10 },
  { 299, 7, 10, 8, 1, -10 },
  { 308, 6, 10, 8, 1, -10 },
  { 316, 7, 10, 8, 0, -10 },
  { 325, 6, 10, 8, 1, -10 },
  { 333, 7, 10, 8, 0, -10 },
  { 342, 6, 10, 8, 1, -10 },
  { 350, 7, 13, 8, 0, -10 },
  { 362, 7, 10, 8, 1, -10 },
  { 371, 6, 10, 8, 1, -10 },
  { 379, 7, 10, 8, 0, -10 },
  { 388, 6, 10, 8, 1, -10 },
  { 396, 8, 10, 8, 0, -10 },
  { 406, 7, 10, 8, 0, -10 },
  { 415, 8, 10, 8, 0, -10 },
  { 425, 8, 10, 8, 0, -10 },
  { 435, 6, 10, 8, 1, -10 },
  { 443, 4, 14, 8, 2, -11 },
  { 450, 6, 14, 8, 1, -11 },
  { 461, 4, 14, 8, 2, -11 },
  { 468, 8, 6, 8, 0, -10 },
  { 474, 8, 2, 8, 0, 1 },
  { 476, 4, 3, 8, 2, -11 },
  { 478, 6, 8, 8, 1, -8 },
  { 484, 6, 11, 8, 1, -11 },
  { 493, 6, 8, 8, 1, -8 },
  { 499, 7, 11, 8, 0, -11 },
  { 509, 7, 8, 8, 0, -8 },
  { 516, 7, 11, 8, 1, -11 },
  { 526, 6, 11, 8, 1, -8 },
  { 535, 6, 11, 8, 1, -11 },
  { 544, 6, 11, 8, 1, -11 },
  { 553, 5, 14, 8, 1, -11 },
  { 562, 7, 11, 8, 1, -11 },
  { 572, 6, 11, 8, 1, -11 },
  { 581, 7, 7, 8, 0, -7 },
  { 588, 6, 8, 8, 1, -8 },
  { 594, 7, 8, 8, 0, -8 },
  { 601, 6, 11, 8, 1, -8 },
  { 610, 7, 11, 8, 0, -8 },
  { 620, 6, 8, 8, 1, -8 },
  { 626, 6, 8, 8, 1, -8 },
  { 632, 6, 10, 8, 1, -10 },
  { 640, 6, 7, 8, 1, -7 },
  { 646, 8, 7, 8, 0, -7 },
  { 653, 8, 7, 8, 0, -7 },
  { 660, 8, 7, 8, 0, -7 },
  { 667, 7, 10, 8, 0, -7 },
  { 676, 6, 7, 8, 1, -7 },
  { 682, 6, 14, 8, 1, -11 },
  { 693, 2, 14, 8, 3, -11 },
  { 697, 6, 14, 8, 1, -11 },
  { 708, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuSansMono_Bold14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_BOLD14PT7B_H_
