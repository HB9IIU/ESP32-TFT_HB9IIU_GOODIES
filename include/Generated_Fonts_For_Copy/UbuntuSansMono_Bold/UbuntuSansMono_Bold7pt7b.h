#ifndef _UBUNTUSANSMONO_BOLD7PT7B_H_
#define _UBUNTUSANSMONO_BOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0xF0, 0x5F, 0x6F, 0xA0, 0x78, 0x61, 0xE4, 0xDE, 0x27,
  0xB0, 0x6A, 0x5A, 0xF0, 0xC0, 0x5A, 0xA4, 0xA5, 0x58, 0x4F, 0x60, 0x4F,
  0x44, 0xE0, 0xC0, 0xC0, 0x32, 0x24, 0x4C, 0x69, 0xD9, 0x60, 0x2E, 0x22,
  0x70, 0xE2, 0x24, 0xF0, 0xE2, 0x61, 0xE0, 0x26, 0xAF, 0x20, 0x64, 0x63,
  0xE0, 0x24, 0xE9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0x72,
  0x60, 0xCC, 0xCE, 0x1E, 0x61, 0xFF, 0x87, 0x68, 0xDC, 0x80, 0x6B, 0xDD,
  0xB7, 0x66, 0x6E, 0x90, 0xEA, 0xE9, 0xE0, 0x78, 0x88, 0x70, 0xE9, 0x99,
  0xE0, 0xE8, 0xE8, 0xF0, 0xF3, 0xC8, 0x78, 0x99, 0x70, 0x99, 0xF9, 0x90,
  0xF4, 0x44, 0xF0, 0x64, 0x9E, 0xBA, 0xCA, 0x90, 0x92, 0x4E, 0x9F, 0xF9,
  0x90, 0x9D, 0xBB, 0x90, 0x69, 0x99, 0x60, 0xE9, 0xF8, 0x80, 0x69, 0x99,
  0x63, 0xE9, 0xEA, 0x90, 0x68, 0x61, 0xE0, 0xF4, 0x44, 0x40, 0x99, 0x99,
  0x60, 0x99, 0x66, 0x60, 0x99, 0xDF, 0xB0, 0x96, 0x66, 0x90, 0x96, 0x64,
  0x40, 0xE2, 0x44, 0xF0, 0xEA, 0xB0, 0xC4, 0x42, 0x23, 0xD5, 0x70, 0x66,
  0x90, 0xF0, 0xC0, 0x67, 0xF0, 0x8E, 0x99, 0xE0, 0x78, 0x87, 0x2E, 0xD6,
  0x69, 0xE6, 0x7F, 0x44, 0x40, 0x76, 0xBE, 0x9E, 0xDA, 0x4C, 0x44, 0x70,
  0x2C, 0x93, 0xC0, 0x8B, 0xAE, 0xB0, 0xC4, 0x44, 0x70, 0xED, 0xD9, 0xF6,
  0xD0, 0x69, 0x96, 0xE9, 0x9E, 0x80, 0x76, 0xB2, 0xF2, 0x40, 0x68, 0xF0,
  0x4F, 0x44, 0x70, 0xB6, 0xB0, 0x9A, 0x66, 0x9D, 0xF6, 0x96, 0x6B, 0x96,
  0x66, 0xC0, 0xDB, 0x6B, 0x24, 0xC0, 0xFC, 0xE4, 0x93, 0xC0, 0x5A,
};

const GFXglyph UbuntuSansMono_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 6, 4, 0, -5 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 1, -5 },
  { 17, 2, 7, 4, 1, -6 },
  { 19, 2, 7, 4, 1, -6 },
  { 21, 4, 3, 4, 0, -5 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 2, 2, 4, 1, -1 },
  { 26, 2, 1, 4, 1, -3 },
  { 27, 2, 1, 4, 1, -1 },
  { 28, 4, 6, 4, 0, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 3, 4, 1, -3 },
  { 62, 2, 4, 4, 1, -3 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 2, 4, 0, -3 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 2, 5, 4, 1, -5 },
  { 70, 4, 6, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 3, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 3, 5, 4, 1, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 6, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 4, 5, 4, 0, -5 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 2, 6, 4, 1, -5 },
  { 150, 4, 6, 4, 0, -5 },
  { 153, 2, 6, 4, 1, -5 },
  { 155, 4, 3, 4, 0, -5 },
  { 157, 4, 1, 4, 0, 0 },
  { 158, 2, 1, 4, 1, -5 },
  { 159, 3, 4, 4, 0, -4 },
  { 161, 4, 5, 4, 0, -5 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 3, 5, 4, 0, -5 },
  { 168, 4, 4, 4, 0, -4 },
  { 170, 4, 5, 4, 0, -5 },
  { 173, 3, 5, 4, 0, -4 },
  { 175, 3, 5, 4, 0, -5 },
  { 177, 4, 5, 4, 0, -5 },
  { 180, 3, 6, 4, 0, -5 },
  { 183, 4, 5, 4, 0, -5 },
  { 186, 4, 5, 4, 0, -5 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 3, 4, 4, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 5, 4, 0, -4 },
  { 198, 3, 5, 4, 0, -4 },
  { 200, 3, 4, 4, 1, -4 },
  { 202, 3, 4, 4, 0, -4 },
  { 204, 4, 5, 4, 0, -5 },
  { 207, 3, 4, 4, 0, -4 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 5, 4, 0, -4 },
  { 218, 2, 4, 4, 1, -4 },
  { 219, 3, 6, 4, 0, -5 },
  { 222, 1, 6, 4, 1, -5 },
  { 223, 3, 6, 4, 0, -5 },
  { 226, 4, 2, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Bold7pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold7pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUSANSMONO_BOLD7PT7B_H_
