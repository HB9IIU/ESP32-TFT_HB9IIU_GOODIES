#ifndef _UBUNTUSANSMONO_BOLD48PT7B_H_
#define _UBUNTUSANSMONO_BOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC7, 0xC3,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0x7E, 0x04, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFF, 0x07, 0xE3, 0xFC, 0x00, 0xC7, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE4, 0x00, 0x1F, 0xDF, 0x80,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x23, 0xF8, 0x00, 0xF8, 0xFF, 0x80, 0x1F, 0x3F, 0xF8, 0x07, 0xC7, 0xDF,
  0x01, 0xF0, 0xF1, 0xE0, 0x3E, 0x1E, 0x3E, 0x0F, 0x83, 0xC7, 0xC1, 0xE0,
  0x78, 0xF8, 0x7C, 0x0F, 0x1F, 0x1F, 0x01, 0xE3, 0xC3, 0xC0, 0x3C, 0x78,
  0xF8, 0x07, 0xFF, 0x3E, 0x00, 0xFF, 0xE7, 0x80, 0x0F, 0xF9, 0xF0, 0x00,
  0xFE, 0x7C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x1E, 0x7F, 0x80, 0x07, 0xCF, 0xF8, 0x01, 0xF3, 0xFF, 0x00,
  0x3C, 0x79, 0xF0, 0x0F, 0x9F, 0x1E, 0x03, 0xE3, 0xE3, 0xC0, 0x7C, 0x7C,
  0x78, 0x1F, 0x0F, 0x8F, 0x07, 0xC1, 0xF1, 0xE0, 0xF8, 0x3E, 0x3C, 0x3E,
  0x03, 0xCF, 0x8F, 0x80, 0x7F, 0xF1, 0xF0, 0x0F, 0xFC, 0x7C, 0x00, 0xFF,
  0x9F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x07, 0xFC, 0x1F, 0x87, 0xFF, 0x0F, 0xC7, 0xFF, 0xC7, 0xC7, 0xF7,
  0xF3, 0xE3, 0xF1, 0xFD, 0xF1, 0xF0, 0x7F, 0xF9, 0xF8, 0x3F, 0xF8, 0xFC,
  0x0F, 0xFC, 0x7E, 0x03, 0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x87,
  0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x7E,
  0x1F, 0xFF, 0x3F, 0x03, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x1E, 0x00, 0x06, 0x00,
  0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0x18, 0x30, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x03, 0x07, 0xC0, 0x87, 0x8F, 0x8F, 0x0F, 0xDF,
  0x3E, 0x3F, 0xDD, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0,
  0x07, 0xF7, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x1E, 0x0F, 0x00,
  0x1C, 0x1C, 0x00, 0x10, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0x81, 0xFC, 0x1F, 0xE3, 0xFE, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF1, 0xFE, 0x0F, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x3F, 0x8F, 0xF8,
  0xFF, 0x0F, 0xC0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFC, 0xFC,
  0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x87,
  0x0F, 0xFF, 0x1F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC, 0xFC, 0x7F, 0xF8, 0xF8,
  0xFF, 0xF1, 0xF1, 0xFF, 0xE1, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xCF, 0xE0, 0x18, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0x81, 0xFE, 0x0C, 0x01, 0xFC, 0x10, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xC0, 0x7F, 0x84, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xD0, 0x00, 0xFF, 0x78, 0x07, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF4, 0x00, 0x3F, 0x9C, 0x03,
  0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x3F,
  0xC3, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFD, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0x87,
  0xF8, 0x7F, 0x0F, 0xFD, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFD, 0xFF, 0xC7, 0xF0, 0xFF, 0x8F, 0xC0,
  0x7F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0,
  0x07, 0xEF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0xC0,
  0x7F, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x0C, 0x00, 0x07,
  0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x3F, 0xCF, 0xF8, 0x7F, 0x07, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xDC, 0x07, 0xFA, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7C, 0x07, 0xFF, 0x7C, 0x1F,
  0xFF, 0x7C, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0xFE, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC,
  0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC,
  0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x1F, 0xF8, 0x7F,
  0xFF, 0x7C, 0x3F, 0xFF, 0x7C, 0x3F, 0xFF, 0x7C, 0x0F, 0xFF, 0x7E, 0x07,
  0xFE, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFF, 0x7E, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0x3F,
  0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x87, 0xFE, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x0E, 0x1F,
  0xC0, 0x02, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x02, 0x1F, 0xF8, 0x1E, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xE1, 0xFF, 0x3F, 0x81, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0,
  0x7F, 0xBF, 0x83, 0xFC, 0xFE, 0x7F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xF0, 0x0E, 0x3F, 0xC0, 0x02, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x1F, 0xF0, 0x7F, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x80,
  0x0F, 0xE3, 0x80, 0x7F, 0x8F, 0x83, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x80,
  0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC3, 0xDE, 0x3E, 0xF1,
  0xEF, 0x1F, 0x78, 0xF7, 0xCF, 0xBC, 0xFB, 0xE7, 0xCF, 0x79, 0xF3, 0xE7,
  0xBC, 0xF9, 0xF3, 0xFE, 0x7C, 0xF9, 0xFE, 0x3E, 0x7C, 0x7F, 0x1F, 0x3E,
  0x3F, 0x8F, 0x9F, 0x1F, 0xC7, 0xCF, 0x8F, 0xC3, 0xE7, 0xC3, 0xE1, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0x7C, 0x3F, 0xFD,
  0xF8, 0xFF, 0xF3, 0xE3, 0xFF, 0xCF, 0xCF, 0xFF, 0x1F, 0x3F, 0xFC, 0x7E,
  0xFF, 0xF0, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7E,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x00,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1E, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x87, 0xFC, 0x7F, 0x03, 0xFC,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x07, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFE, 0xFE, 0x1F, 0xE0, 0x0C, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF9, 0x00, 0x0F, 0xE7,
  0xC0, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x1F,
  0xE7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x87, 0xC3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE3, 0xF0, 0xF9, 0xF1, 0xFC,
  0x7C, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F, 0x1F, 0x3E, 0x7F, 0xCF, 0x9F, 0x3D,
  0xE7, 0xCF, 0x9E, 0xF3, 0xE7, 0xDF, 0x79, 0xF3, 0xEF, 0x1E, 0xF9, 0xF7,
  0x8F, 0x7C, 0xFB, 0xC7, 0xBE, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xF7, 0xF8, 0x07, 0xF9, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFD, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0x9F, 0x00, 0x1F, 0x03, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x03, 0xC0, 0x3E, 0x07,
  0xF8, 0xFF, 0xC7, 0xFF, 0x1F, 0xE0, 0x3E, 0x00, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0x9F, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFC,
  0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xBF, 0x83, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x05, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xF8, 0x02, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x3F,
  0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x00,
  0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC,
  0x03, 0xF7, 0xF8, 0x0F, 0xCF, 0xF8, 0x3F, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x30, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0x3F, 0x80, 0x7E, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x07,
  0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x50, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x3F,
  0x03, 0xF8, 0x02, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF8,
  0x3F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x60, 0x07, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF0, 0x7F, 0xBF, 0x81, 0xFD,
  0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x86, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x90, 0x07, 0xF3, 0xC0,
  0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0x3F, 0x83, 0xFC, 0x7F,
  0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF3,
  0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xFC, 0x07, 0xF3, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x86, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x81, 0xFF, 0xCF, 0xF3, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x1F, 0xFC, 0x7E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0,
  0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F,
  0xFC, 0x3E, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x03, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB,
  0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFF, 0x3F, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB,
  0xF8, 0x0F, 0xE7, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xE0,
  0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xF7, 0xF0,
  0x04, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x01,
  0x8F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x80, 0x07, 0xF7, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x08, 0x1F,
  0xE0, 0x70, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x07, 0xF7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0x80,
  0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80,
  0x1F, 0x9F, 0xC0, 0x0F, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7E, 0x3F,
  0xFC, 0x7F, 0x1F, 0x3E, 0x3F, 0x8F, 0x9F, 0x1F, 0xC7, 0xCF, 0x8F, 0xF3,
  0xE7, 0xCF, 0xF9, 0xF3, 0xE7, 0xFC, 0xF9, 0xF3, 0xDE, 0x7C, 0xFB, 0xEF,
  0xBC, 0x3D, 0xE7, 0xDE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xF8,
  0x7F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x1F,
  0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x03,
  0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xF8, 0x07, 0xE1,
  0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xFB,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x0C,
  0x0F, 0xFC, 0x07, 0xCF, 0xFF, 0x07, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xF8, 0xFF, 0xF9, 0xF8, 0x1F, 0xF8, 0x78, 0x07,
  0xF8, 0x04, 0x00, 0x78, 0x00,
};

const GFXglyph UbuntuSansMono_Bold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 34, 27, 9, -33 },
  { 40, 17, 15, 27, 5, -36 },
  { 72, 25, 33, 27, 1, -33 },
  { 176, 23, 42, 27, 2, -37 },
  { 297, 27, 35, 27, 0, -34 },
  { 416, 25, 34, 27, 1, -34 },
  { 523, 7, 16, 27, 10, -36 },
  { 537, 17, 47, 27, 5, -38 },
  { 637, 17, 47, 27, 5, -38 },
  { 737, 23, 21, 27, 2, -33 },
  { 798, 23, 24, 27, 2, -26 },
  { 867, 12, 17, 27, 7, -9 },
  { 893, 15, 6, 27, 6, -17 },
  { 905, 9, 10, 27, 9, -9 },
  { 917, 21, 47, 27, 3, -38 },
  { 1041, 23, 35, 27, 2, -34 },
  { 1142, 22, 33, 27, 3, -33 },
  { 1233, 23, 34, 27, 2, -34 },
  { 1331, 22, 35, 27, 2, -34 },
  { 1428, 25, 33, 27, 1, -33 },
  { 1532, 22, 34, 27, 2, -33 },
  { 1626, 22, 35, 27, 2, -34 },
  { 1723, 21, 33, 27, 3, -33 },
  { 1810, 23, 35, 27, 2, -34 },
  { 1911, 23, 34, 27, 2, -34 },
  { 2009, 9, 26, 27, 9, -25 },
  { 2039, 12, 33, 27, 6, -25 },
  { 2089, 23, 23, 27, 2, -25 },
  { 2156, 23, 16, 27, 2, -22 },
  { 2202, 23, 23, 27, 2, -25 },
  { 2269, 19, 35, 27, 4, -34 },
  { 2353, 24, 41, 27, 1, -34 },
  { 2476, 26, 33, 27, 0, -33 },
  { 2584, 22, 34, 27, 3, -34 },
  { 2678, 24, 35, 27, 1, -34 },
  { 2783, 22, 34, 27, 3, -34 },
  { 2877, 22, 33, 27, 3, -33 },
  { 2968, 21, 33, 27, 3, -33 },
  { 3055, 24, 35, 27, 1, -34 },
  { 3160, 22, 33, 27, 2, -33 },
  { 3251, 21, 33, 27, 3, -33 },
  { 3338, 22, 34, 27, 2, -33 },
  { 3432, 24, 33, 27, 2, -33 },
  { 3531, 21, 33, 27, 4, -33 },
  { 3618, 25, 33, 27, 1, -33 },
  { 3722, 22, 33, 27, 2, -33 },
  { 3813, 24, 35, 27, 1, -34 },
  { 3918, 22, 34, 27, 3, -34 },
  { 4012, 24, 43, 27, 1, -34 },
  { 4141, 23, 34, 27, 3, -34 },
  { 4239, 23, 35, 27, 2, -34 },
  { 4340, 25, 33, 27, 1, -33 },
  { 4444, 23, 34, 27, 2, -33 },
  { 4542, 25, 33, 27, 1, -33 },
  { 4646, 25, 33, 27, 1, -33 },
  { 4750, 25, 33, 27, 1, -33 },
  { 4854, 25, 33, 27, 1, -33 },
  { 4958, 22, 33, 27, 2, -33 },
  { 5049, 15, 47, 27, 6, -38 },
  { 5138, 21, 47, 27, 3, -38 },
  { 5262, 15, 47, 27, 6, -38 },
  { 5351, 25, 19, 27, 1, -33 },
  { 5411, 26, 6, 27, 0, 3 },
  { 5431, 12, 9, 27, 8, -37 },
  { 5445, 22, 27, 27, 2, -26 },
  { 5520, 22, 38, 27, 3, -37 },
  { 5625, 23, 27, 27, 2, -26 },
  { 5703, 22, 38, 27, 1, -37 },
  { 5808, 23, 27, 27, 2, -26 },
  { 5886, 24, 37, 27, 2, -37 },
  { 5997, 22, 35, 27, 2, -26 },
  { 6094, 21, 37, 27, 3, -37 },
  { 6192, 23, 38, 27, 2, -37 },
  { 6302, 19, 46, 27, 3, -37 },
  { 6412, 23, 37, 27, 3, -37 },
  { 6519, 23, 38, 27, 2, -37 },
  { 6629, 23, 26, 27, 2, -26 },
  { 6704, 21, 26, 27, 3, -26 },
  { 6773, 23, 27, 27, 2, -26 },
  { 6851, 22, 35, 27, 3, -26 },
  { 6948, 22, 35, 27, 2, -26 },
  { 7045, 20, 26, 27, 5, -26 },
  { 7110, 21, 27, 27, 3, -26 },
  { 7181, 23, 34, 27, 2, -33 },
  { 7279, 21, 26, 27, 3, -25 },
  { 7348, 25, 25, 27, 1, -25 },
  { 7427, 25, 25, 27, 1, -25 },
  { 7506, 25, 25, 27, 1, -25 },
  { 7585, 24, 34, 27, 1, -25 },
  { 7687, 19, 25, 27, 4, -25 },
  { 7747, 20, 47, 27, 3, -38 },
  { 7865, 7, 47, 27, 10, -38 },
  { 7907, 20, 47, 27, 3, -38 },
  { 8025, 25, 10, 27, 1, -19 },
};

const GFXfont UbuntuSansMono_Bold48pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold48pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold48pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUSANSMONO_BOLD48PT7B_H_
