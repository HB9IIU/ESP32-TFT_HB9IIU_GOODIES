#ifndef _UBUNTUSANSMONO_BOLD26PT7B_H_
#define _UBUNTUSANSMONO_BOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF3, 0x9C, 0x00, 0x03, 0xDF, 0xFF,
  0x80, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xC6, 0x0E, 0x70,
  0x73, 0x87, 0x1C, 0x39, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x1C, 0x39,
  0xC1, 0xCE, 0x0E, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xCE, 0x0E, 0x70,
  0x73, 0x87, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xE7, 0xFF,
  0x3F, 0xF1, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x70, 0xF7, 0xFF, 0xBF, 0xF8, 0x3F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x7C, 0x0E, 0xF8, 0x3B, 0xB8, 0xE7,
  0x71, 0x8E, 0xE7, 0x1D, 0xDC, 0x1F, 0x30, 0x3E, 0xE0, 0x13, 0x80, 0x06,
  0x60, 0x1D, 0xE0, 0x77, 0xE0, 0xCC, 0xC3, 0x99, 0x8E, 0x33, 0x18, 0x66,
  0x70, 0xFD, 0xC0, 0xF0, 0x1F, 0x01, 0xFC, 0x1E, 0xF0, 0xE3, 0x87, 0x1C,
  0x39, 0xE1, 0xFE, 0x07, 0xE0, 0x3E, 0x73, 0xF3, 0xBF, 0xDD, 0xCF, 0xEE,
  0x3F, 0x70, 0xF3, 0x87, 0x9F, 0xFE, 0x7F, 0xF1, 0xFB, 0xC0, 0xFF, 0xFF,
  0x77, 0x77, 0x60, 0x01, 0x01, 0x83, 0xE3, 0xE1, 0xE1, 0xE1, 0xE0, 0xE0,
  0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0x00, 0x80, 0x20, 0x1C, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x0F, 0x07,
  0x83, 0xE1, 0xF0, 0x70, 0x08, 0x00, 0x07, 0x00, 0x70, 0x47, 0x17, 0x77,
  0x7F, 0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0x3D, 0xC3, 0x9E, 0x18, 0xC0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x39, 0xF7, 0xDF, 0x3C, 0x73,
  0xBC, 0xE0, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x1F,
  0xC1, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x3B, 0x81, 0xDC, 0xEE,
  0xE7, 0x7F, 0x3B, 0xF8, 0x9D, 0xC0, 0xEF, 0x07, 0x78, 0x39, 0xE3, 0xCF,
  0xFC, 0x3F, 0xE0, 0xFC, 0x00, 0x03, 0x80, 0x78, 0x1F, 0x8F, 0xF8, 0x7F,
  0x87, 0x78, 0x47, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x87, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0x87, 0xFE, 0xFF,
  0xE6, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F,
  0x87, 0xFC, 0x7F, 0xE4, 0x1E, 0x00, 0xE0, 0x0E, 0x01, 0xE1, 0xFC, 0x1F,
  0xC1, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x40, 0xF7, 0xFE, 0xFF,
  0xE7, 0xF8, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xF7, 0x87, 0x3C, 0x71, 0xE3, 0x8F, 0x38, 0x79, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE3, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xF8, 0x7F, 0xC0, 0xFE, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x01,
  0xE0, 0x7E, 0x1F, 0xE1, 0xF0, 0x3C, 0x07, 0x80, 0x7A, 0x07, 0xFC, 0xFF,
  0xEF, 0xFF, 0xF0, 0xFF, 0x07, 0xF0, 0x77, 0x07, 0x78, 0xF7, 0xFE, 0x3F,
  0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xE1, 0xE7,
  0x07, 0x38, 0x79, 0xE3, 0x8F, 0xFC, 0x3F, 0xC1, 0xFF, 0x1E, 0xFD, 0xE1,
  0xEF, 0x07, 0x70, 0x3F, 0xC1, 0xCF, 0xFE, 0x7F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC3, 0xFE, 0x7F, 0xE7, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0x7F,
  0xF7, 0xFF, 0x1F, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0xC7, 0xF8, 0x7F,
  0x07, 0x80, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0xF8, 0x1C,
  0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xF9, 0xF3, 0xE7, 0xC3,
  0x0E, 0xF8, 0xE0, 0x00, 0x10, 0x07, 0x80, 0xFC, 0x1F, 0xF7, 0xFC, 0x7F,
  0x03, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0xFC, 0x01, 0xE0, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x40, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0x00, 0xF0, 0x3F, 0x1F, 0xF7, 0xF8, 0xFE, 0x07, 0x00, 0x40, 0x00, 0x7F,
  0x9F, 0xF9, 0xFF, 0x20, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xC0,
  0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xEE, 0x03, 0x71, 0xFF, 0x9F, 0xF9,
  0xFF, 0xCF, 0x3E, 0x71, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x9F, 0x1F,
  0xFC, 0xFF, 0xE1, 0xF3, 0x80, 0x1E, 0x00, 0x7F, 0xE1, 0xFF, 0x03, 0xF8,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0E, 0xE0, 0x3B, 0x81, 0xCE,
  0x07, 0x3C, 0x1C, 0x70, 0xF1, 0xC3, 0xC7, 0x0F, 0xFE, 0x3F, 0xF9, 0xFF,
  0xE7, 0x83, 0x9E, 0x0F, 0x70, 0x3F, 0xC0, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF,
  0xCE, 0x1E, 0xE1, 0xEE, 0x1E, 0xE1, 0xCF, 0xFC, 0xFF, 0x8F, 0xFC, 0xE1,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x0F,
  0xF0, 0xFF, 0xCF, 0xFC, 0xF0, 0x27, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x4F,
  0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x3E, 0xE1,
  0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xEE, 0x1E, 0xE3, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xF8,
  0xFF, 0x8F, 0xFC, 0xF0, 0x2F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x03, 0xB8, 0x1D, 0xE0, 0xEF, 0x07, 0x78, 0x39, 0xE1, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0x80, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x61, 0xE7, 0xFE, 0xFF, 0xC7, 0xF8, 0xF0,
  0xFF, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C, 0x7B, 0xC3, 0xDE, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x3D, 0xE1, 0xEF, 0x8F, 0x3C, 0x78, 0xF3, 0xC3, 0xDE,
  0x1E, 0xF0, 0x7F, 0x83, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x73, 0x87, 0xBE, 0x3D, 0xF1,
  0xEF, 0x9F, 0x7C, 0xDB, 0xB6, 0xDD, 0xF6, 0xEF, 0x37, 0x79, 0xF9, 0xCF,
  0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0,
  0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7,
  0xF7, 0x7F, 0x77, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x07, 0x1F, 0xC1, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x78,
  0x3B, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0x78, 0x39, 0xE3, 0xCF, 0xFC, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x8F, 0xFC,
  0xFF, 0xEE, 0x1E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xEF, 0xFE,
  0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x1F, 0xC1, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x3B, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0x78, 0x39, 0xC3,
  0xCF, 0xFC, 0x3F, 0xE0, 0xFE, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0xF8,
  0x01, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xCE, 0x3E, 0xE1, 0xEE, 0x1E, 0xE1,
  0xEE, 0x1E, 0xFF, 0xCF, 0xFC, 0xFF, 0x0E, 0x78, 0xE3, 0xCE, 0x3C, 0xE1,
  0xEE, 0x1E, 0xE0, 0xFE, 0x0F, 0x1F, 0xF3, 0xFE, 0x7F, 0xE7, 0x02, 0xF0,
  0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x40, 0xF7, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xF7, 0xFF, 0x7F, 0xE3, 0xFC, 0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0xDE, 0x0E,
  0x78, 0x38, 0xE1, 0xE3, 0x87, 0x8F, 0x1C, 0x3C, 0x70, 0x71, 0xC1, 0xCF,
  0x07, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x9C,
  0xFC, 0xE7, 0xEF, 0x3F, 0x79, 0xBB, 0xED, 0xDB, 0x6F, 0xDB, 0x7C, 0xFB,
  0xE3, 0xDF, 0x1E, 0x70, 0xF3, 0x83, 0x80, 0x78, 0x3D, 0xE0, 0xE3, 0xC7,
  0x87, 0x3C, 0x1E, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1F,
  0x00, 0xFE, 0x03, 0xB8, 0x1E, 0xF0, 0x73, 0xC3, 0xC7, 0x9E, 0x1E, 0x78,
  0x3F, 0xC0, 0xF0, 0xF0, 0x3D, 0xE0, 0xF7, 0x83, 0x8E, 0x1E, 0x3C, 0x70,
  0x71, 0xC1, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x1F, 0x00, 0xFC, 0x03,
  0xF8, 0x1E, 0xF0, 0x7B, 0xC3, 0xC7, 0x9F, 0x1E, 0xF8, 0x3D, 0xC0, 0xE1,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0xF3, 0xF1, 0xF0,
  0xC0, 0x3F, 0x83, 0xFE, 0x3F, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x3F, 0xF7,
  0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x8F, 0xFC, 0xFF, 0xEF,
  0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0xF8, 0x27, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0x00, 0x7F, 0xE3,
  0xFF, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0x81, 0xFF,
  0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x3B, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x03, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3C, 0x11, 0xE0, 0x0F, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F, 0xF7, 0xFF, 0x1F,
  0xF0, 0x0F, 0x00, 0xF4, 0x1E, 0x7F, 0xEF, 0xFC, 0x3F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xC7, 0xFE, 0xFF, 0xDC, 0x7B,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0xE7, 0x9F, 0xF7, 0xFC, 0x3F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xFE, 0x1E, 0xE3, 0xCE,
  0x78, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xEF, 0x0E, 0x78, 0xE3, 0xCE,
  0x1E, 0xE1, 0xEE, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0x81, 0xFC, 0x07,
  0xF0, 0x7D, 0xE7, 0xFF, 0xBF, 0xFD, 0xDE, 0xFE, 0x73, 0xF3, 0x9F, 0x9C,
  0xFC, 0xE7, 0xE7, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C,
  0x7F, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xC0, 0x0F, 0x81, 0xFF, 0x1F,
  0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xBC, 0x3C, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xFC, 0xFF, 0xCE,
  0x1E, 0xE1, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0xFF, 0x7F, 0xF3, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F,
  0xCF, 0xFB, 0xFF, 0x78, 0x2F, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xC0,
  0x3E, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x06, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x23, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0xC7, 0xFF, 0xF7, 0xFE, 0x7F, 0xC0, 0xF0, 0x3D, 0xC0,
  0xF7, 0x83, 0x9E, 0x0E, 0x38, 0x78, 0xF1, 0xC3, 0xCF, 0x07, 0x3C, 0x1E,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x1F,
  0x80, 0x76, 0x01, 0xDC, 0xE7, 0x73, 0x9D, 0xDE, 0x77, 0x79, 0xDD, 0xF6,
  0x77, 0xD9, 0xFB, 0x63, 0xCF, 0x8F, 0x3E, 0x3C, 0x70, 0xE1, 0xC0, 0xF0,
  0x7F, 0x87, 0x9E, 0x38, 0x7B, 0xC1, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0xC1, 0xFE, 0x0E, 0x78, 0xF1, 0xEF, 0x0F, 0x70, 0x3C, 0xF0, 0x7F,
  0x83, 0x9C, 0x1C, 0xF1, 0xE7, 0x8F, 0x1C, 0x70, 0xF3, 0x87, 0xBC, 0x1D,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x13, 0xE0,
  0xFE, 0x07, 0xE0, 0x3C, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE1, 0xFC, 0x7C, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x7C, 0x0F, 0x01, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0xF8, 0x7F, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xF0, 0x3E, 0x0F, 0xC3, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x3F, 0x87, 0xF0, 0xF8, 0x00, 0x7C, 0x3B, 0xFB,
  0xFF, 0xFF, 0xCF, 0xE4, 0x1E, 0x00,
};

const GFXglyph UbuntuSansMono_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 9, 8, 15, 3, -20 },
  { 22, 13, 18, 15, 1, -18 },
  { 52, 13, 23, 15, 1, -20 },
  { 90, 15, 18, 15, 0, -18 },
  { 124, 13, 18, 15, 1, -18 },
  { 154, 4, 9, 15, 5, -20 },
  { 159, 9, 26, 15, 3, -21 },
  { 189, 10, 26, 15, 2, -21 },
  { 222, 12, 11, 15, 1, -18 },
  { 239, 12, 13, 15, 1, -14 },
  { 259, 6, 9, 15, 4, -5 },
  { 266, 8, 3, 15, 3, -9 },
  { 269, 5, 5, 15, 5, -5 },
  { 273, 12, 25, 15, 1, -20 },
  { 311, 13, 18, 15, 1, -18 },
  { 341, 12, 18, 15, 1, -18 },
  { 368, 12, 18, 15, 1, -18 },
  { 395, 12, 18, 15, 1, -18 },
  { 422, 13, 18, 15, 1, -18 },
  { 452, 12, 18, 15, 1, -18 },
  { 479, 12, 18, 15, 1, -18 },
  { 506, 12, 18, 15, 1, -18 },
  { 533, 13, 18, 15, 1, -18 },
  { 563, 12, 18, 15, 1, -18 },
  { 590, 5, 14, 15, 5, -14 },
  { 599, 7, 18, 15, 3, -14 },
  { 615, 13, 13, 15, 1, -14 },
  { 637, 12, 9, 15, 1, -12 },
  { 651, 12, 13, 15, 1, -14 },
  { 671, 11, 18, 15, 2, -18 },
  { 696, 13, 22, 15, 1, -18 },
  { 732, 14, 18, 15, 0, -18 },
  { 764, 12, 18, 15, 2, -18 },
  { 791, 13, 18, 15, 1, -18 },
  { 821, 12, 18, 15, 2, -18 },
  { 848, 11, 18, 15, 2, -18 },
  { 873, 11, 18, 15, 2, -18 },
  { 898, 13, 18, 15, 1, -18 },
  { 928, 12, 18, 15, 1, -18 },
  { 955, 11, 18, 15, 2, -18 },
  { 980, 12, 18, 15, 1, -18 },
  { 1007, 13, 18, 15, 1, -18 },
  { 1037, 11, 18, 15, 2, -18 },
  { 1062, 13, 18, 15, 1, -18 },
  { 1092, 12, 18, 15, 1, -18 },
  { 1119, 13, 18, 15, 1, -18 },
  { 1149, 12, 18, 15, 2, -18 },
  { 1176, 13, 23, 15, 1, -18 },
  { 1214, 12, 18, 15, 2, -18 },
  { 1241, 12, 18, 15, 1, -18 },
  { 1268, 13, 18, 15, 1, -18 },
  { 1298, 12, 18, 15, 1, -18 },
  { 1325, 14, 18, 15, 0, -18 },
  { 1357, 13, 18, 15, 1, -18 },
  { 1387, 14, 18, 15, 0, -18 },
  { 1419, 14, 18, 15, 0, -18 },
  { 1451, 12, 18, 15, 1, -18 },
  { 1478, 8, 25, 15, 3, -20 },
  { 1503, 12, 25, 15, 1, -20 },
  { 1541, 8, 25, 15, 3, -20 },
  { 1566, 14, 11, 15, 0, -18 },
  { 1586, 14, 3, 15, 0, 2 },
  { 1592, 7, 5, 15, 4, -20 },
  { 1597, 12, 14, 15, 1, -14 },
  { 1618, 12, 20, 15, 2, -20 },
  { 1648, 13, 14, 15, 1, -14 },
  { 1671, 12, 20, 15, 1, -20 },
  { 1701, 13, 14, 15, 1, -14 },
  { 1724, 13, 20, 15, 1, -20 },
  { 1757, 12, 19, 15, 1, -14 },
  { 1786, 11, 20, 15, 2, -20 },
  { 1814, 13, 20, 15, 1, -20 },
  { 1847, 11, 25, 15, 1, -20 },
  { 1882, 12, 20, 15, 2, -20 },
  { 1912, 13, 20, 15, 1, -20 },
  { 1945, 13, 14, 15, 1, -14 },
  { 1968, 11, 14, 15, 2, -14 },
  { 1988, 13, 14, 15, 1, -14 },
  { 2011, 12, 19, 15, 2, -14 },
  { 2040, 12, 19, 15, 1, -14 },
  { 2069, 10, 14, 15, 3, -14 },
  { 2087, 11, 14, 15, 2, -14 },
  { 2107, 13, 18, 15, 1, -18 },
  { 2137, 11, 14, 15, 2, -14 },
  { 2157, 14, 14, 15, 0, -14 },
  { 2182, 14, 14, 15, 0, -14 },
  { 2207, 13, 14, 15, 1, -14 },
  { 2230, 13, 19, 15, 1, -14 },
  { 2261, 11, 14, 15, 2, -14 },
  { 2281, 11, 25, 15, 2, -20 },
  { 2316, 3, 25, 15, 6, -20 },
  { 2326, 11, 25, 15, 2, -20 },
  { 2361, 13, 5, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_Bold26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_BOLD26PT7B_H_
