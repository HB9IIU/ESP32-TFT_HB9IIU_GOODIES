#ifndef _UBUNTUSANSMONO_BOLD33PT7B_H_
#define _UBUNTUSANSMONO_BOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x80, 0x00, 0xC7, 0xFF, 0xFF, 0xF7, 0x80, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70, 0xF7, 0x0E, 0x07, 0x8F,
  0x03, 0xC7, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x8F, 0x03, 0xC7, 0x01,
  0xE7, 0x80, 0xE3, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x38,
  0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xFD, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7C, 0x02, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x40, 0x1F, 0x78, 0x3F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFC, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E,
  0x01, 0xDF, 0xC0, 0xF7, 0x70, 0x3B, 0x9E, 0x1C, 0xE3, 0x8F, 0x38, 0xE3,
  0x8E, 0x39, 0xC1, 0xDC, 0xF0, 0x7F, 0x38, 0x1F, 0xDC, 0x03, 0xEF, 0x00,
  0x03, 0x80, 0x01, 0xCF, 0x00, 0xF7, 0xE0, 0x3B, 0xFC, 0x1C, 0xE7, 0x0F,
  0x39, 0xC3, 0x8E, 0x71, 0xC3, 0x9C, 0xF0, 0xE7, 0x38, 0x3F, 0xDC, 0x07,
  0xEF, 0x01, 0xF8, 0x00, 0x10, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0x79, 0xE0, 0x3D, 0xF0,
  0x0F, 0xF0, 0x07, 0xE2, 0x03, 0xF1, 0xE7, 0xFC, 0xF3, 0xFE, 0x7B, 0xCF,
  0xB9, 0xE3, 0xFC, 0xF0, 0xFE, 0x78, 0x3E, 0x3C, 0x0F, 0x9F, 0x1F, 0xC7,
  0xFF, 0xF1, 0xFF, 0x78, 0x7E, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x73,
  0x9C, 0x00, 0x60, 0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x06, 0x30, 0x07, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0x78, 0x03,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x03, 0x1C, 0x27, 0x39, 0xDF, 0xFF,
  0xBF, 0xFF, 0xBF, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC3, 0xF7, 0xC3,
  0xC7, 0x83, 0x8C, 0x02, 0x10, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x3E, 0x7F, 0x7F, 0x7F, 0x3F, 0x0E, 0x1E,
  0x7C, 0xF8, 0xF0, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79,
  0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF1,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF0, 0x8F, 0xF8, 0x0F, 0x78,
  0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0x7E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x39, 0xE0, 0x43, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE6, 0x07, 0xC8, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xC4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF7, 0xDF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x3F, 0xF8, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x1F,
  0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x7D, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x02, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x1F,
  0xF0, 0xFF, 0xE1, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFB, 0x81,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xF3, 0xF7, 0xE7, 0xFF, 0x87, 0xFF,
  0x07, 0xF8, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x1E, 0x78, 0x1F,
  0x78, 0x1E, 0x7C, 0x1E, 0x7E, 0x3E, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3C, 0xFE, 0x78, 0x3F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x78, 0x1F, 0x7E, 0x7F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0x80,
  0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE7, 0xEF, 0x87, 0xDE, 0x07, 0xBC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF,
  0xE3, 0xFF, 0x80, 0xDF, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC3,
  0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF,
  0xCF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xDF, 0xFF, 0xFE, 0x7C, 0x1E,
  0x1F, 0x8F, 0xE7, 0xF3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC3, 0xF1, 0xF8, 0xFE, 0x7F, 0x1F, 0x03, 0x83, 0xCF, 0xCF, 0xC3, 0xC1,
  0x00, 0x00, 0x04, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0xE7, 0xFE,
  0x3F, 0xF0, 0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x70,
  0x00, 0x40, 0x00, 0x7F, 0xC7, 0xFF, 0xBF, 0xFD, 0xF7, 0xF4, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C,
  0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xE3, 0xEF, 0xE7, 0xCF, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7,
  0x8F, 0xE7, 0x8F, 0xE3, 0xCF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0x70,
  0x7E, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x82, 0x1F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0xC1, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC0, 0xF9, 0xF0, 0x1E, 0x7C, 0x07,
  0xDE, 0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x7D, 0xFF, 0xF3,
  0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8,
  0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x02, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7E, 0x01, 0x3F, 0xDF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00,
  0x60, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF, 0x8F, 0xDF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3,
  0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xFE,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3E, 0x02, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F,
  0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x40, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF4, 0x07, 0xFE,
  0xFE, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x01, 0x80, 0xF0, 0x3E, 0xF0, 0x7E,
  0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF3, 0xE0,
  0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xF7, 0xE0,
  0xF3, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0, 0x7E,
  0xF0, 0x3E, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78,
  0x1E, 0x3C, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xE7, 0xC3, 0xF3, 0xF1, 0xF9,
  0xF9, 0xDC, 0xFC, 0xEE, 0xF7, 0x77, 0x7B, 0xF3, 0xBD, 0xF9, 0xDE, 0x7C,
  0xEF, 0x3E, 0x77, 0x9E, 0x3B, 0xCF, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0x78,
  0x03, 0xBC, 0x01, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3E,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xEE, 0x3F, 0xDE, 0x7F, 0x9C, 0xFF, 0x3D,
  0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0x80, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x80, 0xFF, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x3E, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7F, 0x7E, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFC,
  0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF9, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F,
  0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0x3C, 0x7C, 0x04, 0x78, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x20, 0x1F, 0x7C, 0x7F, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0x7C, 0x1F, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x01,
  0x80, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E, 0x7C, 0x0F,
  0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0x87, 0xC1,
  0xE1, 0xF0, 0x78, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E, 0xF1, 0xC7,
  0x79, 0xE3, 0xBC, 0xF9, 0xDE, 0x7C, 0xEF, 0x7E, 0x77, 0xBB, 0x3B, 0xDD,
  0xDC, 0xEC, 0xEE, 0x7E, 0x77, 0x3F, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xE7,
  0xC1, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0x7C, 0x07, 0xCF, 0x03, 0xE3, 0xE0,
  0xF0, 0x78, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xC7, 0xC1, 0xE1,
  0xF0, 0xF8, 0x3E, 0x3C, 0x0F, 0x9F, 0x01, 0xEF, 0xC0, 0x7C, 0xF8, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0x87, 0xC1,
  0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7D, 0xF0, 0x7C, 0x7C, 0x7E,
  0x3E, 0x3E, 0x0F, 0xBF, 0x07, 0xFF, 0x01, 0xF7, 0x00, 0xE0, 0x80, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x60, 0x78,
  0xFC, 0x7F, 0x1E, 0x04, 0x1F, 0xC1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x20,
  0x7C, 0x00, 0xF0, 0x03, 0xC1, 0xEF, 0x3F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0,
  0x08, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFB, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xC7,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF,
  0xC0, 0x01, 0xF8, 0x1F, 0xFC, 0xFF, 0xFB, 0xFF, 0xE7, 0xE0, 0x5F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFC, 0x00,
  0x02, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x07, 0xBE, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xEF, 0x87, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC,
  0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x38, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF7, 0xE1, 0xEF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0xC1, 0xEF, 0xFF, 0xCF, 0xFF,
  0x8F, 0xFF, 0x07, 0x9E, 0x00, 0x3C, 0x00, 0xFA, 0x01, 0xF7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x08, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFB, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xF0, 0x02, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x40, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0xC1, 0xF7, 0xFF, 0x7F, 0xFB, 0xFF, 0x87, 0xF8, 0x08,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9,
  0xF0, 0xF9, 0xE0, 0xFB, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFB,
  0xE0, 0xFB, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8,
  0x3E, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x0C, 0x10, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xCF, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3,
  0xC7, 0xF3, 0xC7, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x0F, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF0, 0x00, 0x80, 0x0F, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87,
  0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF,
  0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xE1, 0xEF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xEF, 0x83, 0xDF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFE,
  0x7C, 0x1B, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0x00, 0x3D, 0x00, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3D, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0xF0, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xCF, 0x03, 0xE7,
  0xC1, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x0F, 0x3C,
  0x07, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC3,
  0x8F, 0x79, 0xE3, 0xDE, 0x7C, 0xE7, 0x9F, 0x39, 0xE7, 0xCE, 0x7B, 0xF3,
  0x8E, 0xFC, 0xE3, 0xBB, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xC7, 0xC3,
  0xE1, 0xF0, 0x78, 0x7C, 0x1E, 0x0E, 0x00, 0xF8, 0x1F, 0xBE, 0x0F, 0x0F,
  0x8F, 0x83, 0xCF, 0x81, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xE1,
  0xF1, 0xF0, 0x78, 0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1E, 0x3C, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x3C,
  0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1E, 0x07, 0x1F, 0xC3, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0x1F, 0xF7, 0x07,
  0xF0, 0x40, 0xE0,
};

const GFXglyph UbuntuSansMono_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 23, 18, 6, -23 },
  { 19, 12, 10, 18, 3, -25 },
  { 34, 17, 23, 18, 1, -23 },
  { 83, 16, 30, 18, 1, -26 },
  { 143, 18, 24, 18, 0, -23 },
  { 197, 17, 23, 18, 1, -23 },
  { 246, 5, 11, 18, 7, -25 },
  { 253, 12, 32, 18, 3, -26 },
  { 301, 12, 32, 18, 3, -26 },
  { 349, 15, 15, 18, 2, -23 },
  { 378, 16, 17, 18, 1, -18 },
  { 412, 8, 12, 18, 5, -6 },
  { 424, 10, 5, 18, 4, -12 },
  { 431, 7, 6, 18, 6, -6 },
  { 437, 15, 32, 18, 2, -26 },
  { 497, 16, 24, 18, 1, -23 },
  { 545, 15, 23, 18, 2, -23 },
  { 589, 15, 23, 18, 2, -23 },
  { 633, 15, 24, 18, 2, -23 },
  { 678, 17, 23, 18, 1, -23 },
  { 727, 16, 24, 18, 1, -23 },
  { 775, 15, 24, 18, 2, -23 },
  { 820, 15, 23, 18, 2, -23 },
  { 864, 16, 24, 18, 1, -23 },
  { 912, 15, 23, 18, 2, -23 },
  { 956, 7, 17, 18, 6, -17 },
  { 971, 9, 23, 18, 4, -17 },
  { 997, 15, 17, 18, 2, -18 },
  { 1029, 16, 11, 18, 1, -15 },
  { 1051, 16, 16, 18, 1, -17 },
  { 1083, 13, 23, 18, 3, -23 },
  { 1121, 16, 28, 18, 1, -23 },
  { 1177, 18, 23, 18, 0, -23 },
  { 1229, 15, 23, 18, 2, -23 },
  { 1273, 16, 24, 18, 1, -23 },
  { 1321, 15, 23, 18, 2, -23 },
  { 1365, 15, 23, 18, 2, -23 },
  { 1409, 14, 23, 18, 2, -23 },
  { 1450, 16, 24, 18, 1, -23 },
  { 1498, 15, 23, 18, 2, -23 },
  { 1542, 15, 23, 18, 2, -23 },
  { 1586, 14, 24, 18, 2, -23 },
  { 1628, 16, 23, 18, 2, -23 },
  { 1674, 14, 23, 18, 3, -23 },
  { 1715, 17, 23, 18, 1, -23 },
  { 1764, 15, 23, 18, 2, -23 },
  { 1808, 16, 24, 18, 1, -23 },
  { 1856, 15, 23, 18, 2, -23 },
  { 1900, 16, 29, 18, 1, -23 },
  { 1958, 16, 23, 18, 2, -23 },
  { 2004, 16, 24, 18, 1, -23 },
  { 2052, 17, 23, 18, 1, -23 },
  { 2101, 16, 24, 18, 1, -23 },
  { 2149, 18, 23, 18, 0, -23 },
  { 2201, 17, 23, 18, 1, -23 },
  { 2250, 18, 23, 18, 0, -23 },
  { 2302, 18, 23, 18, 0, -23 },
  { 2354, 15, 23, 18, 2, -23 },
  { 2398, 10, 32, 18, 4, -26 },
  { 2438, 15, 32, 18, 2, -26 },
  { 2498, 10, 32, 18, 4, -26 },
  { 2538, 17, 14, 18, 1, -23 },
  { 2568, 18, 4, 18, 0, 2 },
  { 2577, 8, 7, 18, 6, -26 },
  { 2584, 14, 18, 18, 2, -18 },
  { 2616, 15, 26, 18, 2, -26 },
  { 2665, 15, 18, 18, 2, -18 },
  { 2699, 15, 26, 18, 1, -26 },
  { 2748, 16, 18, 18, 1, -18 },
  { 2784, 17, 26, 18, 1, -26 },
  { 2840, 15, 24, 18, 1, -18 },
  { 2885, 14, 26, 18, 2, -26 },
  { 2931, 16, 26, 18, 1, -26 },
  { 2983, 13, 32, 18, 2, -26 },
  { 3035, 16, 26, 18, 2, -26 },
  { 3087, 16, 25, 18, 1, -25 },
  { 3137, 16, 18, 18, 1, -18 },
  { 3173, 14, 18, 18, 2, -18 },
  { 3205, 16, 19, 18, 1, -18 },
  { 3243, 15, 24, 18, 2, -18 },
  { 3288, 15, 24, 18, 1, -18 },
  { 3333, 14, 18, 18, 3, -18 },
  { 3365, 14, 18, 18, 2, -18 },
  { 3397, 16, 22, 18, 1, -22 },
  { 3441, 14, 17, 18, 2, -17 },
  { 3471, 17, 17, 18, 1, -17 },
  { 3508, 18, 17, 18, 0, -17 },
  { 3547, 17, 17, 18, 1, -17 },
  { 3584, 16, 23, 18, 1, -17 },
  { 3630, 14, 17, 18, 2, -17 },
  { 3660, 14, 32, 18, 2, -26 },
  { 3716, 5, 32, 18, 7, -26 },
  { 3736, 14, 32, 18, 2, -26 },
  { 3792, 17, 7, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_Bold33pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold33pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold33pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUSANSMONO_BOLD33PT7B_H_
