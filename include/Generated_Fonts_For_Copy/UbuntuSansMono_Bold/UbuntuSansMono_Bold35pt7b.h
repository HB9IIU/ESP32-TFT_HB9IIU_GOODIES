#ifndef _UBUNTUSANSMONO_BOLD35PT7B_H_
#define _UBUNTUSANSMONO_BOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xF9, 0xE7,
  0x80, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0x9E,
  0x1C, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x03, 0xC3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x7E, 0x01, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF9, 0x00, 0x7D, 0xF9, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x13, 0xF0, 0x0E, 0x7F, 0x01, 0xC7, 0x78, 0x3C, 0xF3,
  0x83, 0x8F, 0x38, 0x70, 0xF3, 0x8F, 0x0F, 0x38, 0xE0, 0x73, 0x9C, 0x07,
  0xFB, 0xC0, 0x7F, 0x38, 0x03, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x30,
  0x01, 0xCF, 0xC0, 0x3D, 0xFC, 0x03, 0x9D, 0xE0, 0x79, 0xCE, 0x0F, 0x3C,
  0xE0, 0xE3, 0xCE, 0x1E, 0x3C, 0xE3, 0xC1, 0xCE, 0x38, 0x1F, 0xE7, 0x81,
  0xFC, 0xF0, 0x0F, 0xC0, 0x00, 0x20, 0x03, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3C, 0x7C, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x87, 0x8F,
  0xF1, 0xE7, 0xFE, 0x79, 0xEF, 0xDE, 0xF1, 0xFF, 0x3C, 0x3F, 0xCF, 0x07,
  0xF3, 0xC0, 0xF8, 0xF8, 0x3F, 0x3F, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0xDE,
  0x1F, 0xC7, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xE0, 0x00,
  0x40, 0x0E, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xF0, 0x0E, 0x00, 0x40, 0x20, 0x01, 0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xC0, 0x08,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6, 0x7B, 0x9E, 0xFD,
  0xBE, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E,
  0x7C, 0x7E, 0x7C, 0x1C, 0x38, 0x0C, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0C, 0x0F, 0x8F, 0xC7, 0xF3,
  0xF9, 0xFC, 0x7C, 0x0E, 0x0F, 0x1F, 0x3F, 0x1F, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xF9, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xF3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1F, 0x78, 0x0F,
  0xBC, 0x03, 0xFE, 0x71, 0xFF, 0x3C, 0xFF, 0x9E, 0x7F, 0xCF, 0x3F, 0xE7,
  0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x81, 0xE3,
  0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x60,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x7B, 0xE0, 0x43, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x07, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFC, 0xFE, 0x70,
  0x7E, 0x20, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7C,
  0xFC, 0x40, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC8, 0x07, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF1, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE3, 0xF3, 0xE0, 0x79, 0xF0, 0x3E,
  0xF8, 0x1E, 0x7C, 0x0F, 0x3F, 0x0F, 0x8F, 0xEF, 0x83, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xF0, 0xFB, 0xFC, 0xF8, 0x7E, 0x78, 0x0F, 0xBC, 0x07, 0xFE,
  0x01, 0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC,
  0x0F, 0xFC, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7C, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F,
  0xFE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x10, 0xF9, 0xFF, 0xFF, 0xEF,
  0xDF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0F, 0x9F, 0xFF, 0xFE, 0xFD, 0xF0,
  0x08, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3F, 0x0F, 0x0E, 0x7E, 0xFC, 0xF8,
  0xE0, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x3E, 0x01, 0xFF, 0x07, 0xFF, 0x1F,
  0xFC, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFE, 0x7F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0x81, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0x79, 0xFD, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xE0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x3C, 0x7F, 0x1E, 0x3F, 0x8F,
  0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFE, 0x7C, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFD, 0xC3, 0xFE, 0xF0, 0x7C, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x41, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x7C, 0x07,
  0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0x07, 0x00, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0xF8, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x7C, 0x01, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFC, 0xF9, 0xF8, 0x09, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x11, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0x00, 0x18, 0x00, 0x04, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xC3, 0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3D,
  0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x87,
  0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xF3, 0xFC, 0xF1, 0xF8, 0x09, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xEF,
  0xC1, 0xF3, 0xF0, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0x18, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7D, 0x00, 0xFB, 0x03, 0xF7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x1F, 0xF0,
  0x03, 0x00, 0xF8, 0x1F, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0x8F,
  0xC7, 0xC7, 0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0xC1, 0xF3, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x9F, 0x07, 0xCF, 0x83, 0xF7, 0xC0,
  0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x8F, 0xE7, 0x63, 0xF9, 0xDC, 0xFE, 0x77, 0x7F, 0x9D, 0xDD,
  0xEF, 0x3F, 0x7B, 0xCF, 0xDE, 0xF3, 0xE7, 0xBC, 0xF9, 0xEF, 0x1E, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x9F, 0xF7, 0x9F, 0xF3, 0x9F, 0xF3, 0xDF, 0xF1, 0xDF, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0x03, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x7F, 0x1F, 0x07, 0xC7, 0xC0, 0xF9,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x03,
  0xE7, 0x80, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x20, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x8F, 0xF7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x1F, 0x07, 0xC7, 0xC0, 0xF9, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1E, 0xF8, 0x0F, 0xBE, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00,
  0x04, 0x07, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xC3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F,
  0x9F, 0x0F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFE, 0x1C, 0xF8, 0x04, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x60,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x03, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0x78, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x1E, 0x1E,
  0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF1, 0xE7, 0xBC, 0x79, 0xEF,
  0x3E, 0x7B, 0xCF, 0x9E, 0xF3, 0xF7, 0xBC, 0xFD, 0xE7, 0x77, 0x79, 0xDC,
  0xFE, 0x77, 0x3F, 0x9F, 0x8F, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F,
  0x9F, 0x07, 0xE7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x03, 0xE7, 0xC0, 0xF8,
  0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xEF, 0x80,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x78, 0xF8, 0x1F, 0x3E,
  0x03, 0xCF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xF3, 0xE0, 0xFC, 0xFC, 0x3E, 0x1F, 0x1F, 0x87, 0xEF, 0xC0,
  0xFB, 0xE0, 0x3F, 0x78, 0x07, 0x84, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x3C, 0x1F, 0x1F, 0xE3, 0xF8,
  0x78, 0x08, 0x1F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFE, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xFC, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0x86, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x07, 0xDF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F,
  0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x04,
  0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0xC1, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7E, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xDF, 0x00, 0x1F,
  0x00, 0x1F, 0x40, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0,
  0x03, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xEF, 0xEF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x82, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x7F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x60, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F,
  0xE0, 0x1C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F,
  0xBE, 0x1F, 0x9F, 0x0F, 0x8F, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0x81, 0xF7,
  0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0x87,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xFC, 0xF8, 0x3F, 0x7C, 0x0F, 0xBE, 0x07,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x82, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0E,
  0x0C, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0xFF, 0x8F, 0x3F,
  0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x78, 0xFE, 0x3C,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xE0, 0x0F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0xCF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0x3F, 0x1F, 0x07, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x9F, 0x03, 0xE7,
  0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0xFE, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xE7, 0xE1, 0xCF, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x07, 0xD8, 0x0F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x02, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xEF,
  0x87, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0xF8, 0x07, 0xFE,
  0x01, 0xEF, 0x80, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x3D, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x78, 0xF7,
  0x8F, 0x1E, 0xF1, 0xE3, 0xDE, 0x7C, 0x73, 0xCF, 0xCE, 0x79, 0xF9, 0xC7,
  0x3F, 0x78, 0xEE, 0xEF, 0x1D, 0xDF, 0xE3, 0xB9, 0xFC, 0x7F, 0x3F, 0x0F,
  0xC7, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xFC, 0x0F, 0xDF,
  0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0xF8, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0x7E, 0x07, 0x8F, 0x83, 0xE1, 0xF1, 0xF0, 0x7E, 0x78, 0x0F, 0xBE,
  0x01, 0xF0, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x03, 0xCF,
  0x80, 0xFB, 0xC0, 0x3E, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x7F,
  0x80, 0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x1E, 0x03, 0x0F, 0xE0,
  0xF7, 0xFF, 0x7D, 0xFF, 0xFE, 0xFF, 0xFF, 0xBC, 0x3F, 0xC7, 0x03, 0xE0,
};

const GFXglyph UbuntuSansMono_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 13, 11, 20, 3, -27 },
  { 37, 18, 24, 20, 1, -24 },
  { 91, 17, 31, 20, 1, -27 },
  { 157, 20, 26, 20, 0, -25 },
  { 222, 18, 25, 20, 1, -25 },
  { 279, 5, 12, 20, 7, -27 },
  { 287, 12, 35, 20, 4, -28 },
  { 340, 13, 35, 20, 3, -28 },
  { 397, 16, 15, 20, 2, -24 },
  { 427, 16, 18, 20, 2, -19 },
  { 463, 9, 13, 20, 5, -7 },
  { 478, 11, 4, 20, 4, -12 },
  { 484, 7, 7, 20, 6, -7 },
  { 491, 16, 33, 20, 2, -27 },
  { 557, 17, 26, 20, 1, -25 },
  { 613, 16, 24, 20, 2, -24 },
  { 661, 16, 25, 20, 2, -25 },
  { 711, 16, 26, 20, 2, -25 },
  { 763, 18, 24, 20, 1, -24 },
  { 817, 17, 25, 20, 1, -24 },
  { 871, 16, 25, 20, 2, -24 },
  { 921, 16, 24, 20, 2, -24 },
  { 969, 17, 26, 20, 1, -25 },
  { 1025, 16, 25, 20, 2, -25 },
  { 1075, 7, 19, 20, 6, -19 },
  { 1092, 8, 25, 20, 5, -19 },
  { 1117, 16, 17, 20, 2, -19 },
  { 1151, 16, 12, 20, 2, -16 },
  { 1175, 16, 17, 20, 2, -19 },
  { 1209, 14, 25, 20, 3, -25 },
  { 1253, 17, 30, 20, 1, -25 },
  { 1317, 19, 24, 20, 0, -24 },
  { 1374, 16, 25, 20, 2, -25 },
  { 1424, 17, 26, 20, 1, -25 },
  { 1480, 17, 25, 20, 2, -25 },
  { 1534, 16, 24, 20, 2, -24 },
  { 1582, 15, 24, 20, 2, -24 },
  { 1627, 17, 26, 20, 1, -25 },
  { 1683, 16, 24, 20, 2, -24 },
  { 1731, 16, 24, 20, 2, -24 },
  { 1779, 15, 25, 20, 2, -24 },
  { 1826, 17, 24, 20, 2, -24 },
  { 1877, 15, 24, 20, 3, -24 },
  { 1922, 18, 24, 20, 1, -24 },
  { 1976, 16, 24, 20, 2, -24 },
  { 2024, 18, 26, 20, 1, -25 },
  { 2083, 17, 25, 20, 2, -25 },
  { 2137, 18, 32, 20, 1, -25 },
  { 2209, 17, 25, 20, 2, -25 },
  { 2263, 16, 26, 20, 2, -25 },
  { 2315, 18, 24, 20, 1, -24 },
  { 2369, 16, 25, 20, 2, -24 },
  { 2419, 18, 24, 20, 1, -24 },
  { 2473, 18, 24, 20, 1, -24 },
  { 2527, 19, 24, 20, 0, -24 },
  { 2584, 18, 24, 20, 1, -24 },
  { 2638, 16, 24, 20, 2, -24 },
  { 2686, 11, 33, 20, 4, -27 },
  { 2732, 16, 33, 20, 2, -27 },
  { 2798, 11, 33, 20, 4, -27 },
  { 2844, 18, 14, 20, 1, -24 },
  { 2876, 19, 4, 20, 0, 2 },
  { 2886, 9, 7, 20, 6, -27 },
  { 2894, 15, 19, 20, 2, -19 },
  { 2930, 16, 27, 20, 2, -27 },
  { 2984, 16, 19, 20, 2, -19 },
  { 3022, 16, 27, 20, 1, -27 },
  { 3076, 17, 19, 20, 1, -19 },
  { 3117, 18, 27, 20, 1, -27 },
  { 3178, 16, 26, 20, 1, -19 },
  { 3230, 15, 27, 20, 2, -27 },
  { 3281, 17, 27, 20, 1, -27 },
  { 3339, 14, 34, 20, 2, -27 },
  { 3399, 17, 27, 20, 2, -27 },
  { 3457, 17, 27, 20, 1, -27 },
  { 3515, 17, 19, 20, 1, -19 },
  { 3556, 15, 19, 20, 2, -19 },
  { 3592, 18, 20, 20, 1, -19 },
  { 3637, 16, 25, 20, 2, -19 },
  { 3687, 16, 25, 20, 1, -19 },
  { 3737, 15, 19, 20, 3, -19 },
  { 3773, 15, 19, 20, 2, -19 },
  { 3809, 18, 24, 20, 1, -24 },
  { 3863, 15, 18, 20, 2, -18 },
  { 3897, 18, 18, 20, 1, -18 },
  { 3938, 19, 18, 20, 0, -18 },
  { 3981, 18, 18, 20, 1, -18 },
  { 4022, 18, 25, 20, 1, -18 },
  { 4079, 14, 18, 20, 3, -18 },
  { 4111, 15, 33, 20, 2, -27 },
  { 4173, 5, 33, 20, 7, -27 },
  { 4194, 15, 33, 20, 2, -27 },
  { 4256, 18, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_Bold35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_BOLD35PT7B_H_
