#ifndef _UBUNTUSANSMONO_BOLD17PT7B_H_
#define _UBUNTUSANSMONO_BOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x0F, 0xF0, 0xDF, 0x7C, 0xF3, 0xCC, 0x19, 0x8D,
  0x86, 0xDF, 0xFF, 0xF9, 0x98, 0xD9, 0xFF, 0xFF, 0xB3, 0x19, 0x8D, 0x80,
  0x18, 0x18, 0x7F, 0xFE, 0xC0, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0x87, 0xFE,
  0x7C, 0x18, 0x18, 0x70, 0xE8, 0xF4, 0xDA, 0x4F, 0x63, 0x60, 0x2C, 0x3F,
  0x36, 0x93, 0x59, 0xB8, 0x70, 0x3C, 0x1F, 0x19, 0x8C, 0xC3, 0xE1, 0xD1,
  0xE6, 0xDB, 0xC7, 0x73, 0x9F, 0xE7, 0xB0, 0xFF, 0xF0, 0x08, 0x73, 0x9C,
  0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xE1, 0x83, 0x0F, 0x08, 0x83, 0x0E,
  0x0C, 0x38, 0x61, 0x87, 0x0C, 0x31, 0xC6, 0x18, 0xE7, 0x38, 0xC0, 0x18,
  0x18, 0xDE, 0xFF, 0x18, 0x7C, 0x6E, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x33, 0xCE, 0x2F, 0x20, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0x3C, 0x7E, 0xE6, 0xC7, 0xC3, 0xDB, 0xDB, 0xC3, 0xC7,
  0xC6, 0x7E, 0x7C, 0x08, 0x38, 0xF8, 0xF8, 0x98, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x7F, 0x7F, 0x7C, 0xFE, 0x46, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0x70,
  0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0x86, 0x06, 0x0E, 0x3C, 0x3E, 0x06, 0x07,
  0x06, 0xFE, 0xFC, 0x0E, 0x0E, 0x1E, 0x3E, 0x6E, 0x6E, 0xCE, 0xFF, 0xFF,
  0x0E, 0x0E, 0x0E, 0x7E, 0x7E, 0x60, 0x60, 0x60, 0x7C, 0x1E, 0x06, 0x07,
  0x06, 0xFE, 0xFC, 0x0E, 0x3E, 0x78, 0x60, 0xF8, 0xFE, 0xEE, 0xC7, 0xC7,
  0xE6, 0x7E, 0x7C, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x38,
  0x30, 0x30, 0x30, 0x3C, 0x7E, 0xC6, 0xC7, 0xE6, 0x7C, 0x7E, 0xC6, 0xC3,
  0xC7, 0xFE, 0x7E, 0x3C, 0x7E, 0xC6, 0xC7, 0xC7, 0xE7, 0x7F, 0x3E, 0x0E,
  0x1C, 0x78, 0x70, 0xFF, 0x80, 0x3F, 0xE0, 0x77, 0x70, 0x00, 0x77, 0x73,
  0xEC, 0x02, 0x1F, 0x7E, 0xF0, 0xE0, 0x7C, 0x1F, 0x06, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x7C, 0x0F, 0x0F, 0x3E, 0xF8, 0xC0, 0x7D,
  0xFD, 0x18, 0x30, 0xE3, 0x8E, 0x18, 0x00, 0x60, 0xE1, 0xC0, 0x1E, 0x1F,
  0x98, 0x6C, 0x34, 0xFE, 0xEF, 0x67, 0xB3, 0xD9, 0xE7, 0xD3, 0xEC, 0x03,
  0x00, 0xF8, 0x1A, 0x1C, 0x0E, 0x07, 0x82, 0xC3, 0x61, 0x98, 0xCC, 0xFE,
  0x7F, 0x31, 0xD8, 0x7C, 0x30, 0xFC, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xFE,
  0xC7, 0xC3, 0xC7, 0xFE, 0xFC, 0x3E, 0x7F, 0xE1, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xE0, 0x7F, 0x3F, 0xF8, 0xFE, 0xCE, 0xC7, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC7, 0xC6, 0xFE, 0xF8, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0,
  0xE1, 0xC3, 0x87, 0x00, 0x3E, 0x7F, 0xE1, 0xC0, 0xC0, 0xC0, 0xC7, 0xC7,
  0xC7, 0xE7, 0x7F, 0x3F, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x7E, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0x0F, 0xFF, 0xE0, 0xC7, 0xC6, 0xCE, 0xDC, 0xD8, 0xF0, 0xF8, 0xDC, 0xCE,
  0xCE, 0xC7, 0xC7, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0x63, 0x31, 0x9C, 0xEE, 0xF7, 0x7B, 0xED, 0xB6, 0xDB,
  0x61, 0xB0, 0xD8, 0x7C, 0x30, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB,
  0xCF, 0xCF, 0xC7, 0xC7, 0xC3, 0x3C, 0x7E, 0xE6, 0xC7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0xC7, 0xFE, 0x7C, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE,
  0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xE6, 0xC7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0xC7, 0xFE, 0x7C, 0x18, 0x1F, 0x07, 0xF8, 0xFE, 0xCE, 0xC7,
  0xC6, 0xCE, 0xFE, 0xFC, 0xCE, 0xC6, 0xC7, 0xC3, 0x3E, 0xFE, 0xC2, 0xC0,
  0xE0, 0x7C, 0x3E, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFE, 0x7C, 0xE1, 0xB0,
  0xD8, 0xEC, 0x76, 0x31, 0x98, 0xCC, 0x6C, 0x36, 0x0F, 0x07, 0x83, 0x80,
  0xE1, 0xF0, 0xD8, 0x6C, 0x36, 0xDB, 0x6D, 0xF6, 0xBF, 0x57, 0xB9, 0xDC,
  0xEC, 0x60, 0xE1, 0xB9, 0x8C, 0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x3C, 0x37,
  0x39, 0x98, 0xFC, 0x30, 0xE1, 0xB1, 0xDC, 0xC6, 0x63, 0x70, 0xF0, 0x78,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFE, 0xFE, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0xFF, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38,
  0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0xFF, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x0C, 0x0F, 0x0F, 0x87, 0xE7, 0x33,
  0x1F, 0x86, 0xFF, 0xFF, 0xC0, 0x4E, 0x30, 0x7C, 0xFC, 0x18, 0xBF, 0xF8,
  0xF1, 0xFF, 0x7E, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xE7, 0xE7, 0xE3,
  0xE7, 0xE7, 0xFE, 0xFC, 0x3F, 0x7E, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F,
  0x3F, 0x06, 0x0C, 0x18, 0x37, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xF7,
  0xE0, 0x3C, 0xFE, 0xC7, 0xC3, 0xFF, 0xC0, 0xE0, 0xFE, 0x3E, 0x1F, 0x3F,
  0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x7F,
  0xFF, 0x1E, 0x3C, 0x78, 0xFF, 0xBF, 0x06, 0x0F, 0xFF, 0xE0, 0xE1, 0xC3,
  0x87, 0x0F, 0xDF, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x60, 0x30, 0x30,
  0x30, 0x00, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0x0C,
  0x38, 0x30, 0x07, 0xEF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xFF,
  0x7E, 0xE0, 0xE0, 0xE0, 0xE0, 0xE7, 0xEE, 0xFC, 0xF8, 0xF8, 0xFC, 0xEE,
  0xE6, 0xE7, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3F, 0x1F, 0xFE, 0xFF, 0x9B, 0x9B, 0x9B, 0x9B, 0x83, 0x83, 0x83,
  0xFD, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE6, 0x7C, 0xFE, 0xC7, 0xC7,
  0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0xFC, 0xFE, 0xE7, 0xE7, 0xE3, 0xE7, 0xE7,
  0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xFF,
  0x7E, 0x0C, 0x18, 0x30, 0xFF, 0xFB, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0x7E, 0xFF, 0x87, 0x87, 0xC1, 0xE1, 0xFF, 0xFC, 0x10, 0x30, 0x30, 0xFF,
  0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC7, 0x8F, 0x1E, 0x3C,
  0x7C, 0xF9, 0xBF, 0x7E, 0xE1, 0xB1, 0xD8, 0xCE, 0x63, 0x71, 0xB0, 0x78,
  0x38, 0x1C, 0x00, 0xC1, 0xE0, 0xF3, 0x69, 0xB5, 0xDB, 0xFD, 0xDC, 0xE6,
  0x73, 0x00, 0xE3, 0xB9, 0x8F, 0x83, 0xC1, 0xC0, 0xF0, 0xDC, 0xE6, 0xE3,
  0x80, 0x61, 0xB9, 0xDC, 0xC6, 0x63, 0x30, 0xF0, 0x78, 0x3C, 0x0C, 0x0E,
  0x1E, 0x1E, 0x00, 0xFF, 0xFC, 0x30, 0xE3, 0x86, 0x18, 0x7F, 0xFE, 0x1E,
  0x7C, 0xE1, 0x83, 0x06, 0x0C, 0x78, 0xF0, 0x60, 0xC1, 0x83, 0x07, 0x0F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x07,
  0x0E, 0x30, 0x60, 0xC1, 0x83, 0x3E, 0x78, 0x31, 0x3E, 0xDB, 0xF8, 0x60,
};

const GFXglyph UbuntuSansMono_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 6, 5, 10, 2, -13 },
  { 10, 9, 12, 10, 0, -12 },
  { 24, 8, 15, 10, 1, -13 },
  { 39, 9, 12, 10, 0, -12 },
  { 53, 9, 12, 10, 0, -12 },
  { 67, 2, 6, 10, 4, -13 },
  { 69, 6, 17, 10, 2, -14 },
  { 82, 6, 17, 10, 2, -14 },
  { 95, 8, 8, 10, 1, -12 },
  { 103, 8, 8, 10, 1, -9 },
  { 111, 5, 6, 10, 2, -3 },
  { 115, 5, 2, 10, 2, -6 },
  { 117, 3, 3, 10, 3, -3 },
  { 119, 8, 16, 10, 1, -13 },
  { 135, 8, 12, 10, 1, -12 },
  { 147, 8, 12, 10, 1, -12 },
  { 159, 8, 12, 10, 1, -12 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 8, 12, 10, 1, -12 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 8, 12, 10, 1, -12 },
  { 219, 8, 12, 10, 1, -12 },
  { 231, 8, 12, 10, 1, -12 },
  { 243, 8, 12, 10, 1, -12 },
  { 255, 3, 9, 10, 3, -9 },
  { 259, 4, 12, 10, 2, -9 },
  { 265, 8, 8, 10, 1, -9 },
  { 273, 8, 6, 10, 1, -8 },
  { 279, 8, 8, 10, 1, -9 },
  { 287, 7, 12, 10, 1, -12 },
  { 298, 9, 15, 10, 0, -12 },
  { 315, 9, 12, 10, 0, -12 },
  { 329, 8, 12, 10, 1, -12 },
  { 341, 8, 12, 10, 1, -12 },
  { 353, 8, 12, 10, 1, -12 },
  { 365, 8, 12, 10, 1, -12 },
  { 377, 7, 12, 10, 1, -12 },
  { 388, 8, 12, 10, 1, -12 },
  { 400, 8, 12, 10, 1, -12 },
  { 412, 8, 12, 10, 1, -12 },
  { 424, 7, 12, 10, 1, -12 },
  { 435, 8, 12, 10, 1, -12 },
  { 447, 8, 12, 10, 1, -12 },
  { 459, 9, 12, 10, 0, -12 },
  { 473, 8, 12, 10, 1, -12 },
  { 485, 8, 12, 10, 1, -12 },
  { 497, 8, 12, 10, 1, -12 },
  { 509, 8, 15, 10, 1, -12 },
  { 524, 8, 12, 10, 1, -12 },
  { 536, 8, 12, 10, 1, -12 },
  { 548, 9, 12, 10, 0, -12 },
  { 562, 8, 12, 10, 1, -12 },
  { 574, 9, 12, 10, 0, -12 },
  { 588, 9, 12, 10, 0, -12 },
  { 602, 9, 12, 10, 0, -12 },
  { 616, 9, 12, 10, 0, -12 },
  { 630, 8, 12, 10, 1, -12 },
  { 642, 5, 16, 10, 2, -13 },
  { 652, 8, 16, 10, 1, -13 },
  { 668, 5, 16, 10, 2, -13 },
  { 678, 9, 7, 10, 0, -12 },
  { 686, 9, 2, 10, 0, 1 },
  { 689, 4, 3, 10, 3, -13 },
  { 691, 7, 9, 10, 1, -9 },
  { 699, 8, 13, 10, 1, -13 },
  { 712, 8, 9, 10, 1, -9 },
  { 721, 7, 13, 10, 1, -13 },
  { 733, 8, 9, 10, 1, -9 },
  { 742, 8, 13, 10, 1, -13 },
  { 755, 7, 12, 10, 1, -9 },
  { 766, 7, 13, 10, 1, -13 },
  { 778, 8, 13, 10, 1, -13 },
  { 791, 7, 16, 10, 1, -13 },
  { 805, 8, 13, 10, 1, -13 },
  { 818, 8, 13, 10, 1, -13 },
  { 831, 8, 9, 10, 1, -9 },
  { 840, 7, 9, 10, 1, -9 },
  { 848, 8, 9, 10, 1, -9 },
  { 857, 8, 12, 10, 1, -9 },
  { 869, 7, 12, 10, 1, -9 },
  { 880, 7, 9, 10, 2, -9 },
  { 888, 7, 9, 10, 1, -9 },
  { 896, 8, 12, 10, 1, -12 },
  { 908, 7, 9, 10, 1, -9 },
  { 916, 9, 9, 10, 0, -9 },
  { 927, 9, 9, 10, 0, -9 },
  { 938, 9, 9, 10, 0, -9 },
  { 949, 9, 12, 10, 0, -9 },
  { 963, 7, 9, 10, 1, -9 },
  { 971, 7, 16, 10, 1, -13 },
  { 985, 2, 16, 10, 4, -13 },
  { 989, 7, 16, 10, 1, -13 },
  { 1003, 9, 4, 10, 0, -7 },
};

const GFXfont UbuntuSansMono_Bold17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_BOLD17PT7B_H_
