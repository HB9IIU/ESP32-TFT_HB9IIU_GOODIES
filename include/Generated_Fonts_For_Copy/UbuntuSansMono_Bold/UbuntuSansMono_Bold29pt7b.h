#ifndef _UBUNTUSANSMONO_BOLD29PT7B_H_
#define _UBUNTUSANSMONO_BOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x0E, 0x7F, 0xF7, 0xDE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F,
  0x1D, 0x87, 0x61, 0xC0, 0x0F, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0,
  0xE7, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x39, 0xE0, 0xF3,
  0xC1, 0xE7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0xF0, 0x79, 0xC0,
  0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x9E, 0x02, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF4, 0x03, 0xDF, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0xFC, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x10, 0x00, 0x7C, 0x07, 0x7E, 0x0E, 0xE6, 0x0C,
  0xE7, 0x1C, 0xE7, 0x38, 0xE7, 0x38, 0x66, 0x70, 0x7E, 0xE0, 0x7C, 0xE0,
  0x11, 0xC0, 0x03, 0x88, 0x03, 0xBE, 0x07, 0x7E, 0x0E, 0x67, 0x0E, 0x67,
  0x1C, 0x67, 0x38, 0x67, 0x38, 0x77, 0x70, 0x7E, 0xE0, 0x3E, 0x02, 0x00,
  0x3F, 0x80, 0xFF, 0x03, 0xEF, 0x07, 0x8E, 0x0F, 0x1C, 0x1E, 0x78, 0x3C,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x78, 0x73, 0xF9, 0xE7, 0xFB, 0xDE, 0xFF,
  0x38, 0xFE, 0x70, 0xFC, 0xE0, 0xF1, 0xE1, 0xF3, 0xFF, 0xF3, 0xFF, 0xE3,
  0xF1, 0xE0, 0xFF, 0xFF, 0xFF, 0xF7, 0x76, 0x00, 0x80, 0x78, 0x1F, 0x87,
  0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x0F, 0x00, 0xC0, 0x08, 0x60,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x81, 0x80, 0x40, 0x00,
  0x0F, 0x00, 0x78, 0x21, 0xC1, 0xCE, 0xEF, 0xEF, 0x7F, 0xFD, 0xFF, 0xC1,
  0xF0, 0x1F, 0xC1, 0xEF, 0x1E, 0x78, 0x71, 0x81, 0x08, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0x3E, 0x7D, 0xF9, 0xF3, 0xE1, 0xC7, 0x7E, 0xF8, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x7F, 0x83, 0xFF, 0x0F, 0xFE,
  0x78, 0x79, 0xE1, 0xE7, 0x03, 0xFC, 0x0F, 0xF1, 0x3F, 0xCE, 0xFF, 0x7B,
  0xFD, 0xEF, 0xF3, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x79, 0xF1,
  0xE3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x03, 0x80, 0x7C, 0x07, 0xE0, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC1, 0x9E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF0, 0x02, 0x00, 0x7F, 0x87, 0xFF, 0x3F, 0xFE, 0x70, 0xF8,
  0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0xFF,
  0xDF, 0xFF, 0x7F, 0xFC, 0x03, 0x00, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x20,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x7D, 0x83, 0xE7,
  0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x0F,
  0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x40, 0xF9, 0xFF, 0xCF,
  0xFF, 0x3F, 0xF0, 0x01, 0xF0, 0x3F, 0x87, 0xFC, 0x7F, 0x07, 0xE0, 0x3C,
  0x03, 0xE0, 0x1E, 0xF0, 0xFF, 0xE7, 0xFF, 0xBE, 0xFD, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF8, 0xF3, 0xFF, 0x9F, 0xF8, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x03, 0x00, 0x7F,
  0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x79, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x7C,
  0x78, 0xFF, 0xC1, 0xFE, 0x0F, 0xFC, 0x79, 0xF9, 0xE1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xE0, 0x03, 0x00,
  0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x79, 0xE1, 0xEF, 0x03, 0xFC, 0x0F,
  0x78, 0x3D, 0xE0, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x0D, 0xE0, 0x07,
  0x80, 0x3C, 0x03, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x3C, 0x00, 0x7B,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0x3C,
  0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xEF, 0xCF,
  0x87, 0x1D, 0xF3, 0xC6, 0x00, 0x00, 0x18, 0x03, 0xF0, 0x3F, 0xC3, 0xFE,
  0x7F, 0xC3, 0xFC, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x00, 0x38, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x01,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x7F,
  0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0x70, 0x01, 0x00, 0x00, 0x06,
  0x07, 0xFC, 0xFF, 0xE7, 0xFF, 0x41, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0x00, 0x3F, 0xC1, 0xFF,
  0x8F, 0x9E, 0x78, 0x3D, 0xC0, 0x7E, 0x01, 0xF8, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x71, 0xFB, 0xC7, 0xEF, 0x1F, 0xBC, 0x7E, 0xF1, 0xF9, 0xC7, 0xE7,
  0x9F, 0x9F, 0xFE, 0x3F, 0xDC, 0x3E, 0x70, 0x01, 0xF0, 0x03, 0xFB, 0x87,
  0xFE, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD,
  0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x3E, 0xFF, 0xE7, 0xFE, 0x3F,
  0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF,
  0xBF, 0xF9, 0xFF, 0x80, 0x00, 0xC0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7E,
  0x09, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF8, 0x23,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xE3, 0xEF,
  0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0xF3, 0xF7, 0xFF, 0x3F, 0xF1,
  0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x80, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x7E, 0x09, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x3D, 0xF0,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE8, 0x0F, 0x70, 0xFB, 0xFF, 0xBF, 0xF8, 0x7F, 0x80, 0xF0,
  0x7D, 0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0,
  0x7B, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xBE, 0x0F, 0x3E, 0x1E,
  0x3E, 0x3C, 0x3C, 0x78, 0x7C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF7, 0x81,
  0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x39,
  0xE1, 0xE7, 0x87, 0xDE, 0x1F, 0xFC, 0xFF, 0xB3, 0xFE, 0xCD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x9F, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFD, 0xCF, 0xEE, 0x7F,
  0x3B, 0xF9, 0xDF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xF0, 0x01, 0x00, 0x7F, 0x83, 0xFF, 0x0F,
  0xFE, 0x78, 0x79, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D,
  0xF1, 0xE3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD,
  0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xFF,
  0xFD, 0xFF, 0xCF, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x9F, 0x1E, 0x78,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1F, 0x78, 0x78, 0xFF, 0xE3,
  0xFF, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7C,
  0x00, 0x10, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3,
  0xEF, 0x0F, 0xBC, 0x3C, 0xF0, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xBC,
  0x1F, 0x03, 0x00, 0x7F, 0xC3, 0xFF, 0x9F, 0xFC, 0x78, 0x11, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3D, 0x81, 0xF7, 0xFF, 0xBF, 0xFE,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xDE, 0x0F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF8,
  0xF8, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x78,
  0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x7D, 0xFB,
  0xF7, 0xEE, 0xDF, 0xB3, 0x7E, 0xCF, 0xDF, 0x1F, 0x78, 0x7D, 0xE1, 0xF7,
  0x83, 0xDC, 0x0E, 0x78, 0x1F, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3C, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0x78, 0x1E, 0x7C,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xDE, 0x0F, 0x3E, 0x3E,
  0x3C, 0xF8, 0x7D, 0xE0, 0x7D, 0xC0, 0x71, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x60, 0xF3, 0xF1, 0xF0, 0xC0, 0x0F, 0x81, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xFF, 0x7F, 0xFB, 0xE3,
  0xFE, 0x1F, 0xE0, 0xF7, 0x87, 0xBF, 0xFD, 0xFF, 0xE3, 0xFF, 0x10, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x60, 0xFF,
  0xE7, 0xFF, 0xBF, 0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x00,
  0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x04, 0xFF,
  0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x08, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0xCF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1E, 0xF8,
  0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x03, 0x80, 0x7F, 0x83, 0xFF, 0x1F,
  0xFE, 0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x7C, 0x19, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x40,
  0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xCF, 0xFE, 0xFF,
  0xF7, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1E,
  0xF9, 0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x0F, 0x00, 0x7A, 0x07, 0xDF,
  0xFC, 0xFF, 0xEF, 0xFC, 0x00, 0x10, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x60, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF0, 0x04, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE1, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x80, 0x78,
  0x0F, 0x03, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFD, 0xFF,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x63, 0xFF, 0xFB, 0xFF, 0x7F, 0xC0,
  0x40, 0x10, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0xFB, 0xC7, 0xCF, 0x1E, 0x3C, 0xF0, 0xF7, 0x83,
  0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x83, 0xCF, 0x0F, 0x3E, 0x3C, 0x7C,
  0xF0, 0xF3, 0xC3, 0xEF, 0x07, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x41, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF9, 0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7,
  0x9F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0,
  0x06, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x7C, 0x79, 0xFF,
  0xE3, 0xFF, 0x03, 0xF8, 0x0E, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x0F, 0xFF, 0xFB, 0xFF, 0x9F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0x87, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7, 0x87,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x6F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0x83, 0xFF, 0x7F, 0xEF, 0xFE, 0xF0, 0x2F, 0x00, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFC, 0x03, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x04, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xF7, 0xFF, 0x3F, 0xF0,
  0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F,
  0x71, 0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xEE, 0x73, 0xEE, 0x77, 0xEE,
  0x77, 0x6E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C,
  0xF0, 0x3C, 0xF0, 0xF0, 0xF1, 0xE1, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0xF3, 0xC1, 0xE7, 0xC7, 0x87,
  0x9F, 0x07, 0xBC, 0x0F, 0x80, 0xF8, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x83, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xF8, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0x18, 0x00, 0x7C, 0x1D, 0xFE, 0x7F, 0xFF,
  0xEF, 0x7F, 0xDC, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 20, 16, 5, -20 },
  { 16, 10, 9, 16, 3, -22 },
  { 28, 15, 20, 16, 1, -20 },
  { 66, 14, 26, 16, 1, -23 },
  { 112, 16, 21, 16, 0, -21 },
  { 154, 15, 21, 16, 1, -21 },
  { 194, 4, 10, 16, 6, -22 },
  { 199, 11, 29, 16, 3, -23 },
  { 239, 10, 29, 16, 3, -23 },
  { 276, 13, 13, 16, 2, -20 },
  { 298, 14, 15, 16, 1, -16 },
  { 325, 7, 10, 16, 4, -5 },
  { 334, 9, 4, 16, 4, -10 },
  { 339, 6, 5, 16, 5, -5 },
  { 343, 13, 28, 16, 2, -23 },
  { 389, 14, 21, 16, 1, -21 },
  { 426, 13, 20, 16, 2, -20 },
  { 459, 14, 21, 16, 1, -21 },
  { 496, 14, 21, 16, 1, -21 },
  { 533, 14, 20, 16, 1, -20 },
  { 568, 14, 20, 16, 1, -20 },
  { 603, 13, 20, 16, 2, -20 },
  { 636, 13, 20, 16, 2, -20 },
  { 669, 14, 21, 16, 1, -21 },
  { 706, 14, 21, 16, 1, -21 },
  { 743, 6, 15, 16, 5, -15 },
  { 755, 7, 20, 16, 4, -15 },
  { 773, 14, 14, 16, 1, -15 },
  { 798, 14, 9, 16, 1, -13 },
  { 814, 14, 14, 16, 1, -15 },
  { 839, 12, 21, 16, 2, -21 },
  { 871, 14, 25, 16, 1, -21 },
  { 915, 16, 20, 16, 0, -20 },
  { 955, 13, 20, 16, 2, -20 },
  { 988, 14, 21, 16, 1, -21 },
  { 1025, 13, 20, 16, 2, -20 },
  { 1058, 13, 20, 16, 2, -20 },
  { 1091, 12, 20, 16, 2, -20 },
  { 1121, 14, 21, 16, 1, -21 },
  { 1158, 14, 20, 16, 1, -20 },
  { 1193, 13, 20, 16, 2, -20 },
  { 1226, 13, 20, 16, 1, -20 },
  { 1259, 15, 20, 16, 1, -20 },
  { 1297, 13, 20, 16, 2, -20 },
  { 1330, 14, 20, 16, 1, -20 },
  { 1365, 13, 20, 16, 2, -20 },
  { 1398, 14, 21, 16, 1, -21 },
  { 1435, 13, 20, 16, 2, -20 },
  { 1468, 14, 26, 16, 1, -20 },
  { 1514, 14, 20, 16, 2, -20 },
  { 1549, 14, 21, 16, 1, -21 },
  { 1586, 14, 20, 16, 1, -20 },
  { 1621, 14, 20, 16, 1, -20 },
  { 1656, 16, 20, 16, 0, -20 },
  { 1696, 14, 20, 16, 1, -20 },
  { 1731, 16, 20, 16, 0, -20 },
  { 1771, 16, 20, 16, 0, -20 },
  { 1811, 13, 20, 16, 2, -20 },
  { 1844, 9, 28, 16, 4, -23 },
  { 1876, 13, 28, 16, 2, -23 },
  { 1922, 9, 28, 16, 4, -23 },
  { 1954, 15, 12, 16, 1, -20 },
  { 1977, 16, 3, 16, 0, 2 },
  { 1983, 7, 5, 16, 5, -22 },
  { 1988, 13, 16, 16, 1, -16 },
  { 2014, 13, 23, 16, 2, -23 },
  { 2052, 14, 16, 16, 1, -16 },
  { 2080, 13, 23, 16, 1, -23 },
  { 2118, 14, 16, 16, 1, -16 },
  { 2146, 15, 23, 16, 1, -23 },
  { 2190, 13, 21, 16, 1, -16 },
  { 2225, 12, 23, 16, 2, -23 },
  { 2260, 14, 23, 16, 1, -23 },
  { 2301, 11, 29, 16, 2, -23 },
  { 2341, 14, 23, 16, 2, -23 },
  { 2382, 14, 22, 16, 1, -22 },
  { 2421, 14, 15, 16, 1, -15 },
  { 2448, 12, 16, 16, 2, -16 },
  { 2472, 14, 16, 16, 1, -16 },
  { 2500, 13, 21, 16, 2, -16 },
  { 2535, 13, 21, 16, 1, -16 },
  { 2570, 12, 16, 16, 3, -16 },
  { 2594, 12, 16, 16, 2, -16 },
  { 2618, 14, 20, 16, 1, -20 },
  { 2653, 12, 15, 16, 2, -15 },
  { 2676, 16, 15, 16, 0, -15 },
  { 2706, 16, 15, 16, 0, -15 },
  { 2736, 15, 15, 16, 1, -15 },
  { 2765, 14, 20, 16, 1, -15 },
  { 2800, 12, 15, 16, 2, -15 },
  { 2823, 12, 28, 16, 2, -23 },
  { 2865, 4, 28, 16, 6, -23 },
  { 2879, 12, 28, 16, 2, -23 },
  { 2921, 15, 6, 16, 1, -12 },
};

const GFXfont UbuntuSansMono_Bold29pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold29pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold29pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUSANSMONO_BOLD29PT7B_H_
