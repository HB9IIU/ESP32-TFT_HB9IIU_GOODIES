#ifndef _UBUNTUSANSMONO_BOLD23PT7B_H_
#define _UBUNTUSANSMONO_BOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x07, 0x7B, 0xEE, 0xF7,
  0xFB, 0xFD, 0xFC, 0x66, 0x33, 0x19, 0x8C, 0x0E, 0x70, 0xE6, 0x0C, 0x60,
  0xCE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x19, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x39, 0x83, 0x38, 0x33, 0x87, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x1F,
  0xF7, 0xFC, 0xE1, 0xBC, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1E, 0x01, 0xD0, 0x7F, 0xFF, 0xFF, 0xC7, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x78, 0x3B, 0xE1, 0xB3, 0x19, 0x99, 0xCC, 0xCC, 0x7E, 0xC1, 0xEE, 0x06,
  0x60, 0x06, 0x60, 0x77, 0x83, 0x6C, 0x33, 0x33, 0x99, 0x98, 0xDD, 0x87,
  0xDC, 0x1E, 0x3E, 0x0F, 0xE1, 0xCE, 0x31, 0xC6, 0x30, 0xEE, 0x1F, 0x81,
  0xE7, 0x7C, 0xFD, 0xDF, 0x1F, 0x63, 0xEC, 0x3D, 0xC7, 0xBF, 0xFB, 0xF7,
  0xFF, 0xFF, 0xF8, 0x03, 0x03, 0xC3, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07,
  0x03, 0xC0, 0xF8, 0x18, 0x60, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x0F, 0x03, 0x00, 0x0E, 0x01, 0xC1, 0x39, 0x3A, 0xEF, 0xFE,
  0x1E, 0x06, 0xC1, 0xDC, 0x7B, 0xC2, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x39, 0xF7, 0xCF, 0x1C, 0xEF, 0x10, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x00, 0x1F, 0x07, 0xF1, 0xEF, 0x78,
  0xEE, 0x0F, 0xC1, 0xFB, 0x3F, 0x77, 0xEE, 0xFC, 0x1F, 0x83, 0xF0, 0x7F,
  0x1C, 0xF7, 0x9F, 0xE0, 0xF8, 0x07, 0x01, 0xE0, 0xFC, 0x7F, 0x87, 0xF0,
  0xDE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xFF,
  0xDF, 0xFB, 0xFF, 0x3F, 0x1F, 0xF1, 0xDF, 0x20, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x1F, 0xF1, 0xCF, 0x00, 0xE0, 0x1C, 0x07, 0x87, 0xE0, 0xF8,
  0x1F, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1C, 0xC7, 0xBF, 0xF7, 0xF8, 0x03,
  0xC0, 0xF8, 0x1F, 0x07, 0xE1, 0xFC, 0x77, 0x8E, 0xF3, 0x9E, 0xE3, 0xDC,
  0x7B, 0xFF, 0xFF, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x3F, 0xC7, 0xF8,
  0xFF, 0x18, 0x03, 0x00, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x1D, 0xCF, 0xBF, 0xE7, 0xF8, 0x03, 0xC1, 0xF8, 0x7F, 0x1E,
  0x07, 0x80, 0xE0, 0x1F, 0xE7, 0xFE, 0xF3, 0xDC, 0x3F, 0x83, 0xF0, 0x77,
  0x1E, 0xF7, 0x9F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x3F, 0x8F, 0xF9, 0xCF, 0x70, 0xFE, 0x1C, 0xE3, 0x9E,
  0xF1, 0xFC, 0x3F, 0x8E, 0x7B, 0x87, 0xF0, 0x7E, 0x0F, 0xE3, 0xDF, 0xF1,
  0xFC, 0x3F, 0x0F, 0xF1, 0xCF, 0x78, 0xEE, 0x1F, 0xC1, 0xFC, 0x3B, 0xDF,
  0x7F, 0xE7, 0xF8, 0x07, 0x01, 0xE0, 0x78, 0xFE, 0x1F, 0x83, 0xC0, 0x77,
  0xFE, 0xE0, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0x39, 0xF7, 0xCE, 0x00, 0x00,
  0x00, 0x39, 0xF7, 0xCF, 0x18, 0xEF, 0x30, 0x00, 0xC0, 0x7C, 0x3F, 0xBF,
  0xCF, 0xC1, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3C, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x1F,
  0x03, 0xF8, 0x1F, 0xE0, 0x7E, 0x03, 0xC3, 0xF9, 0xFC, 0xFE, 0x1E, 0x01,
  0x00, 0x00, 0xFF, 0x7F, 0xF9, 0xE0, 0x70, 0x38, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x78, 0x0F, 0xC1, 0xFE, 0x38,
  0x77, 0x07, 0x70, 0x76, 0x3F, 0x67, 0xF6, 0x77, 0xEE, 0x7E, 0xE7, 0xEE,
  0x76, 0xE7, 0x67, 0x76, 0x7F, 0x73, 0xF7, 0x00, 0x38, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1B, 0x01, 0xDC, 0x0E, 0xE0, 0x77,
  0x03, 0x18, 0x38, 0xE1, 0xC7, 0x0F, 0xF8, 0xFF, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xDE, 0x0F, 0xFF, 0x1F, 0xF3, 0xFF, 0x78, 0xEF, 0x1D, 0xE3, 0xBF,
  0xE7, 0xF8, 0xFF, 0xDE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFC, 0x0F, 0xC7, 0xFD, 0xF3, 0xB8, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF9, 0xCF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xF3, 0xFF, 0x78, 0xEF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0xFF, 0x1D, 0xFF, 0xBF, 0xE7, 0xF0, 0xFF, 0xBF, 0xEF,
  0xFB, 0x80, 0xE0, 0x38, 0x0F, 0xF3, 0xFC, 0xFF, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03,
  0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1F,
  0xC7, 0xFD, 0xF3, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x0E, 0xFB, 0xCF, 0xF8, 0xFF, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x41, 0xDD, 0xFF, 0xF9,
  0xFC, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xF0, 0xFE, 0x0F,
  0xC0, 0xFE, 0x0E, 0xF0, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1E, 0xE1, 0xEE,
  0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xDE, 0x3B,
  0xC7, 0xF8, 0xFD, 0xB7, 0xB7, 0xF6, 0xFE, 0xF7, 0xCE, 0xF9, 0xDF, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC,
  0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0x1F, 0x0F, 0xF1, 0xEF, 0x78, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xF7,
  0x9F, 0xE1, 0xF8, 0xFF, 0x1F, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC,
  0x3F, 0x8F, 0xFF, 0xDF, 0xF3, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xF7, 0x9F, 0xF1, 0xF8, 0x0E,
  0x01, 0xE0, 0x1F, 0x80, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF, 0x1C, 0xF1,
  0xEF, 0x1E, 0xF1, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF7, 0x8F, 0x38, 0xF1,
  0xCF, 0x1C, 0xF0, 0xEF, 0x0F, 0x3F, 0xCF, 0xF9, 0xE6, 0x78, 0x0E, 0x01,
  0xE0, 0x1F, 0x01, 0xFC, 0x1F, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E, 0xC7,
  0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xF7, 0x9F, 0xF1, 0xFC, 0xF0,
  0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x1C, 0x70, 0xE3, 0x87, 0x1C,
  0x38, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x80, 0xD8, 0x07, 0xC0, 0x3E, 0x00,
  0xE0, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF3, 0xBE, 0x77,
  0xDE, 0xFB, 0x7F, 0x6F, 0xED, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x06, 0x70,
  0x73, 0xC7, 0x8E, 0x38, 0x7B, 0x81, 0xDC, 0x07, 0xC0, 0x3E, 0x00, 0xE0,
  0x0F, 0x80, 0x7C, 0x07, 0x70, 0x3B, 0xC3, 0x8E, 0x3C, 0x79, 0xC1, 0xDE,
  0x0F, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x77,
  0x01, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x7F, 0xCF, 0xF9, 0xFF, 0x01, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xC0, 0xF0, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC0,
  0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xDE, 0x1E, 0x71, 0xE3, 0xDE,
  0x0F, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x41, 0x8F, 0x8F, 0x08,
  0x7F, 0x8F, 0xF2, 0x3C, 0x07, 0x01, 0xDF, 0xF7, 0xFF, 0x87, 0xE1, 0xFC,
  0x77, 0xFC, 0xFF, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xF3,
  0xFE, 0xF7, 0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x9E, 0xFF,
  0xBF, 0x80, 0x1F, 0xE7, 0xF9, 0xF1, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0xDC, 0xFF, 0x8F, 0xF0, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x73, 0xFD, 0xFF, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0x1F, 0xE7, 0x7F, 0xCF, 0xF0, 0x3F, 0x8F, 0xF9, 0xC7, 0x70, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0xB9, 0xFF, 0x0F, 0xE0, 0x03,
  0xE0, 0xFF, 0x1F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3F, 0xDF, 0xFF, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xFB, 0xDF, 0xF3, 0xFC, 0x07, 0x01, 0xD8, 0xFF, 0xFB, 0xFC, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFF, 0xE7, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x1C, 0x03, 0x80, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x7F, 0x0F, 0xE0, 0xFC, 0x03, 0x03, 0xC1, 0xE0,
  0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x7F, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xEE, 0xF7, 0xFF, 0xF8, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0xF7, 0x3C, 0xE7, 0x1D, 0xC3, 0xF0,
  0x7E, 0x0F, 0xE1, 0xDC, 0x39, 0xC7, 0x3C, 0xE3, 0xDC, 0x3C, 0xFC, 0x1F,
  0x83, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x7B, 0x0F, 0xE0, 0xFC, 0xFF,
  0xDF, 0xFF, 0x3B, 0xE7, 0x7C, 0xE7, 0x9C, 0xF3, 0x9E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x30, 0xFF, 0x7F, 0xF9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3F, 0x8F, 0xF9, 0xEF, 0x70, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEF, 0x79, 0xFF, 0x1F, 0xC0, 0xFF,
  0x3F, 0xEE, 0x7B, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFD, 0xEF,
  0xFB, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3F, 0xDF, 0xF7, 0x9F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFE, 0xF7, 0xFC, 0xFF, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x7F, 0xFF, 0xFF, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x3F, 0xDF, 0xF7, 0x09, 0xC0, 0x7C,
  0x1F, 0xC1, 0xFC, 0x0F, 0x01, 0xDC, 0xFF, 0xFD, 0xFE, 0x04, 0x03, 0x80,
  0x70, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3D, 0xC7, 0xF8, 0x7F, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xFF, 0xEF, 0xF0, 0xF0, 0x7B, 0x83,
  0x9C, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0xF0, 0x77, 0x03, 0xB8, 0x1F, 0x80,
  0x7C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x3F, 0x01, 0x99, 0xCC, 0xCE, 0x66,
  0x73, 0x33, 0x99, 0xBE, 0xCD, 0xBE, 0x7D, 0xE1, 0xCF, 0x0E, 0x38, 0x71,
  0xC0, 0x70, 0x73, 0x8E, 0x3D, 0xC1, 0xDC, 0x0F, 0x80, 0x70, 0x0F, 0x81,
  0xFC, 0x1D, 0xC3, 0x8E, 0x78, 0xFF, 0x07, 0x70, 0x77, 0x87, 0x38, 0xE3,
  0x8E, 0x3C, 0xE1, 0xCE, 0x1D, 0xC1, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0x80,
  0x70, 0x07, 0x04, 0xE0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0,
  0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0x8F, 0xC7,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x3C, 0x1E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xF8, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x0F, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x01, 0xE0, 0xF0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xC7, 0xC0, 0x78, 0x7F, 0xEE, 0xFF,
  0xEC, 0x7C, 0x41, 0x80,
};

const GFXglyph UbuntuSansMono_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 9, 7, 13, 2, -17 },
  { 19, 12, 16, 13, 0, -16 },
  { 43, 11, 21, 13, 1, -18 },
  { 72, 13, 16, 13, 0, -16 },
  { 98, 11, 16, 13, 1, -16 },
  { 120, 3, 7, 13, 5, -17 },
  { 123, 9, 22, 13, 2, -18 },
  { 148, 9, 22, 13, 2, -18 },
  { 173, 11, 10, 13, 1, -16 },
  { 187, 11, 12, 13, 1, -13 },
  { 204, 6, 8, 13, 3, -4 },
  { 210, 7, 3, 13, 3, -8 },
  { 213, 5, 4, 13, 4, -4 },
  { 216, 11, 22, 13, 1, -18 },
  { 247, 11, 16, 13, 1, -16 },
  { 269, 11, 16, 13, 1, -16 },
  { 291, 11, 16, 13, 1, -16 },
  { 313, 11, 16, 13, 1, -16 },
  { 335, 11, 16, 13, 1, -16 },
  { 357, 11, 16, 13, 1, -16 },
  { 379, 11, 16, 13, 1, -16 },
  { 401, 11, 16, 13, 1, -16 },
  { 423, 11, 16, 13, 1, -16 },
  { 445, 11, 16, 13, 1, -16 },
  { 467, 5, 12, 13, 4, -12 },
  { 475, 6, 16, 13, 3, -12 },
  { 487, 11, 11, 13, 1, -12 },
  { 503, 11, 8, 13, 1, -11 },
  { 514, 11, 11, 13, 1, -12 },
  { 530, 9, 16, 13, 2, -16 },
  { 548, 12, 19, 13, 0, -16 },
  { 577, 13, 16, 13, 0, -16 },
  { 603, 11, 16, 13, 1, -16 },
  { 625, 11, 16, 13, 1, -16 },
  { 647, 11, 16, 13, 1, -16 },
  { 669, 10, 16, 13, 2, -16 },
  { 689, 9, 16, 13, 2, -16 },
  { 707, 11, 16, 13, 1, -16 },
  { 729, 11, 16, 13, 1, -16 },
  { 751, 11, 16, 13, 1, -16 },
  { 773, 10, 16, 13, 1, -16 },
  { 793, 12, 16, 13, 1, -16 },
  { 817, 10, 16, 13, 2, -16 },
  { 837, 11, 16, 13, 1, -16 },
  { 859, 11, 16, 13, 1, -16 },
  { 881, 11, 16, 13, 1, -16 },
  { 903, 11, 16, 13, 1, -16 },
  { 925, 11, 20, 13, 1, -16 },
  { 953, 12, 16, 13, 1, -16 },
  { 977, 11, 16, 13, 1, -16 },
  { 999, 11, 16, 13, 1, -16 },
  { 1021, 11, 16, 13, 1, -16 },
  { 1043, 13, 16, 13, 0, -16 },
  { 1069, 11, 16, 13, 1, -16 },
  { 1091, 13, 16, 13, 0, -16 },
  { 1117, 13, 16, 13, 0, -16 },
  { 1143, 11, 16, 13, 1, -16 },
  { 1165, 7, 22, 13, 3, -18 },
  { 1185, 11, 22, 13, 1, -18 },
  { 1216, 7, 22, 13, 3, -18 },
  { 1236, 13, 9, 13, 0, -16 },
  { 1251, 13, 3, 13, 0, 1 },
  { 1256, 6, 5, 13, 4, -18 },
  { 1260, 10, 12, 13, 1, -12 },
  { 1275, 10, 18, 13, 2, -18 },
  { 1298, 11, 12, 13, 1, -12 },
  { 1315, 10, 18, 13, 1, -18 },
  { 1338, 11, 12, 13, 1, -12 },
  { 1355, 12, 18, 13, 1, -18 },
  { 1382, 10, 16, 13, 1, -12 },
  { 1402, 9, 18, 13, 2, -18 },
  { 1423, 11, 18, 13, 1, -18 },
  { 1448, 9, 22, 13, 1, -18 },
  { 1473, 11, 18, 13, 2, -18 },
  { 1498, 11, 18, 13, 1, -18 },
  { 1523, 11, 12, 13, 1, -12 },
  { 1540, 9, 12, 13, 2, -12 },
  { 1554, 11, 12, 13, 1, -12 },
  { 1571, 10, 16, 13, 2, -12 },
  { 1591, 10, 16, 13, 1, -12 },
  { 1611, 10, 12, 13, 2, -12 },
  { 1626, 10, 12, 13, 1, -12 },
  { 1641, 11, 16, 13, 1, -16 },
  { 1663, 9, 12, 13, 2, -12 },
  { 1677, 13, 12, 13, 0, -12 },
  { 1697, 13, 12, 13, 0, -12 },
  { 1717, 12, 12, 13, 0, -12 },
  { 1735, 12, 16, 13, 0, -12 },
  { 1759, 9, 12, 13, 2, -12 },
  { 1773, 9, 22, 13, 2, -18 },
  { 1798, 3, 22, 13, 5, -18 },
  { 1807, 9, 22, 13, 2, -18 },
  { 1832, 12, 5, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_Bold23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_BOLD23PT7B_H_
