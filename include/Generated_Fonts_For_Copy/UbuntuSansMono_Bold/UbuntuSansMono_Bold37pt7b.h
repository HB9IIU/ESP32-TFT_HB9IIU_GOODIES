#ifndef _UBUNTUSANSMONO_BOLD37PT7B_H_
#define _UBUNTUSANSMONO_BOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0xBF, 0xFF, 0xFE, 0xF8,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF0, 0xFF, 0x83, 0x9C, 0x1C, 0xE0, 0xE0, 0x03, 0xC7, 0xC0, 0x78,
  0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x8F,
  0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC3, 0xC0, 0x78, 0xF8,
  0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0x9F, 0x9F, 0x80, 0x27, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0xC0, 0x3F, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x79, 0xFC, 0x07, 0x9F, 0xE0, 0x38, 0xE7, 0x03, 0xCF,
  0x3C, 0x3C, 0x79, 0xE1, 0xC3, 0xCF, 0x1E, 0x1E, 0x79, 0xE0, 0x73, 0xCE,
  0x03, 0xFC, 0xF0, 0x1F, 0xEF, 0x00, 0x7E, 0x70, 0x00, 0xC7, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x9F, 0x00, 0x3D, 0xFC, 0x03, 0xCF, 0xF0, 0x1C, 0xF7,
  0x81, 0xE7, 0x1C, 0x1E, 0x38, 0xE0, 0xE1, 0xC7, 0x0F, 0x0E, 0x38, 0xF0,
  0x79, 0xC7, 0x03, 0xFE, 0x78, 0x0F, 0xE7, 0x80, 0x3F, 0x00, 0x00, 0x40,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xC3, 0xC0,
  0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF8, 0xF3,
  0xFF, 0xBE, 0xF9, 0xFF, 0x9E, 0x1F, 0xF3, 0xC1, 0xFE, 0x78, 0x1F, 0x8F,
  0x01, 0xF1, 0xF0, 0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xF7, 0xC3,
  0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0xE0, 0x00, 0x70,
  0x07, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x40, 0x60, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0x1C, 0x33, 0xCE, 0x7B, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xF7, 0xC1,
  0xF3, 0xF0, 0x78, 0xF0, 0x18, 0x30, 0x04, 0x10, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x0F, 0x0F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x0F, 0x07, 0x0F, 0xBF,
  0x8F, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x8F, 0x83, 0xE7,
  0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x8E, 0x3F, 0xE7,
  0x8F, 0xF9, 0xF3, 0xFE, 0x7C, 0xFF, 0x8E, 0x3F, 0xE0, 0x0F, 0x78, 0x07,
  0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x0F, 0x8F, 0x87, 0xE3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x79, 0xF0, 0x30, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xC7, 0xF3, 0x81, 0xF8, 0x80, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7,
  0x87, 0xE1, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF2,
  0x01, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x01, 0xF3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07,
  0xC7, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x98, 0x07, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFE, 0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC1,
  0xF3, 0xF1, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x1E, 0xF8, 0x1F, 0x3E, 0x0F, 0x9F, 0xCF, 0x87, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8, 0xFE, 0xF8, 0x1F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0x0F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x01, 0x9F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0x80, 0x1E, 0x00, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x3F, 0x7F, 0xFF, 0xFF, 0xFB, 0xE0, 0x0E, 0x1F,
  0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xFC, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3, 0xF0, 0x78, 0x78, 0xF9,
  0xFC, 0xFC, 0x78, 0x00, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x1F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xE7, 0x0F, 0xE8, 0x0F, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0x7E, 0x3E, 0x07,
  0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE3, 0xFC, 0xF8, 0xFF, 0x3C, 0x3F, 0xCF,
  0x0F, 0xF3, 0xC3, 0xFC, 0xF0, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFD, 0xE1, 0xFF, 0x78, 0x0E, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x02, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x38, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xE0, 0x07, 0x9F, 0x00,
  0x79, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8,
  0x1F, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0,
  0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x7F, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x1F, 0xBE, 0x7F, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3,
  0xFF, 0xFD, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xC3, 0x8F, 0xC0, 0x27, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x21, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E,
  0xF8, 0x3F, 0x3E, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xC3, 0x8F, 0xC0, 0x27, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7,
  0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0xC1, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x02, 0x00, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x40, 0x3F, 0x70, 0x7E, 0x7F, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0x80, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x81,
  0xF3, 0xE0, 0xFC, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE7, 0xE0,
  0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xEF, 0xC0, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0x87,
  0xE3, 0xE1, 0xF8, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7E,
  0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x07, 0x8F,
  0x80, 0xF1, 0xF0, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xFC, 0xFC, 0x3F, 0x9D,
  0xC7, 0xF3, 0xB8, 0xFE, 0x77, 0x3F, 0xCE, 0xF7, 0x79, 0xCE, 0xEF, 0x39,
  0xFD, 0xE7, 0x3F, 0x3D, 0xE7, 0xE7, 0xBE, 0x7C, 0xF7, 0xCF, 0x9E, 0xF9,
  0xE3, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0x79,
  0xFF, 0xBE, 0xFF, 0xCF, 0x7F, 0xE7, 0xBF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0xFC, 0x1F, 0x1F, 0x01, 0xF3,
  0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0x7C, 0x3F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x7F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBE,
  0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xF8, 0xFC,
  0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0xFC, 0x7C, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E,
  0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3E, 0x1F, 0x0F, 0x87,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xCF, 0xE0, 0xE7, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF4,
  0x00, 0xFB, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xFC,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC,
  0x00, 0x20, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3E, 0xF8,
  0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E,
  0xF8, 0x03, 0xDF, 0x1C, 0x7B, 0xE7, 0xCF, 0x78, 0xF9, 0xEF, 0x1F, 0x3D,
  0xE7, 0xE7, 0x9C, 0xFE, 0xF3, 0x9D, 0xDE, 0x77, 0xBB, 0xCE, 0xE7, 0xF9,
  0xDC, 0x7F, 0x3B, 0x8F, 0xE7, 0xE1, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7C, 0x07, 0x8F, 0x80, 0xF0, 0x7C, 0x01, 0xF3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xDF, 0x00, 0x7D, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x3E, 0x07, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0x80,
  0xFD, 0xF8, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xEF,
  0xC0, 0x7F, 0xF0, 0x07, 0xCE, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x1C, 0x1F, 0x0F,
  0xCF, 0xF8, 0xFC, 0x1C, 0x02, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFE, 0x38, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x3F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFB, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC7,
  0xFF, 0xE7, 0xFF, 0xE7, 0xFE, 0xF3, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x01, 0x3F, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xF7, 0xC7,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x3E, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3F, 0x1F, 0x9F, 0x83, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x06, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xC0, 0x41, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x81, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xF0, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7,
  0xC0, 0xFB, 0xF0, 0x7D, 0xFE, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0xC0, 0xF3, 0xE0, 0x01, 0xF0, 0x00, 0xFA, 0x00, 0xFD, 0xF1, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xF8, 0x00, 0x18, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xE0, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x40,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x98, 0x1F, 0x3E, 0xFE, 0x7F, 0xFD, 0xFF,
  0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x0F, 0xDF, 0x0F, 0xCF, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7,
  0xC1, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x07, 0xDF, 0x83, 0xE7, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F,
  0x3E, 0x0F, 0xDF, 0x03, 0xEF, 0x81, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x40, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0x0E, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xE3, 0xC7, 0xBC, 0x78, 0xF7, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C,
  0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xF0, 0x1F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFB, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x03, 0xF3, 0xF0, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFD, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01,
  0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xFB, 0xF0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x1F, 0x7F, 0xFF, 0x9F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xBE, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x1E, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x70, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x04, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0xFC, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x87,
  0x0F, 0x78, 0xF8, 0xF7, 0x8F, 0x8F, 0x78, 0xF8, 0xF7, 0x8F, 0x9E, 0x79,
  0xF9, 0xE3, 0x9F, 0xDE, 0x39, 0xFD, 0xE3, 0xDD, 0xDE, 0x3F, 0xDF, 0xE3,
  0xF9, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x80, 0xFC, 0x07, 0xEF, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x8F,
  0x81, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3E, 0x7E,
  0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0xCF, 0x80, 0xFB, 0xE0, 0x1F,
  0x80, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF3,
  0xE0, 0x3E, 0x78, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x9F, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0xFF, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x00, 0x0E, 0x01, 0x07, 0xF0, 0x3C, 0xFF,
  0x8F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF1, 0xFF, 0xBC, 0x1F, 0xE0, 0x80,
  0xF0,
};

const GFXglyph UbuntuSansMono_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 26, 21, 7, -26 },
  { 24, 13, 12, 21, 4, -28 },
  { 44, 19, 26, 21, 1, -26 },
  { 106, 18, 33, 21, 1, -29 },
  { 181, 21, 27, 21, 0, -26 },
  { 252, 19, 26, 21, 1, -26 },
  { 314, 5, 12, 21, 8, -28 },
  { 322, 13, 36, 21, 4, -29 },
  { 381, 13, 36, 21, 4, -29 },
  { 440, 17, 17, 21, 2, -26 },
  { 477, 17, 18, 21, 2, -20 },
  { 516, 9, 13, 21, 5, -7 },
  { 531, 11, 5, 21, 5, -13 },
  { 538, 7, 7, 21, 7, -7 },
  { 545, 17, 36, 21, 2, -29 },
  { 622, 18, 27, 21, 1, -26 },
  { 683, 17, 26, 21, 2, -26 },
  { 739, 17, 26, 21, 2, -26 },
  { 795, 17, 27, 21, 2, -26 },
  { 853, 19, 26, 21, 1, -26 },
  { 915, 18, 27, 21, 1, -26 },
  { 976, 17, 27, 21, 2, -26 },
  { 1034, 17, 26, 21, 2, -26 },
  { 1090, 17, 27, 21, 2, -26 },
  { 1148, 17, 26, 21, 2, -26 },
  { 1204, 7, 20, 21, 7, -20 },
  { 1222, 9, 26, 21, 5, -20 },
  { 1252, 17, 18, 21, 2, -20 },
  { 1291, 17, 12, 21, 2, -17 },
  { 1317, 17, 18, 21, 2, -20 },
  { 1356, 15, 26, 21, 3, -26 },
  { 1405, 18, 32, 21, 1, -26 },
  { 1477, 20, 26, 21, 0, -26 },
  { 1542, 17, 26, 21, 2, -26 },
  { 1598, 18, 27, 21, 1, -26 },
  { 1659, 18, 26, 21, 2, -26 },
  { 1718, 16, 26, 21, 3, -26 },
  { 1770, 15, 26, 21, 3, -26 },
  { 1819, 18, 27, 21, 1, -26 },
  { 1880, 17, 26, 21, 2, -26 },
  { 1936, 17, 26, 21, 2, -26 },
  { 1992, 16, 27, 21, 2, -26 },
  { 2046, 18, 26, 21, 2, -26 },
  { 2105, 16, 26, 21, 3, -26 },
  { 2157, 19, 26, 21, 1, -26 },
  { 2219, 17, 26, 21, 2, -26 },
  { 2275, 19, 27, 21, 1, -26 },
  { 2340, 18, 26, 21, 2, -26 },
  { 2399, 19, 33, 21, 1, -26 },
  { 2478, 18, 26, 21, 2, -26 },
  { 2537, 17, 27, 21, 2, -26 },
  { 2595, 19, 26, 21, 1, -26 },
  { 2657, 17, 27, 21, 2, -26 },
  { 2715, 19, 26, 21, 1, -26 },
  { 2777, 19, 26, 21, 1, -26 },
  { 2839, 20, 26, 21, 0, -26 },
  { 2904, 19, 26, 21, 1, -26 },
  { 2966, 17, 26, 21, 2, -26 },
  { 3022, 11, 36, 21, 5, -29 },
  { 3072, 17, 36, 21, 2, -29 },
  { 3149, 11, 36, 21, 5, -29 },
  { 3199, 19, 15, 21, 1, -26 },
  { 3235, 20, 5, 21, 0, 2 },
  { 3248, 9, 8, 21, 6, -29 },
  { 3257, 16, 20, 21, 2, -20 },
  { 3297, 16, 29, 21, 3, -29 },
  { 3355, 17, 20, 21, 2, -20 },
  { 3398, 17, 29, 21, 1, -29 },
  { 3460, 18, 20, 21, 1, -20 },
  { 3505, 19, 29, 21, 1, -29 },
  { 3574, 17, 27, 21, 1, -20 },
  { 3632, 15, 29, 21, 3, -29 },
  { 3687, 18, 29, 21, 1, -29 },
  { 3753, 15, 36, 21, 2, -29 },
  { 3821, 17, 29, 21, 3, -29 },
  { 3883, 18, 29, 21, 1, -29 },
  { 3949, 19, 20, 21, 1, -20 },
  { 3997, 15, 20, 21, 3, -20 },
  { 4035, 19, 21, 21, 1, -20 },
  { 4085, 16, 27, 21, 3, -20 },
  { 4139, 17, 27, 21, 1, -20 },
  { 4197, 15, 20, 21, 4, -20 },
  { 4235, 16, 20, 21, 2, -20 },
  { 4275, 19, 25, 21, 1, -25 },
  { 4335, 16, 19, 21, 2, -19 },
  { 4373, 19, 19, 21, 1, -19 },
  { 4419, 20, 19, 21, 0, -19 },
  { 4467, 19, 19, 21, 1, -19 },
  { 4513, 19, 26, 21, 1, -19 },
  { 4575, 15, 19, 21, 3, -19 },
  { 4611, 15, 36, 21, 3, -29 },
  { 4679, 5, 36, 21, 8, -29 },
  { 4702, 15, 36, 21, 3, -29 },
  { 4770, 19, 8, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_Bold37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_BOLD37PT7B_H_
