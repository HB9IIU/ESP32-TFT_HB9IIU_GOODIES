#ifndef _UBUNTUSANSMONO_BOLD16PT7B_H_
#define _UBUNTUSANSMONO_BOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xD0, 0x5F, 0x80, 0xDE, 0xF7, 0xB8, 0x80, 0x1B, 0x0D,
  0x84, 0xDF, 0xF3, 0x61, 0xB3, 0xFF, 0xFF, 0x64, 0x36, 0x1B, 0x00, 0x38,
  0x7B, 0xFF, 0x1C, 0x1E, 0x1F, 0x0F, 0x07, 0x0F, 0xFB, 0xE3, 0x87, 0x00,
  0x71, 0xE9, 0xB4, 0x9A, 0xC7, 0xC0, 0x40, 0x7C, 0x6B, 0x25, 0xB2, 0xF1,
  0xC0, 0x3C, 0x33, 0x19, 0x8D, 0x83, 0xC1, 0xD9, 0xFD, 0x9E, 0xC6, 0x3F,
  0x8F, 0xE0, 0xFF, 0xA4, 0x08, 0xCC, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0x86,
  0x38, 0xE1, 0x86, 0x18, 0x63, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0x3B, 0x98,
  0x39, 0x27, 0xFF, 0xF2, 0x8D, 0x8A, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2,
  0x04, 0x08, 0x77, 0x73, 0xEC, 0xFF, 0xC0, 0xFF, 0x80, 0x06, 0x0C, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0x7D,
  0xFF, 0x1E, 0x3D, 0x7E, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0x18, 0xF3, 0xE6,
  0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x7D, 0xFE, 0x38, 0x70, 0xC3,
  0x8E, 0x38, 0xE1, 0xFF, 0xF8, 0xFD, 0xF8, 0x38, 0x73, 0xC7, 0x83, 0x83,
  0x07, 0xFF, 0xF0, 0x06, 0x07, 0x07, 0x86, 0xC3, 0x63, 0x31, 0x99, 0xFF,
  0x06, 0x03, 0x01, 0x80, 0x7E, 0xFD, 0x83, 0x07, 0x9F, 0x83, 0x83, 0x07,
  0xFF, 0xF0, 0x1E, 0x7D, 0xC7, 0x0F, 0xDF, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0,
  0xFF, 0xFC, 0x30, 0x61, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC0, 0x7D, 0xDF,
  0x1E, 0x3F, 0xCF, 0xB3, 0xE3, 0xC7, 0xFD, 0xF0, 0x7D, 0xFF, 0x1E, 0x3C,
  0x7F, 0xDF, 0x87, 0x1D, 0xF1, 0xC0, 0xFF, 0x81, 0xFF, 0x77, 0x70, 0x07,
  0x77, 0x3E, 0x80, 0x02, 0x1C, 0xFF, 0xCE, 0x1F, 0x0F, 0x83, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0xE1, 0xF0, 0xF8, 0x33, 0xFF, 0x30, 0x00, 0xFC, 0xFC,
  0x38, 0x71, 0xC7, 0x0C, 0x00, 0x30, 0x70, 0xC0, 0x3E, 0x73, 0x63, 0x4F,
  0xDF, 0xD9, 0xD9, 0xD9, 0xDD, 0x4F, 0x60, 0x30, 0x1F, 0x1C, 0x0E, 0x05,
  0x86, 0xC3, 0x61, 0xB1, 0x8C, 0xFE, 0x63, 0x31, 0xB8, 0xE0, 0xFD, 0xFF,
  0x1E, 0x3F, 0xDF, 0xB1, 0xE3, 0xC7, 0xFF, 0xF0, 0x1F, 0x3F, 0x60, 0x60,
  0x60, 0xE0, 0x60, 0x60, 0x70, 0x3F, 0x1F, 0xF9, 0xFB, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xCF, 0xFB, 0xE0, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60,
  0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0x83,
  0x00, 0x1F, 0x3F, 0x60, 0x60, 0x60, 0xE3, 0x63, 0x63, 0x63, 0x7F, 0x3F,
  0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFC,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xFF, 0xF8, 0x7E, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x8F, 0xFB, 0xF0, 0xC6, 0xCC, 0xDC, 0xD8, 0xF0, 0xF0,
  0xD8, 0xDC, 0xCE, 0xC6, 0xC7, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0xFF, 0xF8, 0x63, 0x31, 0x9D, 0xCA, 0xA5, 0x52, 0xE9, 0x64, 0x82,
  0x41, 0x60, 0xF0, 0x60, 0xC7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF,
  0x8F, 0x18, 0x3E, 0x7F, 0x63, 0x63, 0x63, 0xE3, 0x63, 0x63, 0x63, 0x7F,
  0x3E, 0xFD, 0xFF, 0x1E, 0x3C, 0x7F, 0xFF, 0x60, 0xC1, 0x83, 0x00, 0x3E,
  0x7F, 0x63, 0x63, 0x63, 0xE3, 0x63, 0x63, 0x63, 0x7F, 0x3E, 0x0C, 0x0F,
  0x03, 0xFC, 0xFE, 0xC6, 0xC6, 0xCE, 0xFC, 0xF8, 0xCC, 0xCE, 0xC6, 0xC7,
  0x7F, 0xFB, 0x06, 0x0F, 0x0F, 0x83, 0x83, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0xE3, 0xB1, 0x98,
  0xCC, 0x66, 0x31, 0xB0, 0xD8, 0x6C, 0x34, 0x0E, 0x07, 0x00, 0xC1, 0xE0,
  0x90, 0x48, 0x25, 0x92, 0xE9, 0x54, 0xAA, 0x77, 0x31, 0x98, 0xC0, 0xE3,
  0xB9, 0x8D, 0x87, 0xC1, 0xC0, 0xE0, 0x78, 0x6C, 0x77, 0x31, 0xB8, 0xE0,
  0xE3, 0xB1, 0x9C, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0xFF, 0xFC, 0x30, 0xE1, 0x86, 0x0C, 0x30, 0xE1, 0xFF, 0xF8, 0xFF,
  0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC1, 0x81, 0x83,
  0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0xC1, 0x83, 0x83, 0xFF,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x1C, 0x0E, 0x0F,
  0x8E, 0xE6, 0x37, 0x1C, 0xFF, 0xFF, 0xC0, 0xCF, 0x20, 0x38, 0xFA, 0x38,
  0x37, 0xFC, 0xF1, 0xFF, 0x7E, 0xC1, 0x83, 0x06, 0xCF, 0xDD, 0xF1, 0xE3,
  0xC7, 0x8F, 0xFF, 0xE0, 0x1C, 0xFF, 0x8E, 0x0C, 0x18, 0x38, 0x3F, 0x3E,
  0x07, 0x07, 0x07, 0x1F, 0x7F, 0x77, 0x67, 0xE7, 0x67, 0x67, 0x7F, 0x3F,
  0x38, 0xFB, 0x9E, 0x3F, 0xFF, 0xF0, 0x7F, 0x7E, 0x3F, 0x3B, 0x30, 0x70,
  0xFE, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x18, 0xFF, 0x9E, 0x3C,
  0x78, 0xFB, 0xBF, 0x06, 0x1F, 0xF7, 0xC0, 0xC1, 0x83, 0x06, 0xCF, 0xD9,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0x70, 0xE0, 0x00, 0x0F, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xF8, 0xF0, 0x1C, 0x70, 0x00, 0x7C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x8F, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xCE, 0xDC, 0xD8,
  0xF0, 0xD8, 0xCC, 0xCE, 0xC7, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xF8, 0xF0, 0x25, 0xFE, 0xDC, 0x99, 0x32, 0x60, 0xC1, 0x82,
  0x39, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x38, 0xFB, 0xBE, 0x3C,
  0x78, 0xF1, 0xFF, 0x7C, 0x31, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xFF, 0xFD,
  0x83, 0x06, 0x00, 0x18, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xFF, 0x7E, 0x0C,
  0x18, 0x30, 0x3B, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC0, 0x3A, 0xFB, 0x97,
  0x07, 0x83, 0xC1, 0xFF, 0xFC, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18,
  0x30, 0x7C, 0xF8, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xBF, 0xE3, 0xB1,
  0x98, 0xC6, 0xC3, 0x61, 0xF0, 0x70, 0x38, 0xC1, 0xE4, 0xF7, 0x4B, 0xA5,
  0x53, 0xB9, 0xDC, 0xC6, 0xE3, 0x9B, 0x0F, 0x83, 0x81, 0xC1, 0xB1, 0x9D,
  0xC7, 0x63, 0x63, 0x33, 0x36, 0x36, 0x1E, 0x1C, 0x0C, 0x18, 0x78, 0xF0,
  0xFE, 0x18, 0x71, 0xC3, 0x0C, 0x3F, 0xFF, 0x0E, 0x7C, 0xC1, 0x83, 0x06,
  0x0C, 0x78, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x0E, 0x30,
  0x60, 0xC1, 0x83, 0x3E, 0x78, 0x79, 0xBF, 0xB1, 0x80,
};

const GFXglyph UbuntuSansMono_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -12 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 14, 9, 1, -12 },
  { 36, 9, 11, 9, 0, -11 },
  { 49, 9, 11, 9, 0, -11 },
  { 62, 3, 5, 9, 3, -12 },
  { 64, 5, 16, 9, 2, -13 },
  { 74, 5, 16, 9, 2, -13 },
  { 84, 7, 7, 9, 1, -11 },
  { 91, 7, 8, 9, 1, -9 },
  { 98, 4, 6, 9, 2, -3 },
  { 101, 5, 2, 9, 2, -6 },
  { 103, 3, 3, 9, 3, -3 },
  { 105, 7, 16, 9, 1, -13 },
  { 119, 7, 11, 9, 1, -11 },
  { 129, 7, 11, 9, 1, -11 },
  { 139, 7, 11, 9, 1, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 9, 11, 9, 0, -11 },
  { 172, 7, 11, 9, 1, -11 },
  { 182, 7, 11, 9, 1, -11 },
  { 192, 7, 11, 9, 1, -11 },
  { 202, 7, 11, 9, 1, -11 },
  { 212, 7, 11, 9, 1, -11 },
  { 222, 3, 8, 9, 3, -8 },
  { 225, 4, 11, 9, 2, -8 },
  { 231, 7, 8, 9, 1, -9 },
  { 238, 7, 5, 9, 1, -7 },
  { 243, 7, 7, 9, 1, -8 },
  { 250, 7, 11, 9, 1, -11 },
  { 260, 8, 13, 9, 0, -11 },
  { 273, 9, 11, 9, 0, -11 },
  { 286, 7, 11, 9, 1, -11 },
  { 296, 8, 11, 9, 0, -11 },
  { 307, 7, 11, 9, 1, -11 },
  { 317, 7, 11, 9, 1, -11 },
  { 327, 7, 11, 9, 1, -11 },
  { 337, 8, 11, 9, 0, -11 },
  { 348, 7, 11, 9, 1, -11 },
  { 358, 7, 11, 9, 1, -11 },
  { 368, 7, 11, 9, 1, -11 },
  { 378, 8, 11, 9, 1, -11 },
  { 389, 7, 11, 9, 1, -11 },
  { 399, 9, 11, 9, 0, -11 },
  { 412, 7, 11, 9, 1, -11 },
  { 422, 8, 11, 9, 0, -11 },
  { 433, 7, 11, 9, 1, -11 },
  { 443, 8, 14, 9, 0, -11 },
  { 457, 8, 11, 9, 1, -11 },
  { 468, 7, 11, 9, 1, -11 },
  { 478, 9, 11, 9, 0, -11 },
  { 491, 7, 11, 9, 1, -11 },
  { 501, 9, 11, 9, 0, -11 },
  { 514, 9, 11, 9, 0, -11 },
  { 527, 9, 11, 9, 0, -11 },
  { 540, 9, 11, 9, 0, -11 },
  { 553, 7, 11, 9, 1, -11 },
  { 563, 5, 16, 9, 2, -13 },
  { 573, 7, 16, 9, 1, -13 },
  { 587, 5, 16, 9, 2, -13 },
  { 597, 9, 6, 9, 0, -11 },
  { 604, 9, 2, 9, 0, 1 },
  { 607, 4, 3, 9, 3, -12 },
  { 609, 7, 9, 9, 1, -9 },
  { 617, 7, 12, 9, 1, -12 },
  { 628, 7, 9, 9, 1, -9 },
  { 636, 8, 12, 9, 0, -12 },
  { 648, 7, 9, 9, 1, -9 },
  { 656, 8, 12, 9, 1, -12 },
  { 668, 7, 12, 9, 1, -9 },
  { 679, 7, 12, 9, 1, -12 },
  { 690, 7, 12, 9, 1, -12 },
  { 701, 6, 15, 9, 1, -12 },
  { 713, 8, 12, 9, 1, -12 },
  { 725, 7, 12, 9, 1, -12 },
  { 736, 7, 9, 9, 1, -9 },
  { 744, 7, 9, 9, 1, -9 },
  { 752, 7, 9, 9, 1, -9 },
  { 760, 7, 12, 9, 1, -9 },
  { 771, 7, 12, 9, 1, -9 },
  { 782, 6, 9, 9, 2, -9 },
  { 789, 7, 9, 9, 1, -9 },
  { 797, 7, 11, 9, 1, -11 },
  { 807, 7, 8, 9, 1, -8 },
  { 814, 9, 8, 9, 0, -8 },
  { 823, 9, 8, 9, 0, -8 },
  { 832, 9, 8, 9, 0, -8 },
  { 841, 8, 11, 9, 0, -8 },
  { 852, 7, 8, 9, 1, -8 },
  { 859, 7, 16, 9, 1, -13 },
  { 873, 3, 16, 9, 3, -13 },
  { 879, 7, 16, 9, 1, -13 },
  { 893, 9, 3, 9, 0, -6 },
};

const GFXfont UbuntuSansMono_Bold16pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold16pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUSANSMONO_BOLD16PT7B_H_
