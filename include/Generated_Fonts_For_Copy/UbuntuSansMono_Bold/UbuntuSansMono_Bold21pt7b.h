#ifndef _UBUNTUSANSMONO_BOLD21PT7B_H_
#define _UBUNTUSANSMONO_BOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0x66, 0x04, 0xFF, 0xE0, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE6, 0x66, 0x46, 0x0C, 0xE1, 0x98, 0x33, 0x0E, 0x6F, 0xFF, 0xFF,
  0xC6, 0x60, 0xCC, 0x39, 0x9F, 0xFF, 0xFF, 0x99, 0x83, 0x30, 0xE6, 0x1D,
  0xC0, 0x0C, 0x03, 0x03, 0xFD, 0xFE, 0xF1, 0xB8, 0x0F, 0x01, 0xF0, 0x7F,
  0x07, 0xE0, 0x3C, 0x07, 0x81, 0xFF, 0xFF, 0xF8, 0xF8, 0x0C, 0x03, 0x00,
  0x30, 0x37, 0x86, 0xD8, 0xCC, 0xCC, 0xC9, 0x8F, 0xB0, 0x7B, 0x00, 0x60,
  0x0D, 0xC0, 0xDE, 0x1B, 0x23, 0x33, 0x33, 0x26, 0x3E, 0xC1, 0xE0, 0x0E,
  0x07, 0xE0, 0xCE, 0x19, 0xC3, 0x38, 0x7E, 0x0F, 0x81, 0xE7, 0x7E, 0xEC,
  0xFD, 0x8F, 0x71, 0xE6, 0x3C, 0xFF, 0xCF, 0xB8, 0xFF, 0xB6, 0xD8, 0x02,
  0x07, 0x1E, 0x1C, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x02, 0x40, 0xE0, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E,
  0x1C, 0x3C, 0x78, 0xF0, 0x40, 0x0C, 0x03, 0x04, 0xC9, 0xB6, 0xFF, 0xC3,
  0x03, 0xE1, 0xDE, 0x33, 0x04, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x33, 0xDE, 0xF1, 0xBB, 0x90,
  0xFF, 0xF0, 0x6F, 0xFF, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0x1E, 0x0F, 0xC7, 0xFB, 0x8E, 0xE1, 0xF8,
  0x7C, 0xDF, 0x37, 0xCD, 0xF8, 0x7E, 0x1F, 0x86, 0x73, 0x9F, 0xE3, 0xF0,
  0x06, 0x03, 0x83, 0xE3, 0xF8, 0x7E, 0x13, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x1F, 0xF7, 0xFC, 0x3E, 0x1F, 0xCF, 0xF9, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFC, 0x3E, 0x3F, 0xC7, 0xF9, 0x0E, 0x03, 0x80, 0xE1, 0xF0, 0x7C,
  0x1F, 0x80, 0xE0, 0x1C, 0x07, 0xC3, 0xBF, 0xEF, 0xF0, 0x03, 0x81, 0xE0,
  0xF8, 0x7E, 0x1B, 0x8E, 0xE7, 0x39, 0x8E, 0xE3, 0xBF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0xE0, 0x38, 0x3F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x07,
  0xE1, 0xFC, 0x07, 0x80, 0xE0, 0x1C, 0x0E, 0x83, 0xBF, 0xEF, 0xE0, 0x01,
  0x83, 0xE1, 0xF8, 0xF0, 0x70, 0x1C, 0x0F, 0xF3, 0xFE, 0xE3, 0xB8, 0x7E,
  0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xBC, 0xE7, 0xB8, 0xF8, 0x7F,
  0xB8, 0xFE, 0x1F, 0x87, 0xE3, 0xDF, 0xE3, 0xF0, 0x1E, 0x1F, 0xC7, 0xFB,
  0x8E, 0xE1, 0xF8, 0x7E, 0x1D, 0xFF, 0x7F, 0xC7, 0xE0, 0x38, 0x1C, 0x3F,
  0x1F, 0x87, 0x80, 0x6F, 0xFF, 0x00, 0x06, 0xFF, 0xF0, 0x33, 0xDE, 0xF0,
  0x00, 0x06, 0x7B, 0xDE, 0x37, 0x72, 0x00, 0x00, 0x81, 0xF1, 0xFF, 0xF8,
  0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x40, 0x3E, 0x0F, 0xE0, 0x7E, 0x07, 0xC1,
  0xF1, 0xFB, 0xF8, 0xF8, 0x10, 0x00, 0x7C, 0xFE, 0xFF, 0x07, 0x07, 0x0F,
  0x1E, 0x3C, 0x38, 0x38, 0x00, 0x10, 0x38, 0x78, 0x38, 0x0F, 0x03, 0xF8,
  0xE3, 0x38, 0x76, 0x06, 0xCF, 0xDB, 0xFF, 0x73, 0xEC, 0x7D, 0x8F, 0xB9,
  0xB7, 0x36, 0x7E, 0xC7, 0xDC, 0x01, 0xC0, 0x1F, 0xC1, 0xFC, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x81, 0xB8, 0x39, 0x83, 0x9C, 0x39, 0xC3,
  0xFC, 0x7F, 0xC7, 0xFE, 0x70, 0xE7, 0x0E, 0xE0, 0xF0, 0x7C, 0x3F, 0xCF,
  0xFB, 0x8E, 0xE1, 0xB8, 0xEF, 0xF3, 0xFC, 0xFF, 0xB8, 0x7E, 0x1F, 0x87,
  0xE3, 0xFF, 0xEF, 0xF0, 0x0F, 0x8F, 0xF7, 0xFD, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x78, 0x9F, 0xF1, 0xFC, 0x7C,
  0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xE7, 0xBF, 0xCF, 0xE0, 0xFF, 0xBF, 0xEF, 0xFB, 0x80, 0xE0,
  0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x0F, 0x0F, 0xF7, 0xFB, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xF3,
  0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x3F, 0xFF, 0xFC, 0x3F, 0x9F, 0xCF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x76, 0x7F, 0xF9, 0xF8, 0xE1, 0xDC, 0x73, 0x8E,
  0x73, 0x8E, 0xF1, 0xDC, 0x3F, 0x07, 0xE0, 0xFE, 0x1D, 0xE3, 0x9C, 0x71,
  0xCE, 0x39, 0xC3, 0xB8, 0x78, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xE1, 0xB8,
  0x6E, 0x3F, 0xCF, 0xF2, 0xF5, 0xBD, 0xEF, 0x7B, 0xDC, 0xF3, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xC1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF9, 0xFE,
  0x7F, 0xDF, 0xB7, 0xEF, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0x7E, 0x1C,
  0x1E, 0x1F, 0xC7, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xF3, 0x9F, 0xE3, 0xF0, 0x7E, 0x3F, 0xEF, 0xFF, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x9F, 0xFF, 0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x1E, 0x0F, 0xC7, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0x9F, 0xE3, 0xF0, 0x30, 0x0F, 0x01,
  0xF0, 0x1C, 0x7C, 0x1F, 0xE3, 0xFE, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0xE7,
  0xFC, 0xFF, 0x1F, 0xE3, 0x9C, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x78, 0x1F,
  0x1F, 0xE7, 0xFB, 0x80, 0xE0, 0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF0,
  0x1C, 0x07, 0x43, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0x9F, 0xE3, 0xF0, 0xE0, 0xEE, 0x1D, 0xC3,
  0xB8, 0x77, 0x0E, 0xE1, 0x8C, 0x71, 0xCE, 0x39, 0x83, 0x30, 0x6E, 0x0F,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0xCF, 0x73, 0xDE, 0xF7, 0xBF, 0x2F, 0xCF, 0xF3, 0xF8, 0xFE, 0x18,
  0xF0, 0xE7, 0x0E, 0x39, 0xC3, 0x9C, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF8, 0x1B, 0x83, 0x9C, 0x71, 0xC7, 0x0E, 0xF0, 0xF0, 0xE0,
  0xEE, 0x1D, 0xC3, 0x98, 0xE3, 0x9C, 0x73, 0x07, 0xE0, 0xF8, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xBF, 0xEF, 0xF8,
  0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0xFF, 0xF1, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x06, 0x00,
  0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0xC3, 0x9C, 0x71, 0xEF, 0x0F, 0x20, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x47, 0x9E, 0x20, 0x7F, 0x3F, 0xD0, 0xE0,
  0x33, 0xFB, 0xFF, 0xC7, 0xC3, 0xE1, 0xFF, 0xDF, 0xE0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xCF, 0xFB, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xEF, 0xFB, 0xFC, 0x1F, 0xDF, 0xE7, 0x8B, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x78, 0x5F, 0xF1, 0xFC, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x39, 0xFD, 0xFF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x9D, 0xFE,
  0x7F, 0x3F, 0x1F, 0xEF, 0x3B, 0x87, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xF0,
  0x9F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x71, 0x1C, 0x03, 0x81, 0xFF, 0xBF,
  0xF1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3F, 0xBF, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0x9F,
  0xC0, 0xE0, 0x7F, 0xFF, 0xF9, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0xFB, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0x38, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x11, 0xFC, 0x3F, 0x07, 0x0F, 0x07, 0x00,
  0x00, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x7F, 0xFF, 0x7C, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE,
  0x3B, 0x9C, 0xEE, 0x3F, 0x0F, 0xC3, 0xB8, 0xE7, 0x38, 0xEE, 0x3F, 0x87,
  0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x11, 0xFC, 0x3F, 0xFF, 0xBF, 0xFD, 0xDF,
  0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFF, 0x7F,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x3F,
  0x1F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0x9F, 0xE3,
  0xF0, 0xFF, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3,
  0xFF, 0xEF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3F, 0xBF, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xBF, 0xCF, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x7F, 0xFF, 0xFF, 0xDC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x00, 0x3F, 0xBF, 0xDC, 0x2E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x43,
  0xFF, 0xDF, 0xC0, 0x38, 0x0E, 0x03, 0x83, 0xFF, 0xFF, 0xCE, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF1, 0x1F, 0xC7, 0xF0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x73, 0xBF, 0xCF, 0xE0, 0xF0, 0xEE,
  0x1D, 0xC3, 0xB8, 0xE3, 0x9C, 0x73, 0x06, 0xE0, 0xFC, 0x1F, 0x01, 0xE0,
  0x38, 0x00, 0xE0, 0x7E, 0x06, 0x66, 0x66, 0x66, 0x6F, 0x66, 0xF6, 0x6F,
  0x67, 0xB6, 0x79, 0xC3, 0x9C, 0x31, 0xC0, 0xF0, 0xE7, 0x38, 0xE6, 0x0F,
  0xC0, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x39, 0xCE, 0x3F, 0xC3, 0x80, 0x70,
  0xEE, 0x1C, 0xE3, 0x1C, 0xE3, 0x9C, 0x3B, 0x87, 0x60, 0xFC, 0x0F, 0x81,
  0xE0, 0x1C, 0x07, 0x07, 0xE0, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0x0F, 0x0E,
  0x1C, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0x0F, 0x8F, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x38, 0x78, 0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x7E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x01, 0xC1, 0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x3F, 0x1F,
  0x00, 0x3C, 0x6F, 0xFD, 0x9F, 0xF1, 0xE0,
};

const GFXglyph UbuntuSansMono_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 8, 7, 12, 2, -16 },
  { 16, 11, 15, 12, 0, -15 },
  { 37, 10, 18, 12, 1, -16 },
  { 60, 12, 15, 12, 0, -15 },
  { 83, 11, 15, 12, 0, -15 },
  { 104, 3, 7, 12, 4, -16 },
  { 107, 8, 21, 12, 2, -17 },
  { 128, 8, 21, 12, 2, -17 },
  { 149, 10, 10, 12, 1, -15 },
  { 162, 10, 10, 12, 1, -11 },
  { 175, 5, 8, 12, 3, -4 },
  { 180, 6, 2, 12, 3, -7 },
  { 182, 4, 4, 12, 4, -4 },
  { 184, 10, 20, 12, 1, -16 },
  { 209, 10, 15, 12, 1, -15 },
  { 228, 10, 15, 12, 1, -15 },
  { 247, 10, 15, 12, 1, -15 },
  { 266, 10, 15, 12, 1, -15 },
  { 285, 10, 15, 12, 1, -15 },
  { 304, 10, 15, 12, 1, -15 },
  { 323, 10, 15, 12, 1, -15 },
  { 342, 10, 15, 12, 1, -15 },
  { 361, 10, 15, 12, 1, -15 },
  { 380, 10, 15, 12, 1, -15 },
  { 399, 4, 11, 12, 4, -11 },
  { 405, 5, 15, 12, 3, -11 },
  { 415, 10, 10, 12, 1, -11 },
  { 428, 10, 7, 12, 1, -10 },
  { 437, 10, 10, 12, 1, -11 },
  { 450, 8, 15, 12, 2, -15 },
  { 465, 11, 18, 12, 0, -15 },
  { 490, 12, 15, 12, 0, -15 },
  { 513, 10, 15, 12, 1, -15 },
  { 532, 10, 15, 12, 1, -15 },
  { 551, 10, 15, 12, 1, -15 },
  { 570, 10, 15, 12, 1, -15 },
  { 589, 9, 15, 12, 1, -15 },
  { 606, 10, 15, 12, 1, -15 },
  { 625, 10, 15, 12, 1, -15 },
  { 644, 10, 15, 12, 1, -15 },
  { 663, 9, 15, 12, 1, -15 },
  { 680, 11, 15, 12, 1, -15 },
  { 701, 9, 15, 12, 2, -15 },
  { 718, 10, 15, 12, 1, -15 },
  { 737, 10, 15, 12, 1, -15 },
  { 756, 10, 15, 12, 1, -15 },
  { 775, 10, 15, 12, 1, -15 },
  { 794, 10, 19, 12, 1, -15 },
  { 818, 11, 15, 12, 1, -15 },
  { 839, 10, 15, 12, 1, -15 },
  { 858, 10, 15, 12, 1, -15 },
  { 877, 10, 15, 12, 1, -15 },
  { 896, 11, 15, 12, 0, -15 },
  { 917, 10, 15, 12, 1, -15 },
  { 936, 12, 15, 12, 0, -15 },
  { 959, 11, 15, 12, 0, -15 },
  { 980, 10, 15, 12, 1, -15 },
  { 999, 6, 20, 12, 3, -16 },
  { 1014, 10, 20, 12, 1, -16 },
  { 1039, 6, 20, 12, 3, -16 },
  { 1054, 12, 9, 12, 0, -15 },
  { 1068, 12, 3, 12, 0, 1 },
  { 1073, 5, 4, 12, 4, -16 },
  { 1076, 9, 11, 12, 1, -11 },
  { 1089, 10, 16, 12, 1, -16 },
  { 1109, 10, 11, 12, 1, -11 },
  { 1123, 9, 16, 12, 1, -16 },
  { 1141, 10, 11, 12, 1, -11 },
  { 1155, 11, 16, 12, 1, -16 },
  { 1177, 9, 15, 12, 1, -11 },
  { 1194, 9, 16, 12, 1, -16 },
  { 1212, 10, 16, 12, 1, -16 },
  { 1232, 8, 20, 12, 1, -16 },
  { 1252, 10, 16, 12, 1, -16 },
  { 1272, 10, 16, 12, 1, -16 },
  { 1292, 10, 11, 12, 1, -11 },
  { 1306, 9, 11, 12, 1, -11 },
  { 1319, 10, 11, 12, 1, -11 },
  { 1333, 10, 15, 12, 1, -11 },
  { 1352, 9, 15, 12, 1, -11 },
  { 1369, 9, 11, 12, 2, -11 },
  { 1382, 9, 11, 12, 1, -11 },
  { 1395, 10, 14, 12, 1, -14 },
  { 1413, 9, 11, 12, 1, -11 },
  { 1426, 11, 11, 12, 0, -11 },
  { 1442, 12, 11, 12, 0, -11 },
  { 1459, 11, 11, 12, 0, -11 },
  { 1475, 11, 15, 12, 0, -11 },
  { 1496, 8, 11, 12, 2, -11 },
  { 1507, 9, 20, 12, 1, -16 },
  { 1530, 3, 20, 12, 4, -16 },
  { 1538, 9, 20, 12, 1, -16 },
  { 1561, 11, 4, 12, 0, -8 },
};

const GFXfont UbuntuSansMono_Bold21pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold21pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUSANSMONO_BOLD21PT7B_H_
