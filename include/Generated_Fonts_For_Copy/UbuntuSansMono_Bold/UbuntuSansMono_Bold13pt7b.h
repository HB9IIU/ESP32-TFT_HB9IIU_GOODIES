#ifndef _UBUNTUSANSMONO_BOLD13PT7B_H_
#define _UBUNTUSANSMONO_BOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x87, 0x60, 0xDE, 0xF6, 0xB0, 0x36, 0x6B, 0xFF, 0xF2,
  0xDF, 0xFF, 0xA4, 0x58, 0x18, 0x7D, 0xF3, 0x07, 0x07, 0x83, 0x83, 0x7F,
  0xF8, 0x40, 0xE3, 0x4A, 0xB7, 0x41, 0x07, 0xCA, 0xA5, 0xCE, 0x38, 0xD1,
  0xA3, 0xC7, 0x6B, 0xF3, 0x66, 0x7E, 0xFE, 0x19, 0x98, 0xC4, 0x63, 0x18,
  0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x8C, 0x63, 0x19, 0x9D, 0xC0, 0x32,
  0xAF, 0xDC, 0xD9, 0x40, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0xED, 0xE0, 0xFF,
  0xFC, 0x0C, 0x61, 0x84, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x30, 0x3C, 0xD9,
  0x1A, 0xBD, 0x68, 0xD1, 0xB6, 0x3C, 0x31, 0xCF, 0x0C, 0x30, 0xC3, 0x0C,
  0xFC, 0xFB, 0x61, 0x86, 0x31, 0x8C, 0x30, 0xFC, 0xF2, 0x61, 0x8E, 0x78,
  0x60, 0xE6, 0xF8, 0x0C, 0x38, 0xF1, 0x66, 0xDF, 0xFF, 0x86, 0x0C, 0x3C,
  0xC1, 0x83, 0x87, 0xC1, 0x81, 0xA6, 0xF8, 0x39, 0xEC, 0x3C, 0xFA, 0x3C,
  0xF6, 0x78, 0xFC, 0x61, 0x8C, 0x30, 0x86, 0x18, 0x60, 0x7B, 0x68, 0xF6,
  0x73, 0x68, 0xF7, 0xF8, 0x7B, 0x68, 0xF3, 0xFD, 0xA1, 0xBC, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xDE, 0x08, 0xFF, 0x30, 0x78, 0x70, 0xFF, 0xF0,
  0x3F, 0x83, 0x83, 0xC7, 0x7B, 0x00, 0xFC, 0xC6, 0x73, 0x30, 0x0E, 0x60,
  0x3C, 0xCD, 0x1E, 0xFD, 0x7E, 0xF5, 0xEF, 0x44, 0xC4, 0x78, 0x18, 0x70,
  0xA1, 0x66, 0xCF, 0x9F, 0xA3, 0xC6, 0xFB, 0x6C, 0xB6, 0xFB, 0x3C, 0xF7,
  0xF8, 0x3E, 0xE5, 0x86, 0x0C, 0x18, 0x18, 0x39, 0x3E, 0xF3, 0x6C, 0xF3,
  0xCF, 0x3C, 0xFE, 0xF0, 0xFB, 0x0C, 0x3E, 0xFB, 0x0C, 0x30, 0xFC, 0xFE,
  0x31, 0x8F, 0xE3, 0x18, 0xC0, 0x3E, 0xE9, 0x86, 0x0C, 0x78, 0xD9, 0xB3,
  0x3E, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0xFC, 0x78, 0x42, 0x10, 0x84, 0x33, 0xF0, 0x8E, 0x6B, 0x2C,
  0xE2, 0xC9, 0xA6, 0x8C, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0x64,
  0xDD, 0xBB, 0x75, 0xFA, 0xF1, 0xE3, 0xC6, 0x8F, 0x3E, 0xEB, 0xBE, 0x79,
  0xE3, 0x8C, 0x3C, 0xD9, 0x1E, 0x3C, 0x78, 0xD1, 0xB6, 0x3C, 0xFB, 0x7C,
  0xF3, 0xFF, 0xCC, 0x30, 0xC0, 0x3C, 0xD9, 0x1E, 0x3C, 0x78, 0xD1, 0xB6,
  0x3C, 0x30, 0x38, 0xF3, 0x6C, 0xF2, 0xFB, 0xCD, 0xB2, 0xCC, 0x7B, 0x2C,
  0x38, 0x78, 0x70, 0xE7, 0xF8, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF6, 0xF8, 0xC6, 0x8D, 0x9B, 0x26,
  0xC5, 0x8A, 0x1C, 0x18, 0xC7, 0x8F, 0x1E, 0xB5, 0xED, 0xDB, 0xB7, 0x64,
  0xC6, 0xD8, 0xB1, 0xC1, 0x87, 0x1B, 0x32, 0xC6, 0xC6, 0xCD, 0xB1, 0x63,
  0x83, 0x06, 0x0C, 0x18, 0xF8, 0x61, 0x8C, 0x21, 0x8C, 0x30, 0xFC, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x8F, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x10,
  0x61, 0x87, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x18, 0x71, 0xB3, 0x7C,
  0x60, 0xFE, 0x5C, 0x80, 0xFF, 0xC3, 0xF8, 0xE7, 0xE0, 0xC3, 0x0C, 0x3E,
  0xFB, 0x3C, 0xF3, 0xDB, 0xE0, 0x7F, 0xEC, 0x20, 0xC3, 0x97, 0xC0, 0x0C,
  0x30, 0xCF, 0x7F, 0x3C, 0xF3, 0x6C, 0xF0, 0x3C, 0xF9, 0x1F, 0xF4, 0x0C,
  0x8F, 0x00, 0x3D, 0xD6, 0x3F, 0xFD, 0x86, 0x18, 0x61, 0x80, 0x3D, 0xF4,
  0x71, 0x65, 0xF1, 0x63, 0x7C, 0xC6, 0x31, 0xEF, 0xE7, 0x39, 0xCE, 0x40,
  0x61, 0x80, 0x38, 0xE1, 0x86, 0x18, 0x34, 0xF0, 0x31, 0xC1, 0xFF, 0x8C,
  0x63, 0x18, 0xE7, 0xE0, 0xC3, 0x0C, 0x37, 0xDB, 0xCE, 0x3C, 0xDB, 0x30,
  0xE1, 0x86, 0x18, 0x61, 0x86, 0x18, 0x34, 0xF0, 0xFD, 0xFF, 0x5E, 0xBC,
  0x78, 0xF1, 0x80, 0xF7, 0xF3, 0x9C, 0xE7, 0x20, 0x38, 0xF9, 0x1E, 0x34,
  0x6D, 0x8F, 0x00, 0xF3, 0xEC, 0xF3, 0xCF, 0x7F, 0xB0, 0xC0, 0x3D, 0xF4,
  0x71, 0x45, 0xB7, 0xC1, 0x04, 0x7F, 0xEC, 0x30, 0xC3, 0x0C, 0x00, 0x7F,
  0xF0, 0xF1, 0xCF, 0xE0, 0x61, 0x8F, 0xFF, 0x61, 0x86, 0x19, 0x3C, 0xCE,
  0x73, 0x9C, 0xE5, 0xE0, 0xC6, 0x8D, 0x93, 0x62, 0xC7, 0x06, 0x00, 0xC3,
  0x87, 0x7A, 0xF6, 0xED, 0x99, 0x00, 0xC6, 0xD8, 0xE0, 0xC3, 0x8D, 0xB1,
  0x80, 0x46, 0xC9, 0x91, 0x63, 0xC7, 0x06, 0x08, 0xF0, 0xFF, 0xCC, 0x66,
  0x63, 0xE0, 0x39, 0x08, 0x42, 0x73, 0x8C, 0x21, 0x08, 0x70, 0xFF, 0xFF,
  0xFF, 0xE1, 0x8C, 0x63, 0x1C, 0x66, 0x31, 0x8D, 0xC0, 0x73, 0xFC, 0x10,
};

const GFXglyph UbuntuSansMono_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 5, 4, 7, 1, -10 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 7, 11, 7, 0, -10 },
  { 26, 7, 9, 7, 0, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 2, 4, 7, 3, -10 },
  { 43, 5, 12, 7, 1, -10 },
  { 51, 5, 12, 7, 1, -10 },
  { 59, 6, 6, 7, 1, -9 },
  { 64, 6, 6, 7, 1, -7 },
  { 69, 3, 4, 7, 2, -2 },
  { 71, 4, 2, 7, 2, -5 },
  { 72, 3, 2, 7, 2, -2 },
  { 73, 6, 12, 7, 1, -10 },
  { 82, 7, 9, 7, 0, -9 },
  { 90, 6, 9, 7, 1, -9 },
  { 97, 6, 9, 7, 1, -9 },
  { 104, 6, 9, 7, 1, -9 },
  { 111, 7, 9, 7, 0, -9 },
  { 119, 7, 9, 7, 0, -9 },
  { 127, 6, 9, 7, 1, -9 },
  { 134, 6, 9, 7, 1, -9 },
  { 141, 6, 9, 7, 1, -9 },
  { 148, 6, 9, 7, 1, -9 },
  { 155, 3, 6, 7, 2, -6 },
  { 158, 3, 8, 7, 2, -6 },
  { 161, 6, 6, 7, 1, -7 },
  { 166, 6, 4, 7, 1, -6 },
  { 169, 6, 6, 7, 1, -7 },
  { 174, 5, 9, 7, 1, -9 },
  { 180, 7, 11, 7, 0, -9 },
  { 190, 7, 9, 7, 0, -9 },
  { 198, 6, 9, 7, 1, -9 },
  { 205, 7, 9, 7, 0, -9 },
  { 213, 6, 9, 7, 1, -9 },
  { 220, 6, 9, 7, 1, -9 },
  { 227, 5, 9, 7, 1, -9 },
  { 233, 7, 9, 7, 0, -9 },
  { 241, 6, 9, 7, 1, -9 },
  { 248, 6, 9, 7, 1, -9 },
  { 255, 5, 9, 7, 1, -9 },
  { 261, 6, 9, 7, 1, -9 },
  { 268, 6, 9, 7, 1, -9 },
  { 275, 7, 9, 7, 0, -9 },
  { 283, 6, 9, 7, 1, -9 },
  { 290, 7, 9, 7, 0, -9 },
  { 298, 6, 9, 7, 1, -9 },
  { 305, 7, 11, 7, 0, -9 },
  { 315, 6, 9, 7, 1, -9 },
  { 322, 6, 9, 7, 1, -9 },
  { 329, 7, 9, 7, 0, -9 },
  { 337, 6, 9, 7, 1, -9 },
  { 344, 7, 9, 7, 0, -9 },
  { 352, 7, 9, 7, 0, -9 },
  { 360, 7, 9, 7, 0, -9 },
  { 368, 7, 9, 7, 0, -9 },
  { 376, 6, 9, 7, 1, -9 },
  { 383, 4, 12, 7, 2, -10 },
  { 389, 6, 12, 7, 1, -10 },
  { 398, 4, 12, 7, 2, -10 },
  { 404, 7, 5, 7, 0, -9 },
  { 409, 7, 1, 7, 0, 1 },
  { 410, 3, 3, 7, 2, -10 },
  { 412, 5, 7, 7, 1, -7 },
  { 417, 6, 10, 7, 1, -10 },
  { 425, 6, 7, 7, 1, -7 },
  { 431, 6, 10, 7, 0, -10 },
  { 439, 7, 7, 7, 0, -7 },
  { 446, 6, 10, 7, 1, -10 },
  { 454, 6, 9, 7, 0, -7 },
  { 461, 5, 10, 7, 1, -10 },
  { 468, 6, 10, 7, 1, -10 },
  { 476, 5, 12, 7, 1, -10 },
  { 484, 6, 10, 7, 1, -10 },
  { 492, 6, 10, 7, 1, -10 },
  { 500, 7, 7, 7, 0, -7 },
  { 507, 5, 7, 7, 1, -7 },
  { 512, 7, 7, 7, 0, -7 },
  { 519, 6, 9, 7, 1, -7 },
  { 526, 6, 9, 7, 0, -7 },
  { 533, 6, 7, 7, 1, -7 },
  { 539, 5, 7, 7, 1, -7 },
  { 544, 6, 9, 7, 1, -9 },
  { 551, 5, 7, 7, 1, -7 },
  { 556, 7, 7, 7, 0, -7 },
  { 563, 7, 7, 7, 0, -7 },
  { 570, 7, 7, 7, 0, -7 },
  { 577, 7, 9, 7, 0, -7 },
  { 585, 5, 7, 7, 1, -7 },
  { 590, 5, 12, 7, 1, -10 },
  { 598, 2, 12, 7, 3, -10 },
  { 601, 5, 12, 7, 1, -10 },
  { 609, 7, 3, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_Bold13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_BOLD13PT7B_H_
