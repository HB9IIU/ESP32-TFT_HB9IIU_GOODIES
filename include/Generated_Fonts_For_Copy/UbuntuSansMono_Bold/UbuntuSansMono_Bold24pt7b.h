#ifndef _UBUNTUSANSMONO_BOLD24PT7B_H_
#define _UBUNTUSANSMONO_BOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0x00, 0x39, 0xFF, 0x70,
  0xF3, 0xF9, 0xFC, 0xEE, 0x77, 0x3B, 0x1D, 0x8E, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x9C, 0x1C, 0xE0, 0xC6,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0xE0, 0xE6, 0x06, 0x70, 0x73, 0x80,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xFC, 0x7F, 0xE7, 0xFE, 0x70, 0x0F, 0x00,
  0x78, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0xF4, 0x0E,
  0xFF, 0xEF, 0xFC, 0x3F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x1B, 0xE1,
  0xFB, 0x0D, 0x98, 0xCC, 0xCE, 0x76, 0x61, 0xF6, 0x0F, 0x70, 0x03, 0x00,
  0x33, 0x83, 0xBE, 0x1B, 0xB1, 0x99, 0x9C, 0xCC, 0xC6, 0x6C, 0x3F, 0xE0,
  0xF0, 0x1E, 0x03, 0xF0, 0x7F, 0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x03,
  0xE0, 0x3C, 0x67, 0xEE, 0xEF, 0xEE, 0x7E, 0xC3, 0xCE, 0x1C, 0xE3, 0xE7,
  0xFE, 0x3E, 0x70, 0xFF, 0xEE, 0xEE, 0x66, 0x02, 0x0F, 0x1E, 0x3C, 0x38,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x02, 0x60, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x07, 0x83, 0x83, 0xC3, 0xC7, 0xC1, 0xC0, 0x80, 0x0E, 0x01,
  0xC1, 0x38, 0x33, 0x77, 0xFF, 0xFF, 0xC3, 0xC0, 0xFC, 0x3B, 0xCF, 0x38,
  0x44, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3C, 0xF3, 0xCF, 0x0C, 0xEF,
  0x98, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xF0, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xF8, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE,
  0x0E, 0xE0, 0xEE, 0xEE, 0xEE, 0xFE, 0x6E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE7,
  0x1E, 0x7F, 0xC3, 0xFC, 0x1F, 0x80, 0x03, 0x01, 0xE0, 0x7C, 0x3F, 0x8F,
  0xF0, 0xEE, 0x11, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x1F, 0xFB, 0xFF, 0x7F, 0xE0, 0x1F, 0x0F, 0xF3, 0xFF, 0x30, 0xF4,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xE0, 0x3F, 0x1F, 0xF1, 0xFF, 0x20, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0x07, 0x80, 0x70, 0x0E,
  0x03, 0xDD, 0xFF, 0xFE, 0xFF, 0x80, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0xFC,
  0x0F, 0xC1, 0xDC, 0x39, 0xC7, 0x9C, 0x71, 0xCE, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1C, 0x03, 0x80, 0x60, 0x1E, 0x03, 0xFC, 0x7F, 0xC0, 0x78, 0x07, 0x80,
  0x70, 0x0E, 0x03, 0xFD, 0xF7, 0xFE, 0xFF, 0x00, 0x00, 0xC0, 0xF8, 0x7F,
  0x1F, 0x83, 0xC0, 0xF0, 0x1D, 0xC7, 0xFE, 0xFF, 0xDE, 0x3F, 0x83, 0xF8,
  0x7F, 0x0E, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0x87, 0xF9, 0xFF,
  0xB8, 0x7F, 0x0F, 0xE1, 0xDE, 0x73, 0xFE, 0x3F, 0x8F, 0xF9, 0xC7, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFE, 0xFB, 0xFE, 0x3F, 0x80, 0x1F, 0x07, 0xF1, 0xFF,
  0x38, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0x7F, 0xE7, 0xFC, 0x7F, 0x80,
  0xF0, 0x3C, 0x0F, 0x1F, 0xE3, 0xF0, 0x78, 0x00, 0x7F, 0xFE, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0xF0, 0x3D, 0xF7, 0xCF, 0x00, 0x00, 0x00, 0x3D, 0xF7,
  0xCF, 0x1C, 0xEF, 0x38, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xFF, 0xF1, 0xF0,
  0x3E, 0x07, 0xF8, 0x3F, 0xC0, 0xFC, 0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x0E, 0x03, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xC0, 0x78, 0x7F, 0x7F, 0x9F, 0xC1, 0xC0, 0x20,
  0x00, 0x7E, 0x3F, 0xEF, 0xFA, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x1E,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x07,
  0xC0, 0xFF, 0x0F, 0x3C, 0x70, 0xE7, 0x03, 0x38, 0xFD, 0x9F, 0xEC, 0xFF,
  0x67, 0x3F, 0x71, 0xFB, 0x8F, 0xCC, 0x76, 0x73, 0xB3, 0xFD, 0x8F, 0xEE,
  0x3F, 0x30, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x0E, 0x00, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x9C, 0x38,
  0xE1, 0xC7, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF, 0x38, 0x39, 0xC1, 0xEE, 0x0F,
  0xF0, 0x38, 0x7E, 0x0F, 0xFC, 0xFF, 0xCF, 0x1E, 0xF0, 0xEF, 0x0E, 0xF1,
  0xCF, 0xFC, 0xFF, 0xCF, 0xFE, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0E, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0x3F, 0xE7, 0x82, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0xFF, 0xCF, 0x1E,
  0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E,
  0xF0, 0xEF, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0xBC, 0x1F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0E, 0xE1, 0xDF,
  0xF9, 0xFF, 0x1F, 0xE0, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x83, 0xDF,
  0xF7, 0xFE, 0x7F, 0x00, 0xF0, 0xFF, 0x1E, 0xF1, 0xCF, 0x3C, 0xF7, 0x8F,
  0x70, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x8F, 0x78, 0xF3, 0xCF,
  0x1E, 0xF1, 0xEF, 0x0F, 0xF0, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E, 0xF9, 0xEF,
  0xBE, 0xFB, 0x6F, 0xF6, 0xEF, 0x6E, 0xE7, 0xEE, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F,
  0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xE0, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x1E,
  0xF0, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E,
  0xE0, 0xEF, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xFC, 0xFF,
  0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xFF, 0xEF, 0xFE, 0xFF,
  0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x03,
  0xFC, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEF, 0x0E, 0x7B, 0xE7, 0xFC, 0x1F, 0x80,
  0xE0, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x02, 0x7E, 0x0F, 0xF8, 0xFF, 0xCF,
  0x1E, 0xF1, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x8F,
  0x38, 0xF3, 0xCF, 0x1E, 0xF0, 0xEF, 0x0F, 0xF0, 0xF0, 0x1F, 0x87, 0xFD,
  0xFF, 0x78, 0x2F, 0x01, 0xE0, 0x1E, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F,
  0x80, 0x70, 0x0E, 0x81, 0xDE, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xDF, 0xFB, 0xFE, 0x3F, 0x80, 0xF0,
  0x3B, 0x83, 0xDC, 0x1E, 0xE0, 0xE7, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0x1C,
  0x38, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0x80, 0xDC, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xEE, 0x7E, 0xE7, 0xEF, 0x6E, 0xF6, 0xFB, 0x6F, 0xB6, 0xF9, 0xEF, 0x9E,
  0xF1, 0xEF, 0x0E, 0x70, 0xE0, 0x70, 0x7B, 0xC3, 0x8E, 0x3C, 0x79, 0xC1,
  0xDE, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3B,
  0xC3, 0xCE, 0x1C, 0x79, 0xE1, 0xCF, 0x0F, 0xF0, 0x78, 0xF0, 0x3B, 0x83,
  0xDE, 0x1C, 0x70, 0xE3, 0x8F, 0x1E, 0x70, 0x77, 0x83, 0xF8, 0x0F, 0xC0,
  0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x1E,
  0x70, 0xF3, 0xCF, 0x0E, 0xF0, 0x79, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x41, 0x8F, 0x9F, 0x18, 0x7F, 0x07, 0xF8, 0xFF, 0x00, 0xF0, 0x0E, 0x3F,
  0xDF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xE3, 0xBF, 0xF3, 0xFE, 0x20, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xC7, 0xFC, 0xFF, 0xDC, 0x7B,
  0x87, 0x70, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x0E, 0xFF, 0xDF, 0xF3, 0xFC,
  0x00, 0x0F, 0xE3, 0xFE, 0x7F, 0xE7, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x7F, 0xE3, 0xFE, 0x0F, 0xF0, 0x00, 0x20, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xFB, 0xFF, 0x7F, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0x7F, 0xEF, 0xFC, 0xFF, 0x80,
  0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0xEF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x01, 0x80, 0xFF, 0x1F,
  0xF1, 0xE3, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0x0F, 0xC7, 0xFD, 0xFF, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xF1, 0xFF, 0xFD, 0xFF, 0x9F, 0xF0, 0x1E, 0x03, 0xD8, 0xF7, 0xFE, 0xFF,
  0x83, 0x00, 0x20, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xE3, 0xFE,
  0xFF, 0xB8, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1C, 0x08, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x08, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x01, 0x01, 0xE0, 0x78, 0x1E,
  0x01, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x77, 0x9F, 0xEF, 0xF0,
  0x20, 0x20, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0x1E,
  0xE7, 0x9D, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xFC, 0x3B, 0xC7, 0x3C, 0xE3,
  0xDC, 0x7B, 0x87, 0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x79, 0xCF, 0xFE,
  0xFF, 0xEC, 0xE7, 0xCE, 0x7C, 0xE7, 0xCE, 0x7C, 0xE7, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x7E, 0x3F, 0xEF, 0xFB, 0x8F, 0xE3, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1F, 0x03,
  0xFC, 0x7F, 0xEF, 0x1E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0E, 0x7F, 0xE7, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xF3, 0xFF, 0x71, 0xEE,
  0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x3B, 0xFF, 0x7F, 0xCF, 0xF1,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0xC7, 0xFD, 0xFF, 0xF8, 0xFF,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3D, 0xFF, 0xBF, 0xF3, 0xFE,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x1F,
  0xC7, 0xF9, 0xFF, 0x38, 0x27, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0,
  0x1D, 0xFF, 0xBF, 0xEF, 0xF8, 0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0xF0, 0x3B,
  0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0x8F, 0x1C, 0x70, 0xF3, 0x83, 0xBC, 0x1D,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0xE0, 0x3F, 0x01, 0xF8,
  0x0E, 0xCE, 0x76, 0x73, 0xB3, 0xDD, 0x9E, 0xCF, 0xF6, 0x7D, 0xB3, 0xEF,
  0x8F, 0x3C, 0x71, 0xE3, 0x8E, 0x00, 0xE0, 0xFF, 0x0E, 0x79, 0xC3, 0xBC,
  0x1F, 0x81, 0xF0, 0x0F, 0x01, 0xF8, 0x3F, 0x83, 0xBC, 0x71, 0xEF, 0x0E,
  0xE0, 0xF0, 0xE0, 0xFF, 0x0E, 0x70, 0xE7, 0x0E, 0x79, 0xE3, 0x9C, 0x39,
  0xC3, 0xDC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x9E,
  0x0F, 0xC0, 0xF8, 0x06, 0x00, 0xFF, 0xBF, 0xEF, 0xF8, 0x1E, 0x0F, 0x03,
  0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC7,
  0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0x83,
  0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x3F, 0x0F, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF0, 0x0F, 0x07, 0xC3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x3F, 0x0F, 0xC0, 0x10, 0x47, 0xC7, 0xFF, 0xFF, 0xFE, 0xC3,
  0xE0,
};

const GFXglyph UbuntuSansMono_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 17, 13, 4, -17 },
  { 12, 9, 7, 13, 2, -18 },
  { 20, 13, 17, 13, 0, -17 },
  { 48, 12, 22, 13, 1, -19 },
  { 81, 13, 17, 13, 0, -17 },
  { 109, 12, 17, 13, 1, -17 },
  { 135, 4, 8, 13, 5, -18 },
  { 139, 8, 24, 13, 3, -19 },
  { 163, 9, 24, 13, 2, -19 },
  { 190, 11, 11, 13, 1, -17 },
  { 206, 11, 12, 13, 1, -13 },
  { 223, 6, 8, 13, 3, -4 },
  { 229, 7, 4, 13, 3, -9 },
  { 233, 5, 4, 13, 4, -4 },
  { 236, 11, 23, 13, 1, -19 },
  { 268, 12, 17, 13, 1, -17 },
  { 294, 11, 17, 13, 1, -17 },
  { 318, 11, 17, 13, 1, -17 },
  { 342, 11, 17, 13, 1, -17 },
  { 366, 12, 17, 13, 1, -17 },
  { 392, 11, 17, 13, 1, -17 },
  { 416, 11, 17, 13, 1, -17 },
  { 440, 11, 17, 13, 1, -17 },
  { 464, 11, 17, 13, 1, -17 },
  { 488, 11, 17, 13, 1, -17 },
  { 512, 5, 12, 13, 4, -12 },
  { 520, 6, 16, 13, 3, -12 },
  { 532, 11, 12, 13, 1, -13 },
  { 549, 11, 8, 13, 1, -11 },
  { 560, 11, 12, 13, 1, -13 },
  { 577, 10, 17, 13, 2, -17 },
  { 599, 13, 21, 13, 0, -17 },
  { 634, 13, 17, 13, 0, -17 },
  { 662, 12, 17, 13, 1, -17 },
  { 688, 12, 17, 13, 1, -17 },
  { 714, 12, 17, 13, 1, -17 },
  { 740, 10, 17, 13, 2, -17 },
  { 762, 10, 17, 13, 2, -17 },
  { 784, 11, 17, 13, 1, -17 },
  { 808, 11, 17, 13, 1, -17 },
  { 832, 11, 17, 13, 1, -17 },
  { 856, 11, 17, 13, 1, -17 },
  { 880, 12, 17, 13, 1, -17 },
  { 906, 10, 17, 13, 2, -17 },
  { 928, 12, 17, 13, 1, -17 },
  { 954, 11, 17, 13, 1, -17 },
  { 978, 12, 17, 13, 1, -17 },
  { 1004, 12, 17, 13, 1, -17 },
  { 1030, 12, 22, 13, 1, -17 },
  { 1063, 12, 17, 13, 1, -17 },
  { 1089, 11, 17, 13, 1, -17 },
  { 1113, 12, 17, 13, 1, -17 },
  { 1139, 11, 17, 13, 1, -17 },
  { 1163, 13, 17, 13, 0, -17 },
  { 1191, 12, 17, 13, 1, -17 },
  { 1217, 13, 17, 13, 0, -17 },
  { 1245, 13, 17, 13, 0, -17 },
  { 1273, 11, 17, 13, 1, -17 },
  { 1297, 7, 23, 13, 3, -19 },
  { 1318, 11, 23, 13, 1, -19 },
  { 1350, 7, 23, 13, 3, -19 },
  { 1371, 13, 10, 13, 0, -17 },
  { 1388, 13, 2, 13, 0, 2 },
  { 1392, 6, 5, 13, 4, -19 },
  { 1396, 11, 13, 13, 1, -13 },
  { 1414, 11, 19, 13, 2, -19 },
  { 1441, 12, 13, 13, 1, -13 },
  { 1461, 11, 19, 13, 1, -19 },
  { 1488, 12, 13, 13, 1, -13 },
  { 1508, 12, 19, 13, 1, -19 },
  { 1537, 11, 18, 13, 1, -13 },
  { 1562, 10, 19, 13, 2, -19 },
  { 1586, 12, 19, 13, 1, -19 },
  { 1615, 10, 24, 13, 1, -19 },
  { 1645, 11, 19, 13, 2, -19 },
  { 1672, 12, 19, 13, 1, -19 },
  { 1701, 12, 13, 13, 1, -13 },
  { 1721, 10, 13, 13, 2, -13 },
  { 1738, 12, 13, 13, 1, -13 },
  { 1758, 11, 17, 13, 2, -13 },
  { 1782, 11, 17, 13, 1, -13 },
  { 1806, 10, 13, 13, 2, -13 },
  { 1823, 11, 13, 13, 1, -13 },
  { 1841, 12, 16, 13, 1, -16 },
  { 1865, 10, 13, 13, 2, -13 },
  { 1882, 13, 13, 13, 0, -13 },
  { 1904, 13, 13, 13, 0, -13 },
  { 1926, 12, 13, 13, 1, -13 },
  { 1946, 12, 18, 13, 1, -13 },
  { 1973, 10, 13, 13, 2, -13 },
  { 1990, 10, 23, 13, 2, -19 },
  { 2019, 3, 23, 13, 5, -19 },
  { 2028, 10, 23, 13, 2, -19 },
  { 2057, 12, 5, 13, 1, -10 },
};

const GFXfont UbuntuSansMono_Bold24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_BOLD24PT7B_H_
