#ifndef _UBUNTUSANSMONO_BOLD27PT7B_H_
#define _UBUNTUSANSMONO_BOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0x9C, 0xE0, 0x00, 0x9F, 0xFF,
  0xDC, 0xF3, 0xFC, 0xFF, 0x3F, 0xCE, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3,
  0x80, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x73, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x0F, 0x38, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF9, 0xE0, 0xCF, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xE0,
  0x0F, 0x40, 0x7B, 0xCF, 0xFF, 0xFD, 0xFF, 0xC1, 0xF8, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x3C, 0x0E, 0xF8, 0x19, 0xB8, 0x77, 0x31, 0xCE, 0x63, 0x1C,
  0xCE, 0x3B, 0xB8, 0x3F, 0x60, 0x3D, 0xC0, 0x07, 0x00, 0x0C, 0xE0, 0x3B,
  0xE0, 0xEE, 0xE1, 0x9D, 0xC7, 0x33, 0x9C, 0x67, 0x30, 0xEE, 0xE1, 0xFB,
  0x81, 0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xFC, 0x1C, 0x70, 0x71, 0xC1, 0xC7,
  0x07, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0xE7, 0xF3, 0xBD, 0xEE, 0xE7,
  0xF3, 0x8F, 0xCE, 0x1F, 0x38, 0x3C, 0xFF, 0xF1, 0xFF, 0xE3, 0xF3, 0xC0,
  0xFF, 0xFF, 0xEE, 0xEE, 0xE6, 0x03, 0x81, 0xF0, 0xF8, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0x80, 0x40, 0x60, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF1, 0xF0, 0xF0, 0x20, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0xEE, 0x67, 0xBF, 0x7F, 0xFC, 0xFF, 0xC1, 0xF0, 0x1D, 0xC1, 0xEF,
  0x0F, 0x3C, 0x11, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0xF9, 0xF3, 0xF3, 0xC3, 0x8F, 0x7C, 0xF1, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07,
  0x78, 0x3F, 0xC1, 0xFE, 0x47, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xC0, 0x7F,
  0x07, 0xF8, 0x3D, 0xC1, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x03,
  0x80, 0x3C, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x3F, 0xC1, 0xDE, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x1F, 0x83, 0xFF, 0x3F, 0xF8, 0xE3,
  0xE2, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x1F, 0x83, 0xFF, 0x1F, 0xF8, 0x43, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xE8, 0x1E, 0x7F, 0xF7, 0xFF, 0x1F, 0xF0, 0x00, 0xE0, 0x0F, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x73, 0x87, 0x9C, 0x38, 0xE3, 0x87,
  0x1C, 0x39, 0xC1, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xD0, 0x1E, 0x7F, 0xF7, 0xFF, 0x3F, 0xE0, 0x00, 0xF0,
  0x1F, 0x83, 0xFC, 0x3F, 0xC3, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0xF8, 0x7F,
  0xE7, 0xFF, 0xBC, 0x3D, 0xE0, 0xFF, 0x07, 0xB8, 0x3D, 0xC1, 0xEF, 0x1E,
  0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0xB8, 0x39, 0xE1, 0xCF,
  0x9E, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0xF3, 0xEF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0x7F, 0xF3, 0xFF, 0x87, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC,
  0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0x78, 0x7B, 0xFF, 0xCF,
  0xFE, 0x3F, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x81, 0xF8,
  0x0F, 0x00, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x03, 0xBF, 0xFF, 0xBC, 0x39,
  0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0xE7, 0xDF, 0x7C, 0xF1, 0xCE, 0xFB,
  0x88, 0x00, 0x00, 0x30, 0x07, 0xC1, 0xFE, 0x3F, 0xEF, 0xF8, 0x7E, 0x03,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFE, 0x00, 0xE0, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x60, 0x03, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0xFC, 0x03, 0xE0, 0xFF, 0x1F, 0xF7, 0xFC, 0x1F, 0x80, 0xE0, 0x04, 0x00,
  0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0xB0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x00, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xE0, 0xF7, 0x03,
  0xF0, 0x1F, 0x8F, 0xFC, 0xFF, 0xCF, 0xFE, 0x79, 0xF3, 0x8F, 0x9C, 0x7C,
  0xE3, 0xE7, 0x1F, 0x3C, 0xFC, 0xFF, 0xE7, 0xFF, 0x0F, 0xDC, 0x00, 0xF0,
  0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x78, 0x1C, 0x70, 0x38,
  0xE0, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0x3C, 0x1E,
  0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x78, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x3E,
  0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x3E, 0xFF, 0xCF, 0xFC, 0xFF, 0xEE, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF, 0x80, 0x07,
  0xF0, 0xFF, 0xCF, 0xFE, 0xFC, 0x27, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x82, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x3E,
  0xE1, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x3E, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xCF, 0xFC, 0xFF, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE,
  0xF8, 0x27, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE1, 0xEF, 0x8F, 0x3F, 0xF9, 0xFF,
  0xC3, 0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF6, 0x1F, 0x7F, 0xEF, 0xFE, 0x7F, 0x80, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F,
  0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x3D, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x73,
  0x83, 0x9E, 0x3D, 0xF1, 0xFF, 0x8F, 0xFE, 0xFF, 0xB7, 0xFD, 0xB7, 0xED,
  0xBF, 0x7D, 0xF9, 0xCF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0xF7, 0x7F, 0xBB, 0xFC, 0xFF, 0xE7,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0E,
  0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xEF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0xFC, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xEF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x0E, 0x00, 0x78, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC7, 0xCE, 0x1E, 0x70,
  0x7B, 0x83, 0xDC, 0x3C, 0xE1, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0E, 0x38,
  0x71, 0xE3, 0x87, 0x9C, 0x3C, 0xE0, 0xF7, 0x07, 0xB8, 0x1E, 0x0F, 0xE1,
  0xFF, 0x9F, 0xFC, 0xF0, 0x47, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE8, 0x0F,
  0x7F, 0xF7, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xEF, 0x1F, 0x7F, 0xF1, 0xFF, 0x87, 0xF0, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xC7, 0x07, 0x8E, 0x0E, 0x1E, 0x3C, 0x3C, 0x78,
  0x38, 0xF0, 0x71, 0xC0, 0xF3, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0xE7, 0xE7, 0x3F, 0x7D, 0xFB,
  0xEF, 0xDB, 0x7E, 0xDF, 0xFE, 0xFF, 0xE3, 0xFF, 0x1F, 0x78, 0xFB, 0x83,
  0xDC, 0x1C, 0x78, 0x1C, 0xF0, 0x78, 0xF0, 0xE1, 0xE3, 0xC1, 0xE7, 0x01,
  0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0xEF, 0x03, 0xDE, 0x07, 0x1E, 0x1E, 0x3C, 0x78, 0x3C, 0xF0, 0x7B,
  0xE0, 0x78, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xE3, 0xC7, 0x83,
  0x8F, 0x07, 0x9C, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00,
  0xFF, 0x03, 0xDE, 0x0F, 0x9E, 0x1E, 0x3E, 0x78, 0x3D, 0xF0, 0x7C, 0xC0,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x41, 0x8F, 0x9F, 0x1C, 0x06,
  0x03, 0xFE, 0x3F, 0xE3, 0xFF, 0x00, 0xF0, 0x07, 0x0F, 0xF3, 0xFF, 0x7F,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0x7F, 0xF7, 0xFF, 0x3F, 0xF0, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF2, 0x0F, 0xFC, 0xFF, 0xEF,
  0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x01, 0xC0, 0x7F, 0xCF, 0xFE, 0x7F,
  0xE7, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x04, 0xF3, 0xFF, 0x7F, 0xF7, 0xFF, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xF3,
  0xFF, 0x1F, 0xF0, 0x02, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x87, 0xF8,
  0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0xF0, 0x27, 0xFF,
  0x1F, 0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xC2, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x01, 0x01, 0xFF, 0x3F, 0xF7, 0xFF, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFF, 0x00, 0xF0, 0x0F, 0x41, 0xF7, 0xFE, 0xFF, 0xC7, 0xF8, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0x87, 0xFC, 0xFF, 0xDF,
  0xFF, 0xC7, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0E, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x43, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x18, 0x00, 0x00,
  0x01, 0xFF, 0x3F, 0xE7, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xDC, 0x7B, 0xFE,
  0xFF, 0xC7, 0xF0, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x3E, 0xF1, 0xE7, 0x9E, 0x3D, 0xE1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xFC, 0x1E, 0xF0, 0xF3, 0xC7, 0x9F, 0x3C, 0x79, 0xE1, 0xEF,
  0x0F, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x43, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C,
  0xFC, 0xE7, 0xE7, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C,
  0x04, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x38, 0x02, 0x00, 0xFE,
  0x0F, 0xF8, 0xFF, 0xEF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1E, 0xF1, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x0C, 0x0F,
  0xF8, 0xFF, 0xCF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x02, 0x01, 0xFF, 0x3F, 0xF7, 0xFF, 0x78, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0x7F, 0xF7,
  0xFF, 0x1F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x07, 0xFD, 0xFF, 0xFF, 0xEF,
  0x01, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x21, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xFF, 0xF7, 0xFE, 0x7F, 0xC0, 0xF8, 0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xC1,
  0xC3, 0xC7, 0x87, 0x8F, 0x07, 0x1C, 0x0F, 0x78, 0x1E, 0xF0, 0x1D, 0xC0,
  0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0xE0, 0x1D,
  0xC0, 0x7B, 0x9C, 0xE7, 0x39, 0xCE, 0x7B, 0x9D, 0xF7, 0x3B, 0xEE, 0x76,
  0xDC, 0x7D, 0xF8, 0xFB, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x07, 0x00, 0xF0,
  0x79, 0xE3, 0xC3, 0x8F, 0x0F, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0xC0, 0xF7, 0x83, 0x8F, 0x1E, 0x3C, 0xF0, 0x7B, 0xC1, 0xF0,
  0xF0, 0x7B, 0x83, 0xDE, 0x1E, 0xF0, 0xE3, 0x8F, 0x1E, 0x78, 0xF3, 0x83,
  0x9C, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1C,
  0x11, 0xE0, 0xFE, 0x07, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x7F, 0x8F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x7E, 0x0F, 0x81, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F,
  0x0F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x1F, 0xC3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xF0, 0x3E, 0x07, 0xC1, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xF8, 0xFE, 0x1F,
  0x80, 0x18, 0x11, 0xF8, 0x7F, 0xFF, 0xBF, 0xFE, 0xE3, 0xF1, 0x03, 0x80,
};

const GFXglyph UbuntuSansMono_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 19, 15, 5, -19 },
  { 13, 10, 9, 15, 3, -21 },
  { 25, 14, 19, 15, 1, -19 },
  { 59, 13, 24, 15, 1, -21 },
  { 98, 15, 19, 15, 0, -19 },
  { 134, 14, 19, 15, 1, -19 },
  { 168, 4, 10, 15, 6, -21 },
  { 173, 10, 26, 15, 3, -21 },
  { 206, 9, 26, 15, 3, -21 },
  { 236, 13, 12, 15, 1, -19 },
  { 256, 13, 14, 15, 1, -15 },
  { 279, 7, 10, 15, 4, -5 },
  { 288, 9, 4, 15, 3, -10 },
  { 293, 5, 5, 15, 5, -5 },
  { 297, 13, 26, 15, 1, -21 },
  { 340, 13, 19, 15, 1, -19 },
  { 371, 13, 19, 15, 1, -19 },
  { 402, 13, 19, 15, 1, -19 },
  { 433, 13, 19, 15, 1, -19 },
  { 464, 13, 19, 15, 1, -19 },
  { 495, 13, 19, 15, 1, -19 },
  { 526, 13, 19, 15, 1, -19 },
  { 557, 13, 19, 15, 1, -19 },
  { 588, 13, 19, 15, 1, -19 },
  { 619, 13, 19, 15, 1, -19 },
  { 650, 5, 14, 15, 5, -14 },
  { 659, 6, 19, 15, 4, -14 },
  { 674, 13, 13, 15, 1, -14 },
  { 696, 13, 9, 15, 1, -12 },
  { 711, 13, 13, 15, 1, -14 },
  { 733, 11, 19, 15, 2, -19 },
  { 760, 13, 23, 15, 1, -19 },
  { 798, 15, 19, 15, 0, -19 },
  { 834, 12, 19, 15, 2, -19 },
  { 863, 13, 19, 15, 1, -19 },
  { 894, 12, 19, 15, 2, -19 },
  { 923, 12, 19, 15, 2, -19 },
  { 952, 11, 19, 15, 2, -19 },
  { 979, 13, 19, 15, 1, -19 },
  { 1010, 13, 19, 15, 1, -19 },
  { 1041, 12, 19, 15, 2, -19 },
  { 1070, 12, 19, 15, 1, -19 },
  { 1099, 14, 19, 15, 1, -19 },
  { 1133, 12, 19, 15, 2, -19 },
  { 1162, 13, 19, 15, 1, -19 },
  { 1193, 13, 19, 15, 1, -19 },
  { 1224, 13, 19, 15, 1, -19 },
  { 1255, 12, 19, 15, 2, -19 },
  { 1284, 13, 24, 15, 1, -19 },
  { 1323, 13, 19, 15, 2, -19 },
  { 1354, 13, 19, 15, 1, -19 },
  { 1385, 13, 19, 15, 1, -19 },
  { 1416, 13, 19, 15, 1, -19 },
  { 1447, 15, 19, 15, 0, -19 },
  { 1483, 13, 19, 15, 1, -19 },
  { 1514, 15, 19, 15, 0, -19 },
  { 1550, 15, 19, 15, 0, -19 },
  { 1586, 13, 19, 15, 1, -19 },
  { 1617, 9, 26, 15, 3, -21 },
  { 1647, 13, 26, 15, 1, -21 },
  { 1690, 9, 26, 15, 3, -21 },
  { 1720, 15, 11, 15, 0, -19 },
  { 1741, 15, 3, 15, 0, 2 },
  { 1747, 6, 5, 15, 5, -21 },
  { 1751, 12, 15, 15, 1, -15 },
  { 1774, 12, 21, 15, 2, -21 },
  { 1806, 13, 15, 15, 1, -15 },
  { 1831, 12, 21, 15, 1, -21 },
  { 1863, 13, 15, 15, 1, -15 },
  { 1888, 14, 21, 15, 1, -21 },
  { 1925, 12, 20, 15, 1, -15 },
  { 1955, 11, 21, 15, 2, -21 },
  { 1984, 13, 21, 15, 1, -21 },
  { 2019, 11, 26, 15, 1, -21 },
  { 2055, 13, 21, 15, 2, -21 },
  { 2090, 13, 21, 15, 1, -21 },
  { 2125, 13, 14, 15, 1, -14 },
  { 2148, 11, 15, 15, 2, -15 },
  { 2169, 13, 15, 15, 1, -15 },
  { 2194, 12, 20, 15, 2, -15 },
  { 2224, 12, 20, 15, 1, -15 },
  { 2254, 11, 14, 15, 3, -14 },
  { 2274, 11, 15, 15, 2, -15 },
  { 2295, 13, 18, 15, 1, -18 },
  { 2325, 11, 14, 15, 2, -14 },
  { 2345, 15, 14, 15, 0, -14 },
  { 2372, 15, 14, 15, 0, -14 },
  { 2399, 14, 14, 15, 1, -14 },
  { 2424, 13, 19, 15, 1, -14 },
  { 2455, 11, 14, 15, 2, -14 },
  { 2475, 11, 26, 15, 2, -21 },
  { 2511, 3, 26, 15, 6, -21 },
  { 2521, 11, 26, 15, 2, -21 },
  { 2557, 14, 6, 15, 1, -11 },
};

const GFXfont UbuntuSansMono_Bold27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_BOLD27PT7B_H_
