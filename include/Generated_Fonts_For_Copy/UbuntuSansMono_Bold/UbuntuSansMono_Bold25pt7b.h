#ifndef _UBUNTUSANSMONO_BOLD25PT7B_H_
#define _UBUNTUSANSMONO_BOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x0F, 0xFF, 0xF0, 0xF3, 0xFC,
  0xFF, 0x3D, 0xCF, 0x73, 0x9C, 0xE7, 0x19, 0x86, 0x07, 0x38, 0x39, 0xC0,
  0xE7, 0x03, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x38, 0x1C, 0xE0,
  0x73, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x73, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0xC3, 0xFF, 0x7F, 0xE7, 0x86, 0xF0,
  0x07, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00,
  0xF6, 0x0F, 0xFF, 0xEF, 0xFE, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x30,
  0x01, 0xF0, 0x77, 0xC3, 0xBB, 0x0C, 0xEE, 0x63, 0xBB, 0x8E, 0xCC, 0x1F,
  0x60, 0x3B, 0x80, 0x0C, 0x00, 0x67, 0x83, 0xBE, 0x0C, 0xDC, 0x77, 0x73,
  0x9D, 0xCC, 0x37, 0x70, 0xFB, 0x83, 0xE0, 0x0C, 0x01, 0xF8, 0x1F, 0xE0,
  0xE7, 0x07, 0x1C, 0x39, 0xC1, 0xCE, 0x0F, 0xE0, 0x3E, 0x43, 0xF3, 0x9F,
  0x9D, 0xCE, 0xEE, 0x7E, 0x71, 0xF3, 0x87, 0x9E, 0xFC, 0x7F, 0xF1, 0xF3,
  0xC0, 0xFF, 0xFF, 0xF7, 0x66, 0x02, 0x03, 0x83, 0xE3, 0xC3, 0xC3, 0xC1,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0E, 0x02, 0x00, 0x20, 0x38,
  0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE1, 0xE1, 0xE3, 0xE0,
  0xE0, 0x20, 0x00, 0x0F, 0x00, 0x70, 0x66, 0x67, 0x6E, 0xFF, 0xF3, 0xFC,
  0x0F, 0x83, 0xFC, 0x79, 0xE1, 0x9C, 0x08, 0x80, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x31, 0xE7, 0xDF, 0x7C, 0x63, 0xBC, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x31, 0xEF, 0xDE, 0x78, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xFC,
  0x3F, 0xC7, 0x9E, 0x70, 0xEF, 0x0F, 0xE0, 0x7E, 0x67, 0xEF, 0x7E, 0xF7,
  0xE6, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x70, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0x07, 0x00, 0xF0, 0x3F, 0x0F, 0xF0, 0x7F, 0x06, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF0, 0x0E, 0x03, 0xF8, 0xFF, 0xC7, 0x3E, 0x41, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x1E, 0x0F, 0xF8, 0x7F, 0xC7, 0x3E, 0x01,
  0xE0, 0x1E, 0x01, 0xE1, 0xFC, 0x1F, 0x81, 0xFC, 0x03, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xE7, 0xFE, 0xFF, 0xCF, 0xF8, 0x01, 0xC0, 0x3C, 0x07,
  0xC0, 0xFC, 0x1F, 0xC1, 0xDC, 0x39, 0xC7, 0x9C, 0x71, 0xCE, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0x80, 0x38, 0x03, 0x80, 0x3F, 0x07, 0xFC, 0x7F, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x80,
  0x03, 0xE0, 0xFE, 0x1F, 0xE3, 0xE0, 0x78, 0x07, 0x80, 0x7F, 0x8F, 0xFC,
  0xFF, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x00, 0x07, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0x70, 0xFF,
  0x0E, 0x70, 0xE7, 0xDE, 0x3F, 0xC3, 0xFC, 0x7F, 0xE7, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x0E, 0x03, 0xFC, 0x7F, 0xC7,
  0x9E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0xF0,
  0xEE, 0x01, 0xE0, 0x3C, 0x0F, 0xC7, 0xF8, 0x7F, 0x07, 0x80, 0x31, 0xEF,
  0xDE, 0x78, 0x00, 0x00, 0x31, 0xEF, 0xDE, 0x78, 0x18, 0x79, 0xF9, 0xE3,
  0xC0, 0x00, 0x00, 0x18, 0x79, 0xF1, 0xF3, 0xC1, 0x8F, 0x7C, 0x60, 0x00,
  0x60, 0x1F, 0x0F, 0xF3, 0xFC, 0xFE, 0x0F, 0x80, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x00, 0xE0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x07, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x7F, 0x8F, 0xE0, 0x70, 0x04,
  0x00, 0x1C, 0x3F, 0xEF, 0xFD, 0x9F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x0F,
  0x07, 0x81, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x07, 0x00,
  0x03, 0x80, 0x7F, 0x07, 0xFC, 0x70, 0x73, 0x03, 0xB8, 0x1D, 0xCF, 0xEC,
  0xFF, 0x67, 0xBB, 0x39, 0xF9, 0xCF, 0xCE, 0x76, 0x73, 0xB3, 0x9D, 0x9F,
  0xEE, 0x7F, 0x71, 0xF9, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0xFC,
  0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0x3C, 0xF0, 0xE1, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF9, 0xE1,
  0xE7, 0x03, 0x9C, 0x0E, 0xF0, 0x3C, 0x08, 0x0F, 0xFC, 0xFF, 0xEF, 0xBE,
  0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x3E, 0xFF, 0x8F, 0xFE, 0xF3, 0xFF, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x03, 0x81, 0xFF,
  0x3F, 0xF7, 0xC6, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x17, 0xFF, 0x3F, 0xF1, 0xFE,
  0x08, 0x0F, 0xF8, 0xFF, 0xCF, 0x7E, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0xFE,
  0xFF, 0xCF, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x81, 0xFF, 0x3F, 0xF7, 0xC6, 0x78, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7,
  0xFF, 0x3F, 0xF1, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x83, 0xDF, 0xFF, 0xFE, 0x7F, 0x80, 0xF0, 0xF7, 0x8F, 0x3C,
  0x71, 0xE7, 0x8F, 0x78, 0x7B, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3D, 0xE1, 0xE7, 0x8F, 0x1E, 0x78, 0xF3, 0xC3, 0xDE, 0x1E, 0xF0, 0x78,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0xEF, 0x0E, 0xF0, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xFF, 0x7E, 0xF7,
  0xEF, 0x7E, 0xF7, 0xE6, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x70, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEE,
  0x7E, 0xE7, 0xE7, 0x7E, 0x37, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x70, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF,
  0x0F, 0x70, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x0C, 0x0F, 0xFC, 0xFF, 0xEF,
  0xBF, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFE, 0xFF, 0xEF,
  0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x06, 0x03,
  0xFC, 0x3F, 0xE7, 0x9E, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x70, 0xE7, 0xFE, 0x3F, 0xC1,
  0xF8, 0x0E, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x00, 0x20, 0x08, 0x07, 0xFC,
  0x3F, 0xF1, 0xEF, 0xCF, 0x0E, 0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xF3, 0xE7,
  0xFF, 0x3F, 0xE1, 0xFF, 0x0F, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x1E, 0xF0,
  0xF7, 0x83, 0xC0, 0x07, 0x03, 0xFE, 0x7F, 0xE7, 0x84, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x40, 0xF7, 0xFE, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0x3D,
  0xC0, 0xE7, 0x03, 0x9E, 0x1E, 0x78, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x07, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE6, 0x7E, 0xF7, 0xEF, 0x7E, 0xF7, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF0, 0xF7, 0x0F, 0x70, 0xE0, 0x78, 0x38, 0xE1, 0xC3, 0xCF, 0x07,
  0x38, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00,
  0xFE, 0x07, 0xB8, 0x1C, 0xF0, 0xF1, 0xC7, 0x87, 0x9E, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3D, 0xE1, 0xE7, 0x87, 0x8E, 0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xEE,
  0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x1F, 0x00, 0xFC, 0x07, 0xF8, 0x1E, 0xE0, 0xF3, 0xC3, 0xC7,
  0x9E, 0x1E, 0xF0, 0x3C, 0x40, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x61, 0xEF, 0xC7, 0x04, 0x04, 0x0F, 0xF8, 0xFF, 0x99, 0xF0, 0x0E, 0x01,
  0xCF, 0xFB, 0xFF, 0xF8, 0xFE, 0x1F, 0xC3, 0xFE, 0xF7, 0xFE, 0x7F, 0xC0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xE7, 0xFE, 0xFF,
  0xDC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xFF, 0xDF,
  0xF3, 0xFC, 0x00, 0x01, 0x01, 0xFF, 0x3F, 0xE7, 0xFE, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xFF, 0x3F, 0xF0, 0xFF,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0x7F, 0xEF,
  0xFC, 0x7F, 0x80, 0x02, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0xF0, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xFE, 0x3F, 0xE1, 0xFE,
  0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x3C, 0x01, 0xE0, 0x0E, 0x03, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xEF, 0xFD, 0xF3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0xEF, 0xFD, 0xFF, 0x9F, 0xF0,
  0x0E, 0x01, 0xD0, 0xFF, 0xFE, 0xFF, 0x87, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x03, 0x81, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x73, 0xDF, 0xFF, 0xF8, 0x78, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F,
  0xC0, 0xFE, 0x0E, 0xF0, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1E, 0xE1, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xE7, 0xE6,
  0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x70, 0xFF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x02, 0x01, 0xF8, 0x7F, 0xE7, 0xFE,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xF7, 0xFE,
  0x3F, 0xC1, 0xF8, 0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x1F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0xFF, 0x7F, 0xEF, 0xF9, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xEF, 0xFD, 0xFF, 0xF8, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xFF, 0xBF, 0xF3, 0xFE, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x02,
  0x07, 0xFD, 0xFF, 0xBE, 0xE7, 0x00, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xE0,
  0x3D, 0x03, 0xBF, 0xF7, 0xFF, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0xFD, 0xFF,
  0x3F, 0xC0, 0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x8E, 0x1C, 0x38, 0x70, 0xF3,
  0xC1, 0xCE, 0x07, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0x80, 0xE0, 0x1F, 0x80, 0x76, 0x31, 0x98, 0xE6, 0x67, 0x99, 0xDE, 0xE7,
  0x7B, 0x9D, 0xFE, 0x7D, 0xF8, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x38, 0x70,
  0xF0, 0xF7, 0x0E, 0x39, 0xE3, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x01, 0xF8,
  0x3F, 0xC3, 0x9C, 0x79, 0xEF, 0x0F, 0xE0, 0x70, 0xF0, 0x7F, 0x0F, 0x70,
  0xE7, 0x8E, 0x78, 0xE3, 0x9E, 0x3D, 0xC1, 0xDC, 0x1D, 0xC1, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0x00, 0xF0, 0x9E, 0x0F, 0xE0, 0xFC, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC3, 0xF1, 0xFC, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC3, 0xE0, 0xE0, 0x3E, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xFC, 0x3F, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x3F, 0x0F, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x1F, 0x01, 0xC1, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x8F, 0xE3, 0xF0, 0xE0, 0x00, 0x38, 0x3B, 0xF3,
  0xBF, 0xFD, 0xDF, 0xEC, 0x3E, 0x00,
};

const GFXglyph UbuntuSansMono_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 10, 8, 14, 2, -19 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 12, 22, 14, 1, -19 },
  { 83, 14, 18, 14, 0, -18 },
  { 115, 13, 18, 14, 1, -18 },
  { 145, 4, 8, 14, 5, -19 },
  { 149, 9, 25, 14, 3, -20 },
  { 178, 9, 25, 14, 2, -20 },
  { 207, 12, 11, 14, 1, -17 },
  { 224, 12, 13, 14, 1, -14 },
  { 244, 6, 9, 14, 4, -5 },
  { 251, 8, 4, 14, 3, -9 },
  { 255, 6, 5, 14, 4, -5 },
  { 259, 12, 25, 14, 1, -20 },
  { 297, 12, 18, 14, 1, -18 },
  { 324, 12, 17, 14, 1, -17 },
  { 350, 12, 18, 14, 1, -18 },
  { 377, 12, 18, 14, 1, -18 },
  { 404, 12, 17, 14, 1, -17 },
  { 430, 12, 17, 14, 1, -17 },
  { 456, 12, 17, 14, 1, -17 },
  { 482, 12, 17, 14, 1, -17 },
  { 508, 12, 18, 14, 1, -18 },
  { 535, 12, 18, 14, 1, -18 },
  { 562, 6, 13, 14, 4, -13 },
  { 572, 7, 17, 14, 3, -13 },
  { 587, 12, 12, 14, 1, -13 },
  { 605, 12, 9, 14, 1, -12 },
  { 619, 12, 12, 14, 1, -13 },
  { 637, 10, 18, 14, 2, -18 },
  { 660, 13, 22, 14, 0, -18 },
  { 696, 14, 17, 14, 0, -17 },
  { 726, 12, 18, 14, 1, -18 },
  { 753, 12, 18, 14, 1, -18 },
  { 780, 12, 18, 14, 1, -18 },
  { 807, 11, 17, 14, 2, -17 },
  { 831, 10, 17, 14, 2, -17 },
  { 853, 12, 18, 14, 1, -18 },
  { 880, 12, 17, 14, 1, -17 },
  { 906, 12, 17, 14, 1, -17 },
  { 932, 11, 17, 14, 1, -17 },
  { 956, 13, 17, 14, 1, -17 },
  { 984, 11, 17, 14, 2, -17 },
  { 1008, 12, 17, 14, 1, -17 },
  { 1034, 12, 17, 14, 1, -17 },
  { 1060, 12, 18, 14, 1, -18 },
  { 1087, 12, 18, 14, 1, -18 },
  { 1114, 12, 23, 14, 1, -18 },
  { 1149, 13, 18, 14, 1, -18 },
  { 1179, 12, 18, 14, 1, -18 },
  { 1206, 12, 17, 14, 1, -17 },
  { 1232, 12, 17, 14, 1, -17 },
  { 1258, 14, 17, 14, 0, -17 },
  { 1288, 12, 17, 14, 1, -17 },
  { 1314, 14, 17, 14, 0, -17 },
  { 1344, 14, 17, 14, 0, -17 },
  { 1374, 12, 17, 14, 1, -17 },
  { 1400, 8, 25, 14, 3, -20 },
  { 1425, 12, 25, 14, 1, -20 },
  { 1463, 8, 25, 14, 3, -20 },
  { 1488, 14, 10, 14, 0, -17 },
  { 1506, 14, 3, 14, 0, 2 },
  { 1512, 6, 5, 14, 4, -19 },
  { 1516, 11, 14, 14, 1, -14 },
  { 1536, 11, 19, 14, 2, -19 },
  { 1563, 12, 14, 14, 1, -14 },
  { 1584, 11, 19, 14, 1, -19 },
  { 1611, 12, 14, 14, 1, -14 },
  { 1632, 13, 19, 14, 1, -19 },
  { 1663, 11, 18, 14, 1, -13 },
  { 1688, 10, 19, 14, 2, -19 },
  { 1712, 12, 19, 14, 1, -19 },
  { 1741, 10, 24, 14, 1, -19 },
  { 1771, 12, 19, 14, 2, -19 },
  { 1800, 12, 19, 14, 1, -19 },
  { 1829, 12, 13, 14, 1, -13 },
  { 1849, 10, 13, 14, 2, -13 },
  { 1866, 12, 14, 14, 1, -14 },
  { 1887, 11, 18, 14, 2, -13 },
  { 1912, 11, 18, 14, 1, -13 },
  { 1937, 11, 13, 14, 2, -13 },
  { 1955, 11, 14, 14, 1, -14 },
  { 1975, 12, 17, 14, 1, -17 },
  { 2001, 10, 13, 14, 2, -13 },
  { 2018, 14, 13, 14, 0, -13 },
  { 2041, 14, 13, 14, 0, -13 },
  { 2064, 12, 13, 14, 1, -13 },
  { 2084, 12, 18, 14, 1, -13 },
  { 2111, 10, 13, 14, 2, -13 },
  { 2128, 10, 25, 14, 2, -20 },
  { 2160, 4, 25, 14, 5, -20 },
  { 2173, 10, 25, 14, 2, -20 },
  { 2205, 13, 5, 14, 1, -10 },
};

const GFXfont UbuntuSansMono_Bold25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_BOLD25PT7B_H_
