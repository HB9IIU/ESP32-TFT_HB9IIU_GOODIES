#ifndef _UBUNTUSANSMONO_BOLD19PT7B_H_
#define _UBUNTUSANSMONO_BOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0xEF, 0xDF, 0xBE, 0x7C, 0x58, 0x80,
  0x1D, 0xC6, 0x61, 0x9B, 0xFF, 0xFF, 0xCE, 0xC3, 0x30, 0xCC, 0xFF, 0xFF,
  0xF3, 0x71, 0x98, 0x66, 0x00, 0x1C, 0x0E, 0x0F, 0xAF, 0xEF, 0x37, 0x03,
  0x80, 0xF8, 0x3F, 0x07, 0x80, 0xE0, 0x7E, 0x7F, 0xF9, 0xF8, 0x38, 0x1C,
  0x00, 0x70, 0xFB, 0x1B, 0x66, 0x6D, 0x8F, 0xB0, 0xEC, 0x03, 0x00, 0x7E,
  0x1B, 0xC6, 0x48, 0xC9, 0x31, 0xEC, 0x3C, 0x3E, 0x0D, 0xC7, 0x31, 0xCC,
  0x36, 0x0F, 0x03, 0xCD, 0xFF, 0x67, 0xB8, 0xE6, 0x39, 0xFF, 0x3C, 0xC0,
  0xFF, 0xFC, 0x80, 0x04, 0x3C, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x07, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x10, 0x41, 0xC1, 0xC1, 0xC1,
  0xC3, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x1C, 0x71, 0xC1,
  0x00, 0x1C, 0x0C, 0x3A, 0xDF, 0xF1, 0xC1, 0xB1, 0xDC, 0x4C, 0x18, 0x0C,
  0x06, 0x1F, 0xFF, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x00, 0x27, 0x77, 0x3E,
  0xC0, 0xFF, 0xFF, 0xC0, 0x27, 0xF7, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x00, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x3E, 0xCF, 0x77,
  0x97, 0xC3, 0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0x0C, 0x1E, 0x3F, 0x1F, 0x84,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF7, 0xF8, 0x7E, 0x7F,
  0x91, 0xC0, 0x60, 0x70, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x1F, 0xFF,
  0xF8, 0xFE, 0x3F, 0x91, 0xC0, 0xE0, 0x71, 0xF0, 0xFC, 0x0E, 0x03, 0x81,
  0xE1, 0xDF, 0xEF, 0xE0, 0x07, 0x07, 0x87, 0xC7, 0xE3, 0x73, 0x3B, 0x9D,
  0x8E, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0x70, 0x7F, 0x3F, 0x98, 0x0C, 0x06,
  0x03, 0xF1, 0xFC, 0x0E, 0x03, 0x81, 0xA1, 0xDF, 0xEF, 0xE0, 0x0F, 0x1F,
  0x8E, 0x0E, 0x0E, 0x07, 0xF3, 0xFD, 0xC7, 0xE3, 0xF1, 0xF8, 0xCF, 0xE3,
  0xE0, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0x7E, 0x3F, 0xB8, 0xFC, 0x6E, 0x33, 0xF9, 0xF9,
  0xDE, 0xC3, 0xE1, 0xF8, 0xFF, 0xE7, 0xE0, 0x08, 0x3F, 0x1F, 0xDC, 0x6E,
  0x3F, 0x1F, 0x8E, 0xFF, 0x3F, 0x03, 0x81, 0xC3, 0xC7, 0xC3, 0x80, 0x27,
  0xF7, 0x00, 0x27, 0xF7, 0x11, 0xDE, 0x70, 0x00, 0x47, 0x79, 0xC7, 0xE6,
  0x00, 0x01, 0x07, 0xCF, 0xDF, 0x8E, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xC0, 0x78, 0x1F, 0x83,
  0xF0, 0x38, 0xFD, 0xF9, 0xF0, 0xC0, 0x00, 0xFE, 0x7F, 0x47, 0x07, 0x07,
  0x1E, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x3C, 0x38, 0x1F, 0x8E, 0x66, 0x0D,
  0x83, 0x6F, 0xF3, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x36, 0xFD, 0x9F, 0x60,
  0x0E, 0x01, 0xF8, 0x3F, 0x0E, 0x07, 0x81, 0xF0, 0x6C, 0x1B, 0x0C, 0xE3,
  0x38, 0xC6, 0x7F, 0x9F, 0xF6, 0x1D, 0x87, 0xE0, 0xC0, 0xFE, 0x7F, 0xB8,
  0xDC, 0x6E, 0x77, 0xF3, 0xFD, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xEF, 0xE0,
  0x3F, 0xBF, 0xFC, 0x3C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x3C,
  0x2F, 0xF3, 0xF8, 0xFE, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF9, 0xDF, 0xCF, 0xC0, 0xFF, 0x7F, 0xB8, 0x1C, 0x0E, 0x07,
  0xFB, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0xBF,
  0xFC, 0x3C, 0x0C, 0x06, 0x03, 0x0F, 0x87, 0xC3, 0xF1, 0xFC, 0xEF, 0xF3,
  0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x38, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0x7F, 0x7F, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x47, 0xFF, 0xFE, 0xE3, 0xF3, 0xB9, 0x9D,
  0xCF, 0xC7, 0xC3, 0xE1, 0xF8, 0xEE, 0x73, 0xB9, 0xDC, 0x7E, 0x38, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0x71, 0x9C, 0x77, 0x3D, 0xEF, 0x7A, 0xDB, 0xB6, 0xED, 0xB3, 0x60, 0xD8,
  0x36, 0x0D, 0x83, 0xE0, 0xC0, 0xC3, 0xF1, 0xFC, 0xFE, 0x7F, 0xBE, 0xDF,
  0x3F, 0x9F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x38, 0x3E, 0x3F, 0xB8, 0xDC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFE,
  0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFE, 0xF8, 0x70, 0x38, 0x1C,
  0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xDC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0xE0, 0x3C, 0x0F, 0x00, 0x80, 0xFE, 0x7F,
  0xB9, 0xDC, 0x7E, 0x3F, 0x3B, 0xFD, 0xFC, 0xEE, 0x73, 0xB9, 0xDC, 0x7E,
  0x38, 0x7F, 0x3F, 0xB8, 0x1C, 0x0F, 0x03, 0xE0, 0xFC, 0x1E, 0x03, 0x81,
  0xE0, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xEF, 0xE7, 0xE0, 0xE0, 0xD8,
  0x76, 0x1D, 0xC7, 0x71, 0x8C, 0x63, 0x38, 0xEC, 0x1B, 0x06, 0xC1, 0xF0,
  0x78, 0x0E, 0x00, 0xE0, 0xD8, 0x36, 0x0D, 0x83, 0x6C, 0xDB, 0xB6, 0xED,
  0xBB, 0x7A, 0xDE, 0xF7, 0x3D, 0xC7, 0x71, 0x80, 0xF1, 0xDC, 0x63, 0xB8,
  0xEC, 0x1F, 0x03, 0x80, 0xE0, 0x7C, 0x1B, 0x0E, 0xE7, 0x19, 0xC7, 0xE1,
  0xC0, 0xE1, 0xDC, 0x77, 0x18, 0xCE, 0x3B, 0x06, 0xC1, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xFF, 0x7F, 0x81, 0xC1, 0xC0, 0xE0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFE, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0,
  0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xFF,
  0xC0, 0x0E, 0x07, 0xC1, 0xF0, 0xEE, 0x73, 0x9C, 0x7E, 0x1C, 0x82, 0xFF,
  0xFF, 0xFF, 0xFC, 0x43, 0x3E, 0x20, 0x7E, 0x7F, 0x07, 0x03, 0x7F, 0xFF,
  0xE3, 0xE3, 0xFF, 0x7F, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF3, 0xFD,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFB, 0xF8, 0x3F, 0xBF, 0xBC,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x7F, 0x9F, 0xC0, 0x01, 0x03, 0x03,
  0x03, 0x03, 0x7F, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F,
  0x3E, 0x3F, 0xB8, 0xF8, 0x7F, 0xFF, 0xFF, 0x01, 0xC2, 0x7F, 0x1F, 0x80,
  0x07, 0x0F, 0xCF, 0x67, 0x03, 0x87, 0xFF, 0xFE, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3,
  0xFF, 0x7F, 0x03, 0x07, 0xFF, 0xFE, 0x38, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x10, 0x1C,
  0x0E, 0x02, 0x00, 0x07, 0xC3, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x88, 0xFC, 0x3E, 0x04, 0x0E, 0x0E, 0x04, 0x00, 0x7F, 0x7F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x86, 0xFE, 0xFE, 0x38, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x1F, 0x9D, 0xDC, 0xFC, 0x7C, 0x3F, 0x1D, 0xCE,
  0x77, 0x1B, 0x8E, 0xF8, 0x7C, 0x3E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x88, 0xFC, 0x3E, 0xFF, 0x7F, 0xF6, 0x7B,
  0x3D, 0x9E, 0xCF, 0x07, 0x83, 0xC1, 0xE0, 0xC0, 0xFE, 0xFF, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3E, 0x3F, 0xB8, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0xC7, 0x7F, 0x1F, 0x00, 0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0x7F,
  0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0x7F, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0xE2, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x7F,
  0xE1, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x1F,
  0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x27, 0xF1, 0xF8, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x3F, 0xE0, 0xD8, 0x77,
  0x1D, 0xC6, 0x33, 0x8E, 0xC1, 0xF0, 0x7C, 0x1E, 0x03, 0x80, 0xC0, 0xF8,
  0x3E, 0xCD, 0xBB, 0x6E, 0xDB, 0xB7, 0xAD, 0xEE, 0x73, 0x8C, 0x60, 0xF1,
  0xCC, 0xE3, 0xB0, 0x7C, 0x0E, 0x07, 0x81, 0xF0, 0xEE, 0x71, 0xB8, 0x70,
  0x71, 0xDC, 0x73, 0x18, 0xC6, 0x3B, 0x86, 0xC1, 0xF0, 0x7C, 0x0E, 0x03,
  0x80, 0xE1, 0xF0, 0x78, 0x28, 0x00, 0x7F, 0x7F, 0x07, 0x0E, 0x1C, 0x38,
  0x30, 0x70, 0xFF, 0xFF, 0x0F, 0x1F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xF8, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0xFC, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x0F, 0x07, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC,
  0xF8, 0xE0, 0x10, 0x9F, 0x37, 0xFF, 0x9E,
};

const GFXglyph UbuntuSansMono_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 7, 6, 11, 2, -14 },
  { 12, 10, 13, 11, 0, -13 },
  { 29, 9, 17, 11, 1, -15 },
  { 49, 11, 13, 11, 0, -13 },
  { 67, 10, 13, 11, 0, -13 },
  { 84, 3, 6, 11, 4, -14 },
  { 87, 7, 19, 11, 2, -15 },
  { 104, 7, 19, 11, 2, -15 },
  { 121, 9, 8, 11, 1, -13 },
  { 130, 9, 9, 11, 1, -10 },
  { 141, 4, 7, 11, 3, -4 },
  { 145, 6, 3, 11, 2, -7 },
  { 148, 4, 4, 11, 3, -4 },
  { 150, 9, 19, 11, 1, -15 },
  { 172, 9, 13, 11, 1, -13 },
  { 187, 9, 13, 11, 1, -13 },
  { 202, 9, 13, 11, 1, -13 },
  { 217, 9, 13, 11, 1, -13 },
  { 232, 9, 13, 11, 1, -13 },
  { 247, 9, 13, 11, 1, -13 },
  { 262, 9, 13, 11, 1, -13 },
  { 277, 9, 13, 11, 1, -13 },
  { 292, 9, 13, 11, 1, -13 },
  { 307, 9, 14, 11, 1, -14 },
  { 323, 4, 10, 11, 3, -10 },
  { 328, 5, 13, 11, 2, -10 },
  { 337, 9, 9, 11, 1, -10 },
  { 348, 9, 7, 11, 1, -9 },
  { 356, 9, 9, 11, 1, -10 },
  { 367, 8, 13, 11, 1, -13 },
  { 380, 10, 16, 11, 0, -13 },
  { 400, 10, 13, 11, 0, -13 },
  { 417, 9, 13, 11, 1, -13 },
  { 432, 9, 13, 11, 1, -13 },
  { 447, 9, 13, 11, 1, -13 },
  { 462, 9, 13, 11, 1, -13 },
  { 477, 8, 13, 11, 1, -13 },
  { 490, 9, 13, 11, 1, -13 },
  { 505, 9, 13, 11, 1, -13 },
  { 520, 9, 13, 11, 1, -13 },
  { 535, 8, 13, 11, 1, -13 },
  { 548, 9, 13, 11, 1, -13 },
  { 563, 8, 13, 11, 2, -13 },
  { 576, 10, 13, 11, 0, -13 },
  { 593, 9, 13, 11, 1, -13 },
  { 608, 9, 13, 11, 1, -13 },
  { 623, 9, 13, 11, 1, -13 },
  { 638, 9, 17, 11, 1, -13 },
  { 658, 9, 13, 11, 1, -13 },
  { 673, 9, 13, 11, 1, -13 },
  { 688, 9, 13, 11, 1, -13 },
  { 703, 9, 13, 11, 1, -13 },
  { 718, 10, 13, 11, 0, -13 },
  { 735, 10, 13, 11, 0, -13 },
  { 752, 10, 13, 11, 0, -13 },
  { 769, 10, 13, 11, 0, -13 },
  { 786, 9, 13, 11, 1, -13 },
  { 801, 6, 19, 11, 2, -15 },
  { 816, 9, 19, 11, 1, -15 },
  { 838, 6, 19, 11, 2, -15 },
  { 853, 10, 8, 11, 0, -13 },
  { 863, 10, 3, 11, 0, 1 },
  { 867, 5, 4, 11, 3, -15 },
  { 870, 8, 10, 11, 1, -10 },
  { 880, 9, 15, 11, 1, -15 },
  { 897, 9, 10, 11, 1, -10 },
  { 909, 8, 15, 11, 1, -15 },
  { 924, 9, 10, 11, 1, -10 },
  { 936, 9, 15, 11, 1, -15 },
  { 953, 8, 14, 11, 1, -10 },
  { 967, 8, 15, 11, 1, -15 },
  { 982, 9, 15, 11, 1, -15 },
  { 999, 8, 19, 11, 1, -15 },
  { 1018, 9, 15, 11, 1, -15 },
  { 1035, 9, 15, 11, 1, -15 },
  { 1052, 9, 10, 11, 1, -10 },
  { 1064, 8, 10, 11, 1, -10 },
  { 1074, 9, 10, 11, 1, -10 },
  { 1086, 9, 14, 11, 1, -10 },
  { 1102, 8, 14, 11, 1, -10 },
  { 1116, 8, 10, 11, 2, -10 },
  { 1126, 8, 10, 11, 1, -10 },
  { 1136, 9, 13, 11, 1, -13 },
  { 1151, 8, 10, 11, 1, -10 },
  { 1161, 10, 10, 11, 0, -10 },
  { 1174, 10, 10, 11, 0, -10 },
  { 1187, 10, 10, 11, 0, -10 },
  { 1200, 10, 14, 11, 0, -10 },
  { 1218, 8, 10, 11, 1, -10 },
  { 1228, 8, 19, 11, 1, -15 },
  { 1247, 3, 19, 11, 4, -15 },
  { 1255, 8, 19, 11, 1, -15 },
  { 1274, 10, 4, 11, 0, -8 },
};

const GFXfont UbuntuSansMono_Bold19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_BOLD19PT7B_H_
