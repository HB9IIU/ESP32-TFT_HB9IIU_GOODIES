#ifndef _UBUNTUSANSMONO_BOLD9PT7B_H_
#define _UBUNTUSANSMONO_BOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xB6, 0x80, 0x3F, 0xD5, 0xF5, 0x70, 0x23, 0xD0, 0xC1, 0xCF,
  0xC4, 0xCE, 0x98, 0x75, 0xCC, 0x72, 0x99, 0xD9, 0x3C, 0xE0, 0x2A, 0x49,
  0x33, 0x20, 0x88, 0x92, 0x5A, 0x80, 0x27, 0xD4, 0xA0, 0x21, 0x3E, 0x42,
  0x00, 0x4D, 0x40, 0xE0, 0xC0, 0x18, 0x8C, 0x42, 0x11, 0x08, 0xC0, 0x76,
  0xEB, 0x15, 0x38, 0x27, 0x08, 0x42, 0x3C, 0xF0, 0x84, 0x44, 0x3C, 0x70,
  0x8C, 0x21, 0xF8, 0x31, 0x95, 0xFF, 0x88, 0x72, 0x1C, 0x21, 0xF8, 0x32,
  0x1D, 0xB5, 0xB8, 0xF8, 0x8C, 0x42, 0x30, 0x72, 0xDC, 0xAD, 0xB8, 0x76,
  0xD6, 0xE3, 0x30, 0xD8, 0x51, 0x58, 0x0B, 0xB0, 0x70, 0x80, 0xF8, 0x3E,
  0x47, 0x87, 0xC8, 0x00, 0xE5, 0xA5, 0x80, 0x74, 0x6F, 0x5A, 0xCD, 0xE0,
  0x22, 0x94, 0xAF, 0xC4, 0xEA, 0xEB, 0xBE, 0x7E, 0x31, 0x84, 0x3C, 0xEB,
  0x9B, 0xBE, 0xE8, 0xE8, 0x8F, 0xF3, 0xC9, 0x00, 0x7E, 0x31, 0xB5, 0xBC,
  0xDE, 0xFF, 0xBD, 0xEC, 0xF4, 0x44, 0x4F, 0x71, 0x11, 0x1F, 0xDF, 0xB9,
  0xED, 0x6C, 0x88, 0x88, 0x8F, 0x56, 0xEB, 0x58, 0xC4, 0xDE, 0xFF, 0xFD,
  0xEC, 0x76, 0xF3, 0xBD, 0xB8, 0xEB, 0xBE, 0x88, 0x76, 0xF3, 0xBD, 0xB8,
  0x83, 0xEB, 0xAE, 0xAB, 0x76, 0x18, 0x21, 0xF8, 0xF9, 0x08, 0x42, 0x10,
  0xDE, 0xF7, 0xBD, 0xB8, 0xDA, 0xD4, 0xA5, 0x10, 0x8C, 0x6B, 0x5D, 0xAC,
  0xDA, 0x88, 0xE5, 0x6C, 0xDA, 0x9C, 0x42, 0x10, 0x70, 0x88, 0xC4, 0x7C,
  0xF2, 0x49, 0x24, 0xE0, 0xC2, 0x18, 0x42, 0x18, 0x42, 0x18, 0xE4, 0x92,
  0x49, 0xE0, 0x32, 0xB6, 0xF8, 0x90, 0x71, 0x7D, 0x70, 0x88, 0xEB, 0xBB,
  0xE0, 0x3A, 0x30, 0x87, 0x80, 0x11, 0x7D, 0xDD, 0x70, 0x72, 0xFF, 0x87,
  0x00, 0x3B, 0x3E, 0xC6, 0x31, 0x80, 0x7D, 0xDD, 0x79, 0x60, 0x93, 0xDB,
  0x68, 0x61, 0x38, 0x42, 0x10, 0xE0, 0x31, 0x71, 0x11, 0x15, 0xE0, 0x88,
  0xBE, 0xCA, 0xB0, 0xE1, 0x08, 0x42, 0x10, 0xE0, 0xF5, 0x6B, 0x18, 0x80,
  0xF6, 0xDA, 0x76, 0xF7, 0xB7, 0x00, 0xEB, 0xBB, 0xE8, 0x80, 0x75, 0xDD,
  0x71, 0x10, 0xF9, 0x88, 0x80, 0xF3, 0x9E, 0x67, 0xD8, 0xC6, 0x1C, 0xB6,
  0xDE, 0x8A, 0xD4, 0xA2, 0x00, 0x8D, 0x6A, 0xB5, 0x00, 0xDA, 0x88, 0xAD,
  0x80, 0xDA, 0x94, 0xE2, 0x53, 0x00, 0xE5, 0x4E, 0x69, 0x28, 0x92, 0x60,
  0xFF, 0x80, 0xC9, 0x22, 0x92, 0xC0, 0x4F, 0xC0,
};

const GFXglyph UbuntuSansMono_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 3, 5, 2, -7 },
  { 22, 3, 9, 5, 1, -7 },
  { 26, 3, 9, 5, 1, -7 },
  { 30, 5, 4, 5, 0, -6 },
  { 33, 5, 5, 5, 0, -5 },
  { 37, 3, 4, 5, 1, -2 },
  { 39, 3, 1, 5, 1, -3 },
  { 40, 1, 2, 5, 2, -2 },
  { 41, 5, 9, 5, 0, -7 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 5, 6, 5, 0, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 5, 6, 5, 0, -6 },
  { 71, 5, 6, 5, 0, -6 },
  { 75, 5, 6, 5, 0, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 5, 6, 5, 0, -6 },
  { 87, 1, 5, 5, 2, -5 },
  { 88, 2, 7, 5, 1, -5 },
  { 90, 5, 5, 5, 0, -5 },
  { 94, 5, 3, 5, 0, -4 },
  { 96, 5, 5, 5, 0, -5 },
  { 100, 3, 6, 5, 1, -6 },
  { 103, 5, 7, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 4, 6, 5, 1, -6 },
  { 122, 4, 6, 5, 1, -6 },
  { 125, 3, 6, 5, 1, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 5, 6, 5, 0, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 4, 6, 5, 0, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 4, 6, 5, 1, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 5, 8, 5, 0, -6 },
  { 169, 4, 6, 5, 1, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 5, 6, 5, 0, -6 },
  { 196, 5, 6, 5, 0, -6 },
  { 200, 5, 6, 5, 0, -6 },
  { 204, 3, 9, 5, 1, -7 },
  { 208, 5, 9, 5, 0, -7 },
  { 214, 3, 9, 5, 1, -7 },
  { 218, 5, 3, 5, 0, -6 },
  { 220, 5, 1, 5, 0, 1 },
  { 221, 2, 2, 5, 2, -7 },
  { 222, 4, 5, 5, 0, -5 },
  { 225, 4, 7, 5, 1, -7 },
  { 229, 5, 5, 5, 0, -5 },
  { 233, 4, 7, 5, 0, -7 },
  { 237, 5, 5, 5, 0, -5 },
  { 241, 5, 7, 5, 0, -7 },
  { 246, 4, 7, 5, 0, -5 },
  { 250, 3, 7, 5, 1, -7 },
  { 253, 5, 7, 5, 0, -7 },
  { 258, 4, 9, 5, 0, -7 },
  { 263, 4, 7, 5, 1, -7 },
  { 267, 5, 7, 5, 0, -7 },
  { 272, 5, 5, 5, 0, -5 },
  { 276, 3, 5, 5, 1, -5 },
  { 278, 5, 5, 5, 0, -5 },
  { 282, 4, 7, 5, 1, -5 },
  { 286, 4, 7, 5, 0, -5 },
  { 290, 4, 5, 5, 1, -5 },
  { 293, 3, 5, 5, 1, -5 },
  { 295, 5, 6, 5, 0, -6 },
  { 299, 3, 5, 5, 1, -5 },
  { 301, 5, 5, 5, 0, -5 },
  { 305, 5, 5, 5, 0, -5 },
  { 309, 5, 5, 5, 0, -5 },
  { 313, 5, 7, 5, 0, -5 },
  { 318, 3, 5, 5, 1, -5 },
  { 320, 3, 9, 5, 1, -7 },
  { 324, 1, 9, 5, 2, -7 },
  { 326, 3, 9, 5, 1, -7 },
  { 330, 5, 2, 5, 0, -4 },
};

const GFXfont UbuntuSansMono_Bold9pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold9pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUSANSMONO_BOLD9PT7B_H_
