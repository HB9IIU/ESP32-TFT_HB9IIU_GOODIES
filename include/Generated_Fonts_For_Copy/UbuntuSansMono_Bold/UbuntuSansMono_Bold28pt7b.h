#ifndef _UBUNTUSANSMONO_BOLD28PT7B_H_
#define _UBUNTUSANSMONO_BOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x00, 0xCF, 0xFF,
  0xDE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3B, 0x86, 0x61,
  0x80, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x87, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x3C, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xF8, 0x3F, 0xF8, 0xFF, 0xE7, 0xCF, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3D, 0x01, 0xF7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF0,
  0x7E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0x7C, 0x0E, 0x7E,
  0x0C, 0xE6, 0x1C, 0xE6, 0x38, 0xE6, 0x30, 0xE6, 0x70, 0x7E, 0xE0, 0x7E,
  0xC0, 0x39, 0xC0, 0x03, 0x80, 0x03, 0x3C, 0x07, 0x7E, 0x0E, 0x6E, 0x0C,
  0xE6, 0x1C, 0xE6, 0x38, 0xE6, 0x38, 0x6E, 0x70, 0x7E, 0xE0, 0x3C, 0x0F,
  0x00, 0xFF, 0x03, 0xFC, 0x1E, 0x78, 0x71, 0xE1, 0xC7, 0x87, 0x9C, 0x1E,
  0xF0, 0x3F, 0x80, 0x7C, 0xC3, 0xE3, 0x9F, 0xCE, 0xF7, 0xBB, 0x8F, 0xEE,
  0x1F, 0x38, 0x3C, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xEE, 0x60, 0x01, 0x80, 0xF0, 0xFC, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x18, 0x60, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x06, 0x00, 0x07,
  0x80, 0x3C, 0x19, 0xC4, 0xF6, 0xF7, 0xFF, 0xFF, 0xFC, 0x1E, 0x01, 0xF8,
  0x1F, 0xE1, 0xE7, 0x87, 0x38, 0x10, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0xFD, 0xFB, 0xF3, 0xE1, 0x87,
  0x7C, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF,
  0x1F, 0xFC, 0x78, 0x79, 0xC1, 0xEF, 0x03, 0xBC, 0x0E, 0xF3, 0x3F, 0xDE,
  0xFF, 0x7B, 0xFC, 0xCF, 0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0x9E, 0x1E, 0x78,
  0xF8, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0xF8, 0x3F, 0x8F, 0xF8,
  0xFF, 0x8F, 0x78, 0x47, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F,
  0x81, 0xFF, 0x3F, 0xFC, 0xFF, 0xE2, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x83, 0xFF, 0x1F,
  0xFC, 0xFF, 0xE2, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xE0, 0x7E,
  0x03, 0xFC, 0x07, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x40, 0xFB,
  0xFF, 0xBF, 0xFC, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3B, 0xC1, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xC3, 0xCF, 0x0F,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0x7E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE8, 0x1F, 0x7F, 0xF7, 0xFF, 0x3F, 0xF0, 0x00, 0x10,
  0x0F, 0x81, 0xFC, 0x1F, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x7F,
  0xE3, 0xFF, 0xBF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xC1, 0xEF, 0x0F,
  0x78, 0x79, 0xFF, 0x8F, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x79, 0xC1, 0xE7, 0x07,
  0x9E, 0x1E, 0x7E, 0xF0, 0xFF, 0x83, 0xFE, 0x1E, 0xFC, 0x78, 0xFB, 0xC1,
  0xEF, 0x03, 0xFC, 0x0F, 0xF8, 0x79, 0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x0F,
  0x80, 0xFF, 0x0F, 0xFC, 0xFB, 0xE7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0x78, 0x3B, 0xE3, 0xDF, 0xFE, 0x7F, 0xF0, 0xF7, 0x80, 0x78, 0x03, 0xC0,
  0x7C, 0x0F, 0xE1, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x7B, 0xFF, 0xFF, 0x78,
  0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x79, 0xF3, 0xF7, 0xE7, 0x87, 0x0E, 0xF9, 0xE3, 0x00,
  0x00, 0x08, 0x01, 0xE0, 0x1F, 0x83, 0xFF, 0x3F, 0xE3, 0xFC, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7E, 0x00, 0x78, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x03, 0xC0, 0x1F, 0x81, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xF8, 0xFF, 0xBF, 0xE0, 0xFC, 0x07,
  0x00, 0x20, 0x00, 0x1F, 0x0F, 0xFC, 0xFF, 0xE7, 0xFE, 0x41, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xFE, 0x1F, 0xF8, 0xFF, 0xE7,
  0xFF, 0x9E, 0xFC, 0xF3, 0xF3, 0xCF, 0xCF, 0x3F, 0x3C, 0xFE, 0xF3, 0xF9,
  0xEF, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0x9C, 0x00, 0x78, 0x00, 0xFF, 0xE1,
  0xFF, 0x81, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEF,
  0x01, 0xDE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x78, 0x38, 0xF0, 0xF0, 0xE1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x3C, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xC0, 0x78, 0x3C, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x0F, 0x78,
  0x7B, 0xC3, 0xDE, 0x3C, 0xFF, 0xE7, 0xFE, 0x3F, 0xF9, 0xE7, 0xEF, 0x0F,
  0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00,
  0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7C, 0x09, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x08, 0xFF, 0xE1, 0xFF, 0xC3, 0xFE, 0x3C,
  0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xDE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xDE,
  0x1E, 0xF3, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFE, 0x7C, 0x09, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0x9E, 0x0E, 0x7C, 0x38,
  0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xEC, 0x1E, 0x7F, 0xF7, 0xFF, 0x0F, 0xF0,
  0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x78,
  0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x3C, 0xF0, 0xF3, 0xE3, 0xC7,
  0xCF, 0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xC0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x79, 0xE1, 0xE7, 0x87, 0xBE, 0x3E, 0xFC, 0xDB,
  0xB3, 0x6E, 0xDD, 0xBB, 0xF6, 0xEF, 0x9B, 0x9E, 0x7E, 0x7B, 0xF9, 0xCF,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xC0, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8,
  0xFE, 0xE7, 0xF7, 0x3F, 0x9D, 0xFC, 0xEF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0E, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0x9C, 0x1E,
  0x78, 0xF9, 0xFF, 0xC3, 0xFF, 0x07, 0xF0, 0x3E, 0x07, 0xFE, 0x3F, 0xF9,
  0xFF, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBF,
  0xFD, 0xFF, 0xCF, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x78,
  0x7B, 0xC1, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E, 0x78, 0x79, 0xFF, 0xC3,
  0xFF, 0x07, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x78,
  0x3C, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xDE,
  0x1E, 0xF0, 0xF7, 0xBF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x79, 0xE3, 0xC7,
  0x9E, 0x3C, 0xF0, 0xF7, 0x87, 0xBC, 0x1F, 0xE0, 0xF0, 0x07, 0xC0, 0xFF,
  0xCF, 0xFC, 0xFD, 0xE7, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x60,
  0x7B, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC1, 0xEF, 0x0F, 0x7F, 0xF9, 0xFF, 0x87, 0xF8, 0xF8,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x8F, 0x0F,
  0x1E, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x79, 0xE0, 0xF3, 0x80, 0xE7, 0x01,
  0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x73, 0xF9,
  0xEF, 0xE7, 0xBF, 0x9E, 0xFE, 0xF9, 0xFB, 0xF6, 0xEC, 0xDB, 0xF3, 0x6F,
  0xCF, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x07, 0x80, 0x78, 0x1E, 0x78,
  0x78, 0xF0, 0xE0, 0xF3, 0xC1, 0xE7, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xEF, 0x03, 0xCF, 0x07,
  0x9E, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x3F, 0xE0, 0x78, 0xF8, 0x1E, 0xF0,
  0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0x83, 0xCF, 0x07, 0x9C, 0x07, 0x78,
  0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x81, 0xFF, 0x83, 0xCF, 0x0F, 0x9F, 0x1E, 0x1E, 0x78, 0x3F,
  0xF0, 0x3C, 0x40, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0xC3,
  0xE7, 0xF3, 0xC1, 0x80, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x41, 0xF0, 0x07,
  0x80, 0x3C, 0x7F, 0xEF, 0xFF, 0x7F, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xF7,
  0xFF, 0xBF, 0xFC, 0xFF, 0xE0, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF0, 0xFF, 0xE7, 0xFF, 0xBE, 0x7D, 0xE1,
  0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x7D,
  0xFF, 0xCF, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0x86,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x82, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x18, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xEF, 0x3F, 0xFB, 0xFF,
  0xDE, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0x1F, 0x3E, 0xF8, 0x7B, 0xC0, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x1F, 0x04, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0xF0, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0x0F, 0xF1, 0xFF, 0xDF, 0xFE, 0xF8, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDE, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFC, 0x01, 0xE0, 0x0F, 0x40, 0xF3, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0x30,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF8, 0xFF,
  0xCF, 0xFE, 0xF3, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x06, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x01,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF,
  0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x77, 0x1E, 0xFF, 0xDF, 0xF1, 0xFC,
  0x00, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x1F, 0xF1, 0xF7, 0x8F, 0x3C, 0xF1, 0xEF, 0x0F, 0xF0, 0x7F, 0x03,
  0xFC, 0x1F, 0xF0, 0xF7, 0x87, 0x9E, 0x3C, 0x79, 0xE3, 0xEF, 0x0F, 0x78,
  0x3C, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x81, 0xFE,
  0x07, 0xFC, 0x0F, 0xE0, 0x7C, 0xF3, 0xFF, 0xEF, 0xFF, 0xB9, 0xCF, 0xE7,
  0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x7F, 0x8F, 0xFC, 0xFF, 0xEF,
  0x3E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F,
  0x3E, 0xF8, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0x9E, 0x3E, 0x7F, 0xF0, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0x87, 0xFE,
  0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3D, 0xE1, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0xDF, 0xFE, 0xF8,
  0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E,
  0xF0, 0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00,
  0x1F, 0xE7, 0xFE, 0x7F, 0xEF, 0x06, 0xF0, 0x0F, 0x80, 0x7F, 0x07, 0xFC,
  0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC2, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0x7F, 0xF7, 0xFF, 0x3F, 0xF0, 0xF8, 0x1E, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x0F, 0x3C, 0x1E,
  0xF0, 0x1D, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x9C, 0x77, 0x3C, 0xEE, 0x79,
  0xDC, 0xF3, 0xBB, 0xE7, 0x77, 0xEC, 0xED, 0xF8, 0xD9, 0xF1, 0xF3, 0xE3,
  0xC7, 0xC7, 0x87, 0x0F, 0x0E, 0x00, 0xF0, 0x3D, 0xE1, 0xE7, 0x8F, 0x0F,
  0x3C, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x83,
  0xDE, 0x0F, 0x3C, 0x78, 0x7B, 0xC1, 0xEF, 0x03, 0xC0, 0xF0, 0x3F, 0xC0,
  0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E,
  0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x8F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0xFC, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x03,
  0xF0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x3C, 0x1D, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0xE1, 0xF8, 0x81, 0x00,
};

const GFXglyph UbuntuSansMono_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 5, -19 },
  { 13, 10, 9, 16, 3, -21 },
  { 25, 14, 19, 16, 1, -19 },
  { 59, 14, 25, 16, 1, -22 },
  { 103, 16, 20, 16, 0, -20 },
  { 143, 14, 20, 16, 1, -20 },
  { 178, 4, 9, 16, 6, -21 },
  { 183, 10, 27, 16, 3, -22 },
  { 217, 10, 27, 16, 3, -22 },
  { 251, 13, 12, 16, 1, -19 },
  { 271, 13, 14, 16, 1, -15 },
  { 294, 7, 10, 16, 4, -5 },
  { 303, 8, 4, 16, 4, -10 },
  { 307, 6, 5, 16, 5, -5 },
  { 311, 13, 27, 16, 1, -22 },
  { 355, 14, 20, 16, 1, -20 },
  { 390, 12, 19, 16, 2, -19 },
  { 419, 13, 20, 16, 1, -20 },
  { 452, 13, 20, 16, 1, -20 },
  { 485, 14, 19, 16, 1, -19 },
  { 519, 13, 19, 16, 1, -19 },
  { 550, 13, 20, 16, 1, -20 },
  { 583, 12, 19, 16, 2, -19 },
  { 612, 14, 20, 16, 1, -20 },
  { 647, 13, 20, 16, 1, -20 },
  { 680, 6, 14, 16, 5, -14 },
  { 691, 7, 19, 16, 4, -14 },
  { 708, 14, 14, 16, 1, -15 },
  { 733, 13, 9, 16, 1, -13 },
  { 748, 13, 14, 16, 1, -15 },
  { 771, 12, 20, 16, 2, -20 },
  { 801, 14, 24, 16, 1, -20 },
  { 843, 15, 19, 16, 0, -19 },
  { 879, 13, 20, 16, 2, -20 },
  { 912, 14, 20, 16, 1, -20 },
  { 947, 13, 20, 16, 2, -20 },
  { 980, 12, 19, 16, 2, -19 },
  { 1009, 12, 19, 16, 2, -19 },
  { 1038, 14, 20, 16, 1, -20 },
  { 1073, 13, 19, 16, 1, -19 },
  { 1104, 12, 19, 16, 2, -19 },
  { 1133, 13, 19, 16, 1, -19 },
  { 1164, 14, 19, 16, 1, -19 },
  { 1198, 12, 19, 16, 2, -19 },
  { 1227, 14, 19, 16, 1, -19 },
  { 1261, 13, 19, 16, 1, -19 },
  { 1292, 14, 20, 16, 1, -20 },
  { 1327, 13, 20, 16, 2, -20 },
  { 1360, 14, 25, 16, 1, -20 },
  { 1404, 13, 20, 16, 2, -20 },
  { 1437, 13, 20, 16, 1, -20 },
  { 1470, 14, 19, 16, 1, -19 },
  { 1504, 13, 19, 16, 1, -19 },
  { 1535, 15, 19, 16, 0, -19 },
  { 1571, 14, 19, 16, 1, -19 },
  { 1605, 15, 19, 16, 0, -19 },
  { 1641, 15, 19, 16, 0, -19 },
  { 1677, 13, 19, 16, 1, -19 },
  { 1708, 8, 27, 16, 4, -22 },
  { 1735, 12, 27, 16, 2, -22 },
  { 1776, 9, 27, 16, 3, -22 },
  { 1807, 15, 11, 16, 0, -19 },
  { 1828, 15, 3, 16, 0, 2 },
  { 1834, 7, 6, 16, 5, -22 },
  { 1840, 13, 15, 16, 1, -15 },
  { 1865, 13, 22, 16, 2, -22 },
  { 1901, 14, 15, 16, 1, -15 },
  { 1928, 13, 22, 16, 1, -22 },
  { 1964, 14, 15, 16, 1, -15 },
  { 1991, 14, 22, 16, 1, -22 },
  { 2030, 13, 20, 16, 1, -15 },
  { 2063, 12, 22, 16, 2, -22 },
  { 2096, 14, 22, 16, 1, -22 },
  { 2135, 11, 27, 16, 2, -22 },
  { 2173, 13, 22, 16, 2, -22 },
  { 2209, 14, 22, 16, 1, -22 },
  { 2248, 14, 15, 16, 1, -15 },
  { 2275, 12, 15, 16, 2, -15 },
  { 2298, 14, 15, 16, 1, -15 },
  { 2325, 13, 20, 16, 2, -15 },
  { 2358, 13, 20, 16, 1, -15 },
  { 2391, 11, 15, 16, 3, -15 },
  { 2412, 12, 15, 16, 2, -15 },
  { 2435, 14, 19, 16, 1, -19 },
  { 2469, 12, 15, 16, 2, -15 },
  { 2492, 15, 15, 16, 0, -15 },
  { 2521, 15, 15, 16, 0, -15 },
  { 2550, 14, 15, 16, 1, -15 },
  { 2577, 14, 20, 16, 1, -15 },
  { 2612, 12, 15, 16, 2, -15 },
  { 2635, 12, 27, 16, 2, -22 },
  { 2676, 4, 27, 16, 6, -22 },
  { 2690, 12, 27, 16, 2, -22 },
  { 2731, 14, 6, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_Bold28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_BOLD28PT7B_H_
