#ifndef _UBUNTUSANSMONO_BOLD40PT7B_H_
#define _UBUNTUSANSMONO_BOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x7E,
  0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0x78, 0x7C, 0xF0,
  0x79, 0xE0, 0xF3, 0xC1, 0xC0, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F,
  0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE1,
  0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xC0, 0x33, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x40, 0x07, 0xEF, 0x01, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0xFE, 0x01,
  0xF7, 0xFC, 0x07, 0x9E, 0xF0, 0x3C, 0x71, 0xC0, 0xF3, 0xC7, 0x07, 0x8F,
  0x1E, 0x3C, 0x3C, 0x70, 0xF0, 0x71, 0xC7, 0x81, 0xEF, 0x3C, 0x07, 0xFC,
  0xF0, 0x0F, 0xE7, 0x80, 0x3F, 0x3C, 0x00, 0x30, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0xFC, 0x00, 0xF7, 0xF8, 0x07, 0x9F, 0xE0, 0x3C, 0xF3, 0xC0,
  0xF3, 0xCF, 0x07, 0x8E, 0x3C, 0x3C, 0x38, 0xF0, 0xF0, 0xE3, 0xC7, 0x83,
  0xCF, 0x3C, 0x0F, 0x3C, 0xF0, 0x3F, 0xE7, 0x80, 0x7F, 0xBC, 0x00, 0xFC,
  0x00, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0xF8, 0x7F, 0x87, 0xC7, 0xFE, 0x3C, 0x7F, 0xF9, 0xE3,
  0xE7, 0xFF, 0x3E, 0x1F, 0xF9, 0xF0, 0x7F, 0x8F, 0x83, 0xFC, 0x7C, 0x0F,
  0xE3, 0xE0, 0x3F, 0x1F, 0x83, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFE, 0x7C, 0x1F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D,
  0xF7, 0x9E, 0x38, 0x00, 0x10, 0x00, 0x70, 0x01, 0xF0, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x08, 0x20, 0x01, 0xE0, 0x07, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xF0,
  0x03, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0x1E, 0x18, 0xF3, 0xCF, 0x1F, 0xBB, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x3F,
  0x7E, 0x0F, 0xCF, 0xE0, 0xF8, 0xF8, 0x0E, 0x1C, 0x00, 0x41, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x0F, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x1E, 0x0F, 0x87, 0xCF,
  0xE3, 0xF0, 0xF8, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF3, 0xF8, 0xFC, 0x1F,
  0x9F, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0xF1, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x1F,
  0xF8, 0x43, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D,
  0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xF8, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7E, 0xF8, 0x07, 0x1F, 0x00, 0x83, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xF7, 0xF8, 0xF0, 0x3F, 0x08, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x7F, 0x88, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00,
  0xFD, 0xC0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFD, 0xFC,
  0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xCF, 0x81, 0xF9, 0xF8, 0x3E, 0x3F, 0xCF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7E, 0x7F, 0x9F, 0x83, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0C,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x3F,
  0x9F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0x7E, 0x07, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x1F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x3F, 0xCF, 0xF3,
  0xFC, 0x7F, 0x1F, 0xC0, 0xF0, 0x78, 0x3E, 0xFF, 0x1F, 0x87, 0x81, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7C,
  0x7F, 0x60, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x01,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0x03, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x1F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x1F,
  0xF1, 0xF1, 0xFF, 0x3E, 0x1F, 0xF3, 0xE1, 0xFF, 0x3E, 0x1F, 0xF3, 0xE1,
  0xFF, 0x1E, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0x9F, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0x78, 0x7F, 0xF7, 0x83, 0xFF, 0x7C, 0x06, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0,
  0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x07,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xF7,
  0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x0F, 0xDF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xF7, 0xE3, 0xF8, 0x02, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x23,
  0xFE, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x1C, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF9, 0xF8, 0x7F, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xEF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xF7, 0xE3, 0xF8, 0x06, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03,
  0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x03, 0xF3, 0xFC,
  0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x18, 0x00, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE2, 0x01, 0xF9,
  0xE1, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x01,
  0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8,
  0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC,
  0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFE, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF8, 0xEE, 0x7F,
  0x9E, 0xE7, 0xB9, 0xEE, 0x7B, 0x9D, 0xF7, 0xBF, 0xDF, 0x79, 0xFD, 0xF7,
  0x9F, 0xDF, 0x79, 0xF9, 0xF7, 0x9F, 0x9F, 0xF8, 0xF9, 0xFF, 0x8F, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xBC, 0x7F, 0xEF, 0x9F, 0xF9, 0xE7, 0xFE, 0x7D, 0xFF, 0x8F, 0x7F, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xDF, 0xC3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x3E,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x3E,
  0x07, 0xE3, 0xF8, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x20, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83,
  0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7,
  0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xF0, 0xF1, 0xF8, 0x02, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xD0, 0x03, 0xF3, 0xC0,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xBF, 0x03, 0xF3, 0xF8, 0xFE, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x3E, 0x01, 0xF9,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x0F, 0x3E,
  0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xF7, 0x9F, 0x9F, 0x79, 0xF9, 0xF7,
  0x9F, 0xDF, 0x7B, 0xDD, 0xF7, 0xBD, 0xDF, 0x7B, 0x9F, 0xF7, 0xB9, 0xFE,
  0x7F, 0x8F, 0xE7, 0xF0, 0xEE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7E, 0x00, 0xF8, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x3E, 0x1F,
  0x80, 0xFC, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xEF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0xFC,
  0x01, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xC0, 0xFC, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F,
  0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F,
  0x9F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x3F,
  0x7F, 0x01, 0xFF, 0xF0, 0x07, 0xC7, 0x00, 0x38, 0x08, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x0E,
  0x07, 0xC3, 0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x04, 0x00, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x84, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x38, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x10, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xE3, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x87, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x81, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x18, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x21, 0xF0,
  0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFD, 0xF8,
  0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7E, 0x07, 0xDF, 0x81, 0xF7,
  0xF8, 0x7C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0x60, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xF0, 0xFE, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x3C, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7E, 0x02, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7E, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x81, 0xFB,
  0xF8, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x0C, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x38, 0x1F, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0x00, 0x00,
  0x38, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x40, 0x3F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xF1, 0xFD, 0xF0, 0x7E, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7E, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE3, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x20, 0x3F, 0x7C, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0,
  0x03, 0x80, 0x38, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x7F, 0x7C, 0x1F, 0xCF, 0x83, 0xF1, 0xF0, 0xFC, 0x3E,
  0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xC7, 0xE0, 0xF8,
  0xFE, 0x1F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7C, 0x1F, 0xCF, 0x81, 0xF9, 0xF0,
  0x1F, 0xBE, 0x03, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE7, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xDF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF0, 0xFF,
  0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F,
  0xF8, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xC3, 0xFB,
  0xE0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFC, 0x00, 0x60,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF8,
  0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3E, 0x1F, 0xEF, 0x81, 0xFB,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xBF, 0x8F,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0x0F, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF,
  0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xF1, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0x0B,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x03, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0x81, 0xC7, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x40, 0x0F, 0xDF, 0x07,
  0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x78, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xE0,
  0x3E, 0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x78, 0x79, 0xE1, 0xF1,
  0xE7, 0xC7, 0xC7, 0x9F, 0x1F, 0x1E, 0x7C, 0xFC, 0x78, 0xF3, 0xF9, 0xE3,
  0xCF, 0xE7, 0x8F, 0x7F, 0x9E, 0x3D, 0xFE, 0xF0, 0xF7, 0x3F, 0xC3, 0xDC,
  0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x0F, 0xC1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xEF, 0xC0,
  0x1F, 0x80, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0x7C, 0x1F, 0x87,
  0xC0, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xDF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x04,
  0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0x00, 0x40, 0xFE, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x7E, 0xFF, 0xF3, 0xE0, 0xFF, 0x8E, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 29, 22, 7, -28 },
  { 30, 15, 12, 22, 4, -30 },
  { 53, 21, 28, 22, 1, -28 },
  { 127, 19, 35, 22, 2, -31 },
  { 211, 22, 29, 22, 0, -28 },
  { 291, 21, 28, 22, 1, -28 },
  { 365, 6, 13, 22, 8, -30 },
  { 375, 15, 40, 22, 4, -32 },
  { 450, 14, 40, 22, 4, -32 },
  { 520, 19, 18, 22, 2, -28 },
  { 563, 19, 20, 22, 2, -22 },
  { 611, 10, 14, 22, 6, -7 },
  { 629, 12, 5, 22, 5, -14 },
  { 637, 8, 7, 22, 7, -7 },
  { 644, 18, 38, 22, 2, -31 },
  { 730, 19, 29, 22, 2, -28 },
  { 799, 19, 28, 22, 2, -28 },
  { 866, 19, 28, 22, 2, -28 },
  { 933, 18, 29, 22, 2, -28 },
  { 999, 20, 28, 22, 1, -28 },
  { 1069, 18, 29, 22, 2, -28 },
  { 1135, 18, 29, 22, 2, -28 },
  { 1201, 18, 28, 22, 2, -28 },
  { 1264, 19, 29, 22, 2, -28 },
  { 1333, 18, 28, 22, 2, -28 },
  { 1396, 8, 21, 22, 7, -21 },
  { 1417, 10, 28, 22, 5, -21 },
  { 1452, 19, 19, 22, 2, -21 },
  { 1498, 19, 13, 22, 2, -18 },
  { 1529, 19, 19, 22, 2, -21 },
  { 1575, 16, 29, 22, 3, -28 },
  { 1633, 20, 34, 22, 1, -28 },
  { 1718, 22, 28, 22, 0, -28 },
  { 1795, 19, 28, 22, 2, -28 },
  { 1862, 20, 29, 22, 1, -28 },
  { 1935, 19, 28, 22, 2, -28 },
  { 2002, 18, 28, 22, 3, -28 },
  { 2065, 17, 28, 22, 3, -28 },
  { 2125, 20, 29, 22, 1, -28 },
  { 2198, 18, 28, 22, 2, -28 },
  { 2261, 18, 28, 22, 2, -28 },
  { 2324, 18, 29, 22, 2, -28 },
  { 2390, 20, 28, 22, 2, -28 },
  { 2460, 18, 28, 22, 3, -28 },
  { 2523, 20, 28, 22, 1, -28 },
  { 2593, 18, 28, 22, 2, -28 },
  { 2656, 20, 29, 22, 1, -28 },
  { 2729, 19, 28, 22, 2, -28 },
  { 2796, 20, 36, 22, 1, -28 },
  { 2886, 20, 28, 22, 2, -28 },
  { 2956, 19, 29, 22, 2, -28 },
  { 3025, 20, 28, 22, 1, -28 },
  { 3095, 19, 29, 22, 2, -28 },
  { 3164, 21, 28, 22, 1, -28 },
  { 3238, 20, 28, 22, 1, -28 },
  { 3308, 22, 28, 22, 0, -28 },
  { 3385, 21, 28, 22, 1, -28 },
  { 3459, 18, 28, 22, 2, -28 },
  { 3522, 12, 38, 22, 5, -31 },
  { 3579, 18, 38, 22, 2, -31 },
  { 3665, 12, 38, 22, 5, -31 },
  { 3722, 21, 17, 22, 1, -28 },
  { 3767, 22, 4, 22, 0, 3 },
  { 3778, 10, 8, 22, 7, -31 },
  { 3788, 18, 22, 22, 2, -22 },
  { 3838, 18, 31, 22, 3, -31 },
  { 3908, 19, 22, 22, 2, -22 },
  { 3961, 18, 31, 22, 1, -31 },
  { 4031, 20, 22, 22, 1, -22 },
  { 4086, 20, 31, 22, 2, -31 },
  { 4164, 19, 30, 22, 1, -22 },
  { 4236, 17, 31, 22, 3, -31 },
  { 4302, 19, 31, 22, 2, -31 },
  { 4376, 16, 39, 22, 2, -31 },
  { 4454, 19, 31, 22, 3, -31 },
  { 4528, 19, 31, 22, 2, -31 },
  { 4602, 20, 21, 22, 1, -21 },
  { 4655, 17, 22, 22, 3, -22 },
  { 4702, 20, 23, 22, 1, -22 },
  { 4760, 18, 29, 22, 3, -22 },
  { 4826, 19, 29, 22, 1, -22 },
  { 4895, 17, 21, 22, 4, -21 },
  { 4940, 18, 22, 22, 2, -22 },
  { 4990, 19, 27, 22, 2, -27 },
  { 5055, 17, 21, 22, 3, -21 },
  { 5100, 21, 21, 22, 1, -21 },
  { 5156, 22, 21, 22, 0, -21 },
  { 5214, 21, 21, 22, 1, -21 },
  { 5270, 20, 29, 22, 1, -21 },
  { 5343, 17, 21, 22, 3, -21 },
  { 5388, 17, 38, 22, 3, -31 },
  { 5469, 6, 38, 22, 8, -31 },
  { 5498, 17, 38, 22, 3, -31 },
  { 5579, 21, 8, 22, 1, -16 },
};

const GFXfont UbuntuSansMono_Bold40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_BOLD40PT7B_H_
