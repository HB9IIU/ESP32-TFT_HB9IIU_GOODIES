#ifndef _UBUNTUSANSMONO_BOLD44PT7B_H_
#define _UBUNTUSANSMONO_BOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x08,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x38, 0x1E, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xC0, 0x18, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0xE0, 0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x9F,
  0xE0, 0x0F, 0x9F, 0xF8, 0x07, 0x8F, 0xFC, 0x07, 0xC7, 0x9E, 0x03, 0xC3,
  0xCF, 0x03, 0xC3, 0xC3, 0xC3, 0xE1, 0xE1, 0xE1, 0xE0, 0x70, 0xF1, 0xE0,
  0x3C, 0xF1, 0xF0, 0x1E, 0x78, 0xF0, 0x0F, 0xFC, 0xF0, 0x03, 0xFE, 0xF8,
  0x01, 0xFE, 0x78, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x60, 0x00, 0x3C, 0xFE, 0x00, 0x3E, 0xFF, 0x80, 0x1E, 0x7F, 0xC0, 0x1E,
  0x7D, 0xF0, 0x1F, 0x3C, 0x78, 0x0F, 0x1E, 0x3C, 0x0F, 0x0F, 0x1E, 0x0F,
  0x87, 0x8F, 0x07, 0x83, 0xC7, 0x87, 0x81, 0xE3, 0xC7, 0xC0, 0xFB, 0xE3,
  0xC0, 0x3F, 0xE3, 0xC0, 0x1F, 0xF3, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x60,
  0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x18, 0x07, 0xF8, 0x3E, 0x1F, 0xF8,
  0xFC, 0x7F, 0xF9, 0xF1, 0xFB, 0xF3, 0xE3, 0xE3, 0xF7, 0xCF, 0xC3, 0xFF,
  0x9F, 0x03, 0xFE, 0x3E, 0x07, 0xFC, 0x7C, 0x07, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xE1, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0x9F, 0x81, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC7, 0x00, 0x00, 0x08, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x18, 0x10, 0x00, 0x38,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x41, 0xF0, 0x03, 0x8F, 0x8E,
  0x3F, 0x79, 0xF1, 0xFD, 0xDF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0xC0,
  0x7E, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x38, 0x38, 0x00, 0x81,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0x83, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x7F, 0x03, 0xC0,
  0x78, 0x3F, 0x3F, 0xCF, 0xF0, 0xFC, 0x1E, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x87,
  0x1F, 0xFC, 0x7C, 0xFF, 0xE3, 0xE7, 0xFF, 0x1F, 0x3F, 0xF8, 0xF9, 0xFF,
  0xC7, 0x8F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFB, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x3F, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0x7E, 0x01, 0xE3, 0xF0, 0x08, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0x0F, 0xF0, 0xE0, 0x3F, 0x82, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC1, 0xFE, 0x30,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF6, 0x00,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8,
  0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x40, 0x0F, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF2, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xF0, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x80,
  0xFC, 0xFE, 0x0F, 0xC3, 0xFC, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFB, 0xFF, 0x1F, 0x87, 0xF8, 0xF8, 0x0F,
  0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xBF, 0xF7, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x87, 0xF1,
  0xF8, 0x1F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xFE, 0x1F, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xEF,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x7F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x10, 0x0F, 0x83, 0xF8,
  0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF0, 0xFC, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xC7, 0xF8, 0xFF, 0x9F,
  0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x1E, 0x07, 0xC1, 0xF3, 0xFC, 0x7F, 0x8F,
  0xC1, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x1F,
  0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCE, 0x07, 0xF2, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF8, 0x7C,
  0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x3F,
  0xF7, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xC7, 0xFC, 0x7E, 0x1F, 0xF1, 0xF8, 0x7F, 0xC7, 0xC1, 0xFF, 0x1F,
  0x07, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0, 0x7F, 0xC7, 0xE1, 0xFF, 0x9F, 0x87,
  0xFE, 0x3F, 0x1F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0x87, 0xFF, 0xDF,
  0x0F, 0xFF, 0x7C, 0x0F, 0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xE0,
  0x03, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0,
  0x07, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xE7, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xC1, 0xE3, 0xFC,
  0x00, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x61, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xCF,
  0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F,
  0xEF, 0xC3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xC1, 0xE3,
  0xFC, 0x00, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFF, 0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0B, 0x80, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE2,
  0x00, 0x7E, 0x38, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xFC, 0x03, 0xFB, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F,
  0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF3, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0,
  0x3F, 0x1F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F,
  0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00,
  0xFE, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F,
  0x1E, 0xE1, 0xFE, 0x3D, 0xC3, 0xFC, 0x7B, 0xC7, 0xF8, 0xF7, 0x9E, 0xF9,
  0xF7, 0x3D, 0xF3, 0xEF, 0x7B, 0xE7, 0xDF, 0xE7, 0xCF, 0xBF, 0xCF, 0x9F,
  0x3F, 0x9F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFC, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1,
  0xF1, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00,
  0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xC0, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xDF, 0x1F, 0xFD, 0xF1, 0xFF, 0xCF, 0x9F, 0xFC, 0xF9, 0xFF,
  0xC7, 0xDF, 0xFC, 0x7D, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E,
  0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE7, 0xFE, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFF, 0x1F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x3F,
  0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7E, 0x7F, 0xE3, 0xF0, 0x7F, 0x9F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xF3,
  0xF1, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x1F,
  0x83, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0x80,
  0xE1, 0xF8, 0x01, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x40, 0x03, 0xFB, 0x80, 0x3F, 0x9F, 0xEF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0x7E, 0x7E,
  0x07, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8,
  0x00, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3, 0xE7, 0xCF, 0xC7, 0xCF, 0x9F,
  0x8F, 0x9F, 0x3F, 0x9F, 0x3C, 0x7F, 0x3E, 0x79, 0xFE, 0x7C, 0xF3, 0xDE,
  0xF9, 0xE7, 0xBD, 0xF3, 0xDE, 0x7B, 0xE7, 0xBC, 0x77, 0xCF, 0x78, 0xFF,
  0x1E, 0xE1, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x00,
  0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFE,
  0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF8,
  0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x3F,
  0xBE, 0x00, 0x3E, 0x1C, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x07, 0x80,
  0xF8, 0x3F, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x0E, 0x00, 0x80, 0x01, 0xF8,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xE1,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x07,
  0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xA0,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x70, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x04, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0xF3, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x83, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x08, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xE0, 0x60, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x70, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x01, 0xFF, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF3, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFC,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x81, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x80, 0x7E, 0x3C, 0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0xEF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC,
  0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x7E,
  0x0F, 0xE3, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x1F,
  0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x81, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x7F, 0xEF, 0xF3,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF1, 0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1,
  0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x7C,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0xC0, 0x7F, 0x7E, 0x01, 0xFD, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xFC, 0x07, 0xE3,
  0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFC, 0x20, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xBF, 0x00, 0xC3, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xC0, 0x77, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x1F, 0x3F, 0x00,
  0x27, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x18, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x02, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0x7C, 0x3E, 0x1E, 0xF8, 0xFE, 0x7C,
  0xF1, 0xFC, 0xF9, 0xE3, 0xF9, 0xF3, 0xC7, 0xF3, 0xE7, 0x9F, 0xF7, 0xCF,
  0xBD, 0xEF, 0x1F, 0x7B, 0xDE, 0x3F, 0xE7, 0xBC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x00, 0xFE, 0x00, 0xFC, 0xFE, 0x03, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xFB,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0x07, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xC0, 0x78, 0x7F, 0xC0, 0xF9, 0xFF, 0xF3, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xBF, 0x3F, 0xFE, 0x7C, 0x0F, 0xF8, 0x78, 0x0F, 0xE0,
  0x00, 0x02, 0x00,
};

const GFXglyph UbuntuSansMono_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 8, 31, 25, 8, -30 },
  { 32, 16, 13, 25, 4, -33 },
  { 58, 23, 30, 25, 1, -30 },
  { 145, 21, 39, 25, 2, -34 },
  { 248, 25, 32, 25, 0, -31 },
  { 348, 23, 31, 25, 1, -31 },
  { 438, 7, 14, 25, 9, -33 },
  { 451, 16, 43, 25, 5, -35 },
  { 537, 16, 43, 25, 4, -35 },
  { 623, 21, 19, 25, 2, -30 },
  { 673, 21, 22, 25, 2, -24 },
  { 731, 11, 16, 25, 6, -8 },
  { 753, 13, 6, 25, 6, -16 },
  { 763, 9, 9, 25, 8, -8 },
  { 774, 20, 42, 25, 2, -34 },
  { 879, 21, 32, 25, 2, -31 },
  { 963, 21, 30, 25, 2, -30 },
  { 1042, 21, 31, 25, 2, -31 },
  { 1124, 20, 32, 25, 2, -31 },
  { 1204, 22, 30, 25, 1, -30 },
  { 1287, 20, 31, 25, 2, -30 },
  { 1365, 20, 32, 25, 2, -31 },
  { 1445, 20, 30, 25, 2, -30 },
  { 1520, 21, 32, 25, 2, -31 },
  { 1604, 21, 31, 25, 2, -31 },
  { 1686, 9, 24, 25, 8, -23 },
  { 1713, 11, 31, 25, 6, -23 },
  { 1756, 21, 21, 25, 2, -23 },
  { 1812, 21, 14, 25, 2, -20 },
  { 1849, 21, 21, 25, 2, -23 },
  { 1905, 18, 32, 25, 3, -31 },
  { 1977, 22, 38, 25, 1, -31 },
  { 2082, 24, 30, 25, 0, -30 },
  { 2172, 20, 31, 25, 3, -31 },
  { 2250, 22, 32, 25, 1, -31 },
  { 2338, 20, 31, 25, 3, -31 },
  { 2416, 20, 30, 25, 3, -30 },
  { 2491, 19, 30, 25, 3, -30 },
  { 2563, 22, 32, 25, 1, -31 },
  { 2651, 20, 30, 25, 2, -30 },
  { 2726, 19, 30, 25, 3, -30 },
  { 2798, 20, 31, 25, 2, -30 },
  { 2876, 22, 30, 25, 2, -30 },
  { 2959, 19, 30, 25, 4, -30 },
  { 3031, 23, 30, 25, 1, -30 },
  { 3118, 20, 30, 25, 2, -30 },
  { 3193, 22, 32, 25, 1, -31 },
  { 3281, 20, 31, 25, 3, -31 },
  { 3359, 22, 39, 25, 1, -31 },
  { 3467, 21, 31, 25, 3, -31 },
  { 3549, 21, 32, 25, 2, -31 },
  { 3633, 22, 30, 25, 1, -30 },
  { 3716, 21, 31, 25, 2, -30 },
  { 3798, 23, 30, 25, 1, -30 },
  { 3885, 23, 30, 25, 1, -30 },
  { 3972, 23, 30, 25, 1, -30 },
  { 4059, 23, 30, 25, 1, -30 },
  { 4146, 20, 30, 25, 2, -30 },
  { 4221, 13, 42, 25, 6, -34 },
  { 4290, 20, 42, 25, 2, -34 },
  { 4395, 14, 42, 25, 5, -34 },
  { 4469, 23, 17, 25, 1, -30 },
  { 4518, 24, 5, 25, 0, 3 },
  { 4533, 11, 9, 25, 7, -34 },
  { 4546, 20, 25, 25, 2, -24 },
  { 4609, 20, 35, 25, 3, -34 },
  { 4697, 21, 25, 25, 2, -24 },
  { 4763, 20, 35, 25, 1, -34 },
  { 4851, 21, 25, 25, 2, -24 },
  { 4917, 22, 34, 25, 2, -34 },
  { 5011, 20, 32, 25, 2, -24 },
  { 5091, 19, 34, 25, 3, -34 },
  { 5172, 21, 35, 25, 2, -34 },
  { 5264, 18, 42, 25, 2, -34 },
  { 5359, 21, 34, 25, 3, -34 },
  { 5449, 21, 35, 25, 2, -34 },
  { 5541, 22, 23, 25, 1, -23 },
  { 5605, 19, 24, 25, 3, -24 },
  { 5662, 22, 25, 25, 1, -24 },
  { 5731, 20, 32, 25, 3, -24 },
  { 5811, 20, 32, 25, 2, -24 },
  { 5891, 19, 24, 25, 4, -24 },
  { 5948, 19, 25, 25, 3, -24 },
  { 6008, 21, 31, 25, 2, -30 },
  { 6090, 19, 24, 25, 3, -23 },
  { 6147, 23, 23, 25, 1, -23 },
  { 6214, 23, 23, 25, 1, -23 },
  { 6281, 23, 23, 25, 1, -23 },
  { 6348, 22, 31, 25, 1, -23 },
  { 6434, 18, 23, 25, 3, -23 },
  { 6486, 19, 42, 25, 3, -34 },
  { 6586, 6, 42, 25, 9, -34 },
  { 6618, 19, 42, 25, 3, -34 },
  { 6718, 23, 10, 25, 1, -18 },
};

const GFXfont UbuntuSansMono_Bold44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_BOLD44PT7B_H_
