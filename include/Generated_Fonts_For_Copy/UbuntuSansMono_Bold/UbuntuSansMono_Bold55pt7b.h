#ifndef _UBUNTUSANSMONO_BOLD55PT7B_H_
#define _UBUNTUSANSMONO_BOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xE3, 0xFE, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x03, 0x80, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFB, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFA, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x7F, 0x80, 0x0E, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x3F, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFC, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xC0, 0x0F, 0xC7,
  0xFF, 0xC0, 0x1F, 0x0F, 0x8F, 0x80, 0x7E, 0x1F, 0x1F, 0x01, 0xF8, 0x3E,
  0x3E, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0xF8, 0xF8, 0x1F, 0x01, 0xF1,
  0xF0, 0x7C, 0x03, 0xE3, 0xE1, 0xF8, 0x07, 0xC7, 0xC3, 0xE0, 0x0F, 0x8F,
  0x8F, 0x80, 0x1F, 0xFF, 0x3F, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x3F, 0xF9,
  0xF0, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7,
  0xFC, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0xFC, 0xFF,
  0xF8, 0x03, 0xF1, 0xF1, 0xF0, 0x07, 0xC7, 0xC3, 0xE0, 0x1F, 0x8F, 0x87,
  0xC0, 0x7E, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x1F, 0x03, 0xF0, 0x7C, 0x3E,
  0x0F, 0xC0, 0xF8, 0x7C, 0x1F, 0x00, 0xF8, 0xF8, 0x7E, 0x01, 0xF3, 0xF1,
  0xF8, 0x03, 0xFF, 0xC3, 0xE0, 0x03, 0xFF, 0x8F, 0xC0, 0x07, 0xFE, 0x3F,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xC1, 0xE0, 0x0F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x0F,
  0xFF, 0xC3, 0xF0, 0xFF, 0xFF, 0x1F, 0x87, 0xF7, 0xF9, 0xFC, 0x7F, 0x1F,
  0xEF, 0xE3, 0xF8, 0x7F, 0xFE, 0x1F, 0x81, 0xFF, 0xF1, 0xFC, 0x07, 0xFF,
  0x8F, 0xE0, 0x1F, 0xF8, 0x7F, 0x00, 0xFF, 0xC3, 0xF8, 0x03, 0xFC, 0x0F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0xC3, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xE3,
  0xF8, 0x0F, 0xFC, 0x1F, 0xE0, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x38, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x01, 0x81, 0xF8, 0x30, 0xF0, 0xF8, 0x7C, 0xFE, 0x7C,
  0xFE, 0x7F, 0xBE, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xFC, 0x07, 0xF8, 0xFF, 0x07,
  0xFC, 0x7F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3E, 0x0F, 0x80, 0x0E, 0x03, 0x80,
  0x01, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x7F, 0x87, 0xFE, 0x3F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE3, 0xFF, 0x1F,
  0xF8, 0x7F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x07, 0xF3, 0xFF, 0x1F, 0xF8,
  0xFF, 0x07, 0xF0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x0F,
  0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0,
  0x10, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00,
  0xFF, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x07, 0xF7, 0xF0, 0x70, 0x7E, 0xFE, 0x1F, 0x0F, 0xFF, 0xC7, 0xF1,
  0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE3, 0xF8, 0xFF, 0xFC,
  0x3E, 0x1F, 0xFF, 0x87, 0x83, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xE7, 0xF8, 0x03, 0xC3, 0xFC, 0x01, 0x81, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFC, 0x07, 0xFC, 0x38, 0x01, 0xFF, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x78, 0x07, 0xFC, 0x10, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x80, 0x01, 0xFE, 0x70, 0x03, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF9, 0xC0,
  0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFE,
  0x03, 0xFC, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF9,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFF, 0x87, 0xF8, 0x1F, 0xFD, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xC1, 0xFC, 0x0F, 0xFC, 0x7F,
  0x80, 0xFF, 0x8F, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF3, 0xF8,
  0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1,
  0xFF, 0x9F, 0xF8, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xBF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xDF, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xFD,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xF8, 0x08,
  0x00, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFF, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF3, 0xFF,
  0x8F, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC2, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xE7, 0xFF, 0x1C,
  0x01, 0xFE, 0x20, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x03, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x7E,
  0x0F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xC3, 0xF8, 0x7F, 0xFC, 0x7F, 0x07, 0xFF,
  0xC7, 0xF0, 0x7F, 0xFC, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0x7F, 0xFC, 0x7F,
  0x07, 0xFF, 0xC7, 0xF0, 0x7F, 0xFC, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0x7F,
  0xFC, 0x3F, 0x07, 0xFF, 0xC3, 0xF8, 0x7F, 0x7C, 0x3F, 0xC7, 0xF7, 0xC1,
  0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0x7E, 0x07, 0xFF,
  0xF3, 0xF0, 0x3F, 0xFF, 0x3F, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x8F,
  0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0,
  0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFC, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07,
  0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xF0, 0x3F, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x01, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0x1C, 0x3F, 0xE0, 0x00, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x04, 0x3F,
  0xF8, 0x03, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFC, 0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xFC, 0xFF, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x1C, 0x3F,
  0xE0, 0x00, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x3F, 0x9F, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0xFE, 0x3F, 0xF0, 0x1F, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x20, 0x01, 0xFE, 0x30, 0x01, 0xFE, 0x7C, 0x07, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xDF, 0xC0, 0x1F,
  0xF3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x8F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x07, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8,
  0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x1F, 0xF0, 0x0F, 0xE3,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFD, 0xFF, 0x80, 0x3F, 0x9F, 0xF8, 0x07,
  0xF1, 0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0x1F, 0xC1, 0xFF, 0x03, 0xF8, 0x3F,
  0xE0, 0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0xE1, 0xFC, 0x07, 0xFC, 0x3F,
  0x80, 0x7F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x0F,
  0xF3, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x0F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07,
  0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xBE, 0x3E, 0xF0, 0xFB, 0xE3,
  0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x9F, 0x3E, 0x7E, 0x7D,
  0xF3, 0xE7, 0xE7, 0xDF, 0x3E, 0x7E, 0x7F, 0xE3, 0xE7, 0xE3, 0xFE, 0x3F,
  0x7E, 0x3F, 0xE3, 0xF7, 0xE3, 0xFE, 0x3F, 0x7E, 0x3F, 0xC3, 0xF7, 0xE1,
  0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xF7, 0xE1, 0xF8, 0x3F, 0x7E, 0x0F, 0x83,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF0, 0xFF, 0xFD, 0xF8, 0x7F,
  0xFE, 0x7E, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF, 0x8F, 0xCF, 0xFF, 0xC7, 0xE7,
  0xFF, 0xE1, 0xFB, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0xFC,
  0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFC,
  0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFB, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xEF,
  0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x87, 0xE0, 0xFF, 0x00, 0x38, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0xC0, 0x00,
  0xFF, 0x3E, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xE0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0xF8, 0x3F, 0x7E, 0x1F, 0xC3, 0xF7, 0xE1, 0xFC, 0x3F, 0x7E, 0x1F, 0xC3,
  0xF7, 0xE3, 0xFC, 0x3F, 0x7E, 0x3F, 0xE3, 0xF7, 0xE3, 0xFE, 0x3F, 0x7E,
  0x3F, 0xE3, 0xF7, 0xE7, 0xDE, 0x3E, 0x7E, 0x7D, 0xF3, 0xE7, 0xE7, 0xDF,
  0x3E, 0x3E, 0xF8, 0xF3, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3,
  0xEF, 0x07, 0xBE, 0x3F, 0xF0, 0x7B, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xE0,
  0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8,
  0x00, 0xFC, 0xFF, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F,
  0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE,
  0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xE1, 0xF0, 0x00,
  0x7C, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x10, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x60, 0x03, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xF8, 0x3F, 0xF7, 0xF0, 0x0F, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0,
  0x3F, 0xEF, 0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xE0, 0x0C, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x06, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x83, 0xFC, 0x0F, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFC,
  0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F,
  0xF7, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x38, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xCF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x20, 0x00,
  0xFF, 0x1E, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xDF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x20, 0x03, 0xF8,
  0xE0, 0x1F, 0xE3, 0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xFB, 0xFC,
  0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFC,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xC0,
  0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xBF,
  0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x60, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0xE1, 0xF8, 0x7F, 0xFC,
  0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83,
  0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F, 0xFF, 0x0F, 0xC1, 0xFF, 0xE1,
  0xF8, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x74,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x03, 0xFE, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xFB, 0xFC,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFC, 0x07, 0xFC, 0xFE,
  0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x07, 0xFD, 0xFE, 0x07,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xF7, 0xFF, 0x03, 0xF8, 0x3C, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xC0, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFD,
  0xFE, 0x01, 0xFE, 0xFF, 0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x00, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x80, 0x02, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x80, 0x1C, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x60, 0x00, 0x7F, 0x7C, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x70, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0x17, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x1F,
  0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00,
  0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x3E, 0x0F, 0xFF, 0x83, 0xF8, 0x7E, 0xFE, 0x1F, 0xC3, 0xF3,
  0xF0, 0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0xFC, 0xFC, 0x7F, 0xC7, 0xE7, 0xE3,
  0xFE, 0x3F, 0x3F, 0x1F, 0xF1, 0xF9, 0xF8, 0xFF, 0x8F, 0x8F, 0xCF, 0xFE,
  0x7C, 0x3E, 0x7D, 0xF3, 0xE1, 0xF3, 0xEF, 0x9F, 0x0F, 0x9E, 0x7D, 0xF8,
  0x7D, 0xF3, 0xFF, 0xC3, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xC3, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0x9F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x60, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0x80, 0x3F, 0xE0, 0x0F, 0x83, 0xFF, 0x80, 0x7E, 0x3F, 0xFF, 0x07, 0xF3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3,
  0xFF, 0xFC, 0x7E, 0x07, 0xFF, 0xC7, 0xE0, 0x0F, 0xFC, 0x07, 0x00, 0x3F,
  0xC0,
};

const GFXglyph UbuntuSansMono_Bold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 39, 31, 10, -38 },
  { 55, 21, 17, 31, 5, -42 },
  { 100, 29, 38, 31, 1, -38 },
  { 238, 27, 49, 31, 2, -43 },
  { 404, 31, 40, 31, 0, -39 },
  { 559, 29, 40, 31, 1, -39 },
  { 704, 9, 19, 31, 11, -42 },
  { 726, 20, 54, 31, 6, -44 },
  { 861, 20, 54, 31, 5, -44 },
  { 996, 25, 24, 31, 3, -38 },
  { 1071, 26, 28, 31, 2, -30 },
  { 1162, 13, 19, 31, 8, -10 },
  { 1193, 17, 8, 31, 7, -20 },
  { 1210, 11, 11, 31, 10, -10 },
  { 1226, 25, 53, 31, 3, -43 },
  { 1392, 27, 40, 31, 2, -39 },
  { 1527, 25, 38, 31, 3, -38 },
  { 1646, 25, 39, 31, 3, -39 },
  { 1768, 25, 40, 31, 3, -39 },
  { 1893, 27, 38, 31, 2, -38 },
  { 2022, 26, 39, 31, 2, -38 },
  { 2149, 25, 39, 31, 3, -38 },
  { 2271, 25, 38, 31, 3, -38 },
  { 2390, 27, 40, 31, 2, -39 },
  { 2525, 25, 39, 31, 3, -39 },
  { 2647, 11, 30, 31, 10, -29 },
  { 2689, 14, 38, 31, 7, -29 },
  { 2756, 26, 27, 31, 3, -29 },
  { 2844, 26, 18, 31, 2, -25 },
  { 2903, 26, 27, 31, 2, -29 },
  { 2991, 23, 40, 31, 4, -39 },
  { 3106, 28, 47, 31, 1, -39 },
  { 3271, 29, 38, 31, 1, -38 },
  { 3409, 26, 40, 31, 3, -39 },
  { 3539, 27, 40, 31, 2, -39 },
  { 3674, 26, 40, 31, 3, -39 },
  { 3804, 24, 38, 31, 4, -38 },
  { 3918, 23, 38, 31, 4, -38 },
  { 4028, 27, 40, 31, 2, -39 },
  { 4163, 25, 38, 31, 3, -38 },
  { 4282, 25, 38, 31, 3, -38 },
  { 4401, 24, 39, 31, 3, -38 },
  { 4518, 27, 38, 31, 3, -38 },
  { 4647, 24, 38, 31, 4, -38 },
  { 4761, 28, 38, 31, 1, -38 },
  { 4894, 25, 38, 31, 3, -38 },
  { 5013, 27, 40, 31, 2, -39 },
  { 5148, 26, 39, 31, 3, -39 },
  { 5275, 27, 49, 31, 2, -39 },
  { 5441, 27, 39, 31, 3, -39 },
  { 5573, 26, 40, 31, 2, -39 },
  { 5703, 27, 38, 31, 2, -38 },
  { 5832, 26, 39, 31, 2, -38 },
  { 5959, 29, 38, 31, 1, -38 },
  { 6097, 28, 38, 31, 1, -38 },
  { 6230, 29, 38, 31, 1, -38 },
  { 6368, 29, 38, 31, 1, -38 },
  { 6506, 25, 38, 31, 3, -38 },
  { 6625, 17, 53, 31, 7, -43 },
  { 6738, 25, 53, 31, 3, -43 },
  { 6904, 17, 53, 31, 7, -43 },
  { 7017, 29, 22, 31, 1, -38 },
  { 7097, 30, 6, 31, 0, 4 },
  { 7120, 14, 11, 31, 9, -43 },
  { 7140, 24, 31, 31, 3, -30 },
  { 7233, 25, 44, 31, 4, -43 },
  { 7371, 26, 31, 31, 3, -30 },
  { 7472, 25, 44, 31, 2, -43 },
  { 7610, 27, 31, 31, 2, -30 },
  { 7715, 28, 43, 31, 2, -43 },
  { 7866, 25, 40, 31, 2, -30 },
  { 7991, 23, 43, 31, 4, -43 },
  { 8115, 27, 44, 31, 2, -43 },
  { 8264, 22, 53, 31, 3, -43 },
  { 8410, 26, 43, 31, 4, -43 },
  { 8550, 27, 43, 31, 2, -42 },
  { 8696, 27, 29, 31, 2, -29 },
  { 8794, 23, 30, 31, 4, -30 },
  { 8881, 27, 31, 31, 2, -30 },
  { 8986, 25, 40, 31, 4, -30 },
  { 9111, 25, 40, 31, 2, -30 },
  { 9236, 23, 29, 31, 5, -29 },
  { 9320, 24, 31, 31, 3, -30 },
  { 9413, 27, 38, 31, 2, -37 },
  { 9542, 23, 30, 31, 4, -29 },
  { 9629, 29, 29, 31, 1, -29 },
  { 9735, 29, 29, 31, 1, -29 },
  { 9841, 29, 29, 31, 1, -29 },
  { 9947, 28, 39, 31, 1, -29 },
  { 10084, 23, 29, 31, 4, -29 },
  { 10168, 23, 53, 31, 4, -43 },
  { 10321, 7, 53, 31, 12, -43 },
  { 10368, 23, 53, 31, 4, -43 },
  { 10521, 29, 11, 31, 1, -22 },
};

const GFXfont UbuntuSansMono_Bold55pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold55pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold55pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _UBUNTUSANSMONO_BOLD55PT7B_H_
