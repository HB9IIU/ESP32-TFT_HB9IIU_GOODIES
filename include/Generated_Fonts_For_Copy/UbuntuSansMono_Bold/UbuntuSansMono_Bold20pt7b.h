#ifndef _UBUNTUSANSMONO_BOLD20PT7B_H_
#define _UBUNTUSANSMONO_BOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x3E, 0x68,
  0xC0, 0x0C, 0xC3, 0x98, 0x77, 0x0C, 0xCF, 0xFF, 0xFF, 0xC6, 0x61, 0xDC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x99, 0x87, 0x70, 0xCE, 0x00, 0x1C, 0x0E, 0x07,
  0x0F, 0xF7, 0xFF, 0x07, 0x81, 0xE0, 0x7E, 0x1F, 0x81, 0xE0, 0x70, 0x1F,
  0xFF, 0xFE, 0x7C, 0x1C, 0x0E, 0x00, 0x70, 0x7F, 0x1B, 0x63, 0x6C, 0xCD,
  0xB0, 0xF6, 0x0D, 0x80, 0x64, 0x0F, 0xC3, 0x6C, 0xCD, 0x99, 0xB6, 0x37,
  0x83, 0x80, 0x1E, 0x07, 0xE0, 0xCC, 0x39, 0x83, 0x30, 0x7C, 0x07, 0x21,
  0xE6, 0x7E, 0xCC, 0xFB, 0x8E, 0x31, 0xE7, 0xFC, 0x7D, 0xC0, 0xFF, 0xFE,
  0xC0, 0x04, 0x1C, 0x71, 0xC7, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x0C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x20, 0x41, 0xC1, 0xC1, 0xC1, 0xC3,
  0x83, 0x87, 0x0E, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x38, 0xE3, 0x82,
  0x00, 0x1C, 0x0E, 0x13, 0x7F, 0x7F, 0xF8, 0xF0, 0xDC, 0xEE, 0x22, 0x00,
  0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00,
  0x33, 0xDE, 0xF3, 0x7B, 0x80, 0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x3E, 0x3F, 0x9C,
  0xFC, 0x7E, 0x1E, 0x4F, 0x77, 0xBB, 0xC1, 0xE0, 0xF8, 0xFC, 0x77, 0xF1,
  0xF0, 0x0E, 0x0F, 0x1F, 0x9F, 0xC6, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC7, 0xFB, 0xFC, 0x3E, 0x7F, 0x99, 0xE8, 0x70, 0x38, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0x7E, 0x7F, 0x91,
  0xC0, 0x70, 0x30, 0x78, 0xF8, 0x7E, 0x03, 0x81, 0xC0, 0xF0, 0x7F, 0xF7,
  0xF0, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x3F, 0x1D, 0xC6, 0x73, 0x9C, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xBF, 0xDC, 0x0E, 0x07,
  0x03, 0xE1, 0xFC, 0x1E, 0x03, 0x81, 0xC0, 0xF0, 0xFF, 0xF7, 0xF0, 0x07,
  0x0F, 0x8F, 0xAF, 0x07, 0x07, 0xF3, 0xFD, 0xEF, 0xE3, 0xF1, 0xF8, 0xEE,
  0x77, 0xF1, 0xF0, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E,
  0x3B, 0x99, 0xFC, 0xFE, 0xE7, 0xF0, 0xF0, 0x7C, 0x7F, 0xFB, 0xF8, 0x3E,
  0x3F, 0xB8, 0xFC, 0x7E, 0x3F, 0x0F, 0xCE, 0xFF, 0x3F, 0x81, 0xC1, 0xC7,
  0xC7, 0xC3, 0x80, 0x6F, 0xFE, 0x00, 0x06, 0xFF, 0xE0, 0x33, 0xDE, 0xE0,
  0x00, 0x06, 0x73, 0xDE, 0x6F, 0x70, 0x00, 0x81, 0xC3, 0xEF, 0xEF, 0x87,
  0x83, 0xF0, 0x7F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x80, 0x70, 0x3F, 0x07, 0xE0, 0xF8, 0x1C, 0x7F, 0xFC, 0xF8, 0x60,
  0x00, 0xFC, 0xFE, 0x8F, 0x07, 0x0E, 0x1E, 0x3C, 0x38, 0x30, 0x00, 0x00,
  0x78, 0x78, 0x38, 0x1F, 0x8F, 0xF3, 0x0D, 0x83, 0x67, 0xDB, 0xFE, 0xEF,
  0x33, 0xCC, 0xF3, 0x36, 0xED, 0xBF, 0x67, 0xDC, 0x03, 0x80, 0x7F, 0x0F,
  0xC0, 0x0E, 0x01, 0xE0, 0x7C, 0x0D, 0x81, 0xB8, 0x37, 0x0E, 0x61, 0x8C,
  0x31, 0xCF, 0xF9, 0xFF, 0x38, 0x66, 0x0F, 0xC1, 0xC0, 0xFE, 0x3F, 0xCE,
  0x7B, 0x8E, 0xE3, 0xB9, 0xCF, 0xE3, 0xFE, 0xE3, 0xB8, 0x7E, 0x1B, 0x8E,
  0xFF, 0xBF, 0x80, 0x1F, 0x8F, 0xE7, 0x8B, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC2, 0x7F, 0x8F, 0xF0, 0xFC, 0x3F, 0xCE,
  0x7B, 0x8E, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEE, 0x3B, 0x9E,
  0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1F,
  0xBF, 0xDC, 0x3C, 0x0E, 0x07, 0x03, 0x01, 0x83, 0xC1, 0xF0, 0xF8, 0x6E,
  0x37, 0xF9, 0xFC, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C, 0xFF, 0xFF, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x7F,
  0xBF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE8,
  0xEF, 0xF3, 0xF0, 0xE3, 0xB8, 0xEE, 0x73, 0xB8, 0xEE, 0x3F, 0x0F, 0x83,
  0xF0, 0xEE, 0x3B, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE3,
  0xB8, 0xEE, 0x3B, 0xDE, 0xF7, 0xB5, 0xED, 0xDB, 0x76, 0xDD, 0xB0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x70, 0xC1, 0xF0, 0xFC, 0x7E, 0x3F, 0x9F, 0xCF,
  0xF7, 0xDB, 0xEF, 0xF3, 0xF9, 0xFC, 0x7E, 0x3F, 0x0C, 0x3E, 0x1F, 0xCF,
  0x3B, 0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x3B, 0x8E,
  0x7F, 0x0F, 0x80, 0xFE, 0x3F, 0xEE, 0x7B, 0x86, 0xE1, 0xF8, 0x7E, 0x3B,
  0xFE, 0xFF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3E, 0x1F, 0xCF,
  0x3B, 0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x3B, 0x8E,
  0x7F, 0x0F, 0x81, 0xC0, 0x3C, 0x07, 0x80, 0x60, 0xFE, 0x3F, 0xCE, 0x7B,
  0x8E, 0xE3, 0xB8, 0xEE, 0x7B, 0xFC, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE3,
  0xB8, 0x70, 0x3F, 0xBF, 0xB8, 0x5C, 0x0E, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0x81, 0xC0, 0x68, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0xFC, 0x77, 0xF9, 0xF8, 0xE0, 0xEC, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0x63,
  0x8C, 0x61, 0xCC, 0x3B, 0x83, 0x70, 0x6C, 0x0F, 0x80, 0xF0, 0x1C, 0x00,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF7, 0x6D, 0xDB, 0x76, 0xD7, 0xBD,
  0xEF, 0x7B, 0x8E, 0xE3, 0xB8, 0xE0, 0xF0, 0xEE, 0x38, 0xE6, 0x1D, 0xC1,
  0xF0, 0x3E, 0x03, 0x80, 0x78, 0x1F, 0x03, 0x70, 0xE6, 0x38, 0xE7, 0x1D,
  0xC1, 0xC0, 0xE0, 0xEE, 0x19, 0xC7, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF,
  0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x0E, 0x01,
  0xE0, 0x7C, 0x1F, 0xC3, 0xB8, 0xE3, 0x9C, 0x7F, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x67, 0xCE, 0x10, 0x3E, 0x3F, 0x9F, 0xE0, 0x70, 0xBB, 0xFF,
  0xCF, 0xC7, 0xE3, 0xFF, 0xDF, 0xE0, 0x20, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3B, 0x8F, 0xF3, 0xFE, 0xE3, 0xB8, 0x6E, 0x1F, 0x86, 0xE3, 0xB8, 0xEF,
  0xF3, 0xF8, 0x0F, 0x1F, 0xDF, 0xFE, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70,
  0xBF, 0xC7, 0xE0, 0x00, 0x81, 0xC0, 0xE0, 0x70, 0x39, 0xDD, 0xFF, 0xFF,
  0xE3, 0xF1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1D, 0xFE, 0x7F, 0x1E, 0x3F, 0x9F,
  0xFC, 0x7E, 0x1F, 0xFF, 0xFF, 0xC0, 0xF0, 0xBF, 0xCF, 0xE0, 0x02, 0x07,
  0xF1, 0xFC, 0xE0, 0x38, 0x3F, 0xEF, 0xFB, 0xFE, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0x3F, 0xFF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xFF, 0xBF, 0xC0, 0xE0, 0x7F, 0xF7, 0xF9, 0xF0, 0x10,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF3, 0xFD, 0xFE, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x10, 0x1C, 0x0E, 0x07, 0x00, 0x07, 0xC3,
  0xE1, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE4, 0x7E, 0x1F, 0x04,
  0x0F, 0x0F, 0x06, 0x00, 0x7F, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x7F, 0xFE, 0x3C, 0x10, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0xFE, 0x3B, 0x9C, 0xEE, 0x3F, 0x0F, 0xC3, 0xB8, 0xEF, 0x39,
  0xCE, 0x3B, 0x87, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x81, 0xC8, 0xFC, 0x3E, 0x73, 0x3F, 0xEF, 0xFB,
  0x77, 0xDD, 0xF7, 0x7D, 0xDF, 0x07, 0xC1, 0xF0, 0x7C, 0x1C, 0x3C, 0x7F,
  0xBF, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x1C,
  0x1F, 0xCF, 0xFB, 0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x8E, 0xE3, 0x9F, 0xC3,
  0xE0, 0x3C, 0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xB8, 0x7E, 0x1B, 0x8E, 0xE3,
  0xBF, 0xEF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0x3F, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xBF, 0xDF, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x3E, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x1F, 0x3F, 0x9F, 0xDC, 0x07, 0x83, 0xF0, 0x7C, 0x07, 0x43, 0xFF, 0xDF,
  0xC0, 0x08, 0x0E, 0x03, 0x83, 0xFE, 0xFF, 0xBF, 0xE3, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE2, 0x1F, 0x87, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0x73, 0xBF, 0xCF, 0xE0, 0xE0, 0xEC, 0x1D, 0xC7,
  0x38, 0xE3, 0x1C, 0x77, 0x0E, 0xE0, 0xD8, 0x1F, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x7C, 0x0F, 0x81, 0xB7, 0x76, 0xEE, 0xDD, 0x9A, 0xF3, 0xDE, 0x7B,
  0xCE, 0x38, 0xC6, 0x00, 0xE0, 0xEE, 0x38, 0xE6, 0x0D, 0xC1, 0xF0, 0x1C,
  0x07, 0xC0, 0xDC, 0x3B, 0x8E, 0x3B, 0xC3, 0x80, 0x70, 0xEE, 0x19, 0xC7,
  0x1C, 0xE3, 0x98, 0x73, 0x07, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x18, 0x07,
  0x07, 0xC0, 0xF8, 0x3C, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x7F, 0xFF, 0xE0, 0x07, 0x8F, 0xC7, 0xE3, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x78, 0x3C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x7E, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03,
  0xC1, 0xE1, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x3F, 0x1E, 0x00,
  0x38, 0x4F, 0xDD, 0xFF, 0x71, 0xE0,
};

const GFXglyph UbuntuSansMono_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 7, 6, 11, 2, -15 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 9, 18, 11, 1, -16 },
  { 54, 11, 14, 11, 0, -14 },
  { 74, 11, 14, 11, 0, -14 },
  { 94, 3, 6, 11, 4, -15 },
  { 97, 7, 20, 11, 2, -16 },
  { 115, 7, 20, 11, 2, -16 },
  { 133, 9, 9, 11, 1, -14 },
  { 144, 9, 10, 11, 1, -11 },
  { 156, 5, 7, 11, 3, -4 },
  { 161, 6, 3, 11, 3, -7 },
  { 164, 4, 4, 11, 4, -4 },
  { 166, 9, 20, 11, 1, -16 },
  { 189, 9, 14, 11, 1, -14 },
  { 205, 9, 14, 11, 1, -14 },
  { 221, 9, 14, 11, 1, -14 },
  { 237, 9, 14, 11, 1, -14 },
  { 253, 10, 14, 11, 1, -14 },
  { 271, 9, 14, 11, 1, -14 },
  { 287, 9, 14, 11, 1, -14 },
  { 303, 9, 14, 11, 1, -14 },
  { 319, 9, 14, 11, 1, -14 },
  { 335, 9, 14, 11, 1, -14 },
  { 351, 4, 11, 11, 4, -11 },
  { 357, 5, 14, 11, 3, -11 },
  { 366, 9, 10, 11, 1, -11 },
  { 378, 9, 6, 11, 1, -9 },
  { 385, 9, 10, 11, 1, -11 },
  { 397, 8, 14, 11, 2, -14 },
  { 411, 10, 17, 11, 0, -14 },
  { 433, 11, 14, 11, 0, -14 },
  { 453, 10, 14, 11, 1, -14 },
  { 471, 10, 14, 11, 1, -14 },
  { 489, 10, 14, 11, 1, -14 },
  { 507, 9, 14, 11, 1, -14 },
  { 523, 9, 14, 11, 1, -14 },
  { 539, 9, 14, 11, 1, -14 },
  { 555, 9, 14, 11, 1, -14 },
  { 571, 9, 14, 11, 1, -14 },
  { 587, 9, 14, 11, 1, -14 },
  { 603, 10, 14, 11, 1, -14 },
  { 621, 8, 14, 11, 2, -14 },
  { 635, 10, 14, 11, 1, -14 },
  { 653, 9, 14, 11, 1, -14 },
  { 669, 10, 14, 11, 1, -14 },
  { 687, 10, 14, 11, 1, -14 },
  { 705, 10, 18, 11, 1, -14 },
  { 728, 10, 14, 11, 1, -14 },
  { 746, 9, 14, 11, 1, -14 },
  { 762, 10, 14, 11, 1, -14 },
  { 780, 9, 14, 11, 1, -14 },
  { 796, 11, 14, 11, 0, -14 },
  { 816, 10, 14, 11, 1, -14 },
  { 834, 11, 14, 11, 0, -14 },
  { 854, 11, 14, 11, 0, -14 },
  { 874, 9, 14, 11, 1, -14 },
  { 890, 6, 20, 11, 3, -16 },
  { 905, 9, 20, 11, 1, -16 },
  { 928, 7, 20, 11, 2, -16 },
  { 946, 11, 8, 11, 0, -14 },
  { 957, 11, 3, 11, 0, 1 },
  { 962, 5, 4, 11, 3, -15 },
  { 965, 9, 11, 11, 1, -11 },
  { 978, 10, 16, 11, 1, -16 },
  { 998, 9, 11, 11, 1, -11 },
  { 1011, 9, 16, 11, 1, -16 },
  { 1029, 9, 11, 11, 1, -11 },
  { 1042, 10, 16, 11, 1, -16 },
  { 1062, 9, 15, 11, 1, -11 },
  { 1079, 9, 16, 11, 1, -16 },
  { 1097, 9, 16, 11, 1, -16 },
  { 1115, 8, 20, 11, 1, -16 },
  { 1135, 10, 16, 11, 1, -16 },
  { 1155, 9, 15, 11, 1, -15 },
  { 1172, 10, 11, 11, 1, -11 },
  { 1186, 9, 11, 11, 1, -11 },
  { 1199, 10, 11, 11, 1, -11 },
  { 1213, 10, 15, 11, 1, -11 },
  { 1232, 9, 15, 11, 1, -11 },
  { 1249, 8, 11, 11, 2, -11 },
  { 1260, 9, 11, 11, 1, -11 },
  { 1273, 10, 14, 11, 1, -14 },
  { 1291, 9, 11, 11, 1, -11 },
  { 1304, 11, 11, 11, 0, -11 },
  { 1320, 11, 11, 11, 0, -11 },
  { 1336, 11, 11, 11, 0, -11 },
  { 1352, 11, 15, 11, 0, -11 },
  { 1373, 9, 11, 11, 1, -11 },
  { 1386, 9, 20, 11, 1, -16 },
  { 1409, 3, 20, 11, 4, -16 },
  { 1417, 9, 20, 11, 1, -16 },
  { 1440, 11, 4, 11, 0, -8 },
};

const GFXfont UbuntuSansMono_Bold20pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold20pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold20pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUSANSMONO_BOLD20PT7B_H_
