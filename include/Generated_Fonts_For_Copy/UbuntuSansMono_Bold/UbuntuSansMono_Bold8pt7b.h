#ifndef _UBUNTUSANSMONO_BOLD8PT7B_H_
#define _UBUNTUSANSMONO_BOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0xB4, 0x55, 0xF6, 0xFA, 0x27, 0xC3, 0x1F, 0x20, 0x5D,
  0xE3, 0x7B, 0x66, 0x67, 0xB7, 0xE0, 0x72, 0x49, 0x11, 0x89, 0x92, 0xB4,
  0x27, 0xA5, 0x2F, 0x22, 0x7C, 0xC0, 0x70, 0x12, 0x22, 0x64, 0xC0, 0x65,
  0x9B, 0x97, 0x26, 0xA2, 0x27, 0x6D, 0x12, 0x4F, 0x69, 0x37, 0x1F, 0x13,
  0x59, 0xF1, 0x74, 0x43, 0x1F, 0x16, 0x6D, 0xD7, 0xF1, 0x22, 0x64, 0x6D,
  0x57, 0x97, 0x65, 0xD7, 0x36, 0x71, 0xC0, 0x71, 0xF0, 0x3C, 0x71, 0xF0,
  0xF0, 0xC3, 0x68, 0xD5, 0xE1, 0x80, 0x25, 0xBD, 0xBB, 0x70, 0x26, 0x65,
  0xF9, 0x6D, 0xDF, 0xDF, 0x35, 0x88, 0xC7, 0x6D, 0xDD, 0xDE, 0xF2, 0x79,
  0xC0, 0xF2, 0x79, 0x00, 0x35, 0x89, 0xD7, 0xDD, 0xDF, 0xDD, 0xF2, 0x22,
  0x2F, 0x71, 0x11, 0x1F, 0xDF, 0xEE, 0xFD, 0x92, 0x49, 0xC0, 0x9D, 0xFB,
  0x99, 0x9D, 0xDB, 0x99, 0x65, 0x99, 0x97, 0x6D, 0xDF, 0xCC, 0x65, 0x99,
  0x97, 0x21, 0x6D, 0xDE, 0xFD, 0x6D, 0x43, 0x1F, 0xF2, 0x22, 0x22, 0x99,
  0x99, 0xD7, 0x99, 0x55, 0x66, 0x99, 0xBB, 0xDD, 0x95, 0x66, 0x5D, 0x95,
  0x76, 0x22, 0x71, 0x26, 0x4F, 0xF2, 0x49, 0x38, 0xC4, 0x42, 0x22, 0x10,
  0xD5, 0x5C, 0x26, 0x59, 0xF0, 0xC0, 0x77, 0xD7, 0x93, 0xDB, 0xC0, 0x7C,
  0xC7, 0x11, 0x79, 0x97, 0x7F, 0x87, 0x74, 0xF4, 0x44, 0x79, 0xD7, 0xB4,
  0x93, 0xDB, 0x40, 0x60, 0xE6, 0x63, 0x20, 0x73, 0x33, 0x6C, 0x93, 0xED,
  0x40, 0xE6, 0x66, 0x63, 0xFB, 0x99, 0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF8,
  0x79, 0x97, 0x10, 0xF2, 0x40, 0x76, 0x1F, 0x4F, 0x44, 0x70, 0xB6, 0xF0,
  0x95, 0x66, 0x9B, 0xF5, 0xD6, 0x6D, 0xD5, 0x62, 0xE4, 0xEA, 0x70, 0x69,
  0x44, 0x98, 0xFE, 0xC9, 0x34, 0xB0, 0xF0,
};

const GFXglyph UbuntuSansMono_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 6, 4, 1, -6 },
  { 3, 3, 2, 4, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 6, 4, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 3, 4, 2, -6 },
  { 18, 3, 8, 4, 1, -6 },
  { 21, 3, 8, 4, 1, -6 },
  { 24, 4, 4, 4, 0, -6 },
  { 26, 4, 4, 4, 0, -4 },
  { 28, 2, 3, 4, 1, -2 },
  { 29, 2, 1, 4, 1, -3 },
  { 30, 2, 2, 4, 1, -2 },
  { 31, 4, 7, 4, 0, -6 },
  { 35, 4, 6, 4, 0, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 2, 5, 4, 1, -5 },
  { 67, 2, 6, 4, 1, -5 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 3, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 3, 6, 4, 1, -6 },
  { 78, 4, 7, 4, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 3, 6, 4, 1, -6 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 4, 6, 4, 0, -6 },
  { 106, 4, 6, 4, 0, -6 },
  { 109, 4, 6, 4, 0, -6 },
  { 112, 4, 6, 4, 0, -6 },
  { 115, 3, 6, 4, 1, -6 },
  { 118, 4, 6, 4, 0, -6 },
  { 121, 4, 6, 4, 0, -6 },
  { 124, 4, 6, 4, 0, -6 },
  { 127, 4, 6, 4, 0, -6 },
  { 130, 4, 8, 4, 0, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 4, 6, 4, 0, -6 },
  { 155, 4, 6, 4, 0, -6 },
  { 158, 4, 6, 4, 0, -6 },
  { 161, 3, 7, 4, 1, -6 },
  { 164, 4, 7, 4, 0, -6 },
  { 168, 2, 7, 4, 1, -6 },
  { 170, 4, 4, 4, 0, -6 },
  { 172, 4, 1, 4, 0, 0 },
  { 173, 2, 1, 4, 1, -6 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 3, 6, 4, 1, -6 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 4, 6, 4, 0, -6 },
  { 189, 4, 6, 4, 0, -4 },
  { 192, 3, 6, 4, 1, -6 },
  { 195, 4, 6, 4, 0, -6 },
  { 198, 4, 8, 4, 0, -6 },
  { 202, 3, 6, 4, 1, -6 },
  { 205, 4, 6, 4, 0, -6 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 3, 4, 4, 1, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 3, 5, 4, 1, -4 },
  { 216, 4, 5, 4, 0, -4 },
  { 219, 3, 4, 4, 1, -4 },
  { 221, 4, 4, 4, 0, -4 },
  { 223, 4, 5, 4, 0, -5 },
  { 226, 3, 4, 4, 1, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 4, 4, 0, -4 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 4, 6, 4, 0, -4 },
  { 237, 3, 4, 4, 1, -4 },
  { 239, 3, 7, 4, 1, -6 },
  { 242, 1, 7, 4, 2, -6 },
  { 243, 3, 7, 4, 1, -6 },
  { 246, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Bold8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_BOLD8PT7B_H_
