#ifndef _UBUNTUSANSMONO_BOLD10PT7B_H_
#define _UBUNTUSANSMONO_BOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x2C, 0xBB, 0xBA, 0x29, 0x7E, 0xAF, 0xA9, 0x40, 0x21, 0xD2,
  0x87, 0x0D, 0x3F, 0x20, 0xCE, 0xAF, 0x08, 0x39, 0x59, 0x80, 0x72, 0x94,
  0xDF, 0xCD, 0xE0, 0xFA, 0x36, 0x4C, 0x88, 0xC4, 0x63, 0x84, 0x22, 0x33,
  0x22, 0x48, 0x4D, 0x6F, 0x27, 0xFE, 0x42, 0x00, 0x6D, 0xC0, 0xFC, 0xF0,
  0x13, 0x22, 0x64, 0x4C, 0x88, 0x72, 0x73, 0xDC, 0xA5, 0xC0, 0x6E, 0xE6,
  0x66, 0xF0, 0xF2, 0xC6, 0x66, 0x21, 0xE0, 0x72, 0xC6, 0x60, 0x8F, 0xC0,
  0x19, 0xDE, 0xBF, 0x8C, 0x60, 0x7A, 0x10, 0xF0, 0x8F, 0xC0, 0x7C, 0x8F,
  0x99, 0xE0, 0xF3, 0x26, 0x44, 0xC0, 0x7A, 0x52, 0xE4, 0xE5, 0xE0, 0x72,
  0x72, 0xF1, 0x99, 0x80, 0xF3, 0xC0, 0x6C, 0x36, 0xA0, 0x1F, 0xB8, 0x70,
  0x80, 0xFF, 0xC1, 0xF0, 0xE1, 0xC7, 0xC8, 0x00, 0xE3, 0x36, 0x04, 0x60,
  0x7A, 0x6F, 0x5A, 0xDD, 0x6D, 0x10, 0x30, 0xC5, 0x16, 0x7B, 0x2C, 0xC0,
  0xEB, 0xBE, 0x99, 0xF0, 0x3A, 0x71, 0x8C, 0x21, 0xE0, 0xEB, 0x99, 0x9B,
  0xE0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x3A, 0x71, 0x9C,
  0xA5, 0xE0, 0xCE, 0x73, 0xFC, 0xE7, 0x20, 0xF6, 0x66, 0x66, 0xF0, 0x78,
  0x42, 0x10, 0xAF, 0xC0, 0xDE, 0xBD, 0xCF, 0x6F, 0x20, 0x88, 0x88, 0x88,
  0xF0, 0x4A, 0xEF, 0x7A, 0xE7, 0x20, 0x99, 0xDD, 0xBB, 0x90, 0x72, 0x73,
  0x9C, 0xA5, 0xC0, 0xF9, 0x9F, 0xE8, 0x80, 0x72, 0x73, 0x9C, 0xA5, 0xC6,
  0x18, 0xEB, 0x9F, 0xAB, 0x90, 0x7A, 0x10, 0xE1, 0xC7, 0xE0, 0xF9, 0x08,
  0x42, 0x10, 0x80, 0xCE, 0x73, 0x9C, 0xA5, 0xE0, 0xCE, 0x52, 0xB5, 0x18,
  0xC0, 0xCE, 0x63, 0x7B, 0xAD, 0x20, 0xCA, 0xCC, 0x67, 0x2F, 0x20, 0xCA,
  0x5C, 0x63, 0x18, 0xC0, 0xF3, 0x24, 0xC8, 0xF0, 0xFB, 0x6D, 0xB6, 0xDC,
  0x88, 0xC4, 0x46, 0x22, 0x31, 0xE4, 0x92, 0x49, 0x3C, 0x31, 0xC5, 0xB3,
  0xFC, 0xB0, 0x78, 0x5F, 0x97, 0x80, 0x88, 0x8F, 0x99, 0x9E, 0x7A, 0x30,
  0x87, 0x80, 0x18, 0xC6, 0xFD, 0xEF, 0x6F, 0x7E, 0x7E, 0x87, 0x80, 0x1C,
  0xA2, 0x3E, 0x20, 0x82, 0x08, 0x7E, 0x72, 0xB2, 0xCF, 0xC0, 0x88, 0x8F,
  0x99, 0x99, 0x23, 0x01, 0xC2, 0x10, 0x87, 0x24, 0x72, 0x49, 0xBC, 0x88,
  0x8B, 0xEE, 0xA9, 0xE1, 0x08, 0x42, 0x10, 0x87, 0xFD, 0x6B, 0x18, 0x80,
  0xF9, 0x99, 0x90, 0x7E, 0x73, 0x97, 0x00, 0xF9, 0x99, 0xF8, 0x80, 0x7E,
  0x73, 0x97, 0x84, 0x20, 0xF8, 0x88, 0x80, 0xF8, 0x71, 0xF0, 0x21, 0x3E,
  0x42, 0x10, 0xE0, 0x99, 0x99, 0xF0, 0xCA, 0xD4, 0xE3, 0x00, 0x8D, 0x6E,
  0xB5, 0x80, 0xD9, 0x8C, 0xFC, 0x80, 0xCA, 0xDC, 0x63, 0x13, 0x80, 0xF2,
  0x4C, 0xF0, 0x74, 0x44, 0xCC, 0x44, 0x47, 0xFF, 0xFF, 0xF0, 0xC6, 0x66,
  0x33, 0x66, 0x6C, 0x6D, 0xC0,
};

const GFXglyph UbuntuSansMono_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 4, 6, 1, -8 },
  { 5, 5, 7, 6, 0, -7 },
  { 10, 5, 9, 6, 0, -8 },
  { 16, 6, 7, 6, 0, -7 },
  { 22, 5, 7, 6, 0, -7 },
  { 27, 2, 4, 6, 2, -8 },
  { 28, 4, 10, 6, 1, -8 },
  { 33, 4, 10, 6, 1, -8 },
  { 38, 4, 4, 6, 1, -7 },
  { 40, 5, 5, 6, 0, -5 },
  { 44, 3, 4, 6, 1, -2 },
  { 46, 3, 2, 6, 1, -4 },
  { 47, 2, 2, 6, 2, -2 },
  { 48, 4, 10, 6, 1, -8 },
  { 53, 5, 7, 6, 0, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 5, 7, 6, 0, -7 },
  { 95, 5, 7, 6, 0, -7 },
  { 100, 2, 5, 6, 2, -5 },
  { 102, 3, 7, 6, 1, -5 },
  { 105, 5, 5, 6, 0, -5 },
  { 109, 5, 4, 6, 0, -5 },
  { 112, 5, 5, 6, 0, -5 },
  { 116, 4, 7, 6, 1, -7 },
  { 120, 5, 9, 6, 0, -7 },
  { 126, 6, 7, 6, 0, -7 },
  { 132, 4, 7, 6, 1, -7 },
  { 136, 5, 7, 6, 0, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 4, 7, 6, 1, -7 },
  { 149, 4, 7, 6, 1, -7 },
  { 153, 5, 7, 6, 0, -7 },
  { 158, 5, 7, 6, 0, -7 },
  { 163, 4, 7, 6, 1, -7 },
  { 167, 5, 7, 6, 0, -7 },
  { 172, 5, 7, 6, 0, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 5, 7, 6, 0, -7 },
  { 186, 4, 7, 6, 1, -7 },
  { 190, 5, 7, 6, 0, -7 },
  { 195, 4, 7, 6, 1, -7 },
  { 199, 5, 9, 6, 0, -7 },
  { 205, 4, 7, 6, 1, -7 },
  { 209, 5, 7, 6, 0, -7 },
  { 214, 5, 7, 6, 0, -7 },
  { 219, 5, 7, 6, 0, -7 },
  { 224, 5, 7, 6, 0, -7 },
  { 229, 5, 7, 6, 0, -7 },
  { 234, 5, 7, 6, 0, -7 },
  { 239, 5, 7, 6, 0, -7 },
  { 244, 4, 7, 6, 1, -7 },
  { 248, 3, 10, 6, 1, -8 },
  { 252, 4, 10, 6, 1, -8 },
  { 257, 3, 10, 6, 1, -8 },
  { 261, 6, 4, 6, 0, -7 },
  { 264, 6, 1, 6, 0, 1 },
  { 265, 2, 2, 6, 2, -8 },
  { 266, 5, 5, 6, 0, -5 },
  { 270, 4, 8, 6, 1, -8 },
  { 274, 5, 5, 6, 0, -5 },
  { 278, 5, 8, 6, 0, -8 },
  { 283, 5, 5, 6, 0, -5 },
  { 287, 6, 8, 6, 0, -8 },
  { 293, 5, 7, 6, 0, -5 },
  { 298, 4, 8, 6, 1, -8 },
  { 302, 5, 8, 6, 0, -8 },
  { 307, 3, 10, 6, 1, -8 },
  { 311, 4, 8, 6, 1, -8 },
  { 315, 5, 8, 6, 0, -8 },
  { 320, 5, 5, 6, 0, -5 },
  { 324, 4, 5, 6, 1, -5 },
  { 327, 5, 5, 6, 0, -5 },
  { 331, 4, 7, 6, 1, -5 },
  { 335, 5, 7, 6, 0, -5 },
  { 340, 4, 5, 6, 1, -5 },
  { 343, 4, 5, 6, 1, -5 },
  { 346, 5, 7, 6, 0, -7 },
  { 351, 4, 5, 6, 1, -5 },
  { 354, 5, 5, 6, 0, -5 },
  { 358, 5, 5, 6, 0, -5 },
  { 362, 5, 5, 6, 0, -5 },
  { 366, 5, 7, 6, 0, -5 },
  { 371, 4, 5, 6, 1, -5 },
  { 374, 4, 10, 6, 1, -8 },
  { 379, 2, 10, 6, 2, -8 },
  { 382, 4, 10, 6, 1, -8 },
  { 387, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_Bold10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_BOLD10PT7B_H_
