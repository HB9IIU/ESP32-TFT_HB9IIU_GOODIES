#ifndef _UBUNTUSANSMONO_BOLD39PT7B_H_
#define _UBUNTUSANSMONO_BOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x7E, 0x7E,
  0xFF, 0xFF, 0x7E, 0x7C, 0x10, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xE1, 0xE7, 0x87,
  0x9C, 0x0E, 0x70, 0x38, 0x03, 0xE3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x87, 0xC7, 0xC0, 0x09,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF9, 0x00, 0x1F, 0x38, 0x07, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00,
  0xFC, 0x01, 0xF7, 0xF8, 0x07, 0x9F, 0xF0, 0x3C, 0x73, 0xC0, 0xE3, 0xC7,
  0x07, 0x8F, 0x1C, 0x3C, 0x3C, 0x70, 0xE0, 0xF1, 0xC7, 0x81, 0xCF, 0x3C,
  0x07, 0xFC, 0xF0, 0x1F, 0xE7, 0x80, 0x3F, 0xBC, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xF0, 0x07, 0xBF, 0xE0, 0x3C,
  0xF7, 0x80, 0xF3, 0x8E, 0x07, 0x8E, 0x38, 0x3C, 0x38, 0xE0, 0xF0, 0xE3,
  0x87, 0x83, 0x8E, 0x3C, 0x0F, 0x78, 0xF0, 0x3F, 0xE7, 0x80, 0x7F, 0x3C,
  0x01, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0x3E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3F, 0x7C, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x1C, 0x1F, 0xE3, 0xE3, 0xFE, 0x3E, 0x7F, 0xF3, 0xE7,
  0xDF, 0xBE, 0xF8, 0xFF, 0xCF, 0x87, 0xFC, 0xF8, 0x3F, 0xCF, 0x81, 0xF8,
  0xF8, 0x0F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFB,
  0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xE7, 0x9E,
  0x78, 0x00, 0x10, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0xC0, 0x20, 0x01, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x78,
  0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x01, 0x07, 0x80,
  0x71, 0xE3, 0x9F, 0x7B, 0xE7, 0xED, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0,
  0x78, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3E, 0x0F, 0xCF, 0xC1, 0xF3,
  0xF0, 0x38, 0x70, 0x04, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF0, 0xFC, 0x0F, 0x07,
  0x83, 0xEF, 0xF1, 0xF8, 0x78, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F,
  0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE3, 0x1F, 0xF1, 0xE7, 0xFC, 0xF9, 0xFF, 0x1E, 0x7F, 0xC7, 0x9F,
  0xF0, 0xC7, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7D, 0xF8, 0x08, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x01, 0xC0, 0x07, 0xFE, 0x03,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0x0F, 0xE3, 0x01, 0xF8, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x07, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0E, 0x0F, 0xC2,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x07,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF9, 0x80, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF,
  0xE0, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x81, 0xF1, 0xF8, 0x3E, 0x1F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xEE, 0x03, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xC1,
  0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF8, 0x0F, 0xBF, 0x03, 0xE7, 0xE0, 0xF9, 0xFC, 0x7C, 0x3F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFC, 0x7E, 0xFF, 0x9F, 0x07, 0xEF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0x87, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFB, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x1F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0x7F, 0x07, 0x81, 0xE1, 0xF3, 0xF8, 0xFC, 0x1E, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0xE0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40,
  0x00, 0x1C, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFE, 0x70, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xF8, 0x7C, 0x7C, 0x07, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xE3, 0xFC, 0xF8, 0x7F, 0x9F, 0x0F, 0xF3, 0xE1, 0xFE, 0x7C, 0x3F, 0xCF,
  0x87, 0xF9, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xE3, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0x78, 0xFF, 0xEF, 0x07, 0xFD, 0xF0, 0x18, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x43, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x79, 0xE0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x00, 0xF9, 0xF8,
  0x07, 0xCF, 0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x3E,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x3F, 0xBF,
  0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xC7,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0x81, 0x8F, 0xC0, 0x13, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x09, 0xFE, 0x0E, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0x80, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xCF, 0xF9, 0xF8, 0x3F,
  0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xFD,
  0xF8, 0x3F, 0x3F, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF8,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x83, 0x8F, 0xC0, 0x13,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xCF,
  0xC0, 0xF9, 0xFE, 0x1F, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x01, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF9, 0x00, 0xFD, 0xE1, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFE, 0x0F, 0xFE, 0x00, 0x20, 0x00, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0,
  0x7E, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC7,
  0xE0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xDF, 0xC0, 0xF9, 0xFC, 0x1F, 0x1F,
  0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E, 0x07,
  0xE7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0xC7,
  0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F, 0x9D, 0xE7, 0xB9, 0xDE, 0x7B, 0xBD,
  0xE7, 0xBF, 0xDE, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xEF, 0x9F,
  0x1E, 0xF8, 0xF1, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xF1, 0xFF, 0xBC, 0x7F, 0xEF, 0x9F, 0xF9, 0xE7, 0xFE, 0x7D,
  0xFF, 0x8F, 0x7F, 0xE3, 0xDF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7E, 0x07, 0xC7,
  0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xC3, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xEF,
  0xC1, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xF0, 0xFC, 0x7E, 0x07, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC3, 0xF0, 0xFC,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xCF, 0xF9, 0xF8, 0x3F, 0x3F, 0x03, 0xE7, 0xE0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xDF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xE7, 0xE0,
  0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x81, 0xCF, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF4, 0x00,
  0xFD, 0xC0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xF0,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE1, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8,
  0xF1, 0xEF, 0x9F, 0x1E, 0xF9, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7,
  0xBF, 0xDE, 0x7B, 0xFD, 0xE7, 0xB9, 0xDE, 0x7F, 0x9D, 0xE7, 0xF9, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7C, 0x3C, 0x03, 0xC0, 0x7E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F,
  0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7E, 0x3E, 0x01, 0xF3,
  0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03,
  0xE7, 0xE0, 0x3E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0,
  0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0x9F, 0x83, 0xF0, 0xFC, 0x7F,
  0x0F, 0xE7, 0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0x38, 0x01, 0xC0,
  0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x20, 0x3C, 0x1F, 0x1F, 0xE7, 0xF8, 0xFC, 0x1C, 0x02, 0x1F, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xEF, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x03, 0xEF, 0x8F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x7E, 0xF8, 0x1F, 0xBE, 0x1F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x9F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xFB, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xE0,
  0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF,
  0xC3, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC,
  0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xC3, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0x1E, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xCF,
  0xDF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0x7D, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF4, 0x00, 0xFC, 0xE0, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x30, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x90, 0x1F,
  0x7C, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xEF, 0x83, 0xFB, 0xE0,
  0xFC, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F,
  0x9F, 0x83, 0xE3, 0xF0, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0,
  0x7E, 0xF8, 0x1F, 0xBE, 0x03, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x70, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0x87, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0x9F, 0x1E, 0xF8, 0xF1, 0xEF, 0x8F, 0x1F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xC1, 0xF7, 0xE0, 0x7D,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F, 0x7F, 0x0F, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x07,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x06, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE7, 0xFF, 0xF3, 0xE0, 0x09, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00,
  0x3E, 0x80, 0x1F, 0x78, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF, 0xC3,
  0xFF, 0xC0, 0x00, 0x40, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x30, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFE, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x3C, 0x3D, 0xE1, 0xE3,
  0xEF, 0x1F, 0x9F, 0x78, 0xFC, 0xFB, 0xE7, 0xE7, 0x8F, 0x3F, 0x3C, 0x7B,
  0xFD, 0xE3, 0xDF, 0xEF, 0x1E, 0xEF, 0x78, 0xFF, 0x3B, 0xC7, 0xF9, 0xFC,
  0x1F, 0x8F, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3C, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xF0, 0xFC,
  0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xFC, 0x7E,
  0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xF7, 0xC0, 0x3E,
  0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x07,
  0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x04, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00,
  0x02, 0x00, 0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0xF8, 0x7F, 0xC7, 0x01, 0xF8, 0x00, 0x06, 0x00,
};

const GFXglyph UbuntuSansMono_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 28, 22, 7, -27 },
  { 29, 14, 13, 22, 4, -30 },
  { 52, 20, 27, 22, 1, -27 },
  { 120, 19, 34, 22, 1, -30 },
  { 201, 22, 29, 22, 0, -28 },
  { 281, 20, 28, 22, 1, -28 },
  { 351, 6, 13, 22, 8, -30 },
  { 361, 14, 38, 22, 4, -31 },
  { 428, 14, 38, 22, 4, -31 },
  { 495, 18, 17, 22, 2, -27 },
  { 534, 18, 19, 22, 2, -21 },
  { 577, 10, 14, 22, 5, -7 },
  { 595, 12, 5, 22, 5, -14 },
  { 603, 8, 7, 22, 7, -7 },
  { 610, 18, 38, 22, 2, -31 },
  { 696, 18, 29, 22, 2, -28 },
  { 762, 18, 27, 22, 2, -27 },
  { 823, 18, 28, 22, 2, -28 },
  { 886, 18, 29, 22, 2, -28 },
  { 952, 20, 27, 22, 1, -27 },
  { 1020, 18, 28, 22, 2, -27 },
  { 1083, 18, 28, 22, 2, -27 },
  { 1146, 18, 27, 22, 2, -27 },
  { 1207, 18, 29, 22, 2, -28 },
  { 1273, 18, 28, 22, 2, -28 },
  { 1336, 8, 20, 22, 7, -20 },
  { 1356, 10, 27, 22, 5, -20 },
  { 1390, 18, 19, 22, 2, -21 },
  { 1433, 18, 13, 22, 2, -18 },
  { 1463, 18, 19, 22, 2, -21 },
  { 1506, 16, 29, 22, 3, -28 },
  { 1564, 19, 34, 22, 1, -28 },
  { 1645, 21, 27, 22, 0, -27 },
  { 1716, 18, 27, 22, 2, -27 },
  { 1777, 19, 29, 22, 1, -28 },
  { 1846, 19, 27, 22, 2, -27 },
  { 1911, 17, 27, 22, 3, -27 },
  { 1969, 16, 27, 22, 3, -27 },
  { 2023, 19, 29, 22, 1, -28 },
  { 2092, 18, 27, 22, 2, -27 },
  { 2153, 18, 27, 22, 2, -27 },
  { 2214, 17, 28, 22, 2, -27 },
  { 2274, 19, 27, 22, 2, -27 },
  { 2339, 17, 27, 22, 3, -27 },
  { 2397, 20, 27, 22, 1, -27 },
  { 2465, 18, 27, 22, 2, -27 },
  { 2526, 20, 29, 22, 1, -28 },
  { 2599, 19, 27, 22, 2, -27 },
  { 2664, 20, 35, 22, 1, -28 },
  { 2752, 19, 27, 22, 2, -27 },
  { 2817, 18, 29, 22, 2, -28 },
  { 2883, 20, 27, 22, 1, -27 },
  { 2951, 18, 28, 22, 2, -27 },
  { 3014, 20, 27, 22, 1, -27 },
  { 3082, 20, 27, 22, 1, -27 },
  { 3150, 21, 27, 22, 0, -27 },
  { 3221, 20, 27, 22, 1, -27 },
  { 3289, 18, 27, 22, 2, -27 },
  { 3350, 12, 38, 22, 5, -31 },
  { 3407, 18, 38, 22, 2, -31 },
  { 3493, 12, 38, 22, 5, -31 },
  { 3550, 20, 16, 22, 1, -27 },
  { 3590, 21, 4, 22, 0, 3 },
  { 3601, 9, 8, 22, 7, -30 },
  { 3610, 17, 21, 22, 2, -21 },
  { 3655, 18, 30, 22, 3, -30 },
  { 3723, 18, 21, 22, 2, -21 },
  { 3771, 18, 30, 22, 1, -30 },
  { 3839, 19, 21, 22, 1, -21 },
  { 3889, 19, 30, 22, 2, -30 },
  { 3961, 18, 28, 22, 1, -21 },
  { 4024, 16, 30, 22, 3, -30 },
  { 4084, 18, 30, 22, 2, -30 },
  { 4152, 15, 37, 22, 2, -30 },
  { 4222, 18, 30, 22, 3, -30 },
  { 4290, 18, 30, 22, 2, -30 },
  { 4358, 20, 21, 22, 1, -21 },
  { 4411, 16, 21, 22, 3, -21 },
  { 4453, 20, 22, 22, 1, -21 },
  { 4508, 17, 28, 22, 3, -21 },
  { 4568, 18, 28, 22, 1, -21 },
  { 4631, 16, 21, 22, 4, -21 },
  { 4673, 17, 21, 22, 2, -21 },
  { 4718, 19, 27, 22, 2, -27 },
  { 4783, 16, 21, 22, 3, -21 },
  { 4825, 20, 21, 22, 1, -21 },
  { 4878, 21, 21, 22, 0, -21 },
  { 4934, 20, 21, 22, 1, -21 },
  { 4987, 20, 28, 22, 1, -21 },
  { 5057, 16, 21, 22, 3, -21 },
  { 5099, 16, 38, 22, 3, -31 },
  { 5175, 6, 38, 22, 8, -31 },
  { 5204, 16, 38, 22, 3, -31 },
  { 5280, 20, 9, 22, 1, -16 },
};

const GFXfont UbuntuSansMono_Bold39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Bold39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Bold39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_BOLD39PT7B_H_
