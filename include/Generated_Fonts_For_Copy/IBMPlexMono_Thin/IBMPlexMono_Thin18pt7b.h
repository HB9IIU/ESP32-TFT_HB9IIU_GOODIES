#ifndef _IBMPLEXMONO_THIN18PT7B_H_
#define _IBMPLEXMONO_THIN18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x88, 0xB6, 0xDA, 0x09, 0x02, 0x40, 0x90, 0x24, 0x71, 0xC4,
  0x81, 0x20, 0x48, 0xF3, 0xC4, 0x82, 0x20, 0x90, 0x24, 0x00, 0x08, 0x08,
  0x3C, 0x4B, 0x89, 0x88, 0x88, 0x68, 0x1E, 0x09, 0x09, 0x09, 0x89, 0x49,
  0x3E, 0x08, 0x08, 0x38, 0x52, 0x28, 0x4A, 0x14, 0x49, 0x0E, 0x00, 0x00,
  0x0E, 0x14, 0x49, 0x14, 0x45, 0x11, 0x83, 0x80, 0x38, 0x22, 0x21, 0x90,
  0x04, 0x01, 0x01, 0x47, 0x34, 0x8A, 0x43, 0x20, 0x90, 0xA7, 0x98, 0xF8,
  0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x44, 0x21, 0x82, 0x08, 0x21, 0x08,
  0x41, 0x08, 0x84, 0x21, 0x11, 0x10, 0x08, 0x04, 0x02, 0x11, 0x17, 0xF0,
  0xC0, 0x90, 0x44, 0x43, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x6A, 0xF8, 0x80, 0x02, 0x08, 0x10, 0x40, 0x81,
  0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0x3C, 0x21, 0x20,
  0x50, 0x28, 0x14, 0x0A, 0x23, 0x02, 0x81, 0x40, 0xA0, 0x48, 0x43, 0xC0,
  0x10, 0x30, 0x50, 0x90, 0x90, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x79, 0x0A, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x0F,
  0xE0, 0x3C, 0x42, 0x81, 0x02, 0x02, 0x3C, 0x06, 0x01, 0x01, 0x01, 0x81,
  0x42, 0x3C, 0x02, 0x03, 0x02, 0x82, 0x42, 0x21, 0x11, 0x09, 0x04, 0x82,
  0x7F, 0xC0, 0x80, 0x40, 0x20, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0x21, 0x01,
  0x02, 0x06, 0x0C, 0x27, 0x80, 0x18, 0x41, 0x04, 0x08, 0x1F, 0x21, 0xC1,
  0x83, 0x06, 0x0C, 0x27, 0x80, 0xFF, 0x81, 0x82, 0x82, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x3E, 0x20, 0xA0, 0x50, 0x28, 0x12,
  0x10, 0xF0, 0xC6, 0x81, 0x40, 0xA0, 0x68, 0x23, 0xE0, 0x7D, 0x06, 0x0C,
  0x18, 0x30, 0x61, 0xBD, 0x04, 0x08, 0x20, 0x82, 0x00, 0x80, 0x80, 0x40,
  0x00, 0x6A, 0x02, 0x08, 0x63, 0x08, 0x10, 0x10, 0x18, 0x0C, 0x04, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x43, 0x08,
  0x61, 0x00, 0x3C, 0x86, 0x08, 0x10, 0x20, 0x8E, 0x10, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x38, 0x8A, 0x0C, 0x19, 0xF4, 0x70, 0xE1, 0xC3, 0x46, 0x7C,
  0x08, 0x08, 0x0F, 0x00, 0x08, 0x0C, 0x06, 0x04, 0x82, 0x41, 0x21, 0x08,
  0x84, 0x7E, 0x20, 0xA0, 0x50, 0x28, 0x08, 0xFD, 0x0A, 0x0C, 0x18, 0x30,
  0xBF, 0x41, 0x83, 0x06, 0x0C, 0x1F, 0xC0, 0x1C, 0x22, 0x41, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x41, 0x22, 0x1C, 0xF8, 0x84, 0x82, 0x82,
  0x82, 0x82, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1C, 0x62, 0x41,
  0x80, 0x80, 0x80, 0x80, 0x87, 0x81, 0x81, 0x41, 0x63, 0x1D, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x7C, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x18, 0x61, 0x78, 0x83, 0x82, 0x84, 0x88,
  0x90, 0xA0, 0xD0, 0x90, 0x88, 0x84, 0x84, 0x82, 0x81, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x83, 0x06, 0x1E,
  0x3C, 0xB9, 0x6C, 0xD9, 0xA3, 0x06, 0x0C, 0x18, 0x20, 0x83, 0x07, 0x0E,
  0x1A, 0x34, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x38, 0x20, 0x3C, 0x21, 0x20,
  0x50, 0x28, 0x14, 0x0A, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x48, 0x43, 0xC0,
  0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0x81, 0x02, 0x04, 0x08, 0x00,
  0x3C, 0x21, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x03, 0x02, 0x81, 0x40, 0xA0,
  0x48, 0x43, 0xC0, 0x40, 0x20, 0x1E, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFE, 0x91, 0x12, 0x14, 0x28, 0x20, 0x3C, 0x43, 0x81, 0x80, 0x80, 0x60,
  0x1E, 0x01, 0x01, 0x01, 0x81, 0x41, 0x3E, 0xFF, 0x84, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x27, 0xC0, 0x80, 0xC0,
  0xA0, 0x48, 0x24, 0x22, 0x11, 0x08, 0x48, 0x24, 0x12, 0x06, 0x03, 0x00,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x94, 0xCA, 0x65, 0x2A, 0xA5, 0x52,
  0xA8, 0xC8, 0x64, 0x10, 0x81, 0xC0, 0x90, 0x84, 0x82, 0x40, 0xC0, 0x20,
  0x30, 0x24, 0x11, 0x10, 0x90, 0x28, 0x08, 0x80, 0x50, 0x22, 0x08, 0x84,
  0x12, 0x04, 0x80, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20,
  0x10, 0x0F, 0xF8, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x81,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81,
  0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x0A, 0x09,
  0x04, 0x44, 0x24, 0x0A, 0x02, 0xFF, 0x80, 0xA4, 0x3C, 0x61, 0x00, 0x80,
  0x47, 0xE4, 0x12, 0x09, 0x0C, 0x79, 0x80, 0x81, 0x02, 0x04, 0x0B, 0xD8,
  0x60, 0xC1, 0x83, 0x06, 0x0E, 0x1B, 0xC0, 0x38, 0x8A, 0x0C, 0x08, 0x10,
  0x20, 0xA2, 0x38, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x79, 0x0A, 0x0C, 0x1F, 0xF0, 0x20, 0x41, 0x7C,
  0x1F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFE, 0x03, 0x04, 0x3C, 0x44, 0x82, 0x82, 0x44, 0x38, 0xC0, 0x80, 0x7E,
  0x81, 0x81, 0x82, 0x7C, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x04, 0x00, 0x00, 0xFC, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x83, 0x84,
  0x88, 0xB0, 0xD0, 0x88, 0x84, 0x82, 0x81, 0xF0, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0xF7, 0x4C, 0xA2, 0x31, 0x18,
  0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0xBD, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x82, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x78, 0xBD, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xE1, 0xBD, 0x02, 0x04, 0x08, 0x00, 0x3D, 0x43,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xF7,
  0x8C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x00, 0x7D, 0x06,
  0x04, 0x07, 0xC0, 0x40, 0xC1, 0x7C, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC3, 0x7A, 0x83, 0x06, 0x14, 0x24, 0x89, 0x0A, 0x18, 0x10, 0x88,
  0xCC, 0x66, 0x32, 0xAA, 0x55, 0x2A, 0x95, 0x86, 0x42, 0x00, 0x83, 0x09,
  0x21, 0x81, 0x06, 0x12, 0x42, 0x82, 0x81, 0x41, 0x42, 0x42, 0x24, 0x24,
  0x14, 0x18, 0x08, 0x10, 0x10, 0x10, 0x60, 0xFE, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x40, 0xFE, 0x1E, 0x40, 0x81, 0x01, 0x01, 0x02, 0x78, 0x18, 0x10,
  0x41, 0x02, 0x04, 0x08, 0x0F, 0xFF, 0xFF, 0xF0, 0x20, 0x40, 0x82, 0x08,
  0x08, 0x0F, 0x30, 0x80, 0x81, 0x01, 0x02, 0x04, 0x78, 0x70, 0xC8, 0xA2,
  0x50, 0xE0,
};

const GFXglyph IBMPlexMono_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 13, 11, 5, -13 },
  { 3, 3, 5, 11, 4, -13 },
  { 5, 10, 13, 11, 0, -13 },
  { 22, 8, 17, 11, 1, -15 },
  { 39, 10, 13, 11, 0, -13 },
  { 56, 9, 13, 11, 1, -13 },
  { 71, 1, 5, 11, 5, -13 },
  { 72, 4, 16, 11, 4, -14 },
  { 80, 5, 16, 11, 2, -14 },
  { 90, 9, 9, 11, 1, -10 },
  { 101, 9, 9, 11, 1, -10 },
  { 112, 2, 4, 11, 4, -1 },
  { 113, 5, 1, 11, 3, -6 },
  { 114, 1, 1, 11, 5, -1 },
  { 115, 7, 16, 11, 2, -14 },
  { 129, 9, 13, 11, 1, -13 },
  { 144, 8, 13, 11, 2, -13 },
  { 157, 7, 13, 11, 2, -13 },
  { 169, 8, 13, 11, 1, -13 },
  { 182, 9, 13, 11, 1, -13 },
  { 197, 7, 13, 11, 2, -13 },
  { 209, 7, 13, 11, 2, -13 },
  { 221, 8, 13, 11, 1, -13 },
  { 234, 9, 13, 11, 1, -13 },
  { 249, 7, 13, 11, 2, -13 },
  { 261, 1, 9, 11, 5, -9 },
  { 263, 2, 12, 11, 4, -9 },
  { 266, 7, 10, 11, 2, -10 },
  { 275, 9, 5, 11, 1, -8 },
  { 281, 7, 10, 11, 2, -10 },
  { 290, 7, 13, 11, 2, -13 },
  { 302, 7, 15, 11, 2, -13 },
  { 316, 9, 13, 11, 1, -13 },
  { 331, 7, 13, 11, 2, -13 },
  { 343, 8, 13, 11, 1, -13 },
  { 356, 8, 13, 11, 2, -13 },
  { 369, 7, 13, 11, 2, -13 },
  { 381, 7, 13, 11, 2, -13 },
  { 393, 8, 13, 11, 1, -13 },
  { 406, 7, 13, 11, 2, -13 },
  { 418, 7, 13, 11, 2, -13 },
  { 430, 6, 13, 11, 2, -13 },
  { 440, 8, 13, 11, 2, -13 },
  { 453, 7, 13, 11, 3, -13 },
  { 465, 7, 13, 11, 2, -13 },
  { 477, 7, 13, 11, 2, -13 },
  { 489, 9, 13, 11, 1, -13 },
  { 504, 7, 13, 11, 2, -13 },
  { 516, 9, 16, 11, 1, -13 },
  { 534, 7, 13, 11, 2, -13 },
  { 546, 8, 13, 11, 1, -13 },
  { 559, 9, 13, 11, 1, -13 },
  { 574, 7, 13, 11, 2, -13 },
  { 586, 9, 13, 11, 1, -13 },
  { 601, 9, 13, 11, 1, -13 },
  { 616, 9, 13, 11, 1, -13 },
  { 631, 10, 13, 11, 0, -13 },
  { 648, 9, 13, 11, 1, -13 },
  { 663, 4, 16, 11, 5, -14 },
  { 671, 7, 16, 11, 2, -14 },
  { 685, 4, 16, 11, 2, -14 },
  { 693, 9, 7, 11, 1, -13 },
  { 701, 9, 1, 11, 1, 2 },
  { 703, 2, 3, 11, 4, -14 },
  { 704, 9, 9, 11, 1, -9 },
  { 715, 7, 13, 11, 2, -13 },
  { 727, 7, 9, 11, 2, -9 },
  { 735, 8, 13, 11, 1, -13 },
  { 748, 7, 9, 11, 2, -9 },
  { 756, 8, 13, 11, 2, -13 },
  { 769, 8, 15, 11, 2, -11 },
  { 784, 7, 13, 11, 2, -13 },
  { 796, 8, 13, 11, 2, -13 },
  { 809, 6, 17, 11, 2, -13 },
  { 822, 8, 13, 11, 2, -13 },
  { 835, 7, 13, 11, 2, -13 },
  { 847, 9, 9, 11, 1, -9 },
  { 858, 7, 9, 11, 2, -9 },
  { 866, 7, 9, 11, 2, -9 },
  { 874, 7, 13, 11, 2, -9 },
  { 886, 8, 13, 11, 1, -9 },
  { 899, 9, 9, 11, 1, -9 },
  { 910, 7, 9, 11, 2, -9 },
  { 918, 8, 13, 11, 1, -13 },
  { 931, 7, 9, 11, 2, -9 },
  { 939, 7, 9, 11, 2, -9 },
  { 947, 9, 9, 11, 1, -9 },
  { 958, 7, 9, 11, 2, -9 },
  { 966, 8, 13, 11, 1, -9 },
  { 979, 7, 9, 11, 2, -9 },
  { 987, 7, 16, 11, 2, -14 },
  { 1001, 1, 16, 11, 5, -14 },
  { 1003, 7, 16, 11, 2, -14 },
  { 1017, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_Thin18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_THIN18PT7B_H_
