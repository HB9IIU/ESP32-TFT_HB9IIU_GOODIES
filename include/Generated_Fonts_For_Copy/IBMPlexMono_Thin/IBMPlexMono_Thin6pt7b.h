#ifndef _IBMPLEXMONO_THIN6PT7B_H_
#define _IBMPLEXMONO_THIN6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0x80, 0x7A, 0xE0, 0x5F, 0x3E, 0x80, 0xFB, 0xF0, 0xF3, 0xF0,
  0x80, 0x6A, 0xB0, 0xFC, 0x5E, 0x80, 0x5D, 0x00, 0x80, 0xC0, 0x00, 0x5A,
  0xA0, 0xF6, 0xF0, 0xAB, 0xDB, 0x65, 0xF0, 0x3E, 0xB0, 0xF1, 0xF0, 0xAF,
  0xE9, 0x40, 0xF7, 0xF0, 0xF6, 0x00, 0x10, 0xE4, 0xE0, 0x98, 0xDA, 0xFE,
  0xC0, 0x59, 0xD0, 0xFF, 0xF2, 0x70, 0xFF, 0xEF, 0xEE, 0xF2, 0xF0, 0xFF,
  0xEB, 0xD7, 0xEB, 0xAB, 0xFF, 0xFF, 0xF6, 0xF0, 0xFA, 0xF6, 0xD6, 0xFB,
  0xF1, 0xF0, 0xE9, 0x20, 0xFF, 0xB7, 0x20, 0xBF, 0xD0, 0xAB, 0x50, 0xB9,
  0x20, 0xEA, 0x70, 0xFC, 0xAA, 0x90, 0xFC, 0xD4, 0xE0, 0x80, 0xFF, 0x80,
  0xBF, 0xEC, 0x3E, 0xF0, 0xEC, 0x7D, 0x30, 0xFB, 0xBF, 0x2B, 0x75, 0xC0,
  0xBB, 0xAB, 0xFF, 0x80, 0xFC, 0xFC, 0xFE, 0xF6, 0xB0, 0xEB, 0x80, 0xDC,
  0x5D, 0x30, 0xFC, 0xE8, 0xFE, 0x80, 0xEC, 0xB9, 0x20, 0xEC, 0x6A, 0xB0,
  0xFC, 0xAB, 0xA0, 0xE0,
};

const GFXglyph IBMPlexMono_Thin6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 1, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -3 },
  { 18, 3, 3, 4, 0, -3 },
  { 20, 1, 1, 4, 1, 0 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 2, 6, 4, 1, -5 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 2, 4, 4, 1, -4 },
  { 28, 2, 4, 4, 1, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 2, 4, 4, 1, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 2, 4, 4, 1, -4 },
  { 41, 1, 3, 4, 1, -3 },
  { 42, 1, 4, 4, 1, -3 },
  { 43, 2, 3, 4, 1, -3 },
  { 44, 3, 1, 4, 0, -2 },
  { 45, 2, 3, 4, 1, -3 },
  { 46, 2, 4, 4, 1, -4 },
  { 47, 2, 5, 4, 1, -4 },
  { 49, 3, 4, 4, 0, -4 },
  { 51, 2, 4, 4, 1, -4 },
  { 52, 3, 4, 4, 0, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 4, 4, 1, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 2, 4, 4, 1, -4 },
  { 69, 3, 5, 4, 0, -4 },
  { 71, 2, 4, 4, 1, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 2, 4, 4, 1, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 1, 6, 4, 2, -5 },
  { 88, 2, 6, 4, 1, -5 },
  { 90, 1, 6, 4, 1, -5 },
  { 91, 3, 2, 4, 0, -4 },
  { 92, 3, 1, 4, 0, 0 },
  { 93, 1, 1, 4, 1, -5 },
  { 94, 3, 3, 4, 0, -3 },
  { 96, 2, 4, 4, 1, -4 },
  { 97, 2, 3, 4, 1, -3 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 2, 3, 4, 1, -3 },
  { 101, 3, 4, 4, 0, -4 },
  { 103, 2, 4, 4, 1, -3 },
  { 104, 2, 4, 4, 1, -4 },
  { 105, 2, 4, 4, 1, -4 },
  { 106, 2, 5, 4, 1, -4 },
  { 108, 2, 4, 4, 1, -4 },
  { 109, 2, 4, 4, 1, -4 },
  { 110, 3, 3, 4, 0, -3 },
  { 112, 2, 3, 4, 1, -3 },
  { 113, 2, 3, 4, 1, -3 },
  { 114, 2, 4, 4, 1, -3 },
  { 115, 3, 4, 4, 0, -3 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 2, 3, 4, 1, -3 },
  { 120, 3, 4, 4, 0, -4 },
  { 122, 2, 3, 4, 1, -3 },
  { 123, 2, 3, 4, 1, -3 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 2, 3, 4, 1, -3 },
  { 127, 3, 4, 4, 0, -3 },
  { 129, 2, 3, 4, 1, -3 },
  { 130, 2, 6, 4, 1, -5 },
  { 132, 1, 6, 4, 1, -5 },
  { 133, 2, 6, 4, 1, -5 },
  { 135, 3, 1, 4, 0, -2 },
};

const GFXfont IBMPlexMono_Thin6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_THIN6PT7B_H_
