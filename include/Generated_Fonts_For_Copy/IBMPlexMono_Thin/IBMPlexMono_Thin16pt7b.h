#ifndef _IBMPLEXMONO_THIN16PT7B_H_
#define _IBMPLEXMONO_THIN16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xFF, 0x1A, 0x09, 0x04, 0x8E, 0x71, 0x20, 0xA0, 0x91,
  0xC7, 0x24, 0x12, 0x09, 0x00, 0x10, 0x20, 0xF6, 0x99, 0x12, 0x14, 0x1E,
  0x12, 0x26, 0x4A, 0x93, 0xC2, 0x04, 0x00, 0x70, 0xC4, 0xA2, 0x51, 0x47,
  0x40, 0x00, 0xDC, 0x51, 0x48, 0xA4, 0x61, 0xC0, 0x38, 0x48, 0x84, 0x80,
  0x40, 0x63, 0x94, 0x8C, 0x84, 0x86, 0x7B, 0xF0, 0x2A, 0x49, 0x24, 0x92,
  0x44, 0x40, 0x84, 0x22, 0x21, 0x11, 0x12, 0x22, 0x48, 0x10, 0x10, 0x10,
  0xD3, 0x3C, 0x28, 0x44, 0x46, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0xF0, 0xF0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41,
  0x08, 0x20, 0x82, 0x00, 0x3C, 0x86, 0x0C, 0x18, 0x32, 0x60, 0xC1, 0x82,
  0x84, 0xF0, 0x10, 0x30, 0x50, 0x90, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x7F, 0x3C, 0x8A, 0x08, 0x10, 0x20, 0x82, 0x08, 0x21, 0x83, 0xF8, 0x3C,
  0x8A, 0x08, 0x23, 0x80, 0x80, 0x81, 0x83, 0x09, 0xE0, 0x04, 0x0C, 0x14,
  0x24, 0x44, 0x84, 0x84, 0xFF, 0x04, 0x04, 0x04, 0x7F, 0x02, 0x04, 0x0B,
  0xC8, 0x40, 0x81, 0x82, 0x84, 0xF0, 0x18, 0x41, 0x02, 0x0B, 0xC8, 0x60,
  0xC1, 0x82, 0x84, 0xF0, 0xFF, 0x06, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10,
  0x40, 0x80, 0x3C, 0x86, 0x0C, 0x14, 0x27, 0xB1, 0xC1, 0x83, 0x05, 0xF0,
  0x3C, 0x86, 0x0C, 0x18, 0x28, 0x4F, 0x82, 0x04, 0x10, 0xC0, 0x81, 0x81,
  0xE0, 0x02, 0x18, 0x43, 0x08, 0x08, 0x0C, 0x04, 0x06, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x86, 0x10, 0xC0, 0x7A, 0x18, 0x41,
  0x08, 0x42, 0x08, 0x00, 0x02, 0x00, 0x3C, 0x8A, 0x0C, 0xFA, 0x74, 0x68,
  0xD1, 0xA7, 0x3E, 0x02, 0x03, 0xE0, 0x10, 0x28, 0x28, 0x28, 0x44, 0x44,
  0x44, 0x7E, 0x82, 0x82, 0x81, 0xFA, 0x18, 0x61, 0x8B, 0xE8, 0x61, 0x86,
  0x1F, 0x80, 0x3C, 0x86, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x84, 0xF0,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0xFE, 0x08, 0x20,
  0x83, 0xF8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20,
  0x82, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x23, 0xC1, 0x82, 0x84,
  0xF8, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x40, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x78, 0x42, 0x10, 0x84,
  0x21, 0x8C, 0x5C, 0x87, 0x12, 0x44, 0x8A, 0x1C, 0x24, 0x48, 0x89, 0x0A,
  0x18, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x83, 0x8F,
  0x1D, 0x5A, 0xB2, 0x64, 0xC1, 0x83, 0x06, 0x08, 0x86, 0x18, 0x71, 0xC6,
  0x99, 0x65, 0x8E, 0x38, 0x40, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x84, 0xF0, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x08, 0x00,
  0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0x81, 0x01,
  0xC0, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA8, 0x92, 0x28, 0x40, 0x3D, 0x86,
  0x04, 0x04, 0x07, 0x80, 0x81, 0x82, 0x84, 0xF0, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x17, 0x80, 0x81, 0x82, 0x82, 0x82, 0x44, 0x44, 0x44, 0x28,
  0x28, 0x28, 0x10, 0x81, 0x81, 0x82, 0x92, 0xB2, 0xAA, 0xAA, 0xAA, 0xC6,
  0xC2, 0x42, 0x83, 0x82, 0x44, 0x28, 0x28, 0x10, 0x28, 0x28, 0x44, 0x82,
  0x83, 0x80, 0xA0, 0x90, 0x44, 0x41, 0x40, 0xA0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0xFE, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80, 0x80,
  0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x82, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x93,
  0xC0, 0x10, 0x28, 0x48, 0x44, 0x82, 0x83, 0xFF, 0xA4, 0x78, 0x04, 0x04,
  0x7C, 0x84, 0x84, 0x84, 0x7B, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86,
  0x18, 0x7E, 0x7A, 0x28, 0x60, 0x82, 0x18, 0x9C, 0x02, 0x04, 0x08, 0x13,
  0xA8, 0xE0, 0xC1, 0x83, 0x05, 0x09, 0xF0, 0x3C, 0x86, 0x0F, 0xF8, 0x10,
  0x10, 0x9E, 0x0F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFE, 0x03, 0x04, 0x3C, 0x42, 0x42, 0x42, 0x44, 0x78, 0x40, 0x7E,
  0x81, 0x81, 0x7E, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x10, 0x00, 0x07, 0x02, 0x04, 0x08, 0x10, 0x20, 0x43, 0xF8, 0x08, 0x01,
  0xF0, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x81, 0x02, 0x04, 0x08, 0x71,
  0x24, 0x70, 0x91, 0x12, 0x14, 0x10, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x47, 0xF0, 0xE7, 0x36, 0x4C, 0x99, 0x32, 0x64, 0xC9,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x50,
  0x9E, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x00, 0x3A, 0x8E,
  0x0C, 0x18, 0x30, 0x50, 0x9F, 0x02, 0x04, 0x08, 0xE7, 0x38, 0x30, 0x20,
  0x20, 0x20, 0x20, 0xFE, 0x3D, 0x86, 0x03, 0xC0, 0x60, 0x60, 0xBE, 0x20,
  0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x5F, 0x83, 0x05, 0x12, 0x22, 0x85, 0x0A, 0x08, 0x91, 0xB1,
  0xA9, 0xAA, 0xAA, 0xCA, 0xC6, 0xC2, 0x82, 0x88, 0xA0, 0x83, 0x05, 0x11,
  0x41, 0x83, 0x05, 0x12, 0x22, 0x85, 0x0C, 0x08, 0x10, 0x43, 0x80, 0xFC,
  0x21, 0x08, 0x42, 0x08, 0x3F, 0x3C, 0x82, 0x08, 0x10, 0x4E, 0x0C, 0x10,
  0x82, 0x08, 0x20, 0xF0, 0xFF, 0xFC, 0xE0, 0x82, 0x08, 0x41, 0x03, 0xD8,
  0x41, 0x02, 0x08, 0x23, 0x80, 0x61, 0x92, 0x8E,
};

const GFXglyph IBMPlexMono_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 1, 11, 10, 4, -11 },
  { 3, 2, 4, 10, 4, -12 },
  { 4, 9, 11, 10, 0, -11 },
  { 17, 7, 15, 10, 1, -13 },
  { 31, 9, 11, 10, 0, -11 },
  { 44, 8, 11, 10, 1, -11 },
  { 55, 1, 4, 10, 4, -12 },
  { 56, 3, 14, 10, 4, -12 },
  { 62, 4, 14, 10, 2, -12 },
  { 69, 8, 8, 10, 1, -9 },
  { 77, 8, 9, 10, 1, -9 },
  { 86, 1, 4, 10, 4, -1 },
  { 87, 4, 1, 10, 3, -5 },
  { 88, 1, 1, 10, 4, -1 },
  { 89, 6, 14, 10, 2, -12 },
  { 100, 7, 11, 10, 1, -11 },
  { 110, 8, 11, 10, 1, -11 },
  { 121, 7, 11, 10, 1, -11 },
  { 131, 7, 11, 10, 1, -11 },
  { 141, 8, 11, 10, 1, -11 },
  { 152, 7, 11, 10, 1, -11 },
  { 162, 7, 11, 10, 1, -11 },
  { 172, 7, 11, 10, 1, -11 },
  { 182, 7, 11, 10, 1, -11 },
  { 192, 7, 11, 10, 1, -11 },
  { 202, 1, 8, 10, 4, -8 },
  { 203, 1, 11, 10, 4, -8 },
  { 205, 7, 9, 10, 1, -9 },
  { 213, 8, 4, 10, 1, -7 },
  { 217, 7, 9, 10, 1, -9 },
  { 225, 6, 11, 10, 2, -11 },
  { 234, 7, 13, 10, 1, -11 },
  { 246, 8, 11, 10, 1, -11 },
  { 257, 6, 11, 10, 2, -11 },
  { 266, 7, 11, 10, 1, -11 },
  { 276, 6, 11, 10, 2, -11 },
  { 285, 6, 11, 10, 2, -11 },
  { 294, 6, 11, 10, 2, -11 },
  { 303, 7, 11, 10, 1, -11 },
  { 313, 6, 11, 10, 2, -11 },
  { 322, 7, 11, 10, 1, -11 },
  { 332, 5, 11, 10, 2, -11 },
  { 339, 7, 11, 10, 2, -11 },
  { 349, 6, 11, 10, 2, -11 },
  { 358, 7, 11, 10, 1, -11 },
  { 368, 6, 11, 10, 2, -11 },
  { 377, 7, 11, 10, 1, -11 },
  { 387, 6, 11, 10, 2, -11 },
  { 396, 7, 14, 10, 1, -11 },
  { 409, 6, 11, 10, 2, -11 },
  { 418, 7, 11, 10, 1, -11 },
  { 428, 8, 11, 10, 1, -11 },
  { 439, 6, 11, 10, 2, -11 },
  { 448, 8, 11, 10, 1, -11 },
  { 459, 8, 11, 10, 1, -11 },
  { 470, 8, 11, 10, 1, -11 },
  { 481, 9, 11, 10, 0, -11 },
  { 494, 8, 11, 10, 1, -11 },
  { 505, 4, 14, 10, 4, -12 },
  { 512, 6, 14, 10, 2, -12 },
  { 523, 3, 14, 10, 2, -12 },
  { 529, 8, 6, 10, 1, -11 },
  { 535, 8, 1, 10, 1, 2 },
  { 536, 2, 3, 10, 3, -13 },
  { 537, 8, 8, 10, 1, -8 },
  { 545, 6, 12, 10, 2, -12 },
  { 554, 6, 8, 10, 2, -8 },
  { 560, 7, 12, 10, 1, -12 },
  { 571, 7, 8, 10, 1, -8 },
  { 578, 8, 12, 10, 1, -12 },
  { 590, 8, 13, 10, 1, -10 },
  { 603, 6, 12, 10, 2, -12 },
  { 612, 7, 11, 10, 2, -11 },
  { 622, 5, 14, 10, 2, -11 },
  { 631, 7, 12, 10, 2, -12 },
  { 642, 7, 12, 10, 1, -12 },
  { 653, 7, 8, 10, 1, -8 },
  { 660, 6, 8, 10, 2, -8 },
  { 666, 7, 8, 10, 1, -8 },
  { 673, 6, 11, 10, 2, -8 },
  { 682, 7, 11, 10, 1, -8 },
  { 692, 8, 8, 10, 1, -8 },
  { 700, 7, 8, 10, 1, -8 },
  { 707, 7, 11, 10, 1, -11 },
  { 717, 6, 8, 10, 2, -8 },
  { 723, 7, 8, 10, 1, -8 },
  { 730, 8, 8, 10, 1, -8 },
  { 738, 7, 8, 10, 1, -8 },
  { 745, 7, 11, 10, 1, -8 },
  { 755, 6, 8, 10, 2, -8 },
  { 761, 6, 14, 10, 2, -12 },
  { 772, 1, 14, 10, 4, -12 },
  { 774, 6, 14, 10, 2, -12 },
  { 785, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Thin16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_THIN16PT7B_H_
