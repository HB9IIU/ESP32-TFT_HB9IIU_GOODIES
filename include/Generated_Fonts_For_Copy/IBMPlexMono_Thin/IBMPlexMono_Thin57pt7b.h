#ifndef _IBMPLEXMONO_THIN57PT7B_H_
#define _IBMPLEXMONO_THIN57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x62, 0x22, 0x22,
  0x22, 0x22, 0x24, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0C, 0x00, 0x02, 0x00, 0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x04, 0x01, 0x00, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x08, 0x02, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x10, 0x04,
  0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x20, 0x08,
  0x00, 0x00, 0x20, 0x08, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0E, 0x10, 0xE0, 0x0C, 0x04, 0x0E, 0x06, 0x01,
  0x00, 0xC3, 0x00, 0x40, 0x19, 0x80, 0x10, 0x02, 0x40, 0x04, 0x00, 0x10,
  0x01, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x40, 0x04, 0x00,
  0x10, 0x01, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x20, 0x04,
  0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x10, 0x00, 0x03,
  0x84, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0xE0,
  0x00, 0x04, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x10,
  0x02, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00, 0x30, 0x00, 0x40, 0x04, 0x00,
  0x10, 0x01, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x40, 0x04,
  0x00, 0x10, 0x03, 0x80, 0x04, 0x00, 0xB0, 0x01, 0x00, 0x26, 0x00, 0x40,
  0x10, 0xC0, 0x10, 0x08, 0x0C, 0x04, 0x0C, 0x01, 0xE1, 0x0E, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0x30, 0x70, 0x00, 0x08, 0xC0, 0x30, 0x00, 0x23, 0x00, 0x20,
  0x00, 0xC4, 0x00, 0x20, 0x01, 0x18, 0x00, 0x40, 0x04, 0x20, 0x00, 0x80,
  0x08, 0x40, 0x01, 0x80, 0x20, 0x80, 0x03, 0x00, 0xC1, 0x00, 0x06, 0x01,
  0x02, 0x00, 0x0C, 0x04, 0x04, 0x00, 0x18, 0x08, 0x08, 0x00, 0x20, 0x20,
  0x08, 0x00, 0x40, 0xC0, 0x10, 0x00, 0x81, 0x00, 0x30, 0x02, 0x04, 0x00,
  0x30, 0x0C, 0x08, 0x00, 0x30, 0x70, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x30, 0x18, 0x30, 0x00, 0x40, 0x40, 0x10, 0x01,
  0x01, 0x00, 0x10, 0x02, 0x06, 0x00, 0x20, 0x08, 0x08, 0x00, 0x60, 0x30,
  0x10, 0x00, 0x40, 0x40, 0x20, 0x00, 0x81, 0x00, 0xC0, 0x01, 0x02, 0x01,
  0x80, 0x02, 0x08, 0x03, 0x00, 0x04, 0x30, 0x02, 0x00, 0x08, 0x40, 0x04,
  0x00, 0x11, 0x00, 0x08, 0x00, 0x62, 0x00, 0x18, 0x00, 0x88, 0x00, 0x10,
  0x01, 0x30, 0x00, 0x10, 0x04, 0x40, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x1F, 0x84, 0x0C, 0x00, 0x80, 0x40, 0x20, 0x04,
  0x06, 0x00, 0x80, 0x20, 0x20, 0x02, 0x01, 0x03, 0x00, 0x08, 0x08, 0x10,
  0x00, 0x60, 0x40, 0x80, 0x01, 0x82, 0x0C, 0x00, 0x06, 0x30, 0x60, 0x00,
  0x11, 0x03, 0x00, 0x00, 0x48, 0x18, 0x00, 0x01, 0x40, 0x40, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x13, 0x02,
  0x00, 0x01, 0x8C, 0x08, 0x00, 0x18, 0x30, 0x30, 0x01, 0x00, 0xC0, 0xE0,
  0x30, 0x02, 0x01, 0xFE, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x04,
  0xF0, 0x04, 0x01, 0xD0, 0xF0, 0x20, 0xF0, 0x00, 0xF1, 0x3C, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x61,
  0x8C, 0x30, 0xC3, 0x18, 0x61, 0x84, 0x10, 0xC2, 0x00, 0xFF, 0xFE, 0x7F,
  0xF7, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x08,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x08, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x07, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x40, 0x00, 0x03, 0x10,
  0x00, 0x01, 0x84, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60,
  0x10, 0x00, 0x30, 0x04, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x03, 0x80, 0xE0, 0x03, 0x00, 0x08, 0x02, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x61, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x08, 0x18, 0x00, 0x30,
  0x07, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x08, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x04,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x1F, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0xFF, 0x00, 0x23, 0x00, 0xE0, 0x2C,
  0x00, 0x30, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x04, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x07,
  0x00, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0xFF, 0x00, 0x43, 0x00, 0xC0, 0x4C,
  0x00, 0x30, 0x58, 0x00, 0x18, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x04, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x20,
  0x00, 0x10, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x08, 0x08, 0x00, 0x04, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x70, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x05,
  0x30, 0x00, 0x05, 0x18, 0x00, 0x0B, 0x0C, 0x00, 0x32, 0x03, 0x80, 0xE2,
  0x00, 0xFF, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x1C, 0xF3, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC6, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x41, 0x0C, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x07, 0x01, 0x80, 0x06, 0x0C, 0x00,
  0x04, 0x20, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x60, 0x00, 0x80, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x14, 0x00, 0x7E, 0x28, 0x03, 0x06, 0x50, 0x08, 0x02, 0xA0,
  0x30, 0x03, 0x40, 0x40, 0x07, 0x81, 0x80, 0x07, 0x02, 0x00, 0x0E, 0x04,
  0x00, 0x1C, 0x08, 0x00, 0x38, 0x10, 0x00, 0x70, 0x20, 0x00, 0xE0, 0x40,
  0x01, 0xC0, 0x80, 0x03, 0x81, 0x00, 0x07, 0x02, 0x00, 0x0E, 0x04, 0x00,
  0x1C, 0x08, 0x00, 0x38, 0x10, 0x00, 0x50, 0x10, 0x00, 0xA0, 0x20, 0x03,
  0x40, 0x20, 0x0A, 0x80, 0x60, 0x25, 0x00, 0x3F, 0x8A, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xE0,
  0x0C, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0x00, 0x03, 0x82, 0x00, 0x01, 0x84, 0x00, 0x01,
  0x88, 0x00, 0x01, 0x10, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x0C, 0x80,
  0x00, 0x31, 0x00, 0x00, 0xC2, 0x00, 0x07, 0x07, 0xFF, 0xFC, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x03, 0x20, 0x00, 0x02, 0x40, 0x00, 0x02, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x90,
  0x00, 0x03, 0x20, 0x00, 0x18, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x80, 0x03, 0x80, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x60, 0x80, 0x03, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x80, 0x00, 0x80, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x98, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x63, 0x00, 0x00, 0x50, 0x80, 0x00,
  0x28, 0x20, 0x00, 0x24, 0x0C, 0x00, 0x62, 0x03, 0x80, 0xE1, 0x00, 0x3F,
  0xC0, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x22, 0x00, 0x03, 0x18, 0x00,
  0x30, 0x60, 0x03, 0x00, 0xC0, 0x70, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x90, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x81, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0x80,
  0x40, 0x00, 0x40, 0x60, 0x00, 0x20, 0x58, 0x00, 0x10, 0x66, 0x00, 0x08,
  0x61, 0x00, 0x04, 0x60, 0xC0, 0x02, 0x60, 0x30, 0x01, 0x60, 0x08, 0x00,
  0xA0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0x40, 0x10, 0x00, 0x30,
  0x08, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x64, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xA0, 0x00,
  0x07, 0xA0, 0x00, 0x05, 0xB0, 0x00, 0x05, 0x90, 0x00, 0x09, 0x98, 0x00,
  0x09, 0x88, 0x00, 0x19, 0x88, 0x00, 0x11, 0x84, 0x00, 0x31, 0x84, 0x00,
  0x21, 0x82, 0x00, 0x61, 0x82, 0x00, 0x41, 0x83, 0x00, 0x41, 0x81, 0x00,
  0x81, 0x81, 0x80, 0x81, 0x80, 0x81, 0x01, 0x80, 0xC1, 0x01, 0x80, 0x43,
  0x01, 0x80, 0x42, 0x01, 0x80, 0x26, 0x01, 0x80, 0x24, 0x01, 0x80, 0x34,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1D, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x72, 0x00, 0x00, 0xE6, 0x00, 0x01,
  0xC4, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x08, 0x00, 0x0E, 0x08, 0x00, 0x1C,
  0x10, 0x00, 0x38, 0x10, 0x00, 0x70, 0x20, 0x00, 0xE0, 0x20, 0x01, 0xC0,
  0x40, 0x03, 0x80, 0x40, 0x07, 0x00, 0x80, 0x0E, 0x00, 0x80, 0x1C, 0x01,
  0x80, 0x38, 0x01, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x02, 0x01, 0xC0, 0x06,
  0x03, 0x80, 0x04, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x08, 0x1C, 0x00, 0x18,
  0x38, 0x00, 0x10, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x21, 0xC0, 0x00, 0x63,
  0x80, 0x00, 0x47, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x9C, 0x00, 0x01, 0xB8,
  0x00, 0x01, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x7F, 0x80, 0x00, 0x70, 0x38, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x08, 0x00, 0x06, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x08, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x07, 0x01, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x70, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x38, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x08, 0x00, 0x06, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x08, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x07, 0x01, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x70, 0xFF, 0xFF, 0xC0, 0x80, 0x10, 0x00, 0x80, 0x18, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x80, 0x06, 0x00, 0x80, 0x02, 0x00, 0x80, 0x03,
  0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x40, 0x80, 0x00, 0x20, 0x80, 0x00, 0x30, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x03, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x46, 0x00, 0x01, 0x86, 0x00, 0x02, 0x06, 0x00,
  0x08, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x10, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x20, 0x02, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x20, 0x06, 0x00,
  0x22, 0x00, 0x60, 0x06, 0x20, 0x07, 0x00, 0x62, 0x00, 0xD0, 0x04, 0x20,
  0x09, 0x00, 0x42, 0x00, 0x98, 0x04, 0x20, 0x18, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x43, 0x01, 0x0C, 0x04, 0x30, 0x20, 0x40, 0x41,
  0x02, 0x04, 0x0C, 0x10, 0x20, 0x60, 0xC1, 0x06, 0x02, 0x08, 0x10, 0x40,
  0x20, 0x81, 0x04, 0x02, 0x08, 0x10, 0x40, 0x10, 0x81, 0x08, 0x01, 0x08,
  0x10, 0x80, 0x10, 0x81, 0x88, 0x01, 0x88, 0x19, 0x80, 0x08, 0x80, 0x90,
  0x00, 0x98, 0x09, 0x00, 0x0D, 0x80, 0xB0, 0x00, 0x50, 0x0A, 0x00, 0x05,
  0x00, 0xA0, 0x00, 0x50, 0x0A, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x04, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x01,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x18, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x04, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x08, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x04, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x40, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x04, 0x00, 0x08, 0x03, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x40, 0x40, 0x00, 0x08, 0x30, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x81, 0x81, 0x81, 0x01, 0x03, 0x03, 0x02,
  0x02, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x10, 0x00, 0x10, 0x08, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x07, 0xFF, 0xE0, 0x0E, 0x00, 0x08, 0x04, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00,
  0x06, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0xA0, 0x30, 0x00, 0xC8, 0x03,
  0x00, 0xE1, 0xF0, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x1F, 0xC0, 0x10, 0xC0, 0x70, 0x26, 0x00,
  0x30, 0x48, 0x00, 0x10, 0xA0, 0x00, 0x11, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01,
  0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x28, 0x00, 0x04, 0x48, 0x00,
  0x10, 0x98, 0x00, 0xC1, 0x0C, 0x07, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x40, 0x00, 0xC1, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0x40, 0x00, 0x30, 0x40, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x70, 0x18,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0xFE, 0x04, 0x1C, 0x06, 0x10, 0xC0, 0x06, 0x46, 0x00, 0x0D,
  0x30, 0x00, 0x14, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x80, 0x00,
  0x33, 0x00, 0x01, 0x46, 0x00, 0x0D, 0x0C, 0x00, 0x64, 0x1C, 0x06, 0x10,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x80, 0xC0, 0x04, 0x00, 0x30,
  0x08, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x02, 0x20, 0x00, 0x02, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C,
  0x08, 0x00, 0x18, 0x06, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x40, 0x00, 0xC0,
  0x68, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x20, 0x02, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x60, 0x10, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x10, 0x08, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x08, 0x04,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x08, 0x01, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x0F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x1F, 0xC0, 0x43, 0x01, 0xC2, 0x60, 0x03, 0x16, 0x00, 0x0C, 0xA0,
  0x00, 0x26, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x7F, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x20, 0x80, 0x00, 0x40, 0x80, 0x01, 0x80, 0x80, 0x03, 0x00,
  0x80, 0x06, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x80, 0x20, 0x00,
  0x80, 0xC0, 0x00, 0x81, 0x80, 0x00, 0x83, 0x40, 0x00, 0x86, 0x60, 0x00,
  0x88, 0x30, 0x00, 0x90, 0x18, 0x00, 0xA0, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x80, 0x02, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x7E, 0x22, 0x0C, 0x20, 0xCB, 0x01, 0x90,
  0x0A, 0x80, 0x28, 0x02, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00, 0x18,
  0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00,
  0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01,
  0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x60,
  0x01, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00,
  0x60, 0x01, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x80, 0x04,
  0x00, 0x60, 0x01, 0x00, 0x10, 0x01, 0xFC, 0x04, 0x30, 0x1C, 0x26, 0x00,
  0x31, 0x60, 0x00, 0xCA, 0x00, 0x02, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x58,
  0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0xFF, 0x00, 0x03, 0x80, 0xC0, 0x04, 0x00, 0x30, 0x08, 0x00, 0x18,
  0x10, 0x00, 0x08, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x10, 0x00, 0x08, 0x08, 0x00, 0x18,
  0x04, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x01,
  0x0C, 0x07, 0x02, 0x60, 0x03, 0x04, 0x80, 0x01, 0x0A, 0x00, 0x01, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00,
  0xA0, 0x00, 0x01, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x32,
  0x80, 0x00, 0x44, 0x80, 0x01, 0x09, 0x80, 0x0C, 0x10, 0xC0, 0x70, 0x20,
  0x7F, 0x80, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1C, 0x06,
  0x10, 0xC0, 0x06, 0x46, 0x00, 0x0D, 0x30, 0x00, 0x14, 0x80, 0x00, 0x34,
  0x00, 0x00, 0xD0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00,
  0x01, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x33, 0x00, 0x01, 0x46, 0x00, 0x0D,
  0x0C, 0x00, 0x64, 0x1C, 0x06, 0x10, 0x0F, 0xE0, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0xFF, 0xE0, 0x7F, 0xE0, 0x04, 0x70, 0x00, 0x00, 0x98, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0x00, 0xE0, 0x08, 0x00, 0x18, 0x10,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x7F, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x05,
  0x20, 0x00, 0x53, 0x00, 0x19, 0x0C, 0x07, 0x10, 0x3F, 0x80, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00,
  0x04, 0x30, 0x00, 0x04, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x08, 0x00,
  0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x30, 0x04, 0x00,
  0x20, 0x06, 0x00, 0x20, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x01, 0x00,
  0xC0, 0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x81, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x34, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x28, 0x00,
  0xD0, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x26,
  0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x80, 0x42, 0x01, 0x82, 0x01, 0x0C, 0x04, 0x08, 0x04, 0x10, 0x10,
  0x20, 0x10, 0x40, 0x40, 0xC0, 0x81, 0x03, 0x01, 0x02, 0x04, 0x08, 0x04,
  0x08, 0x10, 0x20, 0x10, 0x20, 0x20, 0x80, 0x20, 0x80, 0x84, 0x00, 0x86,
  0x02, 0x10, 0x02, 0x10, 0x08, 0x40, 0x08, 0x40, 0x21, 0x00, 0x11, 0x00,
  0xC8, 0x00, 0x44, 0x01, 0x20, 0x01, 0x30, 0x04, 0x80, 0x06, 0x80, 0x16,
  0x00, 0x0A, 0x00, 0x50, 0x00, 0x28, 0x01, 0xC0, 0x00, 0xA0, 0x03, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x40, 0x01, 0x00, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x24, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC1, 0x00, 0x01,
  0x81, 0x80, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0C,
  0x00, 0x30, 0x08, 0x00, 0x18, 0x10, 0x00, 0x08, 0x20, 0x00, 0x04, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x08, 0x18, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08,
  0x00, 0x10, 0x04, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00,
  0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x26, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x10, 0xC6, 0x00, 0x01, 0x10, 0x10, 0x00, 0x22, 0x00,
  0x80, 0x02, 0x20, 0x04, 0x00, 0x26, 0x00, 0x20, 0x04, 0x40, 0x01, 0x00,
  0x44, 0x00, 0x08, 0x08, 0x40, 0x00, 0x61, 0x08, 0x00, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 4, 40, 34, 15, -40 },
  { 21, 9, 14, 34, 13, -42 },
  { 37, 32, 40, 34, 1, -40 },
  { 197, 26, 53, 34, 4, -46 },
  { 370, 31, 41, 34, 2, -40 },
  { 529, 29, 41, 34, 2, -40 },
  { 678, 2, 14, 34, 16, -42 },
  { 682, 13, 51, 34, 14, -43 },
  { 765, 13, 51, 34, 8, -43 },
  { 848, 29, 28, 34, 3, -31 },
  { 950, 27, 27, 34, 4, -31 },
  { 1042, 6, 14, 34, 13, -4 },
  { 1053, 15, 1, 34, 10, -18 },
  { 1055, 4, 4, 34, 15, -4 },
  { 1057, 22, 51, 34, 6, -43 },
  { 1198, 26, 41, 34, 4, -40 },
  { 1332, 26, 40, 34, 5, -40 },
  { 1462, 25, 40, 34, 5, -40 },
  { 1587, 24, 41, 34, 4, -40 },
  { 1710, 28, 40, 34, 3, -40 },
  { 1850, 24, 41, 34, 5, -40 },
  { 1973, 24, 41, 34, 5, -40 },
  { 2096, 25, 40, 34, 4, -40 },
  { 2221, 26, 41, 34, 4, -40 },
  { 2355, 24, 40, 34, 5, -40 },
  { 2475, 4, 30, 34, 15, -30 },
  { 2490, 6, 40, 34, 13, -30 },
  { 2520, 24, 30, 34, 5, -32 },
  { 2610, 27, 11, 34, 4, -23 },
  { 2648, 24, 30, 34, 5, -32 },
  { 2738, 22, 40, 34, 6, -40 },
  { 2848, 23, 46, 34, 5, -40 },
  { 2981, 28, 40, 34, 3, -40 },
  { 3121, 23, 40, 34, 6, -40 },
  { 3236, 26, 41, 34, 4, -40 },
  { 3370, 24, 40, 34, 6, -40 },
  { 3490, 23, 40, 34, 6, -40 },
  { 3605, 24, 40, 34, 6, -40 },
  { 3725, 25, 41, 34, 4, -40 },
  { 3854, 23, 40, 34, 6, -40 },
  { 3969, 24, 40, 34, 5, -40 },
  { 4089, 21, 41, 34, 5, -40 },
  { 4197, 25, 40, 34, 6, -40 },
  { 4322, 22, 40, 34, 8, -40 },
  { 4432, 24, 40, 34, 5, -40 },
  { 4552, 23, 40, 34, 6, -40 },
  { 4667, 26, 41, 34, 4, -40 },
  { 4801, 24, 40, 34, 6, -40 },
  { 4921, 26, 48, 34, 4, -40 },
  { 5077, 24, 40, 34, 6, -40 },
  { 5197, 26, 41, 34, 4, -40 },
  { 5331, 30, 40, 34, 2, -40 },
  { 5481, 23, 41, 34, 6, -40 },
  { 5599, 28, 40, 34, 3, -40 },
  { 5739, 28, 40, 34, 3, -40 },
  { 5879, 28, 40, 34, 3, -40 },
  { 6019, 31, 40, 34, 2, -40 },
  { 6174, 28, 40, 34, 3, -40 },
  { 6314, 14, 51, 34, 15, -43 },
  { 6404, 22, 51, 34, 6, -43 },
  { 6545, 13, 51, 34, 6, -43 },
  { 6628, 26, 21, 34, 4, -40 },
  { 6697, 28, 1, 34, 3, 7 },
  { 6701, 7, 9, 34, 12, -43 },
  { 6709, 26, 31, 34, 4, -30 },
  { 6810, 23, 43, 34, 7, -42 },
  { 6934, 23, 31, 34, 6, -30 },
  { 7024, 22, 43, 34, 5, -42 },
  { 7143, 24, 31, 34, 5, -30 },
  { 7236, 25, 42, 34, 5, -42 },
  { 7368, 27, 44, 34, 5, -32 },
  { 7517, 21, 42, 34, 7, -42 },
  { 7628, 24, 42, 34, 7, -42 },
  { 7754, 20, 53, 34, 5, -42 },
  { 7887, 24, 42, 34, 8, -42 },
  { 8013, 24, 42, 34, 5, -42 },
  { 8139, 26, 30, 34, 4, -30 },
  { 8237, 21, 30, 34, 7, -30 },
  { 8316, 24, 31, 34, 5, -30 },
  { 8409, 23, 41, 34, 7, -30 },
  { 8527, 22, 41, 34, 5, -30 },
  { 8640, 27, 29, 34, 5, -29 },
  { 8738, 24, 31, 34, 5, -30 },
  { 8831, 28, 40, 34, 2, -40 },
  { 8971, 20, 30, 34, 7, -29 },
  { 9046, 24, 29, 34, 5, -29 },
  { 9133, 30, 29, 34, 2, -29 },
  { 9242, 24, 29, 34, 5, -29 },
  { 9329, 24, 40, 34, 5, -29 },
  { 9449, 22, 29, 34, 6, -29 },
  { 9529, 21, 51, 34, 7, -43 },
  { 9663, 1, 51, 34, 17, -43 },
  { 9670, 21, 51, 34, 7, -43 },
  { 9804, 28, 10, 34, 3, -22 },
};

const GFXfont IBMPlexMono_Thin57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_THIN57PT7B_H_
