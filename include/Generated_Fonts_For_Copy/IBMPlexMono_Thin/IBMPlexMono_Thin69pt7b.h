#ifndef _IBMPLEXMONO_THIN69PT7B_H_
#define _IBMPLEXMONO_THIN69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin69pt7bBitmaps[] PROGMEM = {
  0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xEF, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xE1, 0x87, 0x80, 0x0E, 0x03, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x00, 0xC4, 0x00, 0x30,
  0x00, 0xD8, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x80, 0x03, 0x00, 0x01, 0x00, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x1F, 0x60, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0x9F, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x60, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x0B, 0x00, 0x06, 0x00,
  0x33, 0x00, 0x0C, 0x00, 0x43, 0x00, 0x18, 0x01, 0x83, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x60, 0x30, 0x00, 0xF0, 0xC3, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x46, 0x00, 0x40, 0x00, 0x06, 0x20, 0x01, 0x00, 0x00, 0x22, 0x00, 0x0C,
  0x00, 0x02, 0x30, 0x00, 0x20, 0x00, 0x31, 0x00, 0x01, 0x80, 0x01, 0x08,
  0x00, 0x04, 0x00, 0x18, 0x40, 0x00, 0x20, 0x00, 0x86, 0x00, 0x01, 0x00,
  0x08, 0x30, 0x00, 0x08, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x04, 0x0C, 0x00,
  0x02, 0x00, 0x60, 0x60, 0x00, 0x10, 0x02, 0x01, 0x00, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x04, 0x03, 0x00, 0x40, 0x00, 0x60, 0x10, 0x03, 0x00, 0x02,
  0x01, 0x80, 0x08, 0x00, 0x30, 0x08, 0x00, 0x20, 0x01, 0x00, 0x80, 0x01,
  0x80, 0x10, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xC0, 0x38, 0x38, 0x00, 0x04, 0x03, 0x00, 0x60, 0x00, 0x40,
  0x30, 0x01, 0x80, 0x06, 0x03, 0x00, 0x04, 0x00, 0x20, 0x10, 0x00, 0x10,
  0x03, 0x00, 0x80, 0x00, 0x80, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x60,
  0x00, 0x30, 0x18, 0x02, 0x00, 0x01, 0x80, 0x80, 0x10, 0x00, 0x0C, 0x0C,
  0x00, 0x80, 0x00, 0x60, 0x40, 0x04, 0x00, 0x03, 0x04, 0x00, 0x20, 0x00,
  0x18, 0x60, 0x01, 0x80, 0x00, 0xC2, 0x00, 0x0C, 0x00, 0x06, 0x30, 0x00,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x00, 0x11,
  0x80, 0x00, 0x30, 0x01, 0x88, 0x00, 0x00, 0xC0, 0x18, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x03,
  0xFC, 0x30, 0x18, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x40, 0x01, 0x00, 0x30, 0x18, 0x00, 0x30, 0x06, 0x02, 0x00,
  0x03, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x10, 0x18, 0x00, 0x03, 0x02, 0x03,
  0x00, 0x00, 0x30, 0x40, 0x60, 0x00, 0x02, 0x08, 0x08, 0x00, 0x00, 0x23,
  0x01, 0x00, 0x00, 0x06, 0x60, 0x20, 0x00, 0x00, 0x68, 0x06, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x00,
  0x00, 0x03, 0x60, 0x30, 0x00, 0x00, 0xC6, 0x02, 0x00, 0x00, 0x10, 0x40,
  0x60, 0x00, 0x04, 0x04, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x70, 0x00, 0xC0,
  0x0C, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0xF0, 0x00, 0x80, 0x03,
  0xC7, 0xC0, 0x10, 0x07, 0xC0, 0x0F, 0x02, 0x07, 0xC0, 0x00, 0x3C, 0x47,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x38, 0x70,
  0xC1, 0x87, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x03, 0x80, 0x02,
  0xC0, 0x03, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x70, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x06, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x03, 0xFE, 0x00,
  0x10, 0xE0, 0x0E, 0x00, 0x88, 0x00, 0x0C, 0x04, 0x80, 0x00, 0x30, 0x28,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x7F, 0xC0, 0x02, 0x0E, 0x03, 0xC0, 0x11, 0x80,
  0x03, 0x81, 0x90, 0x00, 0x06, 0x09, 0x00, 0x00, 0x18, 0x50, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x01, 0x38, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0A,
  0x18, 0x00, 0x00, 0x68, 0x30, 0x00, 0x03, 0x60, 0x60, 0x00, 0x19, 0x00,
  0xC0, 0x00, 0xC4, 0x00, 0xE0, 0x1C, 0x30, 0x00, 0x7F, 0x80, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFE,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xF0, 0x1E, 0x7C, 0xF8,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x04,
  0x18, 0x30, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x60, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x03, 0x60, 0x00, 0xFC, 0x36, 0x00, 0x30, 0x31, 0x40, 0x04, 0x00,
  0x94, 0x00, 0x80, 0x05, 0x40, 0x18, 0x00, 0x34, 0x01, 0x00, 0x03, 0x40,
  0x30, 0x00, 0x34, 0x02, 0x00, 0x03, 0x40, 0x20, 0x00, 0x1C, 0x02, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C,
  0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x1C, 0x02, 0x00, 0x01,
  0x40, 0x20, 0x00, 0x34, 0x03, 0x00, 0x03, 0x40, 0x30, 0x00, 0x34, 0x01,
  0x00, 0x03, 0x40, 0x18, 0x00, 0x54, 0x00, 0xC0, 0x0D, 0x60, 0x06, 0x01,
  0x96, 0x00, 0x3E, 0xE1, 0x60, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x0E, 0x04,
  0x00, 0x00, 0x1C, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x05, 0x04, 0x00,
  0x00, 0x34, 0x18, 0x00, 0x01, 0x90, 0x30, 0x00, 0x0C, 0x40, 0x30, 0x00,
  0x61, 0x00, 0x78, 0x0F, 0x04, 0x00, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x40, 0x70, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0F,
  0x00, 0x00, 0x30, 0x33, 0x00, 0x00, 0x60, 0x42, 0x00, 0x00, 0xC1, 0x06,
  0x00, 0x01, 0x84, 0x06, 0x00, 0x03, 0x18, 0x04, 0x00, 0x06, 0x60, 0x0C,
  0x00, 0x0D, 0x80, 0x0C, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7A, 0x00, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x0B, 0x90, 0x00,
  0x00, 0x6E, 0x60, 0x00, 0x01, 0x39, 0x80, 0x00, 0x0C, 0xE2, 0x00, 0x00,
  0x23, 0x8C, 0x00, 0x01, 0x8E, 0x10, 0x00, 0x06, 0x38, 0x60, 0x00, 0x10,
  0xE0, 0x80, 0x00, 0xC3, 0x83, 0x00, 0x02, 0x0E, 0x04, 0x00, 0x18, 0x38,
  0x18, 0x00, 0x40, 0xE0, 0x20, 0x03, 0x03, 0x80, 0xC0, 0x08, 0x0E, 0x01,
  0x00, 0x60, 0x38, 0x04, 0x01, 0x00, 0xE0, 0x18, 0x04, 0x03, 0x80, 0x20,
  0x30, 0x0E, 0x00, 0xC0, 0x80, 0x38, 0x01, 0x06, 0x00, 0xE0, 0x06, 0x10,
  0x03, 0x80, 0x08, 0xC0, 0x0E, 0x00, 0x32, 0x00, 0x38, 0x00, 0x58, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x38,
  0x00, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xA0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x90, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x03, 0x88, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x84,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x82, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x38, 0x01, 0x00, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0x80, 0x03,
  0x80, 0x0C, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x20, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x10, 0x03, 0x80, 0x01, 0x80,
  0x38, 0x00, 0x08, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x04, 0x03, 0x80,
  0x00, 0x60, 0x38, 0x00, 0x02, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x02, 0x38, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x01, 0x38, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x30, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x40, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x20,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x87, 0x00, 0x00, 0x02, 0x07, 0x00, 0x00, 0x08, 0x03, 0x80, 0x00,
  0x60, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0x10, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x01, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x04, 0x00, 0x18, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x04, 0x40, 0x01, 0x80, 0x06, 0x20, 0x01, 0xC0, 0x03, 0x10,
  0x00, 0xE0, 0x01, 0x88, 0x00, 0x58, 0x00, 0xC4, 0x00, 0x64, 0x00, 0x62,
  0x00, 0x32, 0x00, 0x21, 0x80, 0x11, 0x80, 0x10, 0xC0, 0x08, 0xC0, 0x08,
  0x60, 0x0C, 0x20, 0x04, 0x30, 0x04, 0x18, 0x02, 0x18, 0x02, 0x0C, 0x01,
  0x04, 0x03, 0x02, 0x01, 0x82, 0x01, 0x81, 0x00, 0xC1, 0x00, 0x80, 0xC0,
  0x60, 0x80, 0xC0, 0x20, 0x30, 0x40, 0x60, 0x10, 0x10, 0x30, 0x20, 0x0C,
  0x08, 0x18, 0x30, 0x06, 0x04, 0x0C, 0x18, 0x01, 0x02, 0x06, 0x08, 0x00,
  0xC1, 0x03, 0x04, 0x00, 0x60, 0x80, 0x86, 0x00, 0x10, 0xC0, 0x42, 0x00,
  0x08, 0x60, 0x21, 0x00, 0x06, 0x30, 0x11, 0x80, 0x01, 0x18, 0x08, 0xC0,
  0x00, 0x88, 0x06, 0x40, 0x00, 0x64, 0x03, 0x60, 0x00, 0x32, 0x01, 0xB0,
  0x00, 0x09, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x68, 0x00, 0x03, 0x40, 0x1C,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xFC, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x02, 0xC0, 0x20, 0x00, 0x02,
  0xC0, 0x30, 0x00, 0x04, 0xC0, 0x1C, 0x00, 0x18, 0xC0, 0x07, 0x00, 0xE0,
  0x7F, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x07, 0xFC, 0x00, 0x83,
  0x80, 0xE0, 0x11, 0x80, 0x03, 0x02, 0x60, 0x00, 0x30, 0x58, 0x00, 0x03,
  0x0A, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x02, 0x28, 0x00, 0x00, 0xC5, 0x80, 0x00, 0x30, 0x98,
  0x00, 0x0C, 0x11, 0x80, 0x03, 0x02, 0x0E, 0x03, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x06,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x06, 0x08, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0xFE, 0x03,
  0x01, 0xC0, 0x38, 0x60, 0x60, 0x01, 0x8C, 0x30, 0x00, 0x09, 0x8C, 0x00,
  0x00, 0xB1, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0xC4, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0B,
  0x0C, 0x00, 0x02, 0x60, 0x60, 0x01, 0x8C, 0x07, 0x00, 0xE1, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE1, 0x00, 0x00,
  0x60, 0x19, 0x00, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x80, 0x06, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x07,
  0x80, 0x03, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0xFF, 0x00, 0x83, 0x00, 0xE0, 0x8C, 0x00,
  0x30, 0x90, 0x00, 0x08, 0xA0, 0x00, 0x04, 0xA0, 0x00, 0x06, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x7F, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x30, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x30, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x40, 0x70, 0x00, 0x02, 0x06, 0xC0, 0x00, 0x10,
  0x63, 0x00, 0x00, 0x86, 0x0C, 0x00, 0x04, 0x60, 0x60, 0x00, 0x26, 0x01,
  0x80, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60,
  0x02, 0x00, 0x01, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x04,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x06,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x83, 0xF0, 0x07, 0xE1, 0x18, 0x18, 0x30,
  0x32, 0x40, 0x18, 0x80, 0x35, 0x00, 0x12, 0x00, 0x2A, 0x00, 0x34, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x80, 0xFF, 0x00, 0x83, 0x00, 0xE0, 0x8C, 0x00, 0x30, 0x90, 0x00,
  0x08, 0xA0, 0x00, 0x04, 0xA0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x80, 0xFF, 0x80, 0x10, 0x70, 0x1C, 0x02, 0x30,
  0x00, 0x60, 0x4C, 0x00, 0x06, 0x0B, 0x00, 0x00, 0x61, 0x40, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x45, 0x00, 0x00, 0x18, 0xB0, 0x00, 0x06, 0x13, 0x00, 0x01, 0x82, 0x30,
  0x00, 0x60, 0x41, 0xC0, 0x70, 0x08, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x60, 0x38, 0x07, 0x0C,
  0x0C, 0x00, 0x31, 0x86, 0x00, 0x01, 0x31, 0x80, 0x00, 0x16, 0x20, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x38, 0x80, 0x00, 0x07, 0x18, 0x00, 0x01, 0x61, 0x80, 0x00, 0x4C,
  0x0C, 0x00, 0x31, 0x80, 0xE0, 0x1C, 0x30, 0x03, 0xFC, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x08,
  0x38, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0E, 0x40, 0x00, 0x07, 0x30, 0x00, 0x05, 0x8C, 0x00, 0x04, 0xC3,
  0x00, 0x0C, 0x60, 0xE0, 0x1C, 0x30, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x20, 0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x60, 0x01, 0x00, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x60, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x2C, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x01, 0x90, 0x00, 0x24, 0x00, 0x19, 0x00, 0x06, 0x40,
  0x01, 0x10, 0x00, 0x64, 0x00, 0x11, 0x80, 0x04, 0x60, 0x03, 0x08, 0x00,
  0x46, 0x00, 0x30, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x20,
  0xC0, 0x0C, 0x20, 0x06, 0x04, 0x00, 0x83, 0x00, 0x60, 0x40, 0x08, 0x30,
  0x04, 0x06, 0x00, 0x81, 0x00, 0x40, 0x60, 0x08, 0x10, 0x0C, 0x02, 0x01,
  0x81, 0x00, 0x80, 0x20, 0x18, 0x10, 0x08, 0x03, 0x01, 0x01, 0x80, 0x80,
  0x10, 0x10, 0x18, 0x18, 0x01, 0x01, 0x00, 0x81, 0x00, 0x10, 0x30, 0x08,
  0x10, 0x01, 0x83, 0x00, 0x81, 0x00, 0x08, 0x20, 0x0C, 0x30, 0x00, 0x82,
  0x00, 0xC2, 0x00, 0x08, 0x20, 0x04, 0x20, 0x00, 0xC2, 0x00, 0x42, 0x00,
  0x04, 0x60, 0x04, 0x60, 0x00, 0x44, 0x00, 0x44, 0x00, 0x04, 0x40, 0x06,
  0x40, 0x00, 0x64, 0x00, 0x64, 0x00, 0x02, 0x40, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x28, 0x00, 0x02, 0xC0, 0x02, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0x20, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x83, 0x0C, 0x00, 0x00, 0x42, 0x03, 0x00, 0x00, 0x22,
  0x00, 0x40, 0x00, 0x33, 0x00, 0x10, 0x00, 0x11, 0x00, 0x0C, 0x00, 0x09,
  0x80, 0x03, 0x00, 0x0C, 0x80, 0x00, 0xC0, 0x04, 0x40, 0x00, 0x30, 0x06,
  0x60, 0x00, 0x0C, 0x06, 0x30, 0x00, 0x03, 0x86, 0x10, 0x00, 0x00, 0x7C,
  0x00,
};

const GFXglyph IBMPlexMono_Thin69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 5, 48, 41, 18, -48 },
  { 31, 11, 17, 41, 15, -51 },
  { 55, 38, 48, 41, 2, -48 },
  { 283, 31, 64, 41, 5, -56 },
  { 531, 37, 50, 41, 2, -49 },
  { 763, 35, 50, 41, 3, -49 },
  { 982, 2, 17, 41, 20, -51 },
  { 987, 16, 62, 41, 16, -52 },
  { 1111, 16, 62, 41, 9, -52 },
  { 1235, 35, 34, 41, 3, -38 },
  { 1384, 33, 33, 41, 4, -38 },
  { 1521, 7, 17, 41, 16, -5 },
  { 1536, 18, 1, 41, 12, -22 },
  { 1539, 5, 4, 41, 18, -4 },
  { 1542, 27, 62, 41, 7, -52 },
  { 1752, 32, 50, 41, 5, -49 },
  { 1952, 32, 48, 41, 6, -48 },
  { 2144, 30, 49, 41, 6, -49 },
  { 2328, 29, 50, 41, 5, -49 },
  { 2510, 35, 48, 41, 3, -48 },
  { 2720, 29, 49, 41, 6, -48 },
  { 2898, 29, 49, 41, 6, -48 },
  { 3076, 30, 48, 41, 5, -48 },
  { 3256, 31, 50, 41, 5, -49 },
  { 3450, 30, 49, 41, 6, -49 },
  { 3634, 5, 36, 41, 18, -36 },
  { 3657, 7, 48, 41, 16, -36 },
  { 3699, 30, 37, 41, 6, -40 },
  { 3838, 33, 14, 41, 4, -28 },
  { 3896, 30, 37, 41, 6, -40 },
  { 4035, 27, 49, 41, 7, -49 },
  { 4201, 28, 56, 41, 6, -49 },
  { 4397, 34, 48, 41, 4, -48 },
  { 4601, 29, 48, 41, 7, -48 },
  { 4775, 31, 50, 41, 5, -49 },
  { 4969, 29, 48, 41, 7, -48 },
  { 5143, 28, 48, 41, 7, -48 },
  { 5311, 29, 48, 41, 7, -48 },
  { 5485, 30, 50, 41, 5, -49 },
  { 5673, 28, 48, 41, 7, -48 },
  { 5841, 29, 48, 41, 6, -48 },
  { 6015, 25, 49, 41, 7, -48 },
  { 6169, 31, 48, 41, 7, -48 },
  { 6355, 26, 48, 41, 10, -48 },
  { 6511, 30, 48, 41, 6, -48 },
  { 6691, 28, 48, 41, 7, -48 },
  { 6859, 32, 50, 41, 5, -49 },
  { 7059, 29, 48, 41, 7, -48 },
  { 7233, 32, 58, 41, 5, -49 },
  { 7465, 29, 48, 41, 7, -48 },
  { 7639, 31, 50, 41, 5, -49 },
  { 7833, 36, 48, 41, 3, -48 },
  { 8049, 28, 49, 41, 7, -48 },
  { 8221, 34, 48, 41, 4, -48 },
  { 8425, 33, 48, 41, 4, -48 },
  { 8623, 35, 48, 41, 3, -48 },
  { 8833, 37, 48, 41, 2, -48 },
  { 9055, 35, 48, 41, 3, -48 },
  { 9265, 17, 62, 41, 18, -52 },
  { 9397, 27, 62, 41, 7, -52 },
  { 9607, 16, 62, 41, 7, -52 },
  { 9731, 32, 26, 41, 5, -48 },
  { 9835, 33, 1, 41, 4, 9 },
  { 9840, 9, 11, 41, 14, -52 },
  { 9853, 32, 37, 41, 5, -36 },
  { 10001, 27, 52, 41, 9, -51 },
  { 10177, 27, 37, 41, 8, -36 },
  { 10302, 27, 52, 41, 6, -51 },
  { 10478, 29, 37, 41, 6, -36 },
  { 10613, 31, 51, 41, 6, -51 },
  { 10811, 32, 53, 41, 6, -38 },
  { 11023, 24, 51, 41, 9, -51 },
  { 11176, 29, 52, 41, 8, -52 },
  { 11365, 24, 66, 41, 7, -52 },
  { 11563, 29, 51, 41, 10, -51 },
  { 11748, 29, 51, 41, 6, -51 },
  { 11933, 31, 36, 41, 5, -36 },
  { 12073, 24, 36, 41, 9, -36 },
  { 12181, 29, 37, 41, 6, -36 },
  { 12316, 27, 50, 41, 9, -36 },
  { 12485, 27, 50, 41, 6, -36 },
  { 12654, 32, 36, 41, 6, -36 },
  { 12798, 30, 37, 41, 6, -36 },
  { 12937, 34, 48, 41, 2, -48 },
  { 13141, 25, 37, 41, 8, -36 },
  { 13257, 29, 36, 41, 6, -36 },
  { 13388, 36, 36, 41, 3, -36 },
  { 13550, 29, 36, 41, 6, -36 },
  { 13681, 30, 50, 41, 6, -36 },
  { 13869, 27, 36, 41, 7, -36 },
  { 13991, 25, 62, 41, 8, -52 },
  { 14185, 1, 62, 41, 20, -52 },
  { 14193, 25, 62, 41, 8, -52 },
  { 14387, 33, 12, 41, 4, -27 },
};

const GFXfont IBMPlexMono_Thin69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_THIN69PT7B_H_
