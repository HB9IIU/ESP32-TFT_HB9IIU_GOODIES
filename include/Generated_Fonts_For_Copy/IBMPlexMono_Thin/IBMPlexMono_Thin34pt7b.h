#ifndef _IBMPLEXMONO_THIN34PT7B_H_
#define _IBMPLEXMONO_THIN34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x5A, 0xA0, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x88, 0x00, 0x82, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10,
  0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x40, 0x7E, 0x0F, 0xE0, 0x41,
  0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01, 0x04,
  0x07, 0xE0, 0xFC, 0x04, 0x10, 0x00, 0x82, 0x00, 0x20, 0x80, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x07, 0xF0, 0x18, 0x88, 0x20, 0x86, 0x40, 0x82,
  0x40, 0x81, 0x40, 0x80, 0x40, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80,
  0x18, 0x80, 0x07, 0xC0, 0x00, 0xB8, 0x00, 0x84, 0x00, 0x82, 0x00, 0x81,
  0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x80, 0x81, 0x40, 0x82, 0x20, 0x82,
  0x18, 0x8C, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x1E, 0x00,
  0x58, 0x40, 0x14, 0x08, 0x0A, 0x02, 0x04, 0x80, 0x41, 0x20, 0x10, 0x88,
  0x04, 0x22, 0x02, 0x10, 0x40, 0x88, 0x18, 0x42, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x62, 0x08, 0x11, 0x01, 0x08, 0x40,
  0x42, 0x10, 0x11, 0x04, 0x04, 0x81, 0x01, 0x20, 0x40, 0x50, 0x10, 0x14,
  0x02, 0x0A, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0x0C, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x28, 0x0F, 0x11, 0x02, 0x08, 0x60, 0x84,
  0x0C, 0x21, 0x01, 0x10, 0x80, 0x24, 0x20, 0x05, 0x08, 0x00, 0xC2, 0x00,
  0x10, 0x40, 0x0A, 0x18, 0x04, 0x83, 0x02, 0x10, 0x3F, 0x02, 0xFF, 0x80,
  0x03, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x03, 0x80, 0x80, 0x80, 0x81, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x02,
  0x02, 0x06, 0xF1, 0x1C, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x44,
  0x00, 0x42, 0x00, 0x40, 0x80, 0x20, 0x20, 0x20, 0x10, 0x20, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x2D, 0x25,
  0x24, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x18,
  0x10, 0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x81, 0x81, 0x81, 0x81, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x10, 0x0C, 0x0C, 0x18, 0x07, 0xE0, 0x01, 0x80, 0x02, 0x80,
  0x0C, 0x80, 0x18, 0x80, 0x30, 0x80, 0x60, 0x80, 0x80, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x0F, 0xC0, 0x60, 0x60,
  0x80, 0x42, 0x00, 0x48, 0x00, 0x90, 0x01, 0x00, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x7F, 0xFF, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x22, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x7E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x2C, 0x00, 0x4C, 0x01, 0x04, 0x0C,
  0x03, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x08,
  0x80, 0x04, 0x40, 0x04, 0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x04, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x00, 0x81, 0x00, 0x41, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x3F, 0xF9, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x3F, 0x07, 0x03,
  0x18, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x09, 0x00, 0x63, 0x03, 0x03, 0xF0, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x3F, 0x09, 0x03, 0x28, 0x02, 0xC0, 0x0A, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x09,
  0x80, 0x23, 0x03, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x02,
  0x80, 0x0A, 0x00, 0x48, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x07,
  0xE0, 0x18, 0x18, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0, 0x1C,
  0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x06, 0x18, 0x1C, 0x07, 0xF0, 0x0F,
  0xC0, 0x20, 0x60, 0x80, 0x22, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0D, 0x00, 0x33, 0x00, 0x63, 0x03, 0x41,
  0xF8, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x69, 0x29, 0x24, 0x00, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x60, 0xC2,
  0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x03, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0xC0, 0x60, 0x82, 0x01, 0x08, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x00, 0x60, 0x79, 0x82, 0x16, 0x10, 0x38, 0x40, 0x62, 0x01, 0x88,
  0x06, 0x20, 0x18, 0x80, 0x62, 0x01, 0x88, 0x06, 0x10, 0x18, 0x40, 0x60,
  0x83, 0x81, 0xF6, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0xFE, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x10, 0x04, 0x08,
  0x02, 0x04, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x3F,
  0xF8, 0x20, 0x04, 0x10, 0x02, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x24,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0xFF, 0xE1, 0x00, 0x62, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x12, 0x00, 0xC7, 0xFF, 0x08, 0x01, 0x90, 0x01, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0,
  0x06, 0x7F, 0xF0, 0x07, 0xE0, 0x30, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00,
  0x50, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x34, 0x00, 0x44, 0x01, 0x06, 0x04, 0x03, 0xF0,
  0xFF, 0x82, 0x01, 0x88, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x12, 0x00, 0xC8, 0x06, 0x3F, 0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x3F, 0xFE, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x40, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x50, 0x01, 0x40, 0x0C, 0x80, 0x31, 0x83, 0x41, 0xF1, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0x3F, 0xF8, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x24, 0x01, 0x20, 0x18, 0xC1, 0x81, 0xF0,
  0x80, 0x07, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20,
  0x20, 0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x30, 0x04, 0xA0, 0x0A, 0x20,
  0x18, 0x20, 0x30, 0x40, 0x40, 0x40, 0x80, 0x41, 0x00, 0x82, 0x00, 0x84,
  0x00, 0x88, 0x01, 0x10, 0x01, 0x20, 0x01, 0x40, 0x03, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0x80, 0x17, 0x00, 0x2D, 0x00, 0x5A, 0x01, 0x34, 0x02, 0x64,
  0x08, 0xC8, 0x11, 0x88, 0x43, 0x10, 0x86, 0x12, 0x0C, 0x24, 0x18, 0x28,
  0x30, 0x60, 0x60, 0x40, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x1A, 0x00, 0x68, 0x01, 0x90, 0x06, 0x40, 0x18, 0x80, 0x62, 0x01, 0x84,
  0x06, 0x10, 0x18, 0x20, 0x60, 0x81, 0x81, 0x06, 0x04, 0x18, 0x08, 0x60,
  0x21, 0x80, 0x46, 0x01, 0x18, 0x02, 0x60, 0x09, 0x80, 0x16, 0x00, 0x58,
  0x00, 0xE0, 0x01, 0x07, 0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20, 0x04, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x10, 0x0C, 0x0C,
  0x18, 0x07, 0xE0, 0xFF, 0xE2, 0x00, 0xC8, 0x00, 0xA0, 0x02, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x0C,
  0xFF, 0xE2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x0C,
  0x18, 0x10, 0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x20, 0x04, 0x10, 0x0C, 0x0C, 0x18, 0x07, 0xE0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFC, 0xFF, 0xE2, 0x00, 0xC8, 0x00,
  0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x28, 0x00, 0xA0, 0x0C, 0xFF, 0xE2, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x82, 0x01, 0x08, 0x04, 0x20, 0x08, 0x80, 0x22, 0x00, 0x48, 0x00, 0xA0,
  0x03, 0x07, 0xF0, 0x18, 0x18, 0x20, 0x06, 0x40, 0x02, 0x40, 0x01, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x40, 0x02, 0x20, 0x02, 0x18, 0x0C, 0x07,
  0xF0, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x09, 0x80, 0x23, 0x03, 0x03,
  0xF8, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x08, 0x40, 0x04,
  0x20, 0x02, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x24, 0x00, 0x0A, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x81, 0x41, 0x81, 0x41, 0x81,
  0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x22, 0x44, 0x22, 0x44, 0x22,
  0x44, 0x22, 0x48, 0x12, 0x48, 0x12, 0x28, 0x12, 0x28, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x04, 0x80, 0x01, 0x20, 0x01, 0x08, 0x00, 0x84, 0x00,
  0x81, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x40, 0x08, 0x40, 0x04, 0x20, 0x01,
  0x20, 0x00, 0x60, 0x00, 0x10, 0x00, 0x18, 0x00, 0x12, 0x00, 0x08, 0x80,
  0x08, 0x40, 0x04, 0x10, 0x04, 0x08, 0x04, 0x02, 0x02, 0x00, 0x82, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x24,
  0x00, 0x08, 0x80, 0x04, 0x10, 0x01, 0x04, 0x00, 0x80, 0x80, 0x40, 0x10,
  0x10, 0x04, 0x08, 0x00, 0x84, 0x00, 0x11, 0x00, 0x04, 0x80, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x80, 0x01,
  0x80, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x18, 0x10,
  0x08, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0x88, 0x42, 0x21, 0x1F, 0x80, 0x40, 0xC1, 0x00, 0x84, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xF0, 0xC0, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x18, 0x60, 0xD0,
  0x7E, 0x1C, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x23, 0xE0, 0xB0, 0x63, 0x00, 0x48, 0x00, 0xA0, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x02, 0x80, 0x0A, 0x00, 0x2C, 0x01, 0x2C, 0x18, 0x8F, 0x80, 0x0F, 0x81,
  0x83, 0x18, 0x04, 0x80, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0D, 0x00, 0x2C, 0x02,
  0x30, 0x20, 0x7E, 0x00, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x21, 0xF1, 0x30, 0x6B, 0x00, 0xD0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xA0, 0x05, 0x80, 0x66, 0x0D, 0x0F, 0x88, 0x0F, 0xC0, 0x40,
  0xC2, 0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x14, 0x00, 0x48,
  0x02, 0x18, 0x30, 0x1F, 0x00, 0x01, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x7F, 0xFF, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x07, 0xD0, 0x18, 0x30, 0x20, 0x10,
  0x20, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x20, 0x08,
  0x20, 0x10, 0x18, 0x30, 0x0F, 0xC0, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x1F, 0xF8, 0x60, 0x06, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x40, 0x02, 0x60, 0x0C, 0x1F, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xF8, 0x90, 0x6E, 0x03, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x7F, 0xE0, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x02,
  0x80, 0x32, 0x01, 0x08, 0x08, 0x20, 0x40, 0x82, 0x02, 0x10, 0x08, 0xC0,
  0x25, 0x00, 0xE2, 0x02, 0x04, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x00,
  0x88, 0x01, 0x20, 0x02, 0x80, 0x04, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0xFF, 0xFC, 0x9E, 0x3C, 0xA1, 0x42, 0xC1, 0x81, 0x81, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x8F, 0x89, 0x06, 0xE0, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0x40, 0xC2, 0x01, 0x90, 0x02,
  0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x88, 0x02, 0x10, 0x30, 0x3F,
  0x00, 0x8F, 0x82, 0xC1, 0x8C, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0xB0, 0x04, 0xB0, 0x62, 0x3E, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0x89, 0x83,
  0x58, 0x06, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x2C, 0x03, 0x30,
  0x68, 0x7C, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0xFC, 0x7F, 0x04, 0x80, 0x05, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0xFF, 0xFC, 0x0F, 0xC0, 0x60, 0x61, 0x00, 0x22, 0x00, 0x24, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x01, 0x20, 0x02, 0x30, 0x18, 0x1F, 0xC0,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x03, 0xFF, 0xFE, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x14, 0x03, 0x20, 0x51, 0xF9, 0x80, 0x06, 0x00, 0x14, 0x00, 0x90,
  0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x84, 0x02, 0x10, 0x08, 0x40, 0x12, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x00,
  0x04, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x82, 0x41,
  0x20, 0x90, 0x48, 0x24, 0x12, 0x09, 0x08, 0x42, 0x22, 0x10, 0x88, 0x84,
  0x42, 0x21, 0x10, 0x90, 0x24, 0x24, 0x09, 0x05, 0x02, 0x41, 0x40, 0x60,
  0x60, 0x18, 0x18, 0x06, 0x06, 0x00, 0x80, 0x80, 0x05, 0x00, 0x22, 0x01,
  0x04, 0x04, 0x10, 0x20, 0x21, 0x00, 0x44, 0x00, 0xA0, 0x03, 0x00, 0x0C,
  0x00, 0x28, 0x01, 0x20, 0x08, 0x40, 0x40, 0x81, 0x01, 0x08, 0x06, 0x40,
  0x0A, 0x00, 0x10, 0x80, 0x07, 0x00, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00,
  0x84, 0x02, 0x08, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x21, 0x00,
  0x42, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0xFF, 0xF0, 0x07, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x07, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x06, 0x00,
  0x1F, 0x07, 0x00, 0x80, 0x08, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFE, 0x00,
  0x1C, 0x01, 0x22, 0x01, 0x41, 0x01, 0x80, 0x82, 0x80, 0x62, 0x80, 0x3C,
};

const GFXglyph IBMPlexMono_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 2, 24, 20, 9, -24 },
  { 7, 5, 9, 20, 8, -25 },
  { 13, 19, 24, 20, 1, -24 },
  { 70, 16, 30, 20, 2, -27 },
  { 130, 18, 24, 20, 1, -24 },
  { 184, 18, 24, 20, 1, -24 },
  { 238, 1, 9, 20, 10, -25 },
  { 240, 8, 31, 20, 8, -26 },
  { 271, 7, 31, 20, 5, -26 },
  { 299, 17, 17, 20, 2, -19 },
  { 336, 16, 17, 20, 2, -19 },
  { 370, 3, 9, 20, 8, -3 },
  { 374, 9, 1, 20, 6, -11 },
  { 376, 2, 2, 20, 9, -2 },
  { 377, 13, 31, 20, 4, -26 },
  { 428, 16, 24, 20, 2, -24 },
  { 476, 16, 24, 20, 3, -24 },
  { 524, 15, 24, 20, 3, -24 },
  { 569, 15, 24, 20, 2, -24 },
  { 614, 17, 24, 20, 2, -24 },
  { 665, 14, 24, 20, 3, -24 },
  { 707, 14, 24, 20, 3, -24 },
  { 749, 14, 24, 20, 3, -24 },
  { 791, 16, 24, 20, 2, -24 },
  { 839, 15, 24, 20, 3, -24 },
  { 884, 2, 18, 20, 9, -18 },
  { 889, 3, 24, 20, 8, -18 },
  { 898, 15, 18, 20, 3, -19 },
  { 932, 16, 7, 20, 2, -14 },
  { 946, 15, 18, 20, 3, -19 },
  { 980, 14, 24, 20, 3, -24 },
  { 1022, 14, 28, 20, 3, -24 },
  { 1071, 17, 24, 20, 2, -24 },
  { 1122, 15, 24, 20, 3, -24 },
  { 1167, 15, 24, 20, 3, -24 },
  { 1212, 14, 24, 20, 4, -24 },
  { 1254, 13, 24, 20, 4, -24 },
  { 1293, 14, 24, 20, 4, -24 },
  { 1335, 14, 24, 20, 3, -24 },
  { 1377, 14, 24, 20, 3, -24 },
  { 1419, 14, 24, 20, 3, -24 },
  { 1461, 13, 24, 20, 3, -24 },
  { 1500, 15, 24, 20, 4, -24 },
  { 1545, 13, 24, 20, 5, -24 },
  { 1584, 15, 24, 20, 3, -24 },
  { 1629, 14, 24, 20, 3, -24 },
  { 1671, 16, 24, 20, 2, -24 },
  { 1719, 14, 24, 20, 4, -24 },
  { 1761, 16, 29, 20, 2, -24 },
  { 1819, 14, 24, 20, 4, -24 },
  { 1861, 16, 24, 20, 2, -24 },
  { 1909, 18, 24, 20, 1, -24 },
  { 1963, 14, 24, 20, 3, -24 },
  { 2005, 17, 24, 20, 2, -24 },
  { 2056, 16, 24, 20, 2, -24 },
  { 2104, 17, 24, 20, 2, -24 },
  { 2155, 18, 24, 20, 1, -24 },
  { 2209, 17, 24, 20, 2, -24 },
  { 2260, 8, 31, 20, 9, -26 },
  { 2291, 13, 31, 20, 4, -26 },
  { 2342, 8, 31, 20, 3, -26 },
  { 2373, 16, 13, 20, 2, -24 },
  { 2399, 16, 1, 20, 2, 4 },
  { 2401, 4, 6, 20, 7, -26 },
  { 2404, 15, 18, 20, 3, -18 },
  { 2438, 14, 25, 20, 4, -25 },
  { 2482, 13, 18, 20, 4, -18 },
  { 2512, 13, 25, 20, 3, -25 },
  { 2553, 14, 18, 20, 3, -18 },
  { 2585, 15, 25, 20, 3, -25 },
  { 2632, 16, 26, 20, 3, -19 },
  { 2684, 12, 25, 20, 4, -25 },
  { 2722, 14, 26, 20, 4, -26 },
  { 2768, 12, 33, 20, 3, -26 },
  { 2818, 14, 25, 20, 5, -25 },
  { 2862, 14, 25, 20, 3, -25 },
  { 2906, 16, 18, 20, 2, -18 },
  { 2942, 12, 18, 20, 4, -18 },
  { 2969, 14, 18, 20, 3, -18 },
  { 3001, 14, 25, 20, 4, -18 },
  { 3045, 13, 25, 20, 3, -18 },
  { 3086, 16, 18, 20, 3, -18 },
  { 3122, 15, 18, 20, 3, -18 },
  { 3156, 17, 24, 20, 1, -24 },
  { 3207, 12, 18, 20, 4, -18 },
  { 3234, 14, 18, 20, 3, -18 },
  { 3266, 18, 18, 20, 1, -18 },
  { 3307, 14, 18, 20, 3, -18 },
  { 3339, 15, 25, 20, 3, -18 },
  { 3386, 14, 18, 20, 3, -18 },
  { 3418, 12, 31, 20, 4, -26 },
  { 3465, 1, 31, 20, 10, -26 },
  { 3469, 12, 31, 20, 4, -26 },
  { 3516, 16, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_Thin34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_THIN34PT7B_H_
