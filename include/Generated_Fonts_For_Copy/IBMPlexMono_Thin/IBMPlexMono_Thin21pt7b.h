#ifndef _IBMPLEXMONO_THIN21PT7B_H_
#define _IBMPLEXMONO_THIN21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0xB6, 0xDA, 0x04, 0x40, 0x48, 0x04, 0x80, 0x88, 0x08,
  0x87, 0x8F, 0x08, 0x80, 0x90, 0x09, 0x0F, 0x0E, 0x11, 0x01, 0x10, 0x11,
  0x01, 0x20, 0x22, 0x00, 0x04, 0x01, 0x01, 0xF1, 0x92, 0x84, 0x61, 0x08,
  0x41, 0x10, 0x34, 0x03, 0xC0, 0x48, 0x11, 0x04, 0x41, 0x18, 0x45, 0x92,
  0x1F, 0x01, 0x00, 0x40, 0x70, 0x31, 0x0A, 0x21, 0x42, 0x48, 0x91, 0x12,
  0x1C, 0x00, 0x00, 0x03, 0xC6, 0x88, 0x90, 0xA2, 0x14, 0x43, 0x08, 0xA0,
  0xF0, 0x1C, 0x08, 0x84, 0x11, 0x00, 0x40, 0x08, 0x02, 0x01, 0xC3, 0x88,
  0xA1, 0x28, 0x32, 0x04, 0x81, 0x90, 0xA3, 0xC4, 0xF8, 0x19, 0x10, 0x88,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x41, 0x06, 0x82, 0x08, 0x41,
  0x08, 0x42, 0x08, 0x42, 0x21, 0x08, 0x44, 0x22, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0E, 0x4E, 0x3E, 0x03, 0x00, 0x90, 0x21, 0x04, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x6A, 0xA0, 0xF8, 0x80, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x11, 0x80, 0x60,
  0x18, 0x05, 0x01, 0x40, 0x88, 0x61, 0xE0, 0x08, 0x06, 0x02, 0x81, 0x20,
  0x88, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x0F, 0xFC, 0x3C, 0x21, 0x20, 0x50, 0x20, 0x10, 0x08, 0x04, 0x04, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x03, 0xFE, 0x1E, 0x10, 0x90, 0x20, 0x10,
  0x08, 0x08, 0x78, 0x06, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0B, 0x08, 0x78,
  0x01, 0x00, 0x60, 0x14, 0x02, 0x80, 0x90, 0x22, 0x04, 0x41, 0x08, 0x41,
  0x10, 0x22, 0x04, 0x7F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x7F, 0x40, 0x20,
  0x10, 0x08, 0x05, 0xF3, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x28, 0x12,
  0x18, 0xF0, 0x04, 0x0C, 0x08, 0x04, 0x04, 0x04, 0x02, 0xF9, 0x82, 0x81,
  0x40, 0x60, 0x30, 0x18, 0x12, 0x08, 0xF8, 0xFF, 0xC0, 0xA0, 0x50, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x3E, 0x20, 0xA0, 0x50, 0x18, 0x0C, 0x09, 0x04, 0x7C, 0x63, 0x40, 0x60,
  0x30, 0x18, 0x0E, 0x08, 0xF8, 0x3E, 0x20, 0xA0, 0x50, 0x18, 0x0C, 0x06,
  0x02, 0x87, 0x3D, 0x00, 0x80, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x20,
  0x40, 0x00, 0x1A, 0xA8, 0x00, 0x81, 0x83, 0x02, 0x06, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x0C, 0x08, 0x18, 0x30, 0x20,
  0x00, 0x3E, 0x41, 0x81, 0x81, 0x01, 0x01, 0x02, 0x04, 0x18, 0x10, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x3C, 0x42, 0x81, 0x81, 0x8F, 0x91, 0xA1, 0xA1,
  0xA1, 0xA1, 0xA1, 0x91, 0x8F, 0x80, 0x80, 0x60, 0x3F, 0x04, 0x01, 0x80,
  0x30, 0x09, 0x01, 0x20, 0x24, 0x08, 0x41, 0x08, 0x21, 0x08, 0x10, 0xFE,
  0x20, 0x44, 0x05, 0x00, 0xA0, 0x18, 0xFE, 0x40, 0xA0, 0x50, 0x28, 0x14,
  0x0A, 0x09, 0xFC, 0x81, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0B, 0xF8, 0x3E,
  0x30, 0xA0, 0x50, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x13, 0x08, 0xF8, 0xFC, 0x41, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x14, 0x1B, 0xF0, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0xFE, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3C, 0x21, 0x20, 0x50, 0x18,
  0x04, 0x02, 0x01, 0x00, 0x87, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x0C, 0xFA,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x7F, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x82, 0x42,
  0x3C, 0x80, 0xA0, 0x48, 0x22, 0x10, 0x88, 0x22, 0x09, 0x02, 0xA0, 0xC8,
  0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x28, 0x0C, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0xC0, 0xF0, 0x78, 0x5C, 0x2D, 0x26, 0x93, 0x31, 0x88, 0xC8, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x80, 0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43,
  0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x2C, 0x0E, 0x02, 0x1E, 0x08, 0x64,
  0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01,
  0x40, 0x88, 0x61, 0xE0, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x02, 0xFE, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x1E, 0x08, 0x64,
  0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01,
  0x40, 0x88, 0x61, 0xE0, 0x10, 0x04, 0x01, 0xE0, 0xFE, 0x40, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x02, 0xFE, 0x44, 0x21, 0x10, 0x88, 0x24, 0x0A,
  0x02, 0x1F, 0x18, 0x28, 0x06, 0x00, 0x80, 0x10, 0x03, 0x00, 0x3C, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x80, 0x58, 0x21, 0xF0, 0xFF, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x12, 0x08, 0xF8, 0x80, 0x60,
  0x18, 0x05, 0x02, 0x40, 0x90, 0x22, 0x10, 0x84, 0x21, 0x04, 0x81, 0x20,
  0x48, 0x0C, 0x03, 0x00, 0x40, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x61,
  0x18, 0xC6, 0x31, 0x92, 0x54, 0xA5, 0x29, 0x86, 0x61, 0x98, 0x62, 0x18,
  0x80, 0x48, 0x11, 0x02, 0x10, 0x81, 0x20, 0x24, 0x03, 0x00, 0x20, 0x0C,
  0x02, 0x40, 0x44, 0x10, 0x84, 0x08, 0x80, 0xA0, 0x18, 0x80, 0x30, 0x09,
  0x02, 0x20, 0x42, 0x10, 0x24, 0x04, 0x80, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xFF, 0xC0, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x3F, 0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3E, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7E, 0x04, 0x03,
  0x01, 0x20, 0x84, 0x21, 0x10, 0x24, 0x0A, 0x01, 0xFF, 0xC0, 0x88, 0x80,
  0x7C, 0x41, 0x00, 0x80, 0x40, 0x23, 0xF2, 0x09, 0x04, 0x82, 0x43, 0x1E,
  0x60, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0xFC, 0x1E, 0x30, 0xA0, 0x50, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x81, 0xB1, 0x07, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01, 0x3D,
  0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x21,
  0xA0, 0x50, 0x28, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x20, 0xCF, 0x80, 0x0F,
  0x88, 0x04, 0x02, 0x01, 0x07, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x41, 0xFF, 0x01, 0xCF, 0x84, 0x22, 0x04, 0x81, 0x20,
  0x44, 0x10, 0xF8, 0x40, 0x20, 0x07, 0xF2, 0x02, 0x80, 0xA0, 0x28, 0x09,
  0xFC, 0x81, 0x02, 0x04, 0x08, 0x17, 0xB1, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x02, 0x00, 0x00, 0x0F,
  0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07,
  0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x0A, 0x19, 0x10, 0x90, 0x50,
  0x34, 0x11, 0x08, 0x44, 0x12, 0x05, 0x03, 0xF8, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21,
  0xFF, 0xF3, 0x4E, 0x66, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4,
  0x62, 0x20, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08,
  0x3C, 0x21, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x21, 0x8F,
  0x00, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC,
  0x80, 0x80, 0x80, 0x80, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xF3, 0xC7, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xF8, 0x3E, 0x20, 0xA0,
  0x10, 0x04, 0x01, 0xF0, 0x06, 0x01, 0x80, 0xA0, 0x8F, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0xFF, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x81, 0xC0, 0xA0, 0x48, 0x44, 0x22, 0x10, 0x90,
  0x48, 0x14, 0x0C, 0x02, 0x00, 0x84, 0x31, 0x86, 0x31, 0x49, 0x29, 0x25,
  0x24, 0xA4, 0x93, 0x14, 0x61, 0x8C, 0x30, 0x86, 0x00, 0x81, 0xA0, 0x90,
  0x84, 0x81, 0x80, 0x40, 0x60, 0x48, 0x42, 0x20, 0xA0, 0x60, 0x80, 0xC0,
  0xA0, 0x48, 0x44, 0x21, 0x10, 0x90, 0x48, 0x18, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x03, 0x80, 0xFF, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x80, 0xFF, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x08, 0xF0,
  0x1C, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x0F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x08, 0x08, 0x08, 0x08, 0x10, 0x20, 0x20, 0x10, 0x0F, 0x18, 0x20,
  0x20, 0x10, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x30, 0x52, 0x18, 0x46, 0x0E,
};

const GFXglyph IBMPlexMono_Thin21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 1, 15, 13, 6, -15 },
  { 3, 3, 5, 13, 5, -16 },
  { 5, 12, 15, 13, 0, -15 },
  { 28, 10, 19, 13, 1, -17 },
  { 52, 11, 15, 13, 1, -15 },
  { 73, 10, 15, 13, 1, -15 },
  { 92, 1, 5, 13, 6, -16 },
  { 93, 5, 19, 13, 5, -16 },
  { 105, 5, 19, 13, 3, -16 },
  { 117, 11, 10, 13, 1, -12 },
  { 131, 10, 11, 13, 1, -12 },
  { 145, 2, 6, 13, 5, -2 },
  { 147, 5, 1, 13, 4, -7 },
  { 148, 1, 1, 13, 6, -1 },
  { 149, 8, 19, 13, 2, -16 },
  { 168, 10, 15, 13, 1, -15 },
  { 187, 10, 15, 13, 2, -15 },
  { 206, 9, 15, 13, 2, -15 },
  { 223, 9, 15, 13, 1, -15 },
  { 240, 11, 15, 13, 1, -15 },
  { 261, 9, 15, 13, 2, -15 },
  { 278, 9, 15, 13, 2, -15 },
  { 295, 9, 15, 13, 2, -15 },
  { 312, 9, 15, 13, 2, -15 },
  { 329, 9, 15, 13, 2, -15 },
  { 346, 1, 11, 13, 6, -11 },
  { 348, 2, 15, 13, 5, -11 },
  { 352, 9, 11, 13, 2, -12 },
  { 365, 10, 5, 13, 1, -9 },
  { 372, 9, 11, 13, 2, -12 },
  { 385, 8, 15, 13, 2, -15 },
  { 400, 8, 17, 13, 2, -15 },
  { 417, 11, 15, 13, 1, -15 },
  { 438, 9, 15, 13, 2, -15 },
  { 455, 9, 15, 13, 2, -15 },
  { 472, 9, 15, 13, 2, -15 },
  { 489, 9, 15, 13, 2, -15 },
  { 506, 9, 15, 13, 2, -15 },
  { 523, 9, 15, 13, 2, -15 },
  { 540, 9, 15, 13, 2, -15 },
  { 557, 9, 15, 13, 2, -15 },
  { 574, 8, 15, 13, 2, -15 },
  { 589, 10, 15, 13, 2, -15 },
  { 608, 8, 15, 13, 3, -15 },
  { 623, 9, 15, 13, 2, -15 },
  { 640, 9, 15, 13, 2, -15 },
  { 657, 10, 15, 13, 1, -15 },
  { 676, 9, 15, 13, 2, -15 },
  { 693, 10, 18, 13, 1, -15 },
  { 716, 9, 15, 13, 2, -15 },
  { 733, 10, 15, 13, 1, -15 },
  { 752, 11, 15, 13, 1, -15 },
  { 773, 9, 15, 13, 2, -15 },
  { 790, 10, 15, 13, 1, -15 },
  { 809, 10, 15, 13, 1, -15 },
  { 828, 11, 15, 13, 1, -15 },
  { 849, 11, 15, 13, 1, -15 },
  { 870, 11, 15, 13, 1, -15 },
  { 891, 5, 19, 13, 6, -16 },
  { 903, 8, 19, 13, 2, -16 },
  { 922, 5, 19, 13, 2, -16 },
  { 934, 10, 8, 13, 1, -15 },
  { 944, 10, 1, 13, 1, 2 },
  { 946, 3, 3, 13, 4, -16 },
  { 948, 9, 11, 13, 2, -11 },
  { 961, 8, 16, 13, 3, -16 },
  { 977, 9, 11, 13, 2, -11 },
  { 990, 8, 16, 13, 2, -16 },
  { 1006, 9, 11, 13, 2, -11 },
  { 1019, 9, 16, 13, 2, -16 },
  { 1037, 10, 16, 13, 2, -12 },
  { 1057, 7, 16, 13, 3, -16 },
  { 1071, 9, 15, 13, 2, -15 },
  { 1088, 7, 19, 13, 2, -15 },
  { 1105, 9, 16, 13, 3, -16 },
  { 1123, 9, 16, 13, 2, -16 },
  { 1141, 9, 11, 13, 2, -11 },
  { 1154, 7, 11, 13, 3, -11 },
  { 1164, 9, 11, 13, 2, -11 },
  { 1177, 8, 15, 13, 3, -11 },
  { 1192, 8, 15, 13, 2, -11 },
  { 1207, 10, 11, 13, 2, -11 },
  { 1221, 9, 11, 13, 2, -11 },
  { 1234, 10, 15, 13, 1, -15 },
  { 1253, 8, 11, 13, 2, -11 },
  { 1264, 9, 11, 13, 2, -11 },
  { 1277, 11, 11, 13, 1, -11 },
  { 1293, 9, 11, 13, 2, -11 },
  { 1306, 9, 15, 13, 2, -11 },
  { 1323, 8, 11, 13, 2, -11 },
  { 1334, 8, 19, 13, 2, -16 },
  { 1353, 1, 19, 13, 6, -16 },
  { 1356, 8, 19, 13, 2, -16 },
  { 1375, 10, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_Thin21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_THIN21PT7B_H_
