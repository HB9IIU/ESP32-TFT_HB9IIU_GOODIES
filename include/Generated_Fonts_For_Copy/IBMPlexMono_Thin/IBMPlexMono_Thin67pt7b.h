#ifndef _IBMPLEXMONO_THIN67PT7B_H_
#define _IBMPLEXMONO_THIN67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin67pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x22, 0x22, 0x22, 0x22, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x40, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x20, 0x06, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xE0, 0x87, 0x80, 0x06, 0x01, 0x01, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x60, 0x04, 0x00, 0xC1, 0x80, 0x08, 0x00, 0xC2, 0x00, 0x10,
  0x00, 0xCC, 0x00, 0x20, 0x00, 0x10, 0x00, 0x40, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x40, 0x01, 0x00, 0x01, 0x80, 0x02, 0x00, 0x01, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x04, 0x00, 0x10, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x10, 0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x38, 0x08, 0x00, 0x00,
  0x1E, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x87, 0x80, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x80, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x02, 0x00, 0x01,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x08, 0x00, 0x04, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x40, 0x00, 0x20, 0x01, 0x80, 0x00, 0x40,
  0x03, 0x40, 0x00, 0x80, 0x05, 0xC0, 0x01, 0x00, 0x18, 0xC0, 0x02, 0x00,
  0x20, 0xC0, 0x04, 0x00, 0xC0, 0xC0, 0x08, 0x03, 0x00, 0xE0, 0x10, 0x18,
  0x00, 0x7C, 0x21, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x18, 0x03, 0x00,
  0x00, 0x23, 0x00, 0x18, 0x00, 0x06, 0x20, 0x00, 0x80, 0x00, 0x46, 0x00,
  0x0C, 0x00, 0x0C, 0x40, 0x00, 0x40, 0x00, 0x84, 0x00, 0x04, 0x00, 0x10,
  0x40, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0x06, 0x0C, 0x00, 0x06, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x08, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x40, 0x00, 0x60, 0x10, 0x04, 0x00, 0x04, 0x03, 0x00,
  0x40, 0x00, 0x40, 0x20, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x00, 0x80,
  0xC0, 0x03, 0x00, 0x18, 0x08, 0x00, 0x18, 0x03, 0x01, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x08, 0x0C, 0x01, 0x80, 0x01,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x40, 0x02, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x04, 0x02, 0x00, 0x02, 0x00, 0x80, 0x20,
  0x00, 0x30, 0x18, 0x06, 0x00, 0x03, 0x01, 0x00, 0x60, 0x00, 0x30, 0x30,
  0x06, 0x00, 0x03, 0x02, 0x00, 0x60, 0x00, 0x30, 0x40, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x20, 0x00, 0x30, 0x80, 0x02, 0x00, 0x02, 0x18, 0x00, 0x20,
  0x00, 0x21, 0x00, 0x03, 0x00, 0x06, 0x20, 0x00, 0x10, 0x00, 0x46, 0x00,
  0x01, 0x80, 0x0C, 0x40, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x20, 0x00, 0x00, 0x06, 0x18, 0x00, 0x1F,
  0x86, 0x06, 0x00, 0x08, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x06,
  0x02, 0x00, 0x10, 0x03, 0x03, 0x00, 0x04, 0x01, 0x81, 0x00, 0x03, 0x00,
  0xC1, 0x80, 0x00, 0xC0, 0x40, 0xC0, 0x00, 0x30, 0x20, 0x60, 0x00, 0x0C,
  0x10, 0x20, 0x00, 0x02, 0x08, 0x10, 0x00, 0x00, 0x84, 0x08, 0x00, 0x00,
  0x66, 0x04, 0x00, 0x00, 0x1A, 0x02, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x00, 0xD8, 0x18, 0x00,
  0x00, 0x44, 0x04, 0x00, 0x00, 0x41, 0x03, 0x00, 0x00, 0x60, 0x40, 0xC0,
  0x00, 0x60, 0x30, 0x30, 0x00, 0xE0, 0x0C, 0x07, 0x01, 0xC0, 0x03, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xDF, 0x00, 0x30, 0x03, 0xE0, 0x78, 0x0C, 0x07, 0xC0, 0x03,
  0xC3, 0x0F, 0x80, 0x00, 0x1E, 0xDE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x30,
  0x60, 0xC1, 0x06, 0x0C, 0x10, 0x20, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10,
  0x04, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x06,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x10, 0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x04,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x3F, 0xE0, 0x02, 0x1C, 0x03, 0x80, 0x26, 0x00, 0x06,
  0x02, 0x80, 0x00, 0x30, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x03,
  0xFC, 0x00, 0x61, 0xC0, 0x38, 0x06, 0x70, 0x00, 0xE0, 0x4C, 0x00, 0x03,
  0x05, 0x80, 0x00, 0x18, 0xD0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x04, 0xE0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x78, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x42, 0x00,
  0x00, 0x1A, 0x18, 0x00, 0x00, 0xB0, 0x60, 0x00, 0x19, 0x00, 0xC0, 0x01,
  0x88, 0x03, 0x80, 0x70, 0xC0, 0x03, 0xFE, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x1E,
  0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x86, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x41,
  0x83, 0x04, 0x08, 0x30, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30,
  0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x7E, 0x0A, 0x00, 0x38,
  0x31, 0x40, 0x0C, 0x01, 0x28, 0x03, 0x00, 0x15, 0x00, 0x40, 0x01, 0xA0,
  0x18, 0x00, 0x3C, 0x02, 0x00, 0x07, 0x80, 0x40, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x03, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x38, 0x08, 0x00, 0x07, 0x01,
  0x00, 0x00, 0xE0, 0x20, 0x00, 0x1C, 0x04, 0x00, 0x03, 0x80, 0x80, 0x00,
  0x70, 0x10, 0x00, 0x0E, 0x02, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x10, 0x00, 0x34, 0x02, 0x00, 0x06,
  0x80, 0x60, 0x00, 0xD0, 0x04, 0x00, 0x2A, 0x00, 0x40, 0x05, 0x40, 0x0C,
  0x03, 0x2C, 0x00, 0x7B, 0xC5, 0x80, 0x00, 0x80, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x10, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x03, 0x80, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x1C,
  0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x08, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0A, 0x18, 0x00, 0x00, 0xD0, 0x60,
  0x00, 0x04, 0x81, 0x80, 0x00, 0x44, 0x06, 0x00, 0x0C, 0x20, 0x0E, 0x01,
  0xC1, 0x00, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x86, 0x00, 0x00, 0x81, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x80, 0x0E, 0x03, 0x80, 0x01, 0xFE, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x40, 0x03,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x03, 0x60, 0x00, 0x0C, 0x08, 0xC0,
  0x00, 0x30, 0x43, 0x00, 0x00, 0xC3, 0x06, 0x00, 0x03, 0x18, 0x0C, 0x00,
  0x0C, 0xC0, 0x30, 0x00, 0x36, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x40, 0x00,
  0x00, 0xBB, 0x00, 0x00, 0x0D, 0xC8, 0x00, 0x00, 0x4E, 0x60, 0x00, 0x06,
  0x71, 0x00, 0x00, 0x23, 0x8C, 0x00, 0x01, 0x1C, 0x20, 0x00, 0x18, 0xE1,
  0x80, 0x00, 0x87, 0x04, 0x00, 0x0C, 0x38, 0x20, 0x00, 0x41, 0xC1, 0x80,
  0x06, 0x0E, 0x04, 0x00, 0x20, 0x70, 0x30, 0x03, 0x03, 0x80, 0x80, 0x10,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x10, 0x08, 0x07, 0x00, 0xC0, 0x40, 0x38,
  0x02, 0x06, 0x01, 0xC0, 0x18, 0x20, 0x0E, 0x00, 0x43, 0x00, 0x70, 0x02,
  0x10, 0x03, 0x80, 0x19, 0x80, 0x1C, 0x00, 0x48, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x03, 0x84, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E,
  0x08, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x10, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0x20, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x40, 0x00, 0x70,
  0x0C, 0x00, 0x0E, 0x00, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x01, 0x00,
  0x07, 0x00, 0x30, 0x00, 0xE0, 0x02, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x04, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x08, 0x01, 0xC0, 0x01, 0x80,
  0x38, 0x00, 0x10, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x1C, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x08, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x10, 0xE0, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x23, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0x4E,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x40, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0xFE,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x10, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x60,
  0x01, 0x80, 0x02, 0x60, 0x01, 0x80, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x20,
  0x03, 0x40, 0x06, 0x20, 0x02, 0x40, 0x06, 0x20, 0x02, 0x60, 0x04, 0x20,
  0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x30, 0x04, 0x30,
  0x0C, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x04, 0x30, 0x08, 0x10, 0x0C, 0x30,
  0x08, 0x18, 0x0C, 0x10, 0x18, 0x08, 0x0C, 0x10, 0x10, 0x08, 0x0C, 0x10,
  0x10, 0x0C, 0x08, 0x10, 0x30, 0x0C, 0x08, 0x10, 0x30, 0x04, 0x08, 0x10,
  0x20, 0x04, 0x08, 0x18, 0x20, 0x06, 0x08, 0x18, 0x60, 0x02, 0x08, 0x18,
  0x40, 0x02, 0x08, 0x18, 0x40, 0x03, 0x18, 0x08, 0xC0, 0x03, 0x18, 0x08,
  0x80, 0x01, 0x18, 0x08, 0x80, 0x01, 0x98, 0x09, 0x80, 0x01, 0x90, 0x09,
  0x80, 0x00, 0x90, 0x09, 0x00, 0x00, 0x90, 0x0D, 0x00, 0x00, 0xD0, 0x0F,
  0x00, 0x00, 0xD0, 0x0E, 0x00, 0x00, 0x50, 0x0E, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x02, 0xC0, 0x30, 0x00,
  0x09, 0x80, 0x30, 0x00, 0x63, 0x00, 0x3C, 0x03, 0x83, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x03, 0xFC, 0x00, 0xC3, 0x80, 0x60, 0x18,
  0xC0, 0x03, 0x03, 0x20, 0x00, 0x30, 0x68, 0x00, 0x01, 0x0E, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x26, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x06, 0x34, 0x00, 0x00, 0x86, 0x40, 0x00, 0x20, 0xC6, 0x00, 0x18, 0x18,
  0x70, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x01, 0xFE, 0x03, 0x00, 0xE0, 0x38, 0x60, 0x60, 0x01, 0x8C, 0x18, 0x00,
  0x0D, 0x86, 0x00, 0x00, 0xB1, 0x80, 0x00, 0x0E, 0x20, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x58,
  0x30, 0x00, 0x1B, 0x03, 0x00, 0x0C, 0x60, 0x1C, 0x07, 0x0C, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0x08, 0x00, 0x07, 0x01, 0xD0, 0x00, 0x10, 0x00, 0xE0, 0x00,
  0x40, 0x00, 0x40, 0x01, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x7F, 0x80, 0x87, 0x01, 0xC1, 0x10,
  0x00, 0x62, 0x40, 0x00, 0x65, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x7F, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x78, 0x00, 0x03, 0x06, 0x60,
  0x00, 0x18, 0x61, 0x00, 0x00, 0xC6, 0x0C, 0x00, 0x06, 0x60, 0x30, 0x00,
  0x36, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x20, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0xC0, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xC2, 0x30, 0x60,
  0xC0, 0xC9, 0x00, 0x46, 0x01, 0xA8, 0x01, 0x90, 0x02, 0xC0, 0x02, 0x80,
  0x0F, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x80, 0xFF, 0x01, 0x0E, 0x03, 0x82,
  0x20, 0x00, 0xC4, 0x80, 0x00, 0xCA, 0x00, 0x00, 0x98, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x30, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x10, 0x04, 0x00, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0xFC, 0x00, 0xC0, 0x7F, 0x80, 0x18, 0x70, 0x0C, 0x03,
  0x18, 0x00, 0x60, 0x64, 0x00, 0x06, 0x0D, 0x00, 0x00, 0x21, 0xC0, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0xC0, 0x00, 0x03, 0x38, 0x00,
  0x00, 0xC6, 0x80, 0x00, 0x10, 0xC8, 0x00, 0x04, 0x18, 0xC0, 0x03, 0x03,
  0x0E, 0x01, 0xC0, 0x60, 0x3F, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x60, 0x1C, 0x07, 0x0C, 0x0C, 0x00, 0x31, 0x83, 0x00, 0x01,
  0xB0, 0xC0, 0x00, 0x16, 0x30, 0x00, 0x01, 0xC4, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0B, 0x06,
  0x00, 0x03, 0x60, 0x60, 0x01, 0x8C, 0x03, 0x80, 0xE1, 0x80, 0x1F, 0xE0,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0x80, 0x01, 0xC0,
  0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x07, 0x20,
  0x00, 0x0B, 0x10, 0x00, 0x1B, 0x0C, 0x00, 0x33, 0x07, 0x01, 0xC3, 0x01,
  0xFF, 0x00, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x10, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x20, 0x02, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x08, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x60, 0x00, 0x90, 0x00, 0x2C, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x02, 0x60, 0x01, 0x90, 0x00, 0xC4, 0x00, 0x22,
  0x00, 0x10, 0x80, 0x04, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x43, 0x00,
  0x11, 0x80, 0x18, 0x20, 0x06, 0x10, 0x02, 0x04, 0x00, 0xC2, 0x00, 0x40,
  0x80, 0x10, 0x40, 0x08, 0x18, 0x02, 0x0C, 0x03, 0x01, 0x00, 0x41, 0x80,
  0x40, 0x20, 0x18, 0x10, 0x08, 0x04, 0x03, 0x02, 0x01, 0x00, 0xC0, 0x40,
  0x40, 0x60, 0x08, 0x08, 0x0C, 0x08, 0x01, 0x01, 0x01, 0x81, 0x00, 0x20,
  0x20, 0x10, 0x20, 0x06, 0x0C, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x08, 0x20, 0x01, 0x04, 0x01, 0x84, 0x00, 0x30, 0x80, 0x31,
  0x80, 0x02, 0x30, 0x02, 0x20, 0x00, 0x46, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x08, 0x80, 0x01, 0x90, 0x01, 0xB0, 0x00, 0x12, 0x00, 0x34, 0x00, 0x02,
  0x40, 0x02, 0x80, 0x00, 0x58, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x04, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x40, 0x00,
  0x60, 0x02, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0x0C, 0x38, 0x00, 0x01, 0x18, 0x0C, 0x00, 0x01, 0x30, 0x06, 0x00,
  0x03, 0x20, 0x03, 0x00, 0x02, 0x60, 0x01, 0x80, 0x02, 0x40, 0x00, 0xC0,
  0x04, 0x40, 0x00, 0x60, 0x0C, 0xC0, 0x00, 0x30, 0x08, 0x80, 0x00, 0x0C,
  0x30, 0x80, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Thin67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 4, 47, 40, 18, -47 },
  { 25, 10, 17, 40, 15, -50 },
  { 47, 38, 47, 40, 1, -47 },
  { 271, 31, 63, 40, 4, -55 },
  { 516, 36, 49, 40, 2, -48 },
  { 737, 33, 49, 40, 3, -48 },
  { 940, 2, 17, 40, 19, -50 },
  { 945, 15, 60, 40, 16, -51 },
  { 1058, 15, 60, 40, 9, -51 },
  { 1171, 34, 33, 40, 3, -37 },
  { 1312, 32, 33, 40, 4, -37 },
  { 1444, 7, 17, 40, 15, -5 },
  { 1459, 18, 1, 40, 11, -21 },
  { 1462, 4, 4, 40, 18, -4 },
  { 1464, 26, 60, 40, 7, -51 },
  { 1659, 30, 49, 40, 5, -48 },
  { 1843, 31, 47, 40, 6, -47 },
  { 2026, 29, 48, 40, 6, -48 },
  { 2200, 28, 49, 40, 5, -48 },
  { 2372, 34, 47, 40, 3, -47 },
  { 2572, 28, 48, 40, 6, -47 },
  { 2740, 28, 48, 40, 6, -47 },
  { 2908, 29, 47, 40, 5, -47 },
  { 3079, 30, 49, 40, 5, -48 },
  { 3263, 29, 48, 40, 6, -48 },
  { 3437, 4, 35, 40, 18, -35 },
  { 3455, 7, 47, 40, 15, -35 },
  { 3497, 29, 36, 40, 6, -38 },
  { 3628, 32, 13, 40, 4, -27 },
  { 3680, 29, 36, 40, 6, -38 },
  { 3811, 26, 48, 40, 7, -48 },
  { 3967, 27, 55, 40, 6, -48 },
  { 4153, 34, 47, 40, 3, -47 },
  { 4353, 28, 47, 40, 7, -47 },
  { 4518, 30, 49, 40, 5, -48 },
  { 4702, 28, 47, 40, 7, -47 },
  { 4867, 27, 47, 40, 7, -47 },
  { 5026, 28, 47, 40, 7, -47 },
  { 5191, 29, 49, 40, 5, -48 },
  { 5369, 27, 47, 40, 7, -47 },
  { 5528, 28, 47, 40, 6, -47 },
  { 5693, 25, 48, 40, 6, -47 },
  { 5843, 30, 47, 40, 7, -47 },
  { 6020, 25, 47, 40, 10, -47 },
  { 6167, 29, 47, 40, 6, -47 },
  { 6338, 27, 47, 40, 7, -47 },
  { 6497, 30, 49, 40, 5, -48 },
  { 6681, 28, 47, 40, 7, -47 },
  { 6846, 30, 57, 40, 5, -48 },
  { 7060, 28, 47, 40, 7, -47 },
  { 7225, 31, 49, 40, 4, -48 },
  { 7415, 34, 47, 40, 3, -47 },
  { 7615, 27, 48, 40, 7, -47 },
  { 7777, 33, 47, 40, 4, -47 },
  { 7971, 32, 47, 40, 4, -47 },
  { 8159, 34, 47, 40, 3, -47 },
  { 8359, 36, 47, 40, 2, -47 },
  { 8571, 34, 47, 40, 3, -47 },
  { 8771, 16, 60, 40, 18, -51 },
  { 8891, 26, 60, 40, 7, -51 },
  { 9086, 16, 60, 40, 6, -51 },
  { 9206, 31, 25, 40, 5, -47 },
  { 9303, 32, 1, 40, 4, 8 },
  { 9307, 8, 11, 40, 14, -51 },
  { 9318, 31, 36, 40, 5, -35 },
  { 9458, 27, 51, 40, 8, -50 },
  { 9631, 27, 36, 40, 7, -35 },
  { 9753, 27, 51, 40, 5, -50 },
  { 9926, 28, 36, 40, 6, -35 },
  { 10052, 30, 50, 40, 6, -50 },
  { 10240, 31, 51, 40, 6, -37 },
  { 10438, 23, 50, 40, 9, -50 },
  { 10582, 28, 51, 40, 8, -51 },
  { 10761, 24, 64, 40, 6, -51 },
  { 10953, 29, 50, 40, 9, -50 },
  { 11135, 28, 50, 40, 6, -50 },
  { 11310, 30, 35, 40, 5, -35 },
  { 11442, 23, 35, 40, 9, -35 },
  { 11543, 28, 36, 40, 6, -35 },
  { 11669, 27, 48, 40, 8, -35 },
  { 11831, 27, 48, 40, 5, -35 },
  { 11993, 32, 35, 40, 5, -35 },
  { 12133, 29, 36, 40, 6, -35 },
  { 12264, 33, 47, 40, 2, -47 },
  { 12458, 24, 36, 40, 8, -35 },
  { 12566, 28, 35, 40, 6, -35 },
  { 12689, 35, 35, 40, 3, -35 },
  { 12843, 28, 35, 40, 6, -35 },
  { 12966, 29, 48, 40, 6, -35 },
  { 13140, 26, 35, 40, 7, -35 },
  { 13254, 24, 60, 40, 8, -51 },
  { 13434, 2, 60, 40, 19, -51 },
  { 13449, 24, 60, 40, 8, -51 },
  { 13629, 32, 11, 40, 4, -26 },
};

const GFXfont IBMPlexMono_Thin67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_THIN67PT7B_H_
