#ifndef _IBMPLEXMONO_THIN22PT7B_H_
#define _IBMPLEXMONO_THIN22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0xB6, 0xDB, 0x40, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09,
  0x00, 0x88, 0x3C, 0x3C, 0x22, 0x01, 0x10, 0x08, 0x87, 0xC7, 0x84, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x00, 0x04, 0x00, 0x80, 0x7C, 0x32,
  0x44, 0x45, 0x08, 0x21, 0x02, 0x20, 0x34, 0x01, 0xF0, 0x11, 0x02, 0x20,
  0x42, 0x08, 0x71, 0x11, 0x22, 0x1F, 0x80, 0x80, 0x10, 0x00, 0x78, 0x38,
  0x82, 0x84, 0x48, 0x48, 0x84, 0x88, 0x90, 0x79, 0x00, 0x00, 0x11, 0xC2,
  0x22, 0x24, 0x24, 0x42, 0x44, 0x28, 0x22, 0x81, 0xC0, 0x1C, 0x04, 0x41,
  0x04, 0x20, 0x04, 0x00, 0x40, 0x04, 0x01, 0xC3, 0xCC, 0x90, 0x92, 0x0A,
  0x40, 0xC8, 0x08, 0x86, 0x8F, 0x08, 0xFC, 0x08, 0x88, 0x84, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x42, 0x21, 0x11, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0C, 0x46, 0x7F, 0x03, 0x00, 0x50, 0x11, 0x04, 0x11, 0x02,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x5A, 0xA0, 0xFC, 0x80, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x00, 0x3E, 0x10, 0x48, 0x0A,
  0x02, 0x80, 0xA0, 0x18, 0x06, 0x21, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80,
  0x90, 0x43, 0xE0, 0x08, 0x06, 0x02, 0x81, 0x20, 0x88, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x3E, 0x20,
  0xA0, 0x50, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x04, 0x03, 0xFE, 0x3E, 0x20, 0xA0, 0x40, 0x20, 0x10, 0x10, 0xF0, 0x06,
  0x01, 0x00, 0x40, 0x20, 0x18, 0x12, 0x08, 0xF8, 0x00, 0x80, 0x70, 0x0A,
  0x02, 0x40, 0x88, 0x21, 0x04, 0x21, 0x04, 0x40, 0x88, 0x12, 0x02, 0x7F,
  0xF0, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xC0, 0x20, 0x10, 0x08, 0x05, 0xF1,
  0x05, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0A, 0x08, 0xF8, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x79, 0xC2, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0A, 0x08, 0xF8, 0xFF, 0xC0, 0x60, 0x50, 0x20, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x3E, 0x10, 0x48, 0x0A,
  0x02, 0x80, 0xA0, 0x24, 0x10, 0xF8, 0x63, 0x20, 0x28, 0x06, 0x01, 0x80,
  0xB0, 0x63, 0xE0, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83,
  0x3E, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x20, 0x40, 0x00,
  0x16, 0xA8, 0x00, 0x80, 0x81, 0x83, 0x02, 0x06, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x00, 0x1E, 0x30, 0xA0, 0x30, 0x10, 0x08, 0x04, 0x04, 0x0C, 0x18, 0x08,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3E, 0x30, 0x90, 0x50, 0x18, 0xEC,
  0x8E, 0x43, 0x41, 0xA0, 0xD0, 0x64, 0x32, 0x18, 0xFC, 0x01, 0x00, 0xC0,
  0x1F, 0x00, 0x04, 0x01, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x41,
  0x04, 0x20, 0x84, 0x10, 0xFF, 0x20, 0x24, 0x05, 0x00, 0x60, 0x08, 0xFE,
  0x40, 0xA0, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0xFC, 0x81, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xFC, 0x1E, 0x30, 0xA0, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0B, 0x08, 0x78, 0xFE, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02,
  0x80, 0xA0, 0x4F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x3E, 0x30, 0xA0, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x87,
  0xC0, 0x60, 0x30, 0x18, 0x0B, 0x0C, 0xFA, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x43, 0xFE, 0x7F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x42, 0x3C, 0x80, 0x60, 0x28, 0x12,
  0x08, 0x84, 0x22, 0x09, 0x02, 0xA0, 0xC4, 0x21, 0x08, 0x22, 0x04, 0x81,
  0x20, 0x28, 0x04, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0x80, 0xC0, 0xF0, 0x78,
  0x5A, 0x2D, 0x26, 0x53, 0x31, 0x88, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x80, 0xE0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2,
  0x61, 0x30, 0x58, 0x1C, 0x0E, 0x02, 0x3E, 0x10, 0x48, 0x0A, 0x02, 0x80,
  0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0x90, 0x43,
  0xE0, 0xFF, 0x20, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0xFF,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x3E, 0x10, 0x48, 0x0A,
  0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80,
  0x90, 0x43, 0xE0, 0x20, 0x08, 0x03, 0xC0, 0xFF, 0x20, 0x28, 0x0A, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x02, 0xFF, 0x22, 0x08, 0x42, 0x08, 0x81, 0x20,
  0x48, 0x08, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x78, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x1C, 0x04, 0x41, 0x87, 0xC0, 0xFF,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x08,
  0xF8, 0x80, 0x30, 0x09, 0x01, 0x20, 0x24, 0x08, 0x41, 0x08, 0x21, 0x08,
  0x11, 0x02, 0x20, 0x48, 0x05, 0x00, 0xA0, 0x18, 0x01, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x08, 0xA3, 0x14, 0x52, 0x4A, 0x4A, 0x49,
  0x45, 0x28, 0xA6, 0x14, 0xC1, 0x88, 0x20, 0x80, 0x28, 0x08, 0x82, 0x10,
  0x41, 0x10, 0x14, 0x03, 0x00, 0x20, 0x0A, 0x02, 0x40, 0x44, 0x10, 0x44,
  0x08, 0x80, 0xA0, 0x08, 0x80, 0x38, 0x02, 0x40, 0x42, 0x08, 0x20, 0x81,
  0x10, 0x0A, 0x00, 0xA0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x3F, 0xF8,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0xF0, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43,
  0xF0, 0x04, 0x01, 0x40, 0x48, 0x08, 0x82, 0x08, 0x41, 0x10, 0x14, 0x03,
  0xFF, 0xE0, 0x89, 0x10, 0x3C, 0x30, 0x80, 0x10, 0x04, 0x01, 0x1F, 0xC8,
  0x12, 0x04, 0x81, 0x21, 0xC7, 0x9C, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x1E, 0x10,
  0x90, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x90, 0x87, 0x80, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x3D, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0F, 0xFE, 0x01, 0x00,
  0x80, 0x20, 0x4F, 0xC0, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x83, 0xFE,
  0x01, 0xC0, 0x41, 0xF1, 0x84, 0x41, 0x20, 0x24, 0x11, 0x84, 0x1E, 0x18,
  0x04, 0x01, 0xFE, 0x80, 0x60, 0x18, 0x07, 0x02, 0x3F, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x01, 0x00, 0x00, 0x00, 0xFE,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x0E, 0x09, 0x08, 0x88,
  0x48, 0x3A, 0x11, 0x08, 0x44, 0x12, 0x05, 0x01, 0xF8, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x21, 0xFF, 0xF3, 0xA5, 0x28, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21,
  0x88, 0x62, 0x18, 0x84, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xA0, 0x8F, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x43, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xF3, 0xC5,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xF8,
  0x3E, 0x20, 0xA0, 0x30, 0x04, 0x01, 0xF8, 0x02, 0x01, 0x80, 0xA0, 0x4F,
  0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFC, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x05, 0xF8, 0x80, 0xC0, 0x60, 0x48, 0x24, 0x21,
  0x10, 0x88, 0x48, 0x14, 0x0C, 0x02, 0x00, 0x84, 0x31, 0x86, 0x28, 0xC5,
  0x19, 0x25, 0x24, 0x94, 0x52, 0x8A, 0x61, 0x4C, 0x29, 0x82, 0x00, 0x80,
  0xA0, 0x88, 0x84, 0x81, 0x40, 0x40, 0x50, 0x44, 0x42, 0x20, 0xA0, 0x20,
  0x80, 0xC0, 0x60, 0x48, 0x24, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0C, 0x02,
  0x02, 0x01, 0x01, 0x03, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x3F, 0xE0, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x10,
  0x08, 0x08, 0x08, 0xF0, 0x18, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x1F, 0xFF, 0xFF, 0xF0, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x1F, 0x30, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xF0, 0x38, 0x29, 0x86, 0x19, 0x40, 0xC0,
};

const GFXglyph IBMPlexMono_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 1, 15, 13, 6, -15 },
  { 3, 3, 6, 13, 5, -16 },
  { 6, 13, 15, 13, 0, -15 },
  { 31, 11, 19, 13, 1, -17 },
  { 58, 12, 15, 13, 1, -15 },
  { 81, 11, 15, 13, 1, -15 },
  { 102, 1, 6, 13, 6, -16 },
  { 103, 5, 20, 13, 5, -17 },
  { 116, 5, 20, 13, 3, -17 },
  { 129, 11, 11, 13, 1, -12 },
  { 145, 11, 11, 13, 1, -12 },
  { 161, 2, 6, 13, 5, -2 },
  { 163, 6, 1, 13, 4, -7 },
  { 164, 1, 1, 13, 6, -1 },
  { 165, 9, 20, 13, 2, -17 },
  { 188, 10, 15, 13, 2, -15 },
  { 207, 10, 15, 13, 2, -15 },
  { 226, 9, 15, 13, 2, -15 },
  { 243, 9, 15, 13, 2, -15 },
  { 260, 11, 15, 13, 1, -15 },
  { 281, 9, 15, 13, 2, -15 },
  { 298, 9, 15, 13, 2, -15 },
  { 315, 9, 15, 13, 2, -15 },
  { 332, 10, 15, 13, 2, -15 },
  { 351, 9, 15, 13, 2, -15 },
  { 368, 1, 11, 13, 6, -11 },
  { 370, 2, 15, 13, 5, -11 },
  { 374, 9, 12, 13, 2, -13 },
  { 388, 11, 5, 13, 1, -9 },
  { 395, 9, 12, 13, 2, -13 },
  { 409, 9, 15, 13, 2, -15 },
  { 426, 9, 17, 13, 2, -15 },
  { 446, 11, 15, 13, 1, -15 },
  { 467, 9, 15, 13, 2, -15 },
  { 484, 9, 15, 13, 2, -15 },
  { 501, 10, 15, 13, 2, -15 },
  { 520, 9, 15, 13, 2, -15 },
  { 537, 9, 15, 13, 2, -15 },
  { 554, 9, 15, 13, 2, -15 },
  { 571, 9, 15, 13, 2, -15 },
  { 588, 9, 15, 13, 2, -15 },
  { 605, 8, 15, 13, 2, -15 },
  { 620, 10, 15, 13, 2, -15 },
  { 639, 9, 15, 13, 3, -15 },
  { 656, 9, 15, 13, 2, -15 },
  { 673, 9, 15, 13, 2, -15 },
  { 690, 10, 15, 13, 2, -15 },
  { 709, 10, 15, 13, 2, -15 },
  { 728, 10, 18, 13, 2, -15 },
  { 751, 10, 15, 13, 2, -15 },
  { 770, 11, 15, 13, 1, -15 },
  { 791, 11, 15, 13, 1, -15 },
  { 812, 9, 15, 13, 2, -15 },
  { 829, 11, 15, 13, 1, -15 },
  { 850, 11, 15, 13, 1, -15 },
  { 871, 11, 15, 13, 1, -15 },
  { 892, 12, 15, 13, 1, -15 },
  { 915, 11, 15, 13, 1, -15 },
  { 936, 5, 20, 13, 6, -17 },
  { 949, 9, 20, 13, 2, -17 },
  { 972, 5, 20, 13, 2, -17 },
  { 985, 11, 8, 13, 1, -15 },
  { 996, 11, 1, 13, 1, 2 },
  { 998, 3, 4, 13, 4, -17 },
  { 1000, 10, 11, 13, 2, -11 },
  { 1014, 8, 16, 13, 3, -16 },
  { 1030, 9, 11, 13, 2, -11 },
  { 1043, 8, 16, 13, 2, -16 },
  { 1059, 9, 11, 13, 2, -11 },
  { 1072, 10, 16, 13, 2, -16 },
  { 1092, 10, 17, 13, 2, -13 },
  { 1114, 8, 16, 13, 3, -16 },
  { 1130, 9, 15, 13, 3, -15 },
  { 1147, 8, 19, 13, 2, -15 },
  { 1166, 9, 16, 13, 3, -16 },
  { 1184, 9, 16, 13, 2, -16 },
  { 1202, 10, 11, 13, 2, -11 },
  { 1216, 8, 11, 13, 3, -11 },
  { 1227, 9, 11, 13, 2, -11 },
  { 1240, 8, 15, 13, 3, -11 },
  { 1255, 8, 15, 13, 2, -11 },
  { 1270, 10, 11, 13, 2, -11 },
  { 1284, 9, 11, 13, 2, -11 },
  { 1297, 10, 15, 13, 1, -15 },
  { 1316, 7, 11, 13, 3, -11 },
  { 1326, 9, 11, 13, 2, -11 },
  { 1339, 11, 11, 13, 1, -11 },
  { 1355, 9, 11, 13, 2, -11 },
  { 1368, 9, 15, 13, 2, -11 },
  { 1385, 9, 11, 13, 2, -11 },
  { 1398, 8, 20, 13, 3, -17 },
  { 1418, 1, 20, 13, 6, -17 },
  { 1421, 8, 20, 13, 3, -17 },
  { 1441, 11, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_Thin22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_THIN22PT7B_H_
