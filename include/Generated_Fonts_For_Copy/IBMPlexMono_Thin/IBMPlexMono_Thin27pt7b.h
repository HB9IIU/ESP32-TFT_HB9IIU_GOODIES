#ifndef _IBMPLEXMONO_THIN27PT7B_H_
#define _IBMPLEXMONO_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x3C, 0x99, 0x99, 0x99, 0x90, 0x02, 0x20,
  0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x88, 0x1F, 0x0F, 0x84,
  0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x44, 0x0F, 0x87, 0xC2, 0x10,
  0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x84, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x01, 0xF8, 0x62, 0x44, 0x22, 0x82, 0x18, 0x20, 0x82, 0x08,
  0x20, 0x42, 0x03, 0xA0, 0x07, 0x80, 0x26, 0x02, 0x10, 0x21, 0x02, 0x10,
  0x21, 0x82, 0x14, 0x21, 0x22, 0x61, 0xF8, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x3C, 0x05, 0x18, 0x18, 0x20, 0xA0, 0x84, 0x82, 0x12, 0x08, 0x88, 0x22,
  0x11, 0x90, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x02, 0x22, 0x11, 0x04, 0x48,
  0x12, 0x20, 0x50, 0x81, 0x41, 0x06, 0x02, 0x28, 0x07, 0x00, 0x0F, 0x00,
  0x42, 0x02, 0x04, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0xD0, 0x74, 0x62, 0x20, 0xC8, 0x81, 0x22, 0x02, 0x88, 0x06,
  0x20, 0x08, 0x40, 0x51, 0x82, 0x41, 0xF0, 0xC0, 0xFE, 0x06, 0x10, 0x41,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x81, 0x02, 0x02, 0x04, 0x04, 0x04, 0x06, 0x81, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0x88,
  0x71, 0xEE, 0x00, 0xC0, 0x05, 0x00, 0x12, 0x00, 0x84, 0x04, 0x08, 0x30,
  0x30, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x03, 0xFF,
  0xE0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x29,
  0x29, 0x20, 0xFE, 0xF0, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x00,
  0x0F, 0x83, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x61, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02,
  0x40, 0x23, 0x04, 0x1F, 0x80, 0x02, 0x00, 0x70, 0x06, 0x80, 0x64, 0x06,
  0x20, 0x41, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x1F, 0xFE,
  0x0F, 0x83, 0x0C, 0x40, 0x28, 0x02, 0x80, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xFF, 0xF0, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x1F, 0x00, 0x38, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x2C, 0x18, 0x7C, 0x00, 0x00, 0x20, 0x01, 0x80,
  0x0A, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20,
  0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x22, 0x00, 0x8F, 0xFF, 0xC0, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x3F, 0xE4, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x05, 0xF8, 0x60, 0x44, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x28, 0x02, 0x40, 0x22, 0x0C, 0x1F, 0x80, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x4F,
  0x8B, 0x04, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40,
  0x23, 0x04, 0x1F, 0x80, 0xFF, 0xF8, 0x02, 0x80, 0x28, 0x02, 0x80, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x00, 0x1F, 0x82, 0x04,
  0x40, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x20, 0x41, 0xF8,
  0x30, 0xC4, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x16, 0x06,
  0x1F, 0x80, 0x0F, 0x83, 0x04, 0x40, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x33, 0x05, 0x1F, 0xA0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x6C,
  0x00, 0x00, 0x00, 0x00, 0x52, 0x52, 0x40, 0x00, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x1F,
  0x18, 0x28, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x81, 0xC0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x1F,
  0x18, 0x64, 0x06, 0x01, 0x80, 0x61, 0xD8, 0x8E, 0x41, 0x90, 0x64, 0x19,
  0x06, 0x41, 0x90, 0x64, 0x18, 0x8E, 0x1F, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x07, 0xF0, 0x01, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x20, 0x04, 0x80,
  0x22, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x40, 0x81, 0x02, 0x08, 0x08,
  0x1F, 0xF0, 0x80, 0x42, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00,
  0x40, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x9F, 0xE2, 0x03, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x50, 0x1B, 0xFE, 0x00, 0x0F, 0x83, 0x04, 0x20, 0x24, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x01, 0x20, 0x23, 0x04, 0x0F, 0x80, 0xFF, 0x10, 0x32,
  0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x33, 0xF8, 0x00,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x1F, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x02,
  0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83, 0xF8, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x60, 0x33, 0x05, 0x0F, 0x90, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F,
  0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x7F, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03,
  0x01, 0x80, 0xA0, 0x8F, 0x80, 0x80, 0x38, 0x04, 0x80, 0x88, 0x08, 0x81,
  0x08, 0x20, 0x84, 0x08, 0x80, 0x98, 0x0A, 0x40, 0xC4, 0x08, 0x20, 0x81,
  0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x48, 0x02, 0x80, 0x30, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x80, 0x1C,
  0x03, 0xC0, 0x3A, 0x05, 0xA0, 0x59, 0x09, 0x90, 0x99, 0x11, 0x89, 0x18,
  0xA1, 0x86, 0x18, 0x21, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1A, 0x03, 0x40, 0x64,
  0x0C, 0x81, 0x88, 0x31, 0x06, 0x10, 0xC2, 0x18, 0x23, 0x04, 0x60, 0x4C,
  0x05, 0x80, 0xB0, 0x0E, 0x01, 0x80, 0x0F, 0x83, 0x0C, 0x40, 0x24, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x23, 0x04, 0x1F, 0x80, 0xFF,
  0x90, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0B, 0xFE, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x00, 0x0F, 0x83, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x14, 0x02, 0x40, 0x23, 0x04, 0x1F, 0x80, 0x40, 0x04, 0x00, 0x40, 0x03,
  0xE0, 0xFF, 0x90, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0B, 0xFE, 0x42, 0x08, 0x21, 0x04, 0x20, 0x44, 0x04, 0x80,
  0x90, 0x0A, 0x00, 0x80, 0x1F, 0x86, 0x04, 0x40, 0x38, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x38, 0x00, 0x78, 0x00, 0x60, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x01, 0x40, 0x12, 0x06, 0x1F, 0x80, 0xFF, 0xFC, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x48, 0x10, 0xFC, 0x00, 0x80, 0x05,
  0x00, 0x24, 0x00, 0x90, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x08, 0x50, 0xC2, 0x86, 0x14, 0x48,
  0xA2, 0x45, 0x12, 0x29, 0x12, 0x48, 0x51, 0x42, 0x8C, 0x14, 0x60, 0x63,
  0x03, 0x18, 0x08, 0x40, 0x0D, 0x00, 0x22, 0x01, 0x04, 0x08, 0x10, 0x20,
  0x21, 0x00, 0x48, 0x01, 0x20, 0x03, 0x00, 0x04, 0x00, 0x30, 0x01, 0x20,
  0x08, 0x40, 0x21, 0x01, 0x02, 0x08, 0x04, 0x20, 0x11, 0x00, 0x28, 0x00,
  0x40, 0x80, 0x06, 0x00, 0x24, 0x00, 0x88, 0x04, 0x20, 0x20, 0x40, 0x80,
  0x84, 0x02, 0x20, 0x04, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x7F,
  0xF8, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x06, 0x00,
  0x60, 0x09, 0x01, 0x08, 0x10, 0x82, 0x04, 0x20, 0x44, 0x02, 0x80, 0x18,
  0x01, 0xFF, 0xF8, 0xC4, 0x21, 0x1F, 0x06, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x3F, 0xC4, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x41,
  0xC3, 0xE3, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xC5,
  0x04, 0xC0, 0x50, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x0A, 0x82, 0x4F, 0x80, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xA0, 0x22, 0x08,
  0x3E, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0xC9,
  0x05, 0x40, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x28, 0x04, 0x83, 0x8F, 0x90, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x02,
  0x80, 0x18, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x40, 0x34, 0x02,
  0x30, 0x40, 0xF8, 0x03, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x07, 0xFF, 0x00, 0x78, 0x02,
  0x03, 0xF0, 0x20, 0x82, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x20, 0x40,
  0x82, 0x03, 0xE0, 0x60, 0x04, 0x00, 0x10, 0x00, 0x7F, 0x88, 0x02, 0x80,
  0x0C, 0x00, 0x60, 0x04, 0xC0, 0x61, 0xFC, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xF2, 0x82, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7F,
  0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xFF, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x14, 0x04, 0x81, 0x10, 0xC2, 0x20, 0x48, 0x0A, 0x81,
  0x88, 0x20, 0x84, 0x10, 0x81, 0x10, 0x12, 0x01, 0x40, 0x10, 0xFC, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x0F, 0xFF, 0xB8, 0xEC, 0x51, 0x82, 0x18, 0x41, 0x84, 0x18,
  0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18,
  0x41, 0x9F, 0x28, 0x2C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0F, 0x83, 0x04, 0x40, 0x24,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24,
  0x02, 0x30, 0x40, 0xF8, 0x9F, 0x14, 0x13, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x2A, 0x09, 0x3E, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x24, 0x15, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x12,
  0x0E, 0x3E, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xFC, 0xF8,
  0x28, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xF8, 0x1F, 0x82, 0x06,
  0x40, 0x24, 0x00, 0x40, 0x02, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x10, 0x01,
  0x00, 0x1C, 0x01, 0x20, 0x21, 0xFC, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x7F, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0xFE, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x61, 0xCF, 0x90, 0x80, 0x30, 0x0A, 0x01, 0x40,
  0x44, 0x08, 0x81, 0x08, 0x41, 0x08, 0x21, 0x02, 0x40, 0x48, 0x0A, 0x00,
  0xC0, 0x08, 0x00, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x41, 0x84, 0x89,
  0x12, 0x24, 0x48, 0x92, 0x12, 0x48, 0x49, 0x21, 0x43, 0x05, 0x0C, 0x0C,
  0x30, 0x30, 0x40, 0x40, 0xC0, 0x34, 0x02, 0x20, 0x41, 0x08, 0x09, 0x00,
  0x90, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x82, 0x04, 0x40, 0x28,
  0x03, 0x80, 0x18, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x10, 0x81,
  0x08, 0x11, 0x00, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x70, 0x00, 0xFF, 0xC0, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x3F, 0xF0,
  0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x20, 0x10, 0xF8, 0x03, 0x00, 0x20, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x07, 0xC3, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFC, 0x00, 0x38, 0x0A, 0x60, 0xA1,
  0x85, 0x06, 0x28, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 19, 16, 7, -19 },
  { 6, 4, 7, 16, 6, -20 },
  { 10, 15, 19, 16, 1, -19 },
  { 46, 12, 25, 16, 2, -22 },
  { 84, 14, 19, 16, 1, -19 },
  { 118, 14, 19, 16, 1, -19 },
  { 152, 1, 7, 16, 8, -20 },
  { 153, 7, 25, 16, 6, -21 },
  { 175, 6, 25, 16, 4, -21 },
  { 194, 14, 13, 16, 1, -15 },
  { 217, 13, 13, 16, 2, -15 },
  { 239, 3, 7, 16, 6, -2 },
  { 242, 7, 1, 16, 5, -9 },
  { 243, 2, 2, 16, 7, -2 },
  { 244, 10, 25, 16, 3, -21 },
  { 276, 12, 19, 16, 2, -19 },
  { 305, 13, 19, 16, 2, -19 },
  { 336, 12, 19, 16, 2, -19 },
  { 365, 11, 19, 16, 2, -19 },
  { 392, 14, 19, 16, 1, -19 },
  { 426, 12, 19, 16, 2, -19 },
  { 455, 12, 19, 16, 2, -19 },
  { 484, 12, 19, 16, 2, -19 },
  { 513, 12, 19, 16, 2, -19 },
  { 542, 12, 19, 16, 2, -19 },
  { 571, 2, 15, 16, 7, -15 },
  { 575, 3, 20, 16, 6, -15 },
  { 583, 12, 14, 16, 2, -15 },
  { 604, 13, 6, 16, 2, -11 },
  { 614, 12, 14, 16, 2, -15 },
  { 635, 10, 19, 16, 3, -19 },
  { 659, 10, 22, 16, 3, -19 },
  { 687, 14, 19, 16, 1, -19 },
  { 721, 11, 19, 16, 3, -19 },
  { 748, 12, 19, 16, 2, -19 },
  { 777, 11, 19, 16, 3, -19 },
  { 804, 11, 19, 16, 3, -19 },
  { 831, 11, 19, 16, 3, -19 },
  { 858, 12, 19, 16, 2, -19 },
  { 887, 11, 19, 16, 3, -19 },
  { 914, 12, 19, 16, 2, -19 },
  { 943, 9, 19, 16, 3, -19 },
  { 965, 12, 19, 16, 3, -19 },
  { 994, 10, 19, 16, 4, -19 },
  { 1018, 12, 19, 16, 2, -19 },
  { 1047, 11, 19, 16, 3, -19 },
  { 1074, 12, 19, 16, 2, -19 },
  { 1103, 11, 19, 16, 3, -19 },
  { 1130, 12, 23, 16, 2, -19 },
  { 1165, 11, 19, 16, 3, -19 },
  { 1192, 12, 19, 16, 2, -19 },
  { 1221, 14, 19, 16, 1, -19 },
  { 1255, 11, 19, 16, 3, -19 },
  { 1282, 14, 19, 16, 1, -19 },
  { 1316, 13, 19, 16, 2, -19 },
  { 1347, 14, 19, 16, 1, -19 },
  { 1381, 14, 19, 16, 1, -19 },
  { 1415, 14, 19, 16, 1, -19 },
  { 1449, 7, 25, 16, 7, -21 },
  { 1471, 10, 25, 16, 3, -21 },
  { 1503, 6, 25, 16, 3, -21 },
  { 1522, 12, 10, 16, 2, -19 },
  { 1537, 13, 1, 16, 2, 3 },
  { 1539, 4, 4, 16, 5, -20 },
  { 1541, 12, 14, 16, 2, -14 },
  { 1562, 11, 20, 16, 3, -20 },
  { 1590, 11, 14, 16, 3, -14 },
  { 1610, 11, 20, 16, 2, -20 },
  { 1638, 12, 14, 16, 2, -14 },
  { 1659, 12, 20, 16, 2, -20 },
  { 1689, 13, 21, 16, 2, -16 },
  { 1724, 10, 20, 16, 3, -20 },
  { 1749, 11, 20, 16, 3, -20 },
  { 1777, 9, 25, 16, 3, -20 },
  { 1806, 11, 20, 16, 4, -20 },
  { 1834, 12, 20, 16, 2, -20 },
  { 1864, 12, 14, 16, 2, -14 },
  { 1885, 10, 14, 16, 3, -14 },
  { 1903, 12, 14, 16, 2, -14 },
  { 1924, 11, 19, 16, 3, -14 },
  { 1951, 11, 19, 16, 2, -14 },
  { 1978, 13, 14, 16, 2, -14 },
  { 2001, 12, 14, 16, 2, -14 },
  { 2022, 13, 19, 16, 1, -19 },
  { 2053, 10, 14, 16, 3, -14 },
  { 2071, 11, 14, 16, 3, -14 },
  { 2091, 14, 14, 16, 1, -14 },
  { 2116, 12, 14, 16, 2, -14 },
  { 2137, 12, 19, 16, 2, -14 },
  { 2166, 10, 14, 16, 3, -14 },
  { 2184, 10, 25, 16, 3, -21 },
  { 2216, 1, 25, 16, 8, -21 },
  { 2220, 10, 25, 16, 3, -21 },
  { 2252, 13, 5, 16, 2, -11 },
};

const GFXfont IBMPlexMono_Thin27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_THIN27PT7B_H_
