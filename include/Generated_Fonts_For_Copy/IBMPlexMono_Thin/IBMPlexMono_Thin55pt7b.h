#ifndef _IBMPLEXMONO_THIN55PT7B_H_
#define _IBMPLEXMONO_THIN55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20,
  0x00, 0x00, 0x7F, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x08, 0x02, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0x40, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x04, 0x01, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x20, 0x08, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x80, 0x20,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFE, 0x00, 0x0E, 0x10,
  0xE0, 0x0C, 0x08, 0x0C, 0x08, 0x04, 0x03, 0x08, 0x02, 0x00, 0xCC, 0x01,
  0x00, 0x24, 0x00, 0x80, 0x02, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0x80,
  0x10, 0x00, 0x40, 0x08, 0x00, 0x20, 0x04, 0x00, 0x10, 0x02, 0x00, 0x08,
  0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x20, 0x00,
  0x1C, 0x10, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x02, 0x78,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x40, 0x10, 0x00, 0x20,
  0x0C, 0x00, 0x10, 0x02, 0x00, 0x08, 0x01, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x07, 0x00, 0x10, 0x02, 0xC0, 0x08, 0x01, 0x30, 0x04, 0x01, 0x0C,
  0x02, 0x01, 0x83, 0x81, 0x01, 0x00, 0x70, 0x87, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x48, 0x02, 0x00, 0x06, 0x80, 0x08, 0x00, 0x24, 0x00, 0x40,
  0x02, 0x40, 0x01, 0x00, 0x12, 0x00, 0x08, 0x01, 0x10, 0x00, 0x40, 0x18,
  0x80, 0x02, 0x00, 0x84, 0x00, 0x10, 0x08, 0x20, 0x00, 0x80, 0x41, 0x00,
  0x04, 0x04, 0x08, 0x00, 0x20, 0x60, 0x20, 0x02, 0x02, 0x01, 0x00, 0x10,
  0x20, 0x04, 0x01, 0x01, 0x00, 0x18, 0x30, 0x10, 0x00, 0x3E, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x7C, 0x00, 0x08, 0x0C, 0x18, 0x00, 0x80,
  0x80, 0x20, 0x04, 0x08, 0x00, 0x80, 0x40, 0x40, 0x04, 0x06, 0x04, 0x00,
  0x30, 0x20, 0x20, 0x00, 0x82, 0x01, 0x00, 0x04, 0x10, 0x08, 0x00, 0x21,
  0x00, 0x40, 0x01, 0x18, 0x02, 0x00, 0x08, 0x80, 0x10, 0x00, 0x48, 0x00,
  0x80, 0x06, 0x40, 0x02, 0x00, 0x24, 0x00, 0x10, 0x01, 0x60, 0x00, 0x40,
  0x12, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x30, 0x03, 0xF1, 0x81, 0x80,
  0x20, 0x30, 0x08, 0x02, 0x02, 0x00, 0x40, 0x20, 0x60, 0x02, 0x02, 0x04,
  0x00, 0x30, 0x20, 0x40, 0x01, 0x82, 0x0C, 0x00, 0x0C, 0x20, 0xC0, 0x00,
  0x42, 0x0C, 0x00, 0x02, 0x40, 0xC0, 0x00, 0x14, 0x0C, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x13, 0x02, 0x00,
  0x03, 0x18, 0x30, 0x00, 0x60, 0xC1, 0x80, 0x0C, 0x06, 0x06, 0x03, 0x80,
  0x20, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x18, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x10, 0x01, 0x9E, 0x02, 0x03, 0xC0, 0x78, 0x43, 0xC0, 0x01, 0xEB,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x04, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x39, 0x8C, 0x62, 0x31, 0x88, 0x46,
  0x21, 0x08, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0,
  0x70, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x20,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x04, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x13, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x06, 0x01, 0x80, 0x18, 0x00, 0x60, 0x30, 0x00, 0x30, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x0E,
  0x03, 0x80, 0x30, 0x01, 0x80, 0x80, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x42, 0x00, 0x01, 0x03, 0x00, 0x04, 0x03, 0x80, 0x70,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x40, 0x10, 0x00, 0x10, 0x02, 0x00, 0x06, 0x00, 0x40, 0x00, 0x80, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x80, 0x10, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40,
  0x20, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x04, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x1F, 0xFF, 0xF8, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0xFF,
  0x00, 0xCE, 0x03, 0x81, 0x20, 0x00, 0x82, 0x80, 0x00, 0x86, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x63, 0x00, 0x01, 0x81, 0x80, 0x06, 0x01, 0xC0,
  0x38, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x7F, 0x00, 0x47, 0x01, 0xC0, 0x98, 0x00, 0xC1, 0x40, 0x00, 0x45,
  0x00, 0x00, 0x4A, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xA0, 0x00,
  0x02, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x80, 0xC0, 0x06, 0x00, 0xE0, 0x38, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x03, 0x00,
  0x04, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x00, 0xE0, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x60, 0x00,
  0xC0, 0x40, 0x00, 0x10, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x90, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x41, 0x00, 0x00, 0x40,
  0x60, 0x00, 0xC0, 0x1E, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x06, 0x03, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x00, 0x83, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x90, 0x00, 0x01, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x06, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x19, 0x80, 0x00, 0x51, 0x80, 0x01, 0x61, 0x80, 0x04,
  0x81, 0xC0, 0x71, 0x00, 0x7F, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x63, 0x11, 0x8C, 0x42, 0x31, 0x08,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x1C, 0x06, 0x00, 0x10, 0x60,
  0x00, 0x46, 0x00, 0x01, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x0C, 0x06, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x62, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x0D, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x0F, 0xC5, 0x00, 0xC0,
  0x9C, 0x06, 0x01, 0x70, 0x10, 0x03, 0x80, 0x80, 0x0E, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00, 0x18, 0x10,
  0x00, 0x60, 0x40, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x20, 0x01, 0x80, 0x80, 0x07, 0x02, 0x00, 0x1C, 0x0C, 0x00, 0xD0,
  0x10, 0x05, 0x40, 0x30, 0x15, 0x00, 0x7F, 0x94, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x10, 0x00,
  0x20, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x0C, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00, 0x20, 0x00, 0x20, 0x0F,
  0xFF, 0xFE, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x83, 0x00, 0x00, 0x86, 0x00, 0x00, 0x8C, 0x00,
  0x01, 0x98, 0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x04, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x98, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x21,
  0x80, 0x01, 0x83, 0xFF, 0xFE, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x70, 0x03, 0x00, 0x18, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x06, 0x18, 0x00, 0x03, 0x10, 0x00, 0x01, 0x30, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x10, 0x00, 0x01, 0x18, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x04, 0x00, 0x04, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x70, 0x00, 0x3F,
  0x80, 0xFF, 0xFC, 0x01, 0x00, 0x07, 0x02, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x50, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x62, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08, 0x00, 0x30, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xA0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xC0, 0xE0, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x04,
  0x10, 0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x10, 0x00, 0x05, 0x08, 0x00, 0x05, 0x0C, 0x00, 0x09,
  0x06, 0x00, 0x11, 0x01, 0xC0, 0x61, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x34,
  0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x04, 0x18, 0x00, 0x80, 0xE0, 0x70,
  0x03, 0xFC, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x80, 0x80, 0x01, 0x00, 0x80, 0x02, 0x00, 0x80, 0x04, 0x00,
  0x80, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00, 0x80, 0x60, 0x00,
  0x80, 0xC0, 0x00, 0x81, 0xC0, 0x00, 0x81, 0x40, 0x00, 0x82, 0x20, 0x00,
  0x84, 0x30, 0x00, 0x88, 0x10, 0x00, 0x90, 0x08, 0x00, 0xA0, 0x0C, 0x00,
  0xE0, 0x04, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x2D, 0x00, 0x00,
  0x5B, 0x00, 0x01, 0x32, 0x00, 0x02, 0x64, 0x00, 0x04, 0xC4, 0x00, 0x11,
  0x88, 0x00, 0x23, 0x08, 0x00, 0x86, 0x10, 0x01, 0x0C, 0x10, 0x04, 0x18,
  0x20, 0x08, 0x30, 0x60, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC1, 0x01, 0x80,
  0x82, 0x03, 0x01, 0x8C, 0x06, 0x01, 0x10, 0x0C, 0x03, 0x60, 0x18, 0x02,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x80, 0x00, 0x3D, 0x80, 0x00, 0x79, 0x00, 0x00, 0xF3, 0x00, 0x01, 0xE2,
  0x00, 0x03, 0xC6, 0x00, 0x07, 0x84, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x08,
  0x00, 0x3C, 0x18, 0x00, 0x78, 0x10, 0x00, 0xF0, 0x30, 0x01, 0xE0, 0x20,
  0x03, 0xC0, 0x20, 0x07, 0x80, 0x40, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80,
  0x3C, 0x00, 0x80, 0x78, 0x01, 0x00, 0xF0, 0x01, 0x01, 0xE0, 0x03, 0x03,
  0xC0, 0x02, 0x07, 0x80, 0x06, 0x0F, 0x00, 0x04, 0x1E, 0x00, 0x0C, 0x3C,
  0x00, 0x08, 0x78, 0x00, 0x18, 0xF0, 0x00, 0x11, 0xE0, 0x00, 0x33, 0xC0,
  0x00, 0x27, 0x80, 0x00, 0x6F, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x70, 0x01,
  0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x04, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0x81, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x48, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x22, 0x00, 0x01, 0x87, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E,
  0x03, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x48, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00,
  0x06, 0x80, 0x00, 0x09, 0x00, 0x00, 0x22, 0x00, 0x01, 0x87, 0xFF, 0xFC,
  0x08, 0x03, 0x00, 0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x04, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x08, 0x04, 0x00, 0x08, 0x08,
  0x00, 0x18, 0x10, 0x00, 0x10, 0x20, 0x00, 0x10, 0x40, 0x00, 0x30, 0x80,
  0x00, 0x21, 0x00, 0x00, 0x62, 0x00, 0x00, 0x44, 0x00, 0x00, 0x48, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x03, 0x02, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x33, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02,
  0x60, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x20, 0x80, 0x00, 0x81,
  0x80, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08,
  0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x08, 0x04, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x20, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x08, 0x00, 0x10, 0x01, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x08,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x26, 0x00,
  0x40, 0x0C, 0x40, 0x1C, 0x01, 0x08, 0x02, 0x80, 0x21, 0x00, 0x50, 0x04,
  0x20, 0x1B, 0x00, 0x84, 0x02, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10, 0x18,
  0xC0, 0x42, 0x02, 0x08, 0x08, 0x40, 0x41, 0x01, 0x0C, 0x08, 0x20, 0x60,
  0x82, 0x02, 0x0C, 0x10, 0x40, 0x41, 0x02, 0x08, 0x08, 0x20, 0x43, 0x01,
  0x84, 0x08, 0x40, 0x10, 0x81, 0x08, 0x02, 0x10, 0x23, 0x00, 0x62, 0x04,
  0x40, 0x04, 0x40, 0x88, 0x00, 0x88, 0x1B, 0x00, 0x1B, 0x03, 0x40, 0x01,
  0x60, 0x28, 0x00, 0x28, 0x05, 0x00, 0x05, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x01,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x60, 0x02, 0x00, 0x08, 0x00, 0x20, 0x02,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x04, 0x04, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x08, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80,
  0x08, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x64, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x10, 0x00, 0x10,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x08, 0x00, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xFF,
  0xC0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x02, 0x02, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x02,
  0x00, 0xC0, 0x01, 0x80, 0x40, 0x00, 0x40, 0x40, 0x00, 0x10, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x80, 0x81,
  0x81, 0x01, 0x01, 0x03, 0x02, 0x01, 0xFE, 0x00, 0x03, 0x81, 0xC0, 0x02,
  0x00, 0x30, 0x02, 0x00, 0x04, 0x02, 0x00, 0x03, 0x03, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x20,
  0x00, 0x1C, 0x18, 0x00, 0x16, 0x06, 0x00, 0x13, 0x01, 0xC0, 0x70, 0xF8,
  0x1F, 0xE0, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x81, 0xFC, 0x02, 0x38, 0x1C, 0x09, 0x80, 0x08, 0x28, 0x00, 0x10, 0xC0,
  0x00, 0x23, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x06, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x28, 0x00, 0x01, 0xA0, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8A,
  0x00, 0x04, 0x26, 0x00, 0x20, 0x8E, 0x03, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x0C, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x10, 0x00,
  0x18, 0x80, 0x00, 0x26, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x61, 0x80,
  0x03, 0x03, 0x00, 0x18, 0x03, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0xFE, 0x04, 0x0E, 0x07,
  0x10, 0x40, 0x06, 0x42, 0x00, 0x05, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x32,
  0x00, 0x00, 0x58, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50,
  0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x16, 0x00, 0x00, 0x48, 0x00,
  0x01, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x30, 0x80, 0x01, 0x41, 0x00, 0x19,
  0x03, 0x01, 0xC4, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x06, 0x03, 0x00,
  0x30, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x84, 0x00, 0x01, 0x18,
  0x00, 0x03, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xB0, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x60, 0x00, 0x40,
  0x60, 0x01, 0x00, 0x30, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x0F, 0xE2, 0x00, 0x0C, 0x06,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x40,
  0x00, 0x60, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x20, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x60, 0x18, 0x00, 0x10, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x06, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x40, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x07, 0x00, 0x0C, 0x00, 0x3F, 0xFC, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x83, 0xFC, 0x08, 0xC0, 0x70, 0x90, 0x01, 0x8A, 0x00, 0x0C,
  0xC0, 0x00, 0x4C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x47, 0xFF, 0xFC, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x20, 0x80, 0x00, 0x81,
  0x00, 0x06, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80, 0x10,
  0x04, 0x00, 0x20, 0x10, 0x00, 0x40, 0xC0, 0x00, 0x83, 0x80, 0x01, 0x0D,
  0x80, 0x02, 0x31, 0x80, 0x04, 0x81, 0x80, 0x0A, 0x01, 0x00, 0x18, 0x01,
  0x00, 0x20, 0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x03, 0x01, 0x00, 0x03,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00, 0x06,
  0x20, 0x00, 0x06, 0x40, 0x00, 0x06, 0x80, 0x00, 0x06, 0xFF, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x4C, 0x30,
  0xC3, 0x28, 0x04, 0x80, 0x58, 0x02, 0x80, 0x3C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x03, 0xFC, 0x08, 0xC0, 0x70, 0x90, 0x01, 0x8A, 0x00, 0x0C,
  0xC0, 0x00, 0x4C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x06, 0x03, 0x00, 0x30, 0x01, 0x80,
  0xC0, 0x01, 0x83, 0x00, 0x01, 0x84, 0x00, 0x01, 0x18, 0x00, 0x03, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x01, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x08, 0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0x30, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x02, 0x38, 0x1C, 0x09,
  0x80, 0x08, 0x28, 0x00, 0x10, 0xC0, 0x00, 0x23, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0, 0x00, 0x04,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x8A, 0x00, 0x04, 0x26, 0x00, 0x20, 0x8E,
  0x03, 0x02, 0x07, 0xF0, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0E,
  0x07, 0x10, 0x40, 0x06, 0x42, 0x00, 0x05, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x32, 0x00, 0x00, 0x58, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x16, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x30, 0x80, 0x01, 0x41, 0x00,
  0x19, 0x03, 0x01, 0xC4, 0x03, 0xF8, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xE0, 0x04, 0x30, 0x00, 0x00, 0x88, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x0C, 0x03, 0x80, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x42, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x70, 0x06, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x20, 0x00, 0x53,
  0x00, 0x05, 0x18, 0x00, 0x90, 0xE0, 0x31, 0x03, 0xFC, 0x00, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x09, 0x00, 0x00, 0x13, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x18, 0x00, 0x10,
  0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x20, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x02,
  0x02, 0x00, 0x04, 0x04, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10,
  0x40, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x80, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x28, 0x00, 0x50, 0x01, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x24, 0x00, 0xC8,
  0x01, 0x20, 0x04, 0x40, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x10, 0x04,
  0x20, 0x10, 0x40, 0x21, 0x00, 0x82, 0x01, 0x08, 0x04, 0x10, 0x08, 0x40,
  0x20, 0x80, 0x43, 0x02, 0x02, 0x06, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80,
  0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x40, 0x10, 0x40, 0xC2, 0x00, 0x86,
  0x02, 0x10, 0x04, 0x20, 0x11, 0x80, 0x31, 0x00, 0x88, 0x00, 0x88, 0x04,
  0x40, 0x04, 0x40, 0x32, 0x00, 0x22, 0x00, 0xB0, 0x00, 0xA0, 0x05, 0x00,
  0x05, 0x00, 0x28, 0x00, 0x28, 0x01, 0x40, 0x01, 0x40, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x80, 0x80, 0x02, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x10, 0x01, 0x00, 0x40,
  0x01, 0x01, 0x00, 0x03, 0x06, 0x00, 0x03, 0x18, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x44, 0x00, 0x01, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x20,
  0x08, 0x00, 0x80, 0x08, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x10, 0x00,
  0x10, 0x40, 0x00, 0x11, 0x00, 0x00, 0x16, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10,
  0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x20, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x02,
  0x02, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x11, 0x00, 0x00, 0x36, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x23, 0x0C, 0x00, 0x0C, 0xC0, 0x40, 0x01, 0x10, 0x04,
  0x00, 0x24, 0x00, 0x40, 0x0C, 0x80, 0x04, 0x01, 0x10, 0x00, 0x40, 0x44,
  0x00, 0x06, 0x18, 0x80, 0x00, 0x3C, 0x00,
};

const GFXglyph IBMPlexMono_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 3, 38, 33, 15, -38 },
  { 16, 9, 14, 33, 12, -41 },
  { 32, 31, 38, 33, 1, -38 },
  { 180, 25, 52, 33, 4, -45 },
  { 343, 29, 40, 33, 2, -39 },
  { 488, 28, 40, 33, 2, -39 },
  { 628, 1, 14, 33, 16, -41 },
  { 630, 13, 50, 33, 13, -42 },
  { 712, 13, 50, 33, 7, -42 },
  { 794, 27, 27, 33, 3, -30 },
  { 886, 27, 27, 33, 3, -30 },
  { 978, 5, 13, 33, 13, -4 },
  { 987, 15, 1, 33, 9, -17 },
  { 989, 3, 3, 33, 15, -3 },
  { 991, 21, 50, 33, 6, -42 },
  { 1123, 25, 40, 33, 4, -39 },
  { 1248, 25, 38, 33, 5, -38 },
  { 1367, 24, 39, 33, 5, -39 },
  { 1484, 23, 40, 33, 4, -39 },
  { 1599, 27, 38, 33, 3, -38 },
  { 1728, 23, 39, 33, 5, -38 },
  { 1841, 23, 39, 33, 5, -38 },
  { 1954, 24, 38, 33, 4, -38 },
  { 2068, 25, 40, 33, 4, -39 },
  { 2193, 23, 39, 33, 5, -39 },
  { 2306, 3, 29, 33, 15, -29 },
  { 2317, 5, 38, 33, 13, -29 },
  { 2341, 23, 29, 33, 5, -31 },
  { 2425, 27, 11, 33, 3, -22 },
  { 2463, 23, 29, 33, 5, -31 },
  { 2547, 21, 39, 33, 6, -39 },
  { 2650, 22, 45, 33, 5, -39 },
  { 2774, 27, 38, 33, 3, -38 },
  { 2903, 23, 38, 33, 5, -38 },
  { 3013, 24, 40, 33, 4, -39 },
  { 3133, 23, 38, 33, 6, -38 },
  { 3243, 22, 38, 33, 6, -38 },
  { 3348, 22, 38, 33, 6, -38 },
  { 3453, 24, 40, 33, 4, -39 },
  { 3573, 23, 38, 33, 5, -38 },
  { 3683, 23, 38, 33, 5, -38 },
  { 3793, 20, 39, 33, 5, -38 },
  { 3891, 24, 38, 33, 6, -38 },
  { 4005, 21, 38, 33, 8, -38 },
  { 4105, 23, 38, 33, 5, -38 },
  { 4215, 23, 38, 33, 5, -38 },
  { 4325, 25, 40, 33, 4, -39 },
  { 4450, 23, 38, 33, 6, -38 },
  { 4560, 25, 47, 33, 4, -39 },
  { 4707, 23, 38, 33, 6, -38 },
  { 4817, 25, 40, 33, 4, -39 },
  { 4942, 29, 38, 33, 2, -38 },
  { 5080, 23, 39, 33, 5, -38 },
  { 5193, 27, 38, 33, 3, -38 },
  { 5322, 27, 38, 33, 3, -38 },
  { 5451, 27, 38, 33, 3, -38 },
  { 5580, 29, 38, 33, 2, -38 },
  { 5718, 27, 38, 33, 3, -38 },
  { 5847, 13, 50, 33, 15, -42 },
  { 5929, 21, 50, 33, 6, -42 },
  { 6061, 13, 50, 33, 5, -42 },
  { 6143, 25, 21, 33, 4, -38 },
  { 6209, 27, 1, 33, 3, 7 },
  { 6213, 7, 9, 33, 11, -42 },
  { 6221, 25, 30, 33, 4, -29 },
  { 6315, 22, 42, 33, 7, -41 },
  { 6431, 22, 30, 33, 6, -29 },
  { 6514, 22, 42, 33, 4, -41 },
  { 6630, 23, 30, 33, 5, -29 },
  { 6717, 24, 41, 33, 5, -41 },
  { 6840, 26, 43, 33, 5, -31 },
  { 6980, 20, 41, 33, 7, -41 },
  { 7083, 23, 41, 33, 6, -41 },
  { 7201, 20, 52, 33, 5, -41 },
  { 7331, 23, 41, 33, 8, -41 },
  { 7449, 23, 41, 33, 5, -41 },
  { 7567, 25, 29, 33, 4, -29 },
  { 7658, 20, 29, 33, 7, -29 },
  { 7731, 23, 30, 33, 5, -29 },
  { 7818, 22, 40, 33, 7, -29 },
  { 7928, 22, 40, 33, 4, -29 },
  { 8038, 27, 28, 33, 4, -28 },
  { 8133, 23, 30, 33, 5, -29 },
  { 8220, 27, 38, 33, 2, -38 },
  { 8349, 20, 29, 33, 6, -28 },
  { 8422, 23, 28, 33, 5, -28 },
  { 8503, 29, 28, 33, 2, -28 },
  { 8605, 23, 28, 33, 5, -28 },
  { 8686, 23, 39, 33, 5, -28 },
  { 8799, 21, 28, 33, 6, -28 },
  { 8873, 21, 50, 33, 6, -42 },
  { 9005, 1, 50, 33, 16, -42 },
  { 9012, 21, 50, 33, 6, -42 },
  { 9144, 27, 9, 33, 3, -21 },
};

const GFXfont IBMPlexMono_Thin55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_THIN55PT7B_H_
