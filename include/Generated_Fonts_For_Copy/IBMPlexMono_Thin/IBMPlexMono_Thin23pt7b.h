#ifndef _IBMPLEXMONO_THIN23PT7B_H_
#define _IBMPLEXMONO_THIN23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x03, 0x99, 0x99, 0x99, 0x06, 0x60, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x44, 0x3E, 0x3C, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x3E, 0x3C, 0x11, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x08, 0x02,
  0x03, 0xE1, 0x26, 0x88, 0x62, 0x08, 0x82, 0x20, 0x48, 0x0F, 0x00, 0xB8,
  0x21, 0x08, 0x42, 0x10, 0x86, 0x21, 0x48, 0x8F, 0xC0, 0x80, 0x20, 0x78,
  0x18, 0x42, 0x84, 0x28, 0x44, 0x84, 0x88, 0x48, 0x85, 0x07, 0x80, 0x01,
  0xE1, 0x22, 0x24, 0x12, 0x41, 0x44, 0x14, 0x41, 0x82, 0x28, 0x1E, 0x1E,
  0x02, 0x10, 0x41, 0x04, 0x08, 0x40, 0x02, 0x00, 0x20, 0x03, 0x07, 0x48,
  0x48, 0x44, 0x82, 0x88, 0x18, 0x80, 0x88, 0x0C, 0x41, 0x43, 0xE2, 0xFC,
  0x0C, 0x42, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x03, 0x82, 0x08, 0x21, 0x04, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x22, 0x11, 0x11, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xC4, 0x33,
  0xDC, 0x06, 0x00, 0xA0, 0x11, 0x01, 0x08, 0x20, 0xC0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x69, 0x49, 0x00, 0xFC, 0xC0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x00, 0x1E, 0x18, 0x68, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x88, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x26, 0x18,
  0x78, 0x0C, 0x03, 0x80, 0xD0, 0x22, 0x08, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07, 0xFF, 0x1E,
  0x18, 0x48, 0x0A, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x03, 0xFF, 0x3E, 0x20, 0xA0, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x7C, 0x03, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x05, 0x04,
  0x7C, 0x00, 0x80, 0x18, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x10, 0x82,
  0x08, 0x40, 0x84, 0x08, 0x80, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x7F, 0x90, 0x04, 0x02, 0x00, 0x80, 0x20, 0x0B, 0xE1, 0x06, 0x80,
  0x80, 0x20, 0x04, 0x01, 0x00, 0xA0, 0x24, 0x10, 0xF8, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x09, 0xE2, 0x86, 0xC0, 0xA0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x26, 0x18, 0xF8, 0xFF, 0xE0, 0x28, 0x0A, 0x04, 0x81, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x3E, 0x10, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x24, 0x18, 0xF8, 0x61,
  0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x08, 0xFC, 0x1E, 0x18, 0x68,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x61, 0x87, 0xA0, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x60, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01,
  0xA5, 0x24, 0x00, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x0C, 0x04,
  0x06, 0x06, 0x02, 0x03, 0x00, 0x1E, 0x10, 0xD0, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x0E, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x1E,
  0x10, 0x90, 0x30, 0x18, 0x0C, 0x3E, 0x23, 0x21, 0x90, 0xC8, 0x64, 0x32,
  0x19, 0x0C, 0x7E, 0x00, 0x80, 0x20, 0x0F, 0xC0, 0x04, 0x00, 0x60, 0x0A,
  0x00, 0xA0, 0x09, 0x01, 0x10, 0x11, 0x01, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0xC4, 0x04, 0x40, 0x44, 0x02, 0x80, 0x28, 0x03, 0xFF, 0x20, 0x68, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x13, 0xFC, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0B, 0xFC, 0x1E, 0x08, 0x64, 0x0A, 0x01, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x50, 0x22, 0x08, 0x7C,
  0xFE, 0x20, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x13, 0xF8, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x1E, 0x18, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x08, 0x02, 0x00, 0x87, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x50, 0x16, 0x1C, 0x79, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x83, 0xFF,
  0x3F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x18, 0x0C, 0x09, 0x0C, 0x7C, 0x80, 0x70, 0x12, 0x04, 0x41, 0x08,
  0x41, 0x08, 0x22, 0x04, 0xC0, 0xA4, 0x18, 0x82, 0x08, 0x40, 0x88, 0x11,
  0x01, 0x20, 0x14, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x60,
  0x3C, 0x0F, 0x05, 0xA1, 0x68, 0x99, 0x26, 0x51, 0x94, 0x62, 0x18, 0x86,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0,
  0x64, 0x19, 0x06, 0x21, 0x88, 0x61, 0x18, 0x46, 0x09, 0x81, 0x60, 0x58,
  0x0E, 0x01, 0x1E, 0x18, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x26, 0x18, 0x78, 0xFF, 0x20,
  0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xFF, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1E, 0x18, 0x68, 0x0A, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x26,
  0x18, 0x78, 0x08, 0x02, 0x00, 0x78, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x02, 0xFF, 0x21, 0x08, 0x42, 0x08, 0x81, 0x20, 0x48,
  0x0A, 0x01, 0x3E, 0x10, 0x68, 0x06, 0x00, 0x80, 0x20, 0x04, 0x00, 0xF0,
  0x03, 0x80, 0x10, 0x04, 0x01, 0x00, 0x60, 0x14, 0x08, 0xFC, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x02, 0x80, 0xA0, 0x24, 0x18, 0xFC, 0x80, 0x38, 0x02, 0x40, 0x24, 0x04,
  0x40, 0x42, 0x04, 0x20, 0x82, 0x08, 0x10, 0x81, 0x10, 0x11, 0x00, 0x90,
  0x0A, 0x00, 0xA0, 0x06, 0x00, 0x40, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x08, 0x61, 0x8A, 0x51, 0x4A, 0x29, 0x25, 0x45, 0x28, 0xA5, 0x14,
  0xA1, 0x98, 0x31, 0x02, 0x80, 0x24, 0x04, 0x20, 0x42, 0x08, 0x11, 0x00,
  0x90, 0x0A, 0x00, 0x40, 0x06, 0x00, 0xA0, 0x11, 0x01, 0x08, 0x20, 0x84,
  0x04, 0x40, 0x28, 0x03, 0x80, 0x18, 0x02, 0x40, 0x24, 0x04, 0x20, 0x81,
  0x08, 0x11, 0x00, 0xA0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x7F, 0xE0, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x0F, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x08, 0x05, 0x01,
  0x20, 0x88, 0x41, 0x10, 0x48, 0x0A, 0x01, 0x80, 0x40, 0xFF, 0xE0, 0x91,
  0x30, 0x3E, 0x30, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xCC, 0x12, 0x04, 0x81,
  0x20, 0xC8, 0x31, 0xF3, 0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xE3, 0x0D,
  0x02, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x86, 0xBC, 0x00,
  0x3C, 0x21, 0x20, 0x50, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xD0,
  0x87, 0x80, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09, 0xF5, 0x07, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83, 0x3E, 0x80, 0x1E, 0x18,
  0x48, 0x0A, 0x02, 0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x36, 0x08,
  0x7C, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC0, 0x00,
  0xE3, 0xE0, 0x84, 0x20, 0x44, 0x08, 0x81, 0x10, 0x21, 0x08, 0x1E, 0x0C,
  0x01, 0x00, 0x20, 0x03, 0xF9, 0x80, 0xA0, 0x14, 0x02, 0x40, 0x47, 0xF0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x7F, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x28, 0x12, 0x18, 0x88, 0x24, 0x0A,
  0x83, 0x20, 0x84, 0x20, 0x88, 0x12, 0x02, 0x80, 0xC0, 0xF8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC0, 0xF3, 0xA3, 0x18, 0x86, 0x21,
  0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0xBC, 0xC2,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x18,
  0x48, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x26, 0x10,
  0x78, 0xBC, 0x61, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xB0, 0xD7, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x3E, 0xA0, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x67, 0xD0, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xF3, 0xE2, 0x80, 0x60, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x7F, 0xE0, 0x3E, 0x10,
  0x68, 0x02, 0x00, 0x40, 0x0F, 0x00, 0x38, 0x01, 0x00, 0x60, 0x14, 0x08,
  0xFC, 0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x7D, 0x80,
  0xE0, 0x24, 0x09, 0x04, 0x41, 0x08, 0x42, 0x20, 0x88, 0x12, 0x05, 0x00,
  0xC0, 0x20, 0x84, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0x8A, 0x28, 0x92, 0x51,
  0x25, 0x12, 0x51, 0x45, 0x0C, 0x60, 0xC6, 0x04, 0x80, 0xD0, 0x22, 0x10,
  0x88, 0x14, 0x03, 0x00, 0xC0, 0x50, 0x22, 0x08, 0x44, 0x0A, 0x03, 0x80,
  0x60, 0x28, 0x09, 0x04, 0x41, 0x08, 0x42, 0x20, 0x88, 0x14, 0x05, 0x00,
  0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0xE0, 0x00, 0x7F, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1F, 0xF0, 0x1F,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x04, 0x08, 0xF0, 0x18, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xFF, 0xFF, 0xF0, 0xF8, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x10, 0x0F, 0x18, 0x20, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x38, 0x29, 0x86, 0x10, 0xC1, 0x18,
  0x1C,
};

const GFXglyph IBMPlexMono_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 16, 14, 6, -16 },
  { 5, 4, 6, 14, 5, -17 },
  { 8, 13, 16, 14, 0, -16 },
  { 34, 10, 20, 14, 2, -18 },
  { 59, 12, 16, 14, 1, -16 },
  { 83, 12, 16, 14, 1, -16 },
  { 107, 1, 6, 14, 6, -17 },
  { 108, 6, 20, 14, 5, -17 },
  { 123, 5, 20, 14, 3, -17 },
  { 136, 12, 11, 14, 1, -13 },
  { 153, 11, 11, 14, 1, -13 },
  { 169, 3, 6, 14, 5, -2 },
  { 172, 6, 1, 14, 4, -8 },
  { 173, 2, 1, 14, 6, -1 },
  { 174, 9, 20, 14, 2, -17 },
  { 197, 10, 16, 14, 2, -16 },
  { 217, 11, 16, 14, 2, -16 },
  { 239, 10, 16, 14, 2, -16 },
  { 259, 9, 16, 14, 2, -16 },
  { 277, 12, 16, 14, 1, -16 },
  { 301, 10, 16, 14, 2, -16 },
  { 321, 10, 16, 14, 2, -16 },
  { 341, 10, 16, 14, 2, -16 },
  { 361, 10, 16, 14, 2, -16 },
  { 381, 10, 16, 14, 2, -16 },
  { 401, 2, 12, 14, 6, -12 },
  { 404, 3, 16, 14, 5, -12 },
  { 410, 10, 12, 14, 2, -13 },
  { 425, 11, 6, 14, 1, -10 },
  { 434, 10, 12, 14, 2, -13 },
  { 449, 9, 16, 14, 2, -16 },
  { 467, 9, 18, 14, 2, -16 },
  { 488, 12, 16, 14, 1, -16 },
  { 512, 10, 16, 14, 2, -16 },
  { 532, 10, 16, 14, 2, -16 },
  { 552, 10, 16, 14, 2, -16 },
  { 572, 10, 16, 14, 2, -16 },
  { 592, 10, 16, 14, 2, -16 },
  { 612, 10, 16, 14, 2, -16 },
  { 632, 10, 16, 14, 2, -16 },
  { 652, 10, 16, 14, 2, -16 },
  { 672, 9, 16, 14, 2, -16 },
  { 690, 11, 16, 14, 2, -16 },
  { 712, 9, 16, 14, 3, -16 },
  { 730, 10, 16, 14, 2, -16 },
  { 750, 10, 16, 14, 2, -16 },
  { 770, 10, 16, 14, 2, -16 },
  { 790, 10, 16, 14, 2, -16 },
  { 810, 10, 19, 14, 2, -16 },
  { 834, 10, 16, 14, 2, -16 },
  { 854, 10, 16, 14, 2, -16 },
  { 874, 12, 16, 14, 1, -16 },
  { 898, 10, 16, 14, 2, -16 },
  { 918, 12, 16, 14, 1, -16 },
  { 942, 11, 16, 14, 1, -16 },
  { 964, 12, 16, 14, 1, -16 },
  { 988, 12, 16, 14, 1, -16 },
  { 1012, 12, 16, 14, 1, -16 },
  { 1036, 6, 20, 14, 6, -17 },
  { 1051, 9, 20, 14, 2, -17 },
  { 1074, 6, 20, 14, 2, -17 },
  { 1089, 10, 9, 14, 2, -16 },
  { 1101, 11, 1, 14, 1, 3 },
  { 1103, 3, 4, 14, 5, -18 },
  { 1105, 10, 12, 14, 2, -12 },
  { 1120, 9, 17, 14, 3, -17 },
  { 1140, 9, 12, 14, 3, -12 },
  { 1154, 9, 17, 14, 2, -17 },
  { 1174, 10, 12, 14, 2, -12 },
  { 1189, 10, 17, 14, 2, -17 },
  { 1211, 11, 18, 14, 2, -13 },
  { 1236, 8, 17, 14, 3, -17 },
  { 1253, 9, 17, 14, 3, -17 },
  { 1273, 8, 22, 14, 2, -17 },
  { 1295, 10, 17, 14, 3, -17 },
  { 1317, 10, 17, 14, 2, -17 },
  { 1339, 10, 12, 14, 2, -12 },
  { 1354, 8, 12, 14, 3, -12 },
  { 1366, 10, 12, 14, 2, -12 },
  { 1381, 9, 17, 14, 3, -12 },
  { 1401, 9, 17, 14, 2, -12 },
  { 1421, 11, 12, 14, 2, -12 },
  { 1438, 10, 12, 14, 2, -12 },
  { 1453, 11, 16, 14, 1, -16 },
  { 1475, 8, 12, 14, 3, -12 },
  { 1487, 10, 12, 14, 2, -12 },
  { 1502, 12, 12, 14, 1, -12 },
  { 1520, 10, 12, 14, 2, -12 },
  { 1535, 10, 17, 14, 2, -12 },
  { 1557, 9, 12, 14, 2, -12 },
  { 1571, 8, 20, 14, 3, -17 },
  { 1591, 1, 20, 14, 6, -17 },
  { 1594, 8, 20, 14, 3, -17 },
  { 1614, 11, 5, 14, 1, -9 },
};

const GFXfont IBMPlexMono_Thin23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_THIN23PT7B_H_
