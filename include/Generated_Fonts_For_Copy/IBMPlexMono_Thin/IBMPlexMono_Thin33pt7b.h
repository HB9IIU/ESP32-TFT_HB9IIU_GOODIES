#ifndef _IBMPLEXMONO_THIN33PT7B_H_
#define _IBMPLEXMONO_THIN33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00,
  0x82, 0x00, 0x20, 0x81, 0xF8, 0x3F, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x0F, 0xC1, 0xF8, 0x10, 0x80,
  0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02,
  0x10, 0x01, 0x04, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0x01,
  0x91, 0x84, 0x20, 0x90, 0x40, 0xA0, 0x80, 0x81, 0x01, 0x02, 0x01, 0x04,
  0x02, 0x08, 0x03, 0x10, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x84, 0x01, 0x04,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x50, 0x40, 0x90,
  0x82, 0x19, 0x18, 0x0F, 0xE0, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x1E,
  0x00, 0x58, 0x40, 0x24, 0x08, 0x12, 0x02, 0x04, 0x80, 0x82, 0x20, 0x20,
  0x88, 0x08, 0x42, 0x02, 0x20, 0x40, 0x88, 0x18, 0x44, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x01, 0x88, 0x40, 0x44, 0x08, 0x22, 0x02, 0x08,
  0x80, 0x44, 0x20, 0x12, 0x08, 0x04, 0x82, 0x02, 0x40, 0x40, 0x90, 0x08,
  0x48, 0x01, 0xE0, 0x07, 0xC0, 0x04, 0x10, 0x04, 0x04, 0x02, 0x01, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x03, 0x40, 0x72, 0x10, 0x42, 0x04, 0x21, 0x01, 0x11, 0x00,
  0xC8, 0x80, 0x34, 0x40, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x84, 0x01, 0x21,
  0x83, 0x08, 0x3E, 0x06, 0xFF, 0x02, 0x08, 0x20, 0x82, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x20, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0xC1, 0x03, 0x39, 0x1C, 0x07, 0xE0, 0x01, 0x80, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x08, 0x20, 0x0C, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x69, 0x29, 0x24, 0x80,
  0xFF, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x00, 0x07, 0xE0, 0x30, 0x20, 0xC0, 0x21, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x11, 0x00, 0x23, 0x00, 0x83, 0x02, 0x01, 0xF8, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x34, 0x00, 0xC8, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0xC1, 0x84, 0x01,
  0x10, 0x02, 0x80, 0x0A, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0xC0, 0xFC, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x40,
  0x08, 0xC0, 0xC0, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x50, 0x00,
  0x50, 0x00, 0x90, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04,
  0x10, 0x08, 0x10, 0x10, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x80,
  0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x3F, 0xF9, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x3F, 0x07, 0x03, 0x10, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xA0, 0x02, 0x40, 0x10, 0xC0, 0x80, 0xFC, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x3F, 0x09, 0x03, 0x38, 0x06, 0xC0, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x90, 0x02, 0x40, 0x10, 0xC0, 0x80, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x30, 0x80, 0x12,
  0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x20, 0x04, 0x30,
  0x30, 0x1F, 0x80, 0xC1, 0xC2, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x43, 0x03, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0xC0, 0xC6, 0x01, 0x90, 0x02, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0xD8, 0x05, 0x30,
  0x28, 0x3F, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x6C, 0x00, 0x00, 0x00, 0x00, 0x1A, 0x4A, 0x49, 0x20, 0x00, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x0F, 0xC0, 0x81, 0x88, 0x06, 0x80, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x03, 0x80, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0xC3, 0x08, 0x04, 0x80, 0x24,
  0x00, 0xA0, 0x06, 0x00, 0x30, 0x3D, 0x82, 0x1C, 0x20, 0x62, 0x03, 0x10,
  0x18, 0x80, 0xC4, 0x06, 0x20, 0x31, 0x01, 0x88, 0x0C, 0x20, 0x61, 0x87,
  0x07, 0xD8, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0xFE, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x3F, 0xFC, 0x20, 0x04, 0x20,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0xC2, 0x00, 0xC8, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x48, 0x02, 0x3F, 0xF8, 0x80, 0x12, 0x00, 0x28,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A,
  0x00, 0x4F, 0xFE, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x40,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x50, 0x02, 0x20, 0x08, 0x60, 0xC0, 0x7C, 0x00, 0xFF, 0x84, 0x06,
  0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x02, 0x40, 0x63, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xE8, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x20, 0x40, 0x21, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x50, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x09, 0x00, 0x31, 0x00, 0xA1, 0x83, 0x41, 0xF8, 0x80, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x23, 0x04, 0x0F, 0x80, 0x80, 0x06, 0x00, 0x28,
  0x01, 0x20, 0x08, 0x80, 0x42, 0x02, 0x08, 0x10, 0x20, 0x80, 0x84, 0x02,
  0x20, 0x09, 0x40, 0x25, 0x00, 0xA2, 0x03, 0x04, 0x08, 0x10, 0x20, 0x20,
  0x80, 0x42, 0x01, 0x08, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x28, 0x00,
  0x40, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0,
  0x80, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x05, 0xA0, 0x16, 0x80, 0x99, 0x02,
  0x64, 0x11, 0x88, 0x46, 0x22, 0x18, 0x48, 0x61, 0x41, 0x85, 0x06, 0x0C,
  0x18, 0x20, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0xC0, 0x07, 0x00, 0x1A, 0x00, 0x68, 0x01,
  0x90, 0x06, 0x40, 0x18, 0x80, 0x62, 0x01, 0x84, 0x06, 0x10, 0x18, 0x20,
  0x60, 0x81, 0x81, 0x06, 0x04, 0x18, 0x08, 0x60, 0x21, 0x80, 0x46, 0x01,
  0x18, 0x02, 0x60, 0x09, 0x80, 0x16, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xE0,
  0x30, 0x20, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x50, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x11, 0x00, 0x23,
  0x00, 0x83, 0x02, 0x01, 0xF8, 0x00, 0xFF, 0xC4, 0x01, 0xA0, 0x05, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05,
  0x00, 0x6F, 0xFC, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x20,
  0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x11, 0x00, 0x23, 0x00, 0x83,
  0x02, 0x01, 0xF8, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x03, 0xF0, 0xFF,
  0xC4, 0x01, 0xA0, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x6F, 0xFC, 0x41, 0x02, 0x08, 0x10,
  0x20, 0x80, 0x84, 0x04, 0x20, 0x11, 0x00, 0x48, 0x02, 0x40, 0x0A, 0x00,
  0x20, 0x07, 0xE0, 0x30, 0x30, 0x80, 0x12, 0x00, 0x14, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0A, 0x00, 0x12, 0x00, 0x43, 0x03, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x10, 0xC0,
  0xC0, 0xFC, 0x00, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x81, 0x82, 0x81, 0x82, 0x42, 0x82, 0x42, 0x82, 0x42,
  0x42, 0x42, 0x42, 0x44, 0x42, 0x44, 0x24, 0x44, 0x24, 0x48, 0x24, 0x48,
  0x14, 0x48, 0x14, 0x30, 0x14, 0x30, 0x14, 0x30, 0x0C, 0x30, 0x0C, 0x80,
  0x01, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x10, 0x08,
  0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x02, 0x40, 0x04, 0x20, 0x08, 0x20, 0x08, 0x10, 0x10, 0x08, 0x20,
  0x08, 0x20, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x00, 0x50,
  0x00, 0x24, 0x00, 0x10, 0x80, 0x04, 0x10, 0x02, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x04, 0x08, 0x00, 0x84, 0x00, 0x22, 0x00, 0x04, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x08, 0x20, 0x08, 0x20, 0x04, 0x40, 0x02, 0x80, 0x03,
  0xFF, 0xFF, 0x84, 0x42, 0x10, 0x1F, 0x80, 0xC0, 0x83, 0x00, 0x84, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x3F, 0xF0, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x20, 0x68, 0x3F,
  0x1E, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x11, 0xF0, 0xB0, 0x66, 0x01, 0xA0, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x60,
  0x0A, 0xC1, 0x91, 0xF0, 0x0F, 0x81, 0x83, 0x10, 0x05, 0x00, 0x28, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x0D, 0x00, 0x46, 0x0C, 0x0F, 0x80, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x21, 0xF1, 0x30, 0x6A, 0x00,
  0xF0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x0C, 0xC1, 0xA1, 0xF1, 0x0F,
  0xC0, 0xC0, 0x82, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60,
  0x01, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x32,
  0x00, 0x8C, 0x0C, 0x0F, 0xC0, 0x01, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x7F, 0xFF, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x40, 0x3F, 0x80, 0xC1, 0x02, 0x01, 0x04,
  0x02, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x10, 0x80, 0x41, 0x00,
  0x81, 0x82, 0x03, 0xF8, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xFF, 0xE3, 0x00, 0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x60,
  0x0C, 0x3F, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0xF8, 0xB0, 0x4C, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xFF, 0xFC, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x27, 0xFE, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x06, 0x80, 0x22, 0x01, 0x08, 0x08, 0x20, 0xC0, 0x84, 0x02, 0x20, 0x09,
  0x40, 0x29, 0x00, 0xC2, 0x02, 0x04, 0x08, 0x08, 0x20, 0x10, 0x80, 0x22,
  0x00, 0x88, 0x01, 0x20, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x9E,
  0x3D, 0x46, 0x87, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x8F, 0x8B, 0x04, 0xC0, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0F, 0xC0, 0xC0,
  0x86, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x09, 0x00, 0x26, 0x01, 0x0C,
  0x08, 0x0F, 0xC0, 0x8F, 0x85, 0x83, 0x30, 0x0D, 0x00, 0x28, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0B, 0x00, 0x56, 0x0C, 0x8F, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x0F, 0x89, 0x83, 0x50, 0x07, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x66, 0x0D, 0x0F, 0x88, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFC, 0x7E, 0x09,
  0x00, 0x14, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0xFF, 0xFC, 0x0F, 0xC0, 0xC0, 0xC4, 0x00, 0x90, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x14, 0x00, 0x8C, 0x06, 0x0F, 0xE0, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x36, 0x0D, 0x1F, 0x10, 0x80,
  0x06, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x10, 0x80, 0x42, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x12, 0x00,
  0x50, 0x00, 0xC0, 0x03, 0x00, 0x80, 0xC0, 0xE0, 0x30, 0x28, 0x14, 0x09,
  0x05, 0x02, 0x41, 0x20, 0x90, 0x48, 0x24, 0x22, 0x11, 0x08, 0x84, 0x22,
  0x11, 0x08, 0x84, 0x42, 0x41, 0x10, 0x90, 0x28, 0x24, 0x0A, 0x05, 0x02,
  0x81, 0x80, 0xA0, 0x60, 0x18, 0x18, 0x04, 0x00, 0x80, 0x0D, 0x00, 0x22,
  0x01, 0x04, 0x08, 0x10, 0x40, 0x21, 0x00, 0x48, 0x00, 0xC0, 0x02, 0x00,
  0x14, 0x00, 0x48, 0x02, 0x10, 0x10, 0x40, 0x80, 0x82, 0x01, 0x10, 0x02,
  0x80, 0x0C, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x10, 0x80,
  0x42, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x00, 0x84, 0x02, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x50, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x3C, 0x00, 0x7F, 0xF8, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xFF, 0xF8,
  0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0xFC, 0x00, 0xE0,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xF0,
  0x60, 0x08, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xE0, 0x3C, 0x01,
  0x62, 0x01, 0x41, 0x02, 0x80, 0x82, 0x80, 0x44, 0x80, 0x38,
};

const GFXglyph IBMPlexMono_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 2, 23, 20, 9, -23 },
  { 7, 5, 8, 20, 7, -24 },
  { 12, 18, 23, 20, 1, -23 },
  { 64, 15, 29, 20, 2, -26 },
  { 119, 18, 23, 20, 1, -23 },
  { 171, 17, 23, 20, 1, -23 },
  { 220, 1, 8, 20, 9, -24 },
  { 221, 7, 30, 20, 8, -25 },
  { 248, 8, 30, 20, 4, -25 },
  { 278, 16, 16, 20, 2, -18 },
  { 310, 16, 17, 20, 2, -19 },
  { 344, 3, 9, 20, 8, -3 },
  { 348, 8, 1, 20, 6, -11 },
  { 349, 2, 2, 20, 9, -2 },
  { 350, 13, 30, 20, 3, -25 },
  { 399, 15, 23, 20, 2, -23 },
  { 443, 15, 23, 20, 3, -23 },
  { 487, 14, 23, 20, 3, -23 },
  { 528, 14, 23, 20, 2, -23 },
  { 569, 16, 23, 20, 2, -23 },
  { 615, 14, 23, 20, 3, -23 },
  { 656, 14, 23, 20, 3, -23 },
  { 697, 14, 23, 20, 3, -23 },
  { 738, 15, 23, 20, 2, -23 },
  { 782, 14, 23, 20, 3, -23 },
  { 823, 2, 17, 20, 9, -17 },
  { 828, 3, 23, 20, 8, -17 },
  { 837, 14, 18, 20, 3, -19 },
  { 869, 16, 7, 20, 2, -14 },
  { 883, 14, 18, 20, 3, -19 },
  { 915, 13, 23, 20, 3, -23 },
  { 953, 13, 27, 20, 3, -23 },
  { 997, 16, 23, 20, 2, -23 },
  { 1043, 14, 23, 20, 3, -23 },
  { 1084, 14, 23, 20, 3, -23 },
  { 1125, 13, 23, 20, 4, -23 },
  { 1163, 13, 23, 20, 4, -23 },
  { 1201, 13, 23, 20, 4, -23 },
  { 1239, 15, 23, 20, 2, -23 },
  { 1283, 14, 23, 20, 3, -23 },
  { 1324, 14, 23, 20, 3, -23 },
  { 1365, 12, 23, 20, 3, -23 },
  { 1400, 14, 23, 20, 4, -23 },
  { 1441, 12, 23, 20, 5, -23 },
  { 1476, 14, 23, 20, 3, -23 },
  { 1517, 14, 23, 20, 3, -23 },
  { 1558, 15, 23, 20, 2, -23 },
  { 1602, 13, 23, 20, 4, -23 },
  { 1640, 15, 27, 20, 2, -23 },
  { 1691, 13, 23, 20, 4, -23 },
  { 1729, 15, 23, 20, 2, -23 },
  { 1773, 17, 23, 20, 1, -23 },
  { 1822, 14, 23, 20, 3, -23 },
  { 1863, 16, 23, 20, 2, -23 },
  { 1909, 16, 23, 20, 2, -23 },
  { 1955, 16, 23, 20, 2, -23 },
  { 2001, 18, 23, 20, 1, -23 },
  { 2053, 16, 23, 20, 2, -23 },
  { 2099, 8, 30, 20, 9, -25 },
  { 2129, 13, 30, 20, 3, -25 },
  { 2178, 8, 30, 20, 3, -25 },
  { 2208, 16, 12, 20, 2, -23 },
  { 2232, 16, 1, 20, 2, 4 },
  { 2234, 4, 5, 20, 7, -25 },
  { 2237, 15, 17, 20, 3, -17 },
  { 2269, 13, 24, 20, 4, -24 },
  { 2308, 13, 17, 20, 4, -17 },
  { 2336, 13, 24, 20, 3, -24 },
  { 2375, 14, 17, 20, 3, -17 },
  { 2405, 15, 24, 20, 3, -24 },
  { 2450, 15, 26, 20, 3, -19 },
  { 2499, 12, 24, 20, 4, -24 },
  { 2535, 14, 25, 20, 4, -25 },
  { 2579, 12, 32, 20, 3, -25 },
  { 2627, 14, 24, 20, 5, -24 },
  { 2669, 14, 24, 20, 3, -24 },
  { 2711, 15, 17, 20, 2, -17 },
  { 2743, 12, 17, 20, 4, -17 },
  { 2769, 14, 17, 20, 3, -17 },
  { 2799, 13, 24, 20, 4, -17 },
  { 2838, 13, 24, 20, 3, -17 },
  { 2877, 15, 17, 20, 3, -17 },
  { 2909, 14, 17, 20, 3, -17 },
  { 2939, 16, 23, 20, 1, -23 },
  { 2985, 12, 17, 20, 4, -17 },
  { 3011, 14, 17, 20, 3, -17 },
  { 3041, 18, 17, 20, 1, -17 },
  { 3080, 14, 17, 20, 3, -17 },
  { 3110, 14, 24, 20, 3, -17 },
  { 3152, 13, 17, 20, 3, -17 },
  { 3180, 12, 30, 20, 4, -25 },
  { 3225, 1, 30, 20, 9, -25 },
  { 3229, 12, 30, 20, 4, -25 },
  { 3274, 16, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_Thin33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_THIN33PT7B_H_
