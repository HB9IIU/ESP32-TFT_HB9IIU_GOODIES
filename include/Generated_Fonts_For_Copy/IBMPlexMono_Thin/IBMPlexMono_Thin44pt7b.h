#ifndef _IBMPLEXMONO_THIN44PT7B_H_
#define _IBMPLEXMONO_THIN44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0xA0, 0x00, 0x0D,
  0xF0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00,
  0x30, 0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x20, 0x00,
  0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40, 0x00,
  0x40, 0x40, 0x00, 0x40, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x40, 0x80, 0x00,
  0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00,
  0x81, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0x01, 0x00, 0x01, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02,
  0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x00, 0xC2, 0x38, 0x10,
  0x20, 0xC2, 0x02, 0x02, 0x40, 0x20, 0x14, 0x02, 0x00, 0x40, 0x20, 0x04,
  0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20, 0x06, 0x02, 0x00,
  0x20, 0x20, 0x01, 0x82, 0x00, 0x0E, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x2F,
  0x00, 0x02, 0x0C, 0x00, 0x20, 0x60, 0x02, 0x02, 0x00, 0x20, 0x10, 0x02,
  0x01, 0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x01, 0x80,
  0x20, 0x1C, 0x02, 0x02, 0x60, 0x20, 0x23, 0x02, 0x0C, 0x0C, 0x23, 0x80,
  0x3F, 0xC0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x0F, 0x80, 0x01, 0x10, 0x60, 0x02, 0x20, 0x20, 0x02, 0x40, 0x10, 0x04,
  0x40, 0x10, 0x04, 0x40, 0x18, 0x08, 0x40, 0x08, 0x10, 0x40, 0x08, 0x10,
  0x40, 0x08, 0x20, 0x40, 0x08, 0x20, 0x40, 0x10, 0x40, 0x40, 0x10, 0x80,
  0x20, 0x20, 0x80, 0x10, 0x61, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x83, 0x0C, 0x01, 0x04, 0x06,
  0x02, 0x08, 0x02, 0x02, 0x08, 0x02, 0x04, 0x08, 0x01, 0x04, 0x08, 0x01,
  0x08, 0x08, 0x01, 0x10, 0x08, 0x01, 0x10, 0x08, 0x01, 0x20, 0x08, 0x01,
  0x20, 0x08, 0x02, 0x40, 0x04, 0x06, 0x80, 0x03, 0x0C, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x20, 0x02, 0x00, 0x40, 0x10,
  0x01, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x03, 0x40, 0x1F, 0x10, 0x80, 0x40, 0x81,
  0x01, 0x04, 0x02, 0x04, 0x10, 0x0C, 0x10, 0x80, 0x18, 0x42, 0x00, 0x21,
  0x08, 0x00, 0x44, 0x20, 0x00, 0xA0, 0x80, 0x01, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x1C, 0x10, 0x00, 0x58, 0x40, 0x02, 0x30, 0x80, 0x10, 0x61, 0x81,
  0x80, 0x81, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0xE0, 0x10, 0x0C, 0x70, 0x41, 0xC0,
  0x39, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x40, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x08, 0x04, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x30, 0x08, 0x00, 0x40, 0x60, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x33, 0x32, 0x66, 0x44, 0x48, 0x80, 0xFF,
  0xF0, 0xDF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x60, 0x08, 0x01, 0x81, 0x00, 0x08,
  0x20, 0x00, 0x42, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04,
  0x10, 0x00, 0x80, 0x80, 0x18, 0x06, 0x07, 0x00, 0x1F, 0xC0, 0x00, 0x60,
  0x00, 0x1A, 0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x20, 0x01, 0x82,
  0x00, 0x20, 0x20, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0x81, 0x80, 0xC0, 0x08, 0x30,
  0x00, 0x84, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x40,
  0x0C, 0x10, 0x00, 0xC4, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x40, 0x00,
  0x24, 0x00, 0x08, 0x60, 0x02, 0x07, 0x01, 0x80, 0x1F, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x28, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80,
  0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x20, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x08, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00, 0x02, 0x08, 0x00,
  0x08, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0x88, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0xFE, 0x04, 0xC0, 0x61, 0x40, 0x0C,
  0x60, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0E, 0x00, 0x02, 0x40, 0x01, 0x88, 0x00, 0xC1, 0x80, 0xC0, 0x1F, 0xC0,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0xFC, 0x04, 0xC0, 0xE2, 0x40, 0x0C,
  0xA0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x02, 0x20, 0x01, 0x84, 0x00, 0xC0, 0xC0, 0xE0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x30, 0x18,
  0x00, 0x83, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04,
  0x30, 0x00, 0x41, 0x80, 0x08, 0x06, 0x03, 0x00, 0x1F, 0xC0, 0x0E, 0x07,
  0x01, 0x00, 0x0C, 0x20, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x02, 0x20, 0x00, 0x61, 0x00, 0x0C, 0x0E, 0x03, 0x80,
  0x3F, 0xC0, 0x03, 0xF8, 0x01, 0x81, 0xC0, 0x40, 0x0C, 0x10, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x80, 0x00, 0xD0,
  0x00, 0x31, 0x00, 0x06, 0x10, 0x01, 0x41, 0x81, 0xC8, 0x0F, 0xE2, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0D,
  0xF0, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x18, 0xC4, 0x63, 0x10, 0x84, 0x42, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x01, 0x81, 0x00, 0x10, 0x80, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x20, 0x40, 0x04, 0x20, 0x00,
  0x88, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x50, 0x1F, 0x18,
  0x0C, 0x36, 0x04, 0x05, 0x81, 0x00, 0xE0, 0x80, 0x18, 0x20, 0x06, 0x08,
  0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01, 0x82, 0x00,
  0x60, 0x80, 0x18, 0x20, 0x06, 0x0C, 0x03, 0x81, 0x00, 0xE0, 0x20, 0x54,
  0x07, 0xE5, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFE, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00,
  0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x82, 0x00, 0x04,
  0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x40, 0x02, 0x01, 0x00, 0x08, 0x04,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0xC0, 0x04, 0x02, 0x00, 0x10, 0x0F, 0xFF, 0xE0, 0x60, 0x00, 0x81, 0x00,
  0x02, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x00,
  0x98, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0xFF, 0xF8, 0x10, 0x00, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0x88, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x06, 0x20, 0x01, 0x87,
  0xFF, 0xE0, 0x80, 0x03, 0x10, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x28,
  0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x09, 0x00, 0x06, 0x3F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x30, 0x0C, 0x00, 0x81, 0x80, 0x04,
  0x10, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x34, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x02,
  0x18, 0x00, 0x40, 0xC0, 0x08, 0x03, 0x03, 0x00, 0x0F, 0xC0, 0xFF, 0xE0,
  0x20, 0x06, 0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00,
  0x0C, 0x80, 0x06, 0x20, 0x06, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x30, 0x0C, 0x01, 0x81,
  0x80, 0x04, 0x10, 0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x32, 0x00, 0x03, 0x20, 0x00, 0x31,
  0x00, 0x05, 0x10, 0x00, 0x50, 0xC0, 0x09, 0x07, 0x03, 0x10, 0x1F, 0xC0,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0xFF, 0xFF,
  0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0,
  0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x21,
  0x00, 0x08, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x20, 0x10, 0x0C, 0x02,
  0x03, 0x00, 0x40, 0x40, 0x08, 0x10, 0x01, 0x06, 0x00, 0x21, 0x40, 0x04,
  0x44, 0x00, 0x90, 0xC0, 0x14, 0x08, 0x03, 0x00, 0x80, 0x60, 0x18, 0x08,
  0x01, 0x01, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x00, 0xA0,
  0x00, 0x08, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x02, 0xD0, 0x00, 0x5A, 0x00, 0x1B, 0x20, 0x02, 0x64, 0x00,
  0xCC, 0x80, 0x11, 0x88, 0x02, 0x31, 0x00, 0x86, 0x10, 0x10, 0xC2, 0x04,
  0x18, 0x20, 0x83, 0x04, 0x20, 0x60, 0x84, 0x0C, 0x08, 0x81, 0x81, 0x20,
  0x30, 0x14, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x08, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0xC0, 0x00,
  0x78, 0x00, 0x1A, 0x00, 0x06, 0xC0, 0x01, 0x90, 0x00, 0x62, 0x00, 0x18,
  0x80, 0x06, 0x10, 0x01, 0x84, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x04,
  0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x08, 0x06, 0x01, 0x01, 0x80, 0x40,
  0x60, 0x08, 0x18, 0x02, 0x06, 0x00, 0x41, 0x80, 0x10, 0x60, 0x02, 0x18,
  0x00, 0x86, 0x00, 0x11, 0x80, 0x04, 0x60, 0x00, 0x98, 0x00, 0x26, 0x00,
  0x05, 0x80, 0x01, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x60,
  0x60, 0x08, 0x01, 0x81, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x04, 0x10, 0x00, 0x80, 0x80, 0x18, 0x06,
  0x07, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x20, 0x01, 0x88, 0x00, 0x12, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x12, 0x00, 0x18, 0xFF, 0xFC, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x60, 0x08, 0x01, 0x81, 0x00, 0x08,
  0x20, 0x00, 0x42, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04,
  0x10, 0x00, 0x80, 0x80, 0x18, 0x06, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0xFC, 0xFF, 0xFC, 0x20, 0x01, 0x88, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00,
  0x18, 0xFF, 0xFC, 0x20, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x22, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x28, 0x00, 0x0C, 0x03,
  0xFC, 0x00, 0xC0, 0x38, 0x10, 0x00, 0xC2, 0x00, 0x02, 0x40, 0x00, 0x14,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x02, 0x60, 0x00, 0x23,
  0x00, 0x0C, 0x0C, 0x03, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x09, 0x00, 0x02, 0x20, 0x01, 0x8C, 0x00, 0x41, 0xC0, 0x60, 0x1F,
  0xE0, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x88, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10,
  0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x10, 0x0C, 0x00,
  0x40, 0x10, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x80,
  0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x01, 0x10,
  0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x28, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x03, 0x00, 0xA0, 0x18, 0x04, 0x80, 0xA0, 0x24, 0x05,
  0x01, 0x20, 0x48, 0x09, 0x02, 0x40, 0x88, 0x11, 0x04, 0x41, 0x08, 0x22,
  0x08, 0x41, 0x10, 0x41, 0x08, 0x82, 0x08, 0x44, 0x20, 0x42, 0x11, 0x02,
  0x10, 0x88, 0x08, 0x84, 0x80, 0x44, 0x24, 0x02, 0x21, 0x20, 0x0A, 0x09,
  0x00, 0x50, 0x50, 0x02, 0x82, 0x80, 0x14, 0x14, 0x00, 0x60, 0xC0, 0x03,
  0x00, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x04, 0x00, 0x0C,
  0x08, 0x00, 0x20, 0x20, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x20, 0x02,
  0x01, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x21, 0x00, 0x00, 0x4C,
  0x00, 0x01, 0xA0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x0C,
  0x04, 0x00, 0x20, 0x18, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x20, 0x01,
  0x81, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x19, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x10, 0x00, 0x08, 0x08, 0x00, 0x08, 0x08, 0x00, 0x10,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x01, 0x00, 0xC0,
  0x00, 0x80, 0x80, 0x00, 0x81, 0x00, 0x00, 0x43, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x14, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xFC, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF8, 0x00, 0x60, 0x00, 0x05,
  0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x20, 0x40, 0x02,
  0x02, 0x00, 0x40, 0x20, 0x04, 0x01, 0x00, 0x80, 0x10, 0x10, 0x00, 0x81,
  0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x01,
  0x80, 0x00, 0x10, 0xFF, 0xFF, 0xF8, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x03, 0xF0, 0x00, 0xC0, 0xC0, 0x10, 0x02, 0x02, 0x00, 0x10, 0x40, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x7F, 0xF8, 0x18, 0x00, 0x82, 0x00, 0x08, 0x40,
  0x00, 0x84, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x84,
  0x00, 0x28, 0x40, 0x02, 0x82, 0x00, 0x48, 0x18, 0x18, 0xF0, 0xFE, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x3F,
  0x02, 0x30, 0x30, 0x90, 0x02, 0x28, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0A, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x4A, 0x00, 0x12, 0x40, 0x08,
  0x8C, 0x0C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84,
  0x00, 0x24, 0x00, 0x0A, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x10, 0x80, 0x10, 0x30, 0x30, 0x07, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x41, 0xFC, 0x21, 0x81, 0x93, 0x00, 0x29,
  0x00, 0x0D, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0C,
  0x80, 0x06, 0x60, 0x05, 0x0C, 0x0C, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0x03, 0x01, 0x00, 0x30, 0x80, 0x04, 0x60, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x84, 0x00, 0x40, 0xC0,
  0x60, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x03, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x20, 0x03, 0xF2, 0x00, 0xC0, 0xE0, 0x18, 0x03, 0x01, 0x00,
  0x10, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20,
  0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x01, 0x00, 0x10, 0x18, 0x02, 0x00,
  0x40, 0xC0, 0x07, 0xF0, 0x01, 0x80, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0x01, 0x00, 0x0C, 0x20, 0x00,
  0x24, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x26, 0x00, 0x04, 0x38, 0x03, 0x80, 0xFF, 0xC0, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x3F, 0x84, 0xC1, 0xCA, 0x00, 0xD8,
  0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x7F, 0xFE, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x02, 0x40, 0x01,
  0x88, 0x00, 0x61, 0x00, 0x18, 0x20, 0x04, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x10, 0x02, 0x04, 0x00, 0x43, 0x80, 0x08, 0xD0, 0x01, 0x21, 0x00,
  0x28, 0x10, 0x06, 0x01, 0x00, 0x80, 0x10, 0x10, 0x03, 0x02, 0x00, 0x20,
  0x40, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x64, 0x00, 0x04,
  0x80, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0xC0, 0x8F, 0x07, 0xC9, 0x08, 0x86, 0xE0,
  0x50, 0x1C, 0x06, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18,
  0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01,
  0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20,
  0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02,
  0x01, 0x80, 0x20, 0x10, 0x8F, 0xE1, 0x30, 0x72, 0x80, 0x36, 0x00, 0x28,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x30, 0x80, 0x04, 0x40, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x20, 0x01, 0x04,
  0x00, 0xC0, 0xC0, 0xC0, 0x0F, 0xC0, 0x83, 0xF0, 0x23, 0x03, 0x09, 0x00,
  0x22, 0x80, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x2C, 0x00,
  0x0B, 0x00, 0x04, 0xA0, 0x01, 0x24, 0x00, 0x88, 0xC0, 0xC2, 0x0F, 0xC0,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x86, 0x06, 0x4C, 0x00,
  0xA4, 0x00, 0x34, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x28, 0x00,
  0x32, 0x00, 0x19, 0x80, 0x14, 0x30, 0x32, 0x0F, 0xE1, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x11, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x03, 0x80, 0xC0, 0xC0, 0x06, 0x10, 0x00, 0x64, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x24,
  0x00, 0x04, 0x60, 0x01, 0x03, 0x00, 0xC0, 0x1F, 0xE0, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xE0, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x03, 0x40,
  0x03, 0x20, 0x05, 0x18, 0x19, 0x07, 0xE0, 0x80, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x40,
  0x04, 0x10, 0x02, 0x02, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x04, 0x04,
  0x01, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x02, 0x10, 0x00, 0x44, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0A, 0x00, 0xA0, 0x14, 0x02, 0x40, 0x28, 0x04,
  0x80, 0x48, 0x09, 0x00, 0x90, 0x11, 0x01, 0x20, 0x42, 0x04, 0x40, 0x84,
  0x08, 0x81, 0x08, 0x10, 0x82, 0x08, 0x21, 0x08, 0x10, 0x42, 0x10, 0x21,
  0x04, 0x20, 0x42, 0x08, 0x40, 0x44, 0x11, 0x00, 0x88, 0x12, 0x01, 0x10,
  0x24, 0x02, 0x40, 0x48, 0x02, 0x80, 0xA0, 0x05, 0x01, 0x40, 0x0A, 0x01,
  0x80, 0x14, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x22, 0x00,
  0x18, 0x40, 0x04, 0x18, 0x02, 0x02, 0x01, 0x00, 0x40, 0xC0, 0x08, 0x20,
  0x03, 0x10, 0x00, 0x48, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00,
  0x48, 0x00, 0x31, 0x00, 0x08, 0x20, 0x04, 0x0C, 0x02, 0x01, 0x01, 0x00,
  0x20, 0x40, 0x04, 0x20, 0x01, 0x90, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00,
  0x30, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x40, 0x80, 0x08, 0x10, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x40, 0x40, 0x08, 0x10, 0x00, 0x82, 0x00, 0x10, 0x80,
  0x02, 0x10, 0x00, 0x22, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x01, 0x80, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x01, 0xC0, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0xFF, 0xC0, 0x1E,
  0x00, 0x09, 0x08, 0x00, 0x50, 0x20, 0x04, 0x80, 0x80, 0x28, 0x02, 0x01,
  0x40, 0x08, 0x12, 0x00, 0x31, 0x10, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 3, 31, 26, 12, -31 },
  { 13, 7, 11, 26, 10, -33 },
  { 23, 24, 31, 26, 1, -31 },
  { 116, 20, 40, 26, 3, -35 },
  { 216, 24, 32, 26, 1, -31 },
  { 312, 22, 32, 26, 2, -31 },
  { 400, 1, 11, 26, 13, -33 },
  { 402, 10, 39, 26, 10, -33 },
  { 451, 10, 39, 26, 6, -33 },
  { 500, 22, 22, 26, 2, -24 },
  { 561, 21, 21, 26, 3, -24 },
  { 617, 4, 11, 26, 10, -3 },
  { 623, 12, 1, 26, 7, -14 },
  { 625, 3, 3, 26, 12, -3 },
  { 627, 17, 39, 26, 5, -33 },
  { 710, 20, 32, 26, 3, -31 },
  { 790, 20, 31, 26, 4, -31 },
  { 868, 19, 31, 26, 4, -31 },
  { 942, 19, 32, 26, 3, -31 },
  { 1018, 22, 31, 26, 2, -31 },
  { 1104, 18, 32, 26, 4, -31 },
  { 1176, 18, 32, 26, 4, -31 },
  { 1248, 20, 31, 26, 3, -31 },
  { 1326, 20, 32, 26, 3, -31 },
  { 1406, 19, 31, 26, 4, -31 },
  { 1480, 3, 23, 26, 12, -23 },
  { 1489, 5, 31, 26, 10, -23 },
  { 1509, 19, 24, 26, 4, -25 },
  { 1566, 21, 9, 26, 3, -18 },
  { 1590, 19, 24, 26, 4, -25 },
  { 1647, 18, 31, 26, 4, -31 },
  { 1717, 18, 36, 26, 4, -31 },
  { 1798, 22, 31, 26, 2, -31 },
  { 1884, 19, 31, 26, 4, -31 },
  { 1958, 20, 32, 26, 3, -31 },
  { 2038, 18, 31, 26, 5, -31 },
  { 2108, 18, 31, 26, 5, -31 },
  { 2178, 18, 31, 26, 5, -31 },
  { 2248, 20, 32, 26, 3, -31 },
  { 2328, 18, 31, 26, 4, -31 },
  { 2398, 18, 31, 26, 4, -31 },
  { 2468, 16, 32, 26, 4, -31 },
  { 2532, 19, 31, 26, 5, -31 },
  { 2606, 17, 31, 26, 6, -31 },
  { 2672, 19, 31, 26, 4, -31 },
  { 2746, 18, 31, 26, 4, -31 },
  { 2816, 20, 32, 26, 3, -31 },
  { 2896, 18, 31, 26, 5, -31 },
  { 2966, 20, 38, 26, 3, -31 },
  { 3061, 18, 31, 26, 5, -31 },
  { 3131, 20, 32, 26, 3, -31 },
  { 3211, 23, 31, 26, 2, -31 },
  { 3301, 18, 32, 26, 4, -31 },
  { 3373, 22, 31, 26, 2, -31 },
  { 3459, 21, 31, 26, 3, -31 },
  { 3541, 22, 31, 26, 2, -31 },
  { 3627, 24, 31, 26, 1, -31 },
  { 3720, 22, 31, 26, 2, -31 },
  { 3806, 10, 39, 26, 12, -33 },
  { 3855, 17, 39, 26, 5, -33 },
  { 3938, 11, 39, 26, 4, -33 },
  { 3992, 20, 17, 26, 3, -31 },
  { 4035, 21, 1, 26, 3, 5 },
  { 4038, 6, 7, 26, 9, -33 },
  { 4044, 20, 24, 26, 3, -23 },
  { 4104, 18, 34, 26, 5, -33 },
  { 4181, 17, 24, 26, 5, -23 },
  { 4232, 17, 34, 26, 4, -33 },
  { 4305, 18, 24, 26, 4, -23 },
  { 4359, 19, 33, 26, 4, -33 },
  { 4438, 20, 34, 26, 4, -25 },
  { 4523, 15, 33, 26, 6, -33 },
  { 4585, 19, 33, 26, 5, -33 },
  { 4664, 16, 42, 26, 4, -33 },
  { 4748, 19, 33, 26, 6, -33 },
  { 4827, 18, 33, 26, 4, -33 },
  { 4902, 20, 23, 26, 3, -23 },
  { 4960, 15, 23, 26, 6, -23 },
  { 5004, 18, 24, 26, 4, -23 },
  { 5058, 18, 32, 26, 5, -23 },
  { 5130, 17, 32, 26, 4, -23 },
  { 5198, 20, 23, 26, 4, -23 },
  { 5256, 19, 24, 26, 4, -23 },
  { 5313, 21, 31, 26, 2, -31 },
  { 5395, 16, 24, 26, 5, -23 },
  { 5443, 18, 23, 26, 4, -23 },
  { 5495, 23, 23, 26, 2, -23 },
  { 5562, 18, 23, 26, 4, -23 },
  { 5614, 19, 32, 26, 4, -23 },
  { 5690, 18, 23, 26, 4, -23 },
  { 5742, 16, 39, 26, 5, -33 },
  { 5820, 1, 39, 26, 13, -33 },
  { 5825, 16, 39, 26, 5, -33 },
  { 5903, 21, 8, 26, 3, -17 },
};

const GFXfont IBMPlexMono_Thin44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_THIN44PT7B_H_
