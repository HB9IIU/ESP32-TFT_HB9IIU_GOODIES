#ifndef _IBMPLEXMONO_THIN41PT7B_H_
#define _IBMPLEXMONO_THIN41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x03, 0x7C,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x20, 0x40,
  0x00, 0x80, 0x80, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x00, 0x01,
  0x02, 0x01, 0xFE, 0x07, 0xF8, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x20,
  0x20, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04,
  0x03, 0xF8, 0x0F, 0xE0, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80,
  0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x38, 0x8C, 0x08,
  0x10, 0x62, 0x02, 0x06, 0x40, 0x40, 0x50, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x01, 0x02, 0x00, 0x18,
  0x40, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x23, 0x80, 0x04, 0x18, 0x00,
  0x81, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x28, 0x04, 0x04, 0x80, 0x81, 0x88, 0x10, 0x60, 0xE2,
  0x38, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x0F, 0x00, 0x04, 0xC3, 0x00, 0x16, 0x02, 0x00, 0x90, 0x08, 0x04,
  0x40, 0x20, 0x12, 0x00, 0x40, 0x88, 0x01, 0x02, 0x20, 0x04, 0x10, 0x80,
  0x10, 0x81, 0x00, 0x42, 0x04, 0x02, 0x10, 0x18, 0x08, 0x40, 0x30, 0xC2,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x04, 0x10,
  0x04, 0x20, 0x20, 0x21, 0x00, 0x40, 0x84, 0x01, 0x04, 0x10, 0x04, 0x10,
  0x40, 0x10, 0x81, 0x00, 0x44, 0x04, 0x01, 0x10, 0x10, 0x04, 0x80, 0x40,
  0x12, 0x00, 0x80, 0x90, 0x01, 0x04, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x41, 0x80, 0x08, 0x04, 0x01, 0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x11, 0x00, 0xF2, 0x18,
  0x08, 0x40, 0xC0, 0x84, 0x06, 0x08, 0x80, 0x30, 0x88, 0x01, 0x08, 0x80,
  0x09, 0x08, 0x00, 0x50, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x02, 0x84,
  0x00, 0x48, 0x60, 0x0C, 0x43, 0x03, 0x02, 0x0F, 0xC0, 0x10, 0xFF, 0xC0,
  0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x18, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x10, 0x04, 0x01, 0x70, 0x20, 0xF0,
  0x71, 0x38, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x44,
  0x00, 0x04, 0x30, 0x00, 0x40, 0x80, 0x02, 0x02, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x30, 0x01, 0x80, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x33, 0x32, 0x26, 0x44, 0x48,
  0xFF, 0xE0, 0xDF, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x01, 0x81, 0x80, 0x40,
  0x0C, 0x10, 0x00, 0x82, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x12, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x06,
  0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x03, 0x20, 0x00, 0x62,
  0x00, 0x0C, 0x20, 0x01, 0x82, 0x00, 0x30, 0x20, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xE0, 0x0C, 0x0C, 0x08, 0x01, 0x08, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x06, 0x06, 0x0C, 0x00,
  0x84, 0x00, 0x24, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x3F, 0x80,
  0x00, 0x70, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x01, 0x20,
  0x00, 0x88, 0x00, 0x83, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80,
  0x00, 0x84, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x04, 0x08, 0x00, 0x40,
  0x40, 0x02, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x10, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x80, 0x02,
  0x08, 0x00, 0x10, 0x7F, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x1F, 0xFF, 0x88, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x8F, 0xE0, 0x2C, 0x06, 0x0C, 0x00, 0xC2, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x43,
  0x00, 0x20, 0x70, 0x30, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0xFE, 0x0D, 0x81, 0xC5, 0x00,
  0x33, 0x00, 0x09, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x40, 0x01,
  0x20, 0x01, 0x08, 0x01, 0x83, 0x03, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0xC0, 0x04, 0x10, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x80, 0xC0, 0x60, 0x07, 0xF0,
  0x03, 0x03, 0x81, 0x80, 0x08, 0x40, 0x00, 0x88, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x28, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x10, 0xC0, 0x04, 0x0E, 0x03, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x0C, 0x0E, 0x0C, 0x01, 0x88, 0x00, 0x64, 0x00, 0x14, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x0A, 0x60, 0x0A, 0x1C, 0x19,
  0x03, 0xF8, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0x80, 0x31,
  0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63,
  0x18, 0x84, 0x62, 0x10, 0x88, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x18, 0x0C,
  0x30, 0x06, 0x60, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x01, 0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x0C, 0x18, 0x10, 0x04,
  0x20, 0x02, 0x60, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xF9, 0x81, 0x85, 0x82, 0x03, 0x82, 0x01, 0x84, 0x01, 0x84, 0x01,
  0x84, 0x01, 0x84, 0x01, 0x84, 0x01, 0x84, 0x01, 0x84, 0x01, 0x84, 0x01,
  0x82, 0x01, 0x82, 0x01, 0x81, 0x03, 0x80, 0xFD, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0xFE,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x00, 0x90,
  0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x20,
  0x40, 0x02, 0x04, 0x00, 0x20, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04,
  0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x08, 0x0F, 0xFF, 0x81,
  0x00, 0x08, 0x10, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x02,
  0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00,
  0x10, 0xFF, 0xF0, 0x40, 0x06, 0x20, 0x01, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x43, 0xFF, 0xE1, 0x00, 0x0C, 0x80,
  0x03, 0x40, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0xCF, 0xFF, 0x80, 0x01, 0xF8, 0x01, 0x81, 0x80, 0x80, 0x10, 0x40, 0x02,
  0x20, 0x00, 0x48, 0x00, 0x14, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x01, 0x20, 0x00, 0x44,
  0x00, 0x20, 0x80, 0x10, 0x18, 0x18, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x20,
  0x06, 0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x60,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0xFD, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x81, 0x01,
  0x80, 0x30, 0x40, 0x04, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x05, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00,
  0x01, 0x20, 0x00, 0xC4, 0x00, 0x51, 0x80, 0x14, 0x38, 0x19, 0x03, 0xF8,
  0x40, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x0F, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x04, 0x80, 0x09, 0x80, 0x21, 0x81, 0x80, 0xFC, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x12, 0x00, 0x08, 0x80, 0x04, 0x20,
  0x02, 0x08, 0x01, 0x82, 0x00, 0x40, 0x80, 0x20, 0x20, 0x10, 0x08, 0x08,
  0x02, 0x04, 0x00, 0x83, 0x00, 0x21, 0x40, 0x08, 0x88, 0x02, 0x63, 0x00,
  0x90, 0x40, 0x28, 0x08, 0x0C, 0x03, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20,
  0x03, 0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x03, 0x20, 0x00, 0x48, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0x40, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x3A, 0x00, 0x0E, 0x80,
  0x05, 0x90, 0x01, 0x64, 0x00, 0xD8, 0x80, 0x26, 0x20, 0x09, 0x88, 0x04,
  0x61, 0x01, 0x18, 0x40, 0x86, 0x08, 0x21, 0x82, 0x10, 0x60, 0x44, 0x18,
  0x12, 0x06, 0x02, 0x81, 0x80, 0xA0, 0x60, 0x10, 0x18, 0x04, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0xE0, 0x00, 0x68, 0x00, 0x34, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x06, 0x20,
  0x03, 0x10, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x40, 0x18,
  0x10, 0x0C, 0x08, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x40, 0xC0, 0x20,
  0x60, 0x08, 0x30, 0x04, 0x18, 0x01, 0x0C, 0x00, 0x86, 0x00, 0x23, 0x00,
  0x11, 0x80, 0x04, 0xC0, 0x02, 0x60, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x18,
  0x03, 0xF8, 0x01, 0x81, 0x80, 0x40, 0x0C, 0x10, 0x00, 0x82, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x28,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x20, 0x60, 0x0C, 0x06, 0x06, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x20,
  0x01, 0x88, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x63, 0xFF, 0xE0, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x81, 0x80, 0x40, 0x0C, 0x10, 0x00,
  0x82, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x40, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x06, 0x00, 0x3F, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xE0,
  0xFF, 0xF8, 0x20, 0x01, 0x88, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x63, 0xFF, 0xE0,
  0x80, 0x80, 0x20, 0x10, 0x08, 0x06, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20,
  0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x20, 0x00, 0x88, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x00, 0x80, 0x07, 0xF8, 0x03, 0x80, 0xC0, 0x80,
  0x06, 0x20, 0x00, 0x64, 0x00, 0x05, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x18, 0x80, 0x06, 0x0E, 0x03,
  0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x40,
  0x01, 0x20, 0x01, 0x08, 0x01, 0x83, 0x01, 0x80, 0xFF, 0x00, 0x80, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x08, 0x08,
  0x00, 0x80, 0x80, 0x08, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0x90,
  0x00, 0x09, 0x00, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x24, 0x02, 0x02,
  0x40, 0x60, 0x24, 0x05, 0x02, 0x40, 0x50, 0x22, 0x09, 0x02, 0x20, 0x90,
  0x22, 0x08, 0x82, 0x21, 0x08, 0x22, 0x10, 0x82, 0x21, 0x04, 0x42, 0x10,
  0x44, 0x22, 0x04, 0x42, 0x20, 0x24, 0x22, 0x02, 0x42, 0x40, 0x24, 0x14,
  0x02, 0x41, 0x40, 0x14, 0x18, 0x01, 0x41, 0x80, 0x14, 0x18, 0x00, 0xC0,
  0xC0, 0x00, 0x12, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x81, 0x00,
  0x08, 0x04, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00,
  0x08, 0x20, 0x00, 0x42, 0x00, 0x01, 0x10, 0x00, 0x05, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x40, 0x00,
  0x41, 0x00, 0x04, 0x08, 0x00, 0x20, 0x20, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x10, 0x10, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x08, 0x80,
  0x00, 0x68, 0x00, 0x01, 0x80, 0x80, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x88, 0x00, 0x04, 0x10, 0x00, 0x10, 0x20, 0x00, 0x80, 0x80, 0x04,
  0x01, 0x00, 0x10, 0x06, 0x00, 0x80, 0x08, 0x04, 0x00, 0x10, 0x10, 0x00,
  0x40, 0x80, 0x00, 0x82, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x14, 0x00, 0x04,
  0x80, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04, 0x10, 0x01, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x04, 0x10, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x00, 0xA0, 0x00, 0x18, 0xFF, 0xFF, 0xF0, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x07, 0xE0, 0x03, 0x03, 0x00, 0x80, 0x10, 0x20, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x3F, 0xF8, 0x18, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x41, 0x00, 0x38,
  0x18, 0x09, 0x00, 0xFC, 0x1E, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87,
  0xE0, 0x98, 0x18, 0xA0, 0x04, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0xC0, 0x02, 0xA0,
  0x04, 0x98, 0x18, 0x87, 0xE0, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x03, 0x40, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x03, 0xF1, 0x0C, 0x0D, 0x10, 0x03, 0x20,
  0x03, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x20, 0x03, 0x10, 0x03, 0x0C, 0x0D, 0x03, 0xF1, 0x07,
  0xE0, 0x0C, 0x0C, 0x0C, 0x01, 0x0C, 0x00, 0x44, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0xA0,
  0x00, 0x88, 0x00, 0x83, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x80, 0x1F, 0x90, 0x06, 0x0E, 0x01, 0x00, 0x40, 0x40, 0x04, 0x08, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x20, 0x08, 0x03, 0x06, 0x00, 0x7F, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC,
  0x18, 0x00, 0x66, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x24, 0x00, 0x08, 0x60, 0x06, 0x03, 0xFF, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x0F, 0xC2, 0x60, 0xE5, 0x00, 0x4C, 0x00, 0x50, 0x00,
  0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x07, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x05, 0xFF, 0xE0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x01, 0xA0, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x03, 0x02,
  0x03, 0x01, 0x02, 0x00, 0x82, 0x00, 0x43, 0x00, 0x22, 0x80, 0x12, 0x20,
  0x0E, 0x08, 0x04, 0x02, 0x02, 0x00, 0x81, 0x00, 0x60, 0x80, 0x10, 0x40,
  0x04, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x14, 0x00, 0x04, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x07,
  0xFF, 0xFC, 0x9F, 0x0F, 0x94, 0x32, 0x1B, 0x02, 0x81, 0x40, 0x60, 0x28,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x02, 0x87, 0xE1, 0x30, 0x72, 0x80, 0x26, 0x00, 0x28,
  0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x07, 0xF0, 0x0C, 0x0C,
  0x08, 0x01, 0x88, 0x00, 0x44, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x05, 0x00, 0x02, 0x40, 0x01, 0x20, 0x01, 0x08, 0x01,
  0x83, 0x03, 0x00, 0x7E, 0x00, 0x87, 0xE0, 0x98, 0x18, 0xA0, 0x04, 0xC0,
  0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0xC0, 0x02, 0xA0, 0x04, 0x98, 0x18, 0x87, 0xE0, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x03, 0xF1, 0x0C, 0x0D, 0x10, 0x03, 0x20, 0x03, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x20, 0x03, 0x10, 0x03, 0x0C, 0x0D, 0x03, 0xF1, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x11, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0C, 0x06, 0x08, 0x00,
  0xC8, 0x00, 0x24, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x58, 0x00, 0x43, 0x00,
  0xC0, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x34,
  0x00, 0xCC, 0x0D, 0x0F, 0xC4, 0x80, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x44, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x20, 0x08, 0x10, 0x04,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80, 0x10,
  0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x50, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x14, 0x03, 0x00, 0xA0,
  0x28, 0x09, 0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0x48, 0x11, 0x02, 0x41,
  0x08, 0x22, 0x08, 0x41, 0x10, 0x41, 0x08, 0x44, 0x08, 0x42, 0x20, 0x42,
  0x11, 0x01, 0x10, 0x88, 0x09, 0x04, 0x80, 0x48, 0x14, 0x02, 0x40, 0xA0,
  0x0A, 0x05, 0x00, 0x50, 0x30, 0x03, 0x01, 0x80, 0x08, 0x00, 0x80, 0x01,
  0xA0, 0x00, 0x88, 0x00, 0x86, 0x00, 0x81, 0x00, 0x80, 0x40, 0x40, 0x10,
  0x40, 0x04, 0x40, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x20, 0x00, 0x28, 0x00,
  0x24, 0x00, 0x21, 0x00, 0x10, 0x40, 0x10, 0x10, 0x10, 0x0C, 0x10, 0x02,
  0x08, 0x00, 0x88, 0x00, 0x28, 0x00, 0x08, 0xC0, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x02, 0x02, 0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x21, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x28, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x03, 0xFE, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x02, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x1C, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x13, 0x18,
  0x01, 0x20, 0x40, 0x14, 0x02, 0x02, 0x40, 0x10, 0x28, 0x00, 0x84, 0x80,
  0x07, 0x80,
};

const GFXglyph IBMPlexMono_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 3, 29, 25, 11, -29 },
  { 12, 7, 10, 25, 9, -30 },
  { 21, 23, 29, 25, 1, -29 },
  { 105, 19, 37, 25, 3, -33 },
  { 193, 22, 29, 25, 1, -29 },
  { 273, 20, 29, 25, 2, -29 },
  { 346, 1, 10, 25, 12, -30 },
  { 348, 9, 37, 25, 10, -31 },
  { 390, 9, 37, 25, 6, -31 },
  { 432, 21, 20, 25, 2, -23 },
  { 485, 19, 21, 25, 3, -23 },
  { 535, 4, 10, 25, 9, -3 },
  { 540, 11, 1, 25, 7, -13 },
  { 542, 3, 3, 25, 11, -3 },
  { 544, 16, 37, 25, 4, -31 },
  { 618, 19, 29, 25, 3, -29 },
  { 687, 20, 29, 25, 3, -29 },
  { 760, 17, 29, 25, 4, -29 },
  { 822, 17, 29, 25, 3, -29 },
  { 884, 21, 29, 25, 2, -29 },
  { 961, 18, 29, 25, 3, -29 },
  { 1027, 17, 29, 25, 4, -29 },
  { 1089, 18, 29, 25, 3, -29 },
  { 1155, 19, 29, 25, 3, -29 },
  { 1224, 17, 29, 25, 4, -29 },
  { 1286, 3, 22, 25, 11, -22 },
  { 1295, 5, 29, 25, 9, -22 },
  { 1314, 18, 22, 25, 3, -24 },
  { 1364, 19, 9, 25, 3, -17 },
  { 1386, 18, 22, 25, 3, -24 },
  { 1436, 16, 29, 25, 4, -29 },
  { 1494, 16, 33, 25, 4, -29 },
  { 1560, 20, 29, 25, 2, -29 },
  { 1633, 17, 29, 25, 4, -29 },
  { 1695, 18, 29, 25, 3, -29 },
  { 1761, 18, 29, 25, 4, -29 },
  { 1827, 17, 29, 25, 4, -29 },
  { 1889, 17, 29, 25, 4, -29 },
  { 1951, 18, 29, 25, 3, -29 },
  { 2017, 17, 29, 25, 4, -29 },
  { 2079, 17, 29, 25, 4, -29 },
  { 2141, 15, 29, 25, 4, -29 },
  { 2196, 18, 29, 25, 4, -29 },
  { 2262, 16, 29, 25, 6, -29 },
  { 2320, 18, 29, 25, 3, -29 },
  { 2386, 17, 29, 25, 4, -29 },
  { 2448, 19, 29, 25, 3, -29 },
  { 2517, 18, 29, 25, 4, -29 },
  { 2583, 19, 34, 25, 3, -29 },
  { 2664, 18, 29, 25, 4, -29 },
  { 2730, 19, 29, 25, 3, -29 },
  { 2799, 21, 29, 25, 2, -29 },
  { 2876, 17, 29, 25, 4, -29 },
  { 2938, 20, 29, 25, 2, -29 },
  { 3011, 20, 29, 25, 2, -29 },
  { 3084, 21, 29, 25, 2, -29 },
  { 3161, 22, 29, 25, 1, -29 },
  { 3241, 21, 29, 25, 2, -29 },
  { 3318, 10, 37, 25, 11, -31 },
  { 3365, 16, 37, 25, 4, -31 },
  { 3439, 10, 37, 25, 4, -31 },
  { 3486, 19, 15, 25, 3, -29 },
  { 3522, 20, 1, 25, 2, 5 },
  { 3525, 6, 7, 25, 8, -31 },
  { 3531, 19, 21, 25, 3, -21 },
  { 3581, 16, 30, 25, 5, -30 },
  { 3641, 16, 21, 25, 5, -21 },
  { 3683, 16, 30, 25, 3, -30 },
  { 3743, 17, 21, 25, 4, -21 },
  { 3788, 19, 30, 25, 3, -30 },
  { 3860, 19, 31, 25, 4, -23 },
  { 3934, 15, 30, 25, 5, -30 },
  { 3991, 17, 30, 25, 5, -30 },
  { 4055, 14, 38, 25, 4, -30 },
  { 4122, 17, 30, 25, 6, -30 },
  { 4186, 17, 30, 25, 4, -30 },
  { 4250, 19, 21, 25, 3, -21 },
  { 4300, 15, 21, 25, 5, -21 },
  { 4340, 17, 21, 25, 4, -21 },
  { 4385, 16, 29, 25, 5, -21 },
  { 4443, 16, 29, 25, 3, -21 },
  { 4501, 20, 21, 25, 3, -21 },
  { 4554, 17, 21, 25, 4, -21 },
  { 4599, 20, 29, 25, 1, -29 },
  { 4672, 14, 21, 25, 5, -21 },
  { 4709, 17, 21, 25, 4, -21 },
  { 4754, 21, 21, 25, 2, -21 },
  { 4810, 17, 21, 25, 4, -21 },
  { 4855, 18, 29, 25, 3, -21 },
  { 4921, 16, 21, 25, 4, -21 },
  { 4963, 15, 37, 25, 5, -31 },
  { 5033, 1, 37, 25, 12, -31 },
  { 5038, 15, 37, 25, 5, -31 },
  { 5108, 20, 7, 25, 2, -16 },
};

const GFXfont IBMPlexMono_Thin41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_THIN41PT7B_H_
