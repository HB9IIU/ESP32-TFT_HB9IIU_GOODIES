#ifndef _IBMPLEXMONO_THIN31PT7B_H_
#define _IBMPLEXMONO_THIN31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x00, 0xF0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x01, 0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x08, 0x40, 0xFC, 0x3F, 0x04, 0x10, 0x02, 0x08, 0x01, 0x08, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x41, 0x03, 0xE0, 0xFC, 0x10, 0x40, 0x08, 0x40,
  0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x03, 0xF0, 0x31, 0x31, 0x04, 0x24, 0x10, 0x60,
  0x40, 0x81, 0x02, 0x04, 0x04, 0x10, 0x10, 0x40, 0x31, 0x00, 0x3E, 0x00,
  0x17, 0x00, 0x42, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01, 0x06,
  0x04, 0x14, 0x10, 0x8C, 0x46, 0x0F, 0xE0, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x3C, 0x01, 0xA1, 0x80, 0xA0, 0x40, 0x90, 0x20, 0x48, 0x08, 0x44, 0x04,
  0x42, 0x04, 0x21, 0x02, 0x20, 0x43, 0x10, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x22, 0x18, 0x22, 0x04, 0x21, 0x02, 0x10, 0x81,
  0x10, 0x40, 0x48, 0x20, 0x48, 0x10, 0x28, 0x04, 0x34, 0x01, 0xE0, 0x07,
  0x80, 0x08, 0x60, 0x10, 0x20, 0x20, 0x10, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x1C, 0x07, 0x22, 0x08, 0x41,
  0x08, 0x40, 0x88, 0x80, 0x48, 0x80, 0x68, 0x80, 0x38, 0x80, 0x10, 0x80,
  0x18, 0x40, 0x24, 0x30, 0x42, 0x1F, 0x83, 0xFF, 0x02, 0x08, 0x20, 0x82,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0xC0, 0x40, 0x80,
  0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x40, 0x86, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x81, 0x70, 0x86,
  0x0E, 0xB8, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x10,
  0x08, 0x08, 0x10, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x2D, 0x25, 0x20,
  0xFF, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x07, 0xC0, 0x60, 0xC2,
  0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x10, 0x60, 0x41, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04, 0x18, 0x30, 0x1F, 0x00, 0x03,
  0x00, 0x14, 0x00, 0x90, 0x0C, 0x40, 0x61, 0x03, 0x04, 0x08, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03,
  0xFF, 0xF0, 0x1F, 0x81, 0x02, 0x10, 0x09, 0x00, 0x28, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x7F, 0xFC, 0x0F, 0xC0, 0x83, 0x08, 0x04, 0x80, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x03, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x02, 0x80, 0x23, 0x06,
  0x07, 0xE0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0x90,
  0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x7F, 0xF2,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x9F,
  0x85, 0x03, 0x10, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xA0, 0x05, 0x00, 0x46, 0x06, 0x0F, 0xC0, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0xFC, 0x2C, 0x19, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x23, 0x06, 0x0F, 0xC0, 0xFF, 0xFE,
  0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x0F, 0xC0, 0x40, 0xC2, 0x00, 0x90, 0x02, 0x40, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x02, 0x20, 0x08, 0x40, 0xC0, 0xFC, 0x06, 0x0C, 0x60, 0x09,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x02,
  0x30, 0x30, 0x3F, 0x00, 0x0F, 0x81, 0x83, 0x10, 0x05, 0x00, 0x28, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x50, 0x06, 0x60, 0xD0,
  0xF9, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x00,
  0x00, 0x0B, 0x49, 0x48, 0x00, 0x08, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x00, 0x0F, 0x83, 0x06, 0x40, 0x14, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0xC0, 0x70, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x0F,
  0x83, 0x04, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x3D, 0x84,
  0x38, 0x81, 0x88, 0x18, 0x81, 0x88, 0x18, 0x81, 0x88, 0x18, 0x81, 0x88,
  0x18, 0x43, 0x83, 0xD8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F,
  0xF0, 0x01, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x88,
  0x02, 0x10, 0x04, 0x20, 0x08, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x82,
  0x01, 0x04, 0x02, 0x0F, 0xFE, 0x10, 0x04, 0x40, 0x08, 0x80, 0x09, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x30, 0x00, 0x40, 0xFF, 0x84, 0x03, 0x20, 0x09,
  0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x24, 0x02, 0x3F,
  0xF1, 0x00, 0x48, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x28, 0x03, 0x7F, 0xE0, 0x07, 0xC0, 0x60, 0xC3, 0x00,
  0x88, 0x01, 0x40, 0x05, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x12, 0x00, 0x4C, 0x02, 0x18, 0x30, 0x1F, 0x00, 0xFF, 0x84,
  0x03, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x06, 0x7F, 0xC0, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x3F, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFC, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x3F, 0xFD, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x07, 0xC0,
  0x60, 0xC2, 0x01, 0x08, 0x02, 0x40, 0x05, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xFE, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x40, 0x05, 0x00, 0x12, 0x00, 0x48, 0x03, 0x18, 0x34, 0x1F,
  0x10, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F,
  0xFC, 0x3F, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xA0, 0x22, 0x0C, 0x3E, 0x00, 0x80, 0x0E, 0x00, 0x28,
  0x01, 0x20, 0x08, 0x80, 0x42, 0x02, 0x08, 0x10, 0x20, 0x80, 0x84, 0x02,
  0x10, 0x08, 0xC0, 0x24, 0x80, 0xA1, 0x03, 0x04, 0x08, 0x08, 0x20, 0x10,
  0x80, 0x42, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x10, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0x80,
  0x5A, 0x02, 0xD0, 0x26, 0x41, 0x32, 0x11, 0x90, 0x8C, 0x48, 0x62, 0x43,
  0x0C, 0x18, 0x20, 0xC1, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x40,
  0x1A, 0x00, 0xC8, 0x06, 0x40, 0x31, 0x01, 0x88, 0x0C, 0x20, 0x61, 0x03,
  0x04, 0x18, 0x20, 0xC0, 0x86, 0x04, 0x30, 0x11, 0x80, 0x8C, 0x02, 0x60,
  0x1B, 0x00, 0x58, 0x01, 0xC0, 0x0C, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x10,
  0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x05,
  0x00, 0x24, 0x00, 0x88, 0x04, 0x18, 0x30, 0x1F, 0x00, 0xFF, 0xC4, 0x01,
  0xA0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x0D, 0xFF, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x60,
  0xC2, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x05, 0x00, 0x34, 0x00, 0x88, 0x04, 0x18, 0x30, 0x3F, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x07, 0xE0, 0xFF, 0xC4, 0x01, 0xA0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x0D, 0xFF, 0xC8, 0x20, 0x40, 0x82, 0x04, 0x10, 0x10, 0x80, 0x44, 0x02,
  0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x04, 0x0F, 0xC0, 0xC0, 0xC4, 0x00,
  0x90, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x50, 0x02, 0x30, 0x18, 0x3F, 0x80, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x00, 0xA0,
  0x04, 0x80, 0x22, 0x06, 0x0F, 0xE0, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x88, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20,
  0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x14, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x82, 0x83, 0x05, 0x06, 0x0A, 0x0A, 0x12, 0x24, 0x24, 0x48,
  0x48, 0x88, 0x92, 0x12, 0x24, 0x24, 0x48, 0x28, 0xA0, 0x51, 0x40, 0xA2,
  0x81, 0x45, 0x01, 0x84, 0x03, 0x00, 0x80, 0x06, 0x80, 0x09, 0x00, 0x21,
  0x00, 0x41, 0x01, 0x02, 0x04, 0x02, 0x08, 0x02, 0x20, 0x04, 0x80, 0x05,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x28, 0x00, 0x88, 0x02, 0x10, 0x04, 0x10,
  0x10, 0x20, 0x40, 0x20, 0x80, 0x22, 0x00, 0x48, 0x00, 0x50, 0x00, 0x40,
  0x80, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x84, 0x00, 0x43, 0x00, 0x40, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x20, 0x04, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x7F,
  0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x0F, 0xF0, 0x01, 0x00, 0x0A, 0x00, 0x48, 0x01,
  0x10, 0x08, 0x40, 0x40, 0x81, 0x01, 0x08, 0x04, 0x20, 0x09, 0x00, 0x28,
  0x00, 0x60, 0x01, 0xFF, 0xFE, 0x84, 0x22, 0x10, 0x1F, 0x80, 0x81, 0x84,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x07, 0xFC, 0x60, 0x11,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x11, 0x00, 0xC6, 0x05, 0x07, 0xE7,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xF0,
  0xA0, 0xCC, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x2A, 0x0C, 0x9F, 0x00, 0x0F,
  0x80, 0x83, 0x08, 0x04, 0x80, 0x24, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x01, 0x90, 0x08, 0x41, 0x81,
  0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x21, 0xF1, 0x10, 0x69, 0x00, 0xD0, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x50, 0x02, 0x80, 0x12, 0x01, 0x88,
  0x34, 0x3E, 0x20, 0x0F, 0x81, 0x83, 0x10, 0x09, 0x00, 0x28, 0x01, 0x40,
  0x06, 0x00, 0x3F, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x01,
  0xA0, 0x08, 0xC1, 0x81, 0xF0, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0x80, 0x00, 0x3C,
  0x01, 0x00, 0xFC, 0x0C, 0x18, 0x20, 0x21, 0x00, 0x44, 0x01, 0x10, 0x04,
  0x40, 0x11, 0x00, 0x82, 0x02, 0x04, 0x10, 0x3F, 0x81, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x3F, 0xF1, 0x80, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x26, 0x01, 0x8F, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0xF8, 0xA0, 0xD8, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03,
  0xFF, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x2F, 0xFC, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x03, 0x80, 0x24, 0x02, 0x20, 0x21,
  0x06, 0x08, 0x40, 0x46, 0x02, 0x50, 0x14, 0x40, 0xC1, 0x04, 0x04, 0x20,
  0x11, 0x00, 0xC8, 0x02, 0x40, 0x0A, 0x00, 0x20, 0xFE, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x9C, 0x7B,
  0x8A, 0x18, 0x30, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41,
  0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10,
  0x60, 0x41, 0x9F, 0x14, 0x1B, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x0F, 0x81, 0x83, 0x10, 0x09, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x20, 0x10, 0xC1,
  0x81, 0xF0, 0x9F, 0x0A, 0x0C, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x2C, 0x02, 0xA0,
  0xC9, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x88, 0x83, 0x48, 0x06, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14, 0x00, 0x90, 0x0C, 0x41, 0xA1,
  0xF1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0xFE,
  0x7E, 0x05, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x7F, 0xFE, 0x1F, 0x81, 0x03, 0x10, 0x05, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xE0, 0x04, 0xC0, 0xC1, 0xF8, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0xFF, 0x81, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F,
  0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xD8, 0x29, 0xF9, 0x80,
  0x0C, 0x00, 0xB0, 0x04, 0x80, 0x44, 0x02, 0x10, 0x10, 0x81, 0x04, 0x08,
  0x10, 0x40, 0x84, 0x04, 0x20, 0x12, 0x00, 0x90, 0x02, 0x80, 0x18, 0x00,
  0x40, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x41, 0x42,
  0x42, 0x42, 0x22, 0x44, 0x22, 0x44, 0x22, 0x24, 0x22, 0x24, 0x14, 0x28,
  0x14, 0x28, 0x14, 0x28, 0x14, 0x18, 0x0C, 0x10, 0x0C, 0x80, 0x1A, 0x00,
  0x88, 0x08, 0x40, 0x81, 0x08, 0x04, 0x40, 0x14, 0x00, 0x40, 0x06, 0x00,
  0x48, 0x02, 0x20, 0x21, 0x02, 0x04, 0x20, 0x11, 0x00, 0x50, 0x03, 0x80,
  0x0C, 0x00, 0xA0, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x81, 0x04, 0x08,
  0x10, 0x80, 0x84, 0x02, 0x20, 0x12, 0x00, 0xD0, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x0F,
  0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x61, 0xF0, 0x03, 0x80, 0x10, 0x02, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xC0,
  0x07, 0xC3, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E, 0x00, 0x38, 0x02, 0x8C,
  0x06, 0x08, 0x14, 0x08, 0x28, 0x08, 0x90, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 2, 22, 19, 8, -22 },
  { 7, 5, 8, 19, 7, -23 },
  { 12, 17, 22, 19, 1, -22 },
  { 59, 14, 28, 19, 2, -25 },
  { 108, 17, 22, 19, 1, -22 },
  { 155, 16, 22, 19, 1, -22 },
  { 199, 1, 8, 19, 9, -23 },
  { 200, 7, 28, 19, 7, -24 },
  { 225, 7, 28, 19, 4, -24 },
  { 250, 16, 15, 19, 1, -17 },
  { 280, 15, 15, 19, 2, -17 },
  { 309, 3, 7, 19, 7, -2 },
  { 312, 8, 1, 19, 5, -10 },
  { 313, 2, 2, 19, 8, -2 },
  { 314, 12, 28, 19, 3, -24 },
  { 356, 14, 22, 19, 2, -22 },
  { 395, 14, 22, 19, 3, -22 },
  { 434, 13, 22, 19, 3, -22 },
  { 470, 13, 22, 19, 2, -22 },
  { 506, 16, 22, 19, 1, -22 },
  { 550, 13, 22, 19, 3, -22 },
  { 586, 13, 22, 19, 3, -22 },
  { 622, 14, 22, 19, 2, -22 },
  { 661, 14, 22, 19, 2, -22 },
  { 700, 13, 22, 19, 3, -22 },
  { 736, 2, 16, 19, 8, -16 },
  { 740, 3, 21, 19, 7, -16 },
  { 748, 13, 17, 19, 3, -18 },
  { 776, 15, 7, 19, 2, -13 },
  { 790, 13, 17, 19, 3, -18 },
  { 818, 12, 22, 19, 3, -22 },
  { 851, 12, 25, 19, 3, -22 },
  { 889, 15, 22, 19, 2, -22 },
  { 931, 13, 22, 19, 3, -22 },
  { 967, 14, 22, 19, 2, -22 },
  { 1006, 13, 22, 19, 3, -22 },
  { 1042, 13, 22, 19, 3, -22 },
  { 1078, 13, 22, 19, 3, -22 },
  { 1114, 14, 22, 19, 2, -22 },
  { 1153, 13, 22, 19, 3, -22 },
  { 1189, 13, 22, 19, 3, -22 },
  { 1225, 11, 22, 19, 3, -22 },
  { 1256, 14, 22, 19, 3, -22 },
  { 1295, 11, 22, 19, 5, -22 },
  { 1326, 13, 22, 19, 3, -22 },
  { 1362, 13, 22, 19, 3, -22 },
  { 1398, 14, 22, 19, 2, -22 },
  { 1437, 13, 22, 19, 3, -22 },
  { 1473, 14, 26, 19, 2, -22 },
  { 1519, 13, 22, 19, 3, -22 },
  { 1555, 14, 22, 19, 2, -22 },
  { 1594, 16, 22, 19, 1, -22 },
  { 1638, 13, 22, 19, 3, -22 },
  { 1674, 15, 22, 19, 2, -22 },
  { 1716, 15, 22, 19, 2, -22 },
  { 1758, 15, 22, 19, 2, -22 },
  { 1800, 17, 22, 19, 1, -22 },
  { 1847, 16, 22, 19, 1, -22 },
  { 1891, 8, 28, 19, 8, -24 },
  { 1919, 12, 28, 19, 3, -24 },
  { 1961, 7, 28, 19, 3, -24 },
  { 1986, 14, 12, 19, 2, -22 },
  { 2007, 15, 1, 19, 2, 4 },
  { 2009, 4, 5, 19, 6, -24 },
  { 2012, 14, 16, 19, 2, -16 },
  { 2040, 12, 23, 19, 4, -23 },
  { 2075, 13, 16, 19, 3, -16 },
  { 2101, 13, 23, 19, 2, -23 },
  { 2139, 13, 16, 19, 3, -16 },
  { 2165, 14, 23, 19, 3, -23 },
  { 2206, 14, 24, 19, 3, -18 },
  { 2248, 11, 23, 19, 4, -23 },
  { 2280, 13, 23, 19, 4, -23 },
  { 2318, 11, 29, 19, 3, -23 },
  { 2358, 13, 23, 19, 4, -23 },
  { 2396, 13, 23, 19, 3, -23 },
  { 2434, 14, 16, 19, 2, -16 },
  { 2462, 11, 16, 19, 4, -16 },
  { 2484, 13, 16, 19, 3, -16 },
  { 2510, 12, 22, 19, 4, -16 },
  { 2543, 13, 22, 19, 2, -16 },
  { 2579, 15, 16, 19, 2, -16 },
  { 2609, 13, 16, 19, 3, -16 },
  { 2635, 15, 22, 19, 1, -22 },
  { 2677, 11, 16, 19, 4, -16 },
  { 2699, 13, 16, 19, 3, -16 },
  { 2725, 16, 16, 19, 1, -16 },
  { 2757, 13, 16, 19, 3, -16 },
  { 2783, 13, 22, 19, 3, -16 },
  { 2819, 12, 16, 19, 3, -16 },
  { 2843, 11, 28, 19, 4, -24 },
  { 2882, 1, 28, 19, 9, -24 },
  { 2886, 11, 28, 19, 4, -24 },
  { 2925, 15, 6, 19, 2, -12 },
};

const GFXfont IBMPlexMono_Thin31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_THIN31PT7B_H_
