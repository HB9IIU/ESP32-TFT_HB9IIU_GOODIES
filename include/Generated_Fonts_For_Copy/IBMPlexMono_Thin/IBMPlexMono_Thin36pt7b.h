#ifndef _IBMPLEXMONO_THIN36PT7B_H_
#define _IBMPLEXMONO_THIN36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x03, 0xC0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08,
  0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x40, 0x7F,
  0x07, 0xF0, 0x10, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0xFC, 0x0F, 0xE0, 0x40, 0x80,
  0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10,
  0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x7F, 0x00, 0xC4, 0x60, 0x82, 0x0C, 0x81, 0x02, 0x40,
  0x80, 0xA0, 0x40, 0x10, 0x20, 0x08, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00,
  0x42, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x43, 0x00, 0x20, 0xC0, 0x10,
  0x20, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0xA0,
  0x40, 0x88, 0x20, 0xC3, 0x90, 0xC0, 0x3F, 0x80, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x32, 0x18, 0x02, 0x40, 0x80,
  0x48, 0x04, 0x04, 0x80, 0x40, 0x88, 0x04, 0x10, 0x80, 0x41, 0x08, 0x04,
  0x20, 0x80, 0x42, 0x04, 0x08, 0x40, 0x21, 0x88, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x02, 0x10, 0xC0, 0x42, 0x02, 0x04, 0x20, 0x20,
  0x84, 0x02, 0x08, 0x40, 0x21, 0x04, 0x02, 0x20, 0x40, 0x22, 0x02, 0x02,
  0x40, 0x20, 0x24, 0x01, 0x0C, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x06, 0x08,
  0x01, 0x01, 0x00, 0x80, 0x20, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x32,
  0x03, 0xD0, 0xC0, 0x84, 0x18, 0x22, 0x03, 0x10, 0x80, 0x44, 0x20, 0x09,
  0x08, 0x01, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x02, 0x84, 0x01, 0x30,
  0xC1, 0x84, 0x1F, 0x80, 0xC0, 0xFF, 0x80, 0x03, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x08, 0x08, 0x05, 0xC2, 0x0E, 0x0E, 0x9C, 0x00, 0x78, 0x00, 0x14, 0x00,
  0x04, 0x80, 0x02, 0x20, 0x01, 0x04, 0x00, 0x40, 0x80, 0x20, 0x10, 0x10,
  0x04, 0x08, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x32, 0x26, 0x44, 0x48, 0x80, 0xFF, 0xC0,
  0xF0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x18,
  0x38, 0x20, 0x0C, 0x40, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x81, 0x81, 0x81,
  0x81, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x0C, 0x18, 0x18, 0x07, 0xE0, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xA0, 0x01, 0x10, 0x01, 0x08, 0x03, 0x04, 0x03,
  0x02, 0x01, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x18, 0x30, 0x20, 0x08, 0x40,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x0F, 0xC0, 0x20, 0x60, 0x80,
  0x22, 0x00, 0x28, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0xC0, 0x7E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x50, 0x00,
  0x90, 0x02, 0x18, 0x18, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x01,
  0x40, 0x00, 0x90, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x04, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x20, 0x10, 0x10, 0x04, 0x04,
  0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x20, 0x01, 0x0F, 0xFF,
  0xFC, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x3F, 0xFC, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x1F, 0x82,
  0xC0, 0xC6, 0x00, 0x48, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x90, 0x03, 0x18, 0x0C,
  0x0F, 0xE0, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x1F, 0x82, 0xC0,
  0xCA, 0x00, 0xD8, 0x00, 0xB0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x14, 0x00, 0x28, 0x00, 0x88, 0x03, 0x0C, 0x0C, 0x07,
  0xE0, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x01,
  0x20, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x0F, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0,
  0x18, 0x38, 0x60, 0x04, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x60, 0x04, 0x30, 0x18,
  0x0F, 0xE0, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02,
  0x40, 0x06, 0x20, 0x06, 0x18, 0x1A, 0x07, 0xE2, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x33, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x32, 0x26, 0x44, 0x48, 0x80, 0x00, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xC0, 0xC4, 0x00,
  0x90, 0x02, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x60, 0x0E, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x07, 0xE0, 0x30, 0x60, 0x40, 0x21, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x80, 0xF3, 0x06, 0x16, 0x08, 0x1C,
  0x20, 0x18, 0x40, 0x30, 0x80, 0x61, 0x00, 0xC2, 0x01, 0x84, 0x03, 0x08,
  0x06, 0x10, 0x0C, 0x10, 0x18, 0x20, 0xE8, 0x3F, 0x50, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x14, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x21, 0x00, 0x08, 0x40, 0x04, 0x10, 0x01, 0x02, 0x00, 0x40, 0x80, 0x20,
  0x20, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x08, 0x1F, 0xFE,
  0x08, 0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x24,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x40, 0xFF, 0xC1, 0x00, 0x62, 0x00,
  0x64, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x44, 0x01, 0x0F, 0xFE, 0x10, 0x03, 0x20, 0x03, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00,
  0xA0, 0x03, 0x40, 0x0C, 0xFF, 0xE0, 0x07, 0xE0, 0x0C, 0x18, 0x30, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x03, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x02, 0x40, 0x03,
  0x20, 0x02, 0x30, 0x04, 0x0C, 0x18, 0x07, 0xE0, 0xFF, 0xC1, 0x00, 0xC2,
  0x00, 0x64, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50,
  0x01, 0x20, 0x06, 0x40, 0x30, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xD0, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xD0, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x30, 0x30, 0xC0, 0x31, 0x00,
  0x24, 0x00, 0x38, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1F, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x24, 0x00, 0xCC, 0x01,
  0x8C, 0x0D, 0x07, 0xE2, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x1F,
  0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x80, 0x09,
  0x00, 0x22, 0x01, 0x0C, 0x08, 0x0F, 0xC0, 0x80, 0x03, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x40, 0x80, 0x80, 0x81,
  0x00, 0x82, 0x00, 0x84, 0x00, 0x8A, 0x00, 0x92, 0x00, 0xA1, 0x00, 0xC0,
  0x80, 0xC0, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x80, 0x03, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xFF, 0xFC, 0x80, 0x03, 0xC0, 0x05, 0xC0, 0x05, 0xA0,
  0x05, 0xA0, 0x09, 0x90, 0x09, 0x90, 0x11, 0x88, 0x11, 0x88, 0x21, 0x84,
  0x21, 0x84, 0x41, 0x84, 0x41, 0x82, 0x81, 0x82, 0x81, 0x81, 0x81, 0x81,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x68, 0x01, 0xA0, 0x06, 0x40, 0x19, 0x00, 0x62, 0x01, 0x88, 0x06, 0x10,
  0x18, 0x40, 0x60, 0x81, 0x82, 0x06, 0x04, 0x18, 0x10, 0x60, 0x21, 0x80,
  0x86, 0x01, 0x18, 0x04, 0x60, 0x09, 0x80, 0x26, 0x00, 0x58, 0x01, 0x60,
  0x03, 0x80, 0x04, 0x07, 0xE0, 0x18, 0x38, 0x20, 0x0C, 0x40, 0x04, 0x40,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20,
  0x0C, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x14, 0x00, 0x28, 0x01, 0x9F, 0xFC, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x18, 0x38, 0x20, 0x0C, 0x40, 0x04,
  0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x20, 0x0C, 0x18, 0x18, 0x07, 0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0xFC, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x14, 0x00, 0x28, 0x01, 0x9F, 0xFC, 0x20, 0x40, 0x40, 0x80, 0x80, 0x81,
  0x00, 0x82, 0x01, 0x04, 0x01, 0x08, 0x01, 0x10, 0x02, 0x20, 0x02, 0x40,
  0x02, 0x80, 0x06, 0x07, 0xF0, 0x0C, 0x06, 0x08, 0x00, 0x88, 0x00, 0x24,
  0x00, 0x0A, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0A,
  0x00, 0x08, 0x80, 0x0C, 0x30, 0x1C, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x24,
  0x00, 0x8C, 0x0C, 0x1F, 0xC0, 0x80, 0x00, 0xE0, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08, 0x10,
  0x02, 0x04, 0x01, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x02, 0x02,
  0x00, 0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00,
  0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x14, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x28, 0x00, 0x09, 0x00, 0x02, 0x40, 0x80, 0x90, 0x30,
  0x24, 0x14, 0x09, 0x05, 0x04, 0x41, 0x21, 0x10, 0x88, 0x44, 0x22, 0x11,
  0x08, 0x44, 0x42, 0x11, 0x09, 0x04, 0x42, 0x40, 0x90, 0x90, 0x24, 0x28,
  0x09, 0x0A, 0x02, 0x82, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x02, 0x00, 0x80,
  0x00, 0xD0, 0x00, 0x22, 0x00, 0x10, 0x80, 0x08, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x10, 0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x14, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x12, 0x00, 0x08, 0x40, 0x04,
  0x10, 0x01, 0x02, 0x00, 0x80, 0x40, 0x40, 0x10, 0x10, 0x02, 0x08, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x02, 0x80, 0x00, 0x40, 0x80, 0x00, 0x34, 0x00,
  0x02, 0x40, 0x00, 0x42, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x10, 0x08,
  0x01, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00,
  0x11, 0x00, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFF,
  0x00, 0xC0, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x44, 0x00, 0x21, 0x00, 0x20,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x10, 0x04, 0x08, 0x01, 0x08, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x0C, 0x00, 0x04, 0xFF, 0xFF, 0x80, 0x82, 0x08, 0x41,
  0x04, 0x0F, 0xC0, 0x30, 0x20, 0x40, 0x10, 0x80, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x1F, 0xF8, 0x60, 0x08, 0xC0,
  0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x38, 0x60,
  0x48, 0x1F, 0x8F, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x87, 0xC1, 0x30, 0x62, 0x80, 0x26,
  0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x60, 0x04,
  0xA0, 0x09, 0x30, 0x62, 0x1F, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90,
  0x02, 0x40, 0x0E, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x50, 0x01, 0x20, 0x08,
  0x60, 0xC0, 0x7C, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x0F, 0xC4, 0x60, 0xD2, 0x00, 0xD0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x01, 0x20, 0x0C,
  0x60, 0xD0, 0x7C, 0x40, 0x07, 0xE0, 0x30, 0x20, 0x80, 0x21, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x01, 0x20, 0x04,
  0x30, 0x30, 0x1F, 0x80, 0x01, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x04, 0x01, 0xFA, 0x01, 0x03, 0x01, 0x00, 0x81, 0x00, 0x20, 0x80,
  0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x02, 0x01, 0x01,
  0x81, 0x00, 0x3F, 0x00, 0x60, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x07, 0xFF, 0x02, 0x00, 0x46, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x03, 0x00,
  0x02, 0x80, 0x01, 0x20, 0x01, 0x8C, 0x03, 0x81, 0xFE, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0x8A,
  0x06, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13,
  0xFF, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x05, 0x00, 0x32, 0x00, 0x84, 0x02,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x80, 0x42, 0x00, 0x8A, 0x01, 0x66, 0x03,
  0x04, 0x04, 0x04, 0x08, 0x04, 0x10, 0x04, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x09, 0x00, 0x0A, 0x00, 0x08, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0xBC, 0x3C, 0xC2, 0x42,
  0x81, 0x81, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x9F, 0x8A,
  0x06, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x07, 0xE0, 0x30, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x20, 0x08, 0x30,
  0x20, 0x1F, 0x80, 0x87, 0xC1, 0x30, 0x62, 0x80, 0x26, 0x00, 0x48, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x60, 0x04, 0xA0, 0x09, 0x30,
  0x62, 0x1F, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x00, 0x0F, 0xC4, 0x60, 0xD2, 0x00, 0xD0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x01, 0x20, 0x0C, 0x60, 0xD0,
  0x7C, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0xFE, 0x3F, 0x81, 0x20, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x10, 0x18, 0x20,
  0x04, 0x40, 0x06, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x02, 0x60, 0x02, 0x18, 0x0C, 0x07, 0xF0, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x0F, 0xFF,
  0xFC, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x40, 0x19, 0x83, 0x43,
  0xE2, 0x80, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x44, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x10, 0x10, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00,
  0x42, 0x00, 0x88, 0x01, 0x10, 0x01, 0x20, 0x02, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x80, 0x60, 0x30, 0x0C, 0x05, 0x02, 0x80, 0xA0, 0x50, 0x14, 0x09,
  0x04, 0x81, 0x20, 0x90, 0x44, 0x11, 0x08, 0x82, 0x21, 0x08, 0x44, 0x21,
  0x10, 0x88, 0x22, 0x11, 0x04, 0x42, 0x20, 0x48, 0x24, 0x09, 0x05, 0x01,
  0x20, 0xA0, 0x28, 0x14, 0x03, 0x03, 0x00, 0x60, 0x20, 0x0C, 0x00, 0xC0,
  0x02, 0x80, 0x08, 0x80, 0x20, 0x80, 0x40, 0x81, 0x01, 0x04, 0x01, 0x08,
  0x01, 0x20, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x12, 0x00, 0x42, 0x01,
  0x04, 0x02, 0x04, 0x08, 0x04, 0x20, 0x04, 0x80, 0x0B, 0x00, 0x08, 0x80,
  0x03, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20,
  0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x0C, 0x1F, 0x80, 0x07, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x3F, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x1F,
  0xE0, 0x1C, 0x00, 0xC8, 0xC0, 0x24, 0x18, 0x09, 0x02, 0x02, 0x80, 0x41,
  0x20, 0x08, 0xC8, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 2, 25, 22, 10, -25 },
  { 8, 6, 9, 22, 8, -27 },
  { 15, 20, 25, 22, 1, -25 },
  { 78, 17, 33, 22, 2, -29 },
  { 149, 20, 25, 22, 1, -25 },
  { 212, 18, 25, 22, 2, -25 },
  { 269, 1, 9, 22, 10, -27 },
  { 271, 8, 32, 22, 9, -27 },
  { 303, 8, 32, 22, 5, -27 },
  { 335, 18, 18, 22, 2, -20 },
  { 376, 17, 17, 22, 2, -20 },
  { 413, 4, 9, 22, 8, -3 },
  { 418, 10, 1, 22, 6, -11 },
  { 420, 2, 2, 22, 10, -2 },
  { 421, 14, 32, 22, 4, -27 },
  { 477, 16, 25, 22, 3, -25 },
  { 527, 17, 25, 22, 3, -25 },
  { 581, 16, 25, 22, 3, -25 },
  { 631, 15, 25, 22, 3, -25 },
  { 678, 18, 25, 22, 2, -25 },
  { 735, 15, 25, 22, 3, -25 },
  { 782, 15, 25, 22, 3, -25 },
  { 829, 15, 25, 22, 3, -25 },
  { 876, 16, 25, 22, 3, -25 },
  { 926, 16, 25, 22, 3, -25 },
  { 976, 2, 19, 22, 10, -19 },
  { 981, 4, 25, 22, 8, -19 },
  { 994, 16, 19, 22, 3, -20 },
  { 1032, 17, 8, 22, 2, -15 },
  { 1049, 16, 19, 22, 3, -20 },
  { 1087, 14, 25, 22, 4, -25 },
  { 1131, 15, 29, 22, 3, -25 },
  { 1186, 18, 25, 22, 2, -25 },
  { 1243, 15, 25, 22, 4, -25 },
  { 1290, 16, 25, 22, 3, -25 },
  { 1340, 15, 25, 22, 4, -25 },
  { 1387, 15, 25, 22, 4, -25 },
  { 1434, 15, 25, 22, 4, -25 },
  { 1481, 15, 25, 22, 3, -25 },
  { 1528, 14, 25, 22, 4, -25 },
  { 1572, 15, 25, 22, 3, -25 },
  { 1619, 14, 25, 22, 3, -25 },
  { 1663, 16, 25, 22, 4, -25 },
  { 1713, 14, 25, 22, 5, -25 },
  { 1757, 16, 25, 22, 3, -25 },
  { 1807, 14, 25, 22, 4, -25 },
  { 1851, 16, 25, 22, 3, -25 },
  { 1901, 15, 25, 22, 4, -25 },
  { 1948, 16, 30, 22, 3, -25 },
  { 2008, 15, 25, 22, 4, -25 },
  { 2055, 17, 25, 22, 2, -25 },
  { 2109, 19, 25, 22, 1, -25 },
  { 2169, 14, 25, 22, 4, -25 },
  { 2213, 18, 25, 22, 2, -25 },
  { 2270, 18, 25, 22, 2, -25 },
  { 2327, 18, 25, 22, 2, -25 },
  { 2384, 20, 25, 22, 1, -25 },
  { 2447, 18, 25, 22, 2, -25 },
  { 2504, 8, 32, 22, 10, -27 },
  { 2536, 14, 32, 22, 4, -27 },
  { 2592, 9, 32, 22, 3, -27 },
  { 2628, 17, 14, 22, 2, -25 },
  { 2658, 17, 1, 22, 2, 4 },
  { 2661, 5, 6, 22, 7, -27 },
  { 2665, 16, 19, 22, 3, -19 },
  { 2703, 15, 27, 22, 4, -27 },
  { 2754, 14, 19, 22, 4, -19 },
  { 2788, 14, 27, 22, 3, -27 },
  { 2836, 15, 19, 22, 3, -19 },
  { 2872, 16, 27, 22, 3, -27 },
  { 2926, 17, 28, 22, 3, -21 },
  { 2986, 12, 27, 22, 5, -27 },
  { 3027, 15, 27, 22, 4, -27 },
  { 3078, 13, 34, 22, 3, -27 },
  { 3134, 15, 27, 22, 5, -27 },
  { 3185, 15, 27, 22, 3, -27 },
  { 3236, 16, 19, 22, 3, -19 },
  { 3274, 12, 19, 22, 5, -19 },
  { 3303, 15, 19, 22, 3, -19 },
  { 3339, 15, 26, 22, 4, -19 },
  { 3388, 14, 26, 22, 3, -19 },
  { 3434, 17, 19, 22, 3, -19 },
  { 3475, 16, 19, 22, 3, -19 },
  { 3513, 18, 25, 22, 1, -25 },
  { 3570, 13, 19, 22, 4, -19 },
  { 3601, 15, 19, 22, 3, -19 },
  { 3637, 19, 19, 22, 1, -19 },
  { 3683, 15, 19, 22, 3, -19 },
  { 3719, 16, 26, 22, 3, -19 },
  { 3771, 14, 19, 22, 4, -19 },
  { 3805, 13, 32, 22, 4, -27 },
  { 3857, 1, 32, 22, 10, -27 },
  { 3861, 13, 32, 22, 4, -27 },
  { 3913, 18, 7, 22, 2, -14 },
};

const GFXfont IBMPlexMono_Thin36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_THIN36PT7B_H_
