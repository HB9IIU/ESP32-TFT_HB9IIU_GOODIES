#ifndef _IBMPLEXMONO_THIN7PT7B_H_
#define _IBMPLEXMONO_THIN7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x66, 0xFB, 0xC0, 0x4E, 0xD2, 0x5E, 0x40, 0xDE, 0x0F,
  0xF0, 0xE8, 0x5E, 0xF0, 0xC0, 0xFC, 0xA6, 0xA0, 0x4D, 0x2E, 0x44, 0xF4,
  0xC0, 0xC0, 0x00, 0x5A, 0xA0, 0xE9, 0xD9, 0xE0, 0x92, 0x4E, 0xC9, 0x4E,
  0xE5, 0x9E, 0x26, 0xAA, 0x70, 0xD3, 0x1C, 0xD3, 0x5C, 0xE9, 0x48, 0xE9,
  0x69, 0xE0, 0xD6, 0xA8, 0x80, 0x98, 0x72, 0x30, 0xFF, 0x89, 0xC0, 0xD6,
  0x00, 0xFF, 0xB0, 0x46, 0xAE, 0x90, 0xDB, 0x5C, 0xD6, 0x4E, 0xD6, 0xDC,
  0xF3, 0xCE, 0xF3, 0x48, 0xD6, 0x7E, 0xB7, 0xDA, 0xF2, 0x4E, 0xD5, 0xC0,
  0xFA, 0x6A, 0x92, 0x4E, 0xB7, 0xDA, 0xB6, 0xFA, 0xE9, 0x99, 0xE0, 0xD7,
  0x48, 0xE9, 0x99, 0xA6, 0xD7, 0x6E, 0xE9, 0x61, 0xE0, 0xF4, 0x44, 0x40,
  0xB6, 0xDC, 0x9A, 0xA6, 0x40, 0x99, 0xD6, 0xA0, 0x96, 0x46, 0x90, 0x9A,
  0x44, 0x40, 0xF2, 0x48, 0xF0, 0xEA, 0xB0, 0xAA, 0x50, 0xFC, 0x4A, 0x90,
  0xF0, 0x80, 0xCB, 0x70, 0x9A, 0xDC, 0xD2, 0x70, 0x7F, 0xC0, 0xD7, 0x70,
  0xFE, 0x4E, 0xFB, 0x4E, 0xBF, 0xC0, 0x52, 0x4E, 0x35, 0x70, 0x97, 0x6A,
  0x92, 0x4E, 0xD6, 0xD0, 0xFF, 0xDA, 0xE0, 0xD6, 0xE8, 0xFF, 0x40, 0xBA,
  0x70, 0xD1, 0x70, 0x4F, 0x44, 0x70, 0xFF, 0xBB, 0x40, 0xDB, 0x5A, 0xFA,
  0x70, 0xBB, 0x48, 0xDB, 0xED, 0xB0, 0xFC, 0xAB, 0xA0, 0xF0,
};

const GFXglyph IBMPlexMono_Thin7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 1, 2, 4, 2, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 1, 6, 4, 2, -5 },
  { 18, 2, 6, 4, 1, -5 },
  { 20, 4, 4, 4, 0, -4 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 1, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -3 },
  { 26, 1, 1, 4, 2, -1 },
  { 27, 2, 6, 4, 1, -5 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 3, 5, 4, 1, -5 },
  { 34, 3, 5, 4, 1, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 1, -5 },
  { 43, 3, 5, 4, 1, -5 },
  { 45, 3, 5, 4, 1, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 1, 4, 4, 2, -4 },
  { 53, 1, 5, 4, 1, -4 },
  { 54, 3, 4, 4, 1, -4 },
  { 56, 4, 2, 4, 0, -3 },
  { 57, 3, 4, 4, 1, -4 },
  { 59, 2, 5, 4, 1, -5 },
  { 61, 2, 6, 4, 1, -5 },
  { 63, 4, 5, 4, 0, -5 },
  { 66, 3, 5, 4, 1, -5 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 3, 5, 4, 1, -5 },
  { 80, 3, 5, 4, 1, -5 },
  { 82, 2, 5, 4, 1, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 3, 5, 4, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 3, 5, 4, 1, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 3, 5, 4, 1, -5 },
  { 97, 4, 6, 4, 0, -5 },
  { 100, 3, 5, 4, 1, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 3, 5, 4, 1, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 2, 6, 4, 2, -5 },
  { 127, 2, 6, 4, 1, -5 },
  { 129, 1, 6, 4, 1, -5 },
  { 130, 4, 3, 4, 0, -5 },
  { 132, 4, 1, 4, 0, 0 },
  { 133, 1, 1, 4, 1, -5 },
  { 134, 3, 4, 4, 1, -4 },
  { 136, 3, 5, 4, 1, -5 },
  { 138, 3, 4, 4, 1, -4 },
  { 140, 2, 5, 4, 1, -5 },
  { 142, 3, 4, 4, 1, -4 },
  { 144, 3, 5, 4, 1, -5 },
  { 146, 3, 5, 4, 1, -4 },
  { 148, 2, 5, 4, 1, -5 },
  { 150, 3, 5, 4, 1, -5 },
  { 152, 2, 6, 4, 1, -5 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 3, 5, 4, 1, -5 },
  { 158, 3, 4, 4, 1, -4 },
  { 160, 2, 4, 4, 1, -4 },
  { 161, 3, 4, 4, 1, -4 },
  { 163, 3, 5, 4, 1, -4 },
  { 165, 2, 5, 4, 1, -4 },
  { 167, 3, 4, 4, 1, -4 },
  { 169, 3, 4, 4, 1, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 2, 4, 4, 1, -4 },
  { 175, 3, 4, 4, 1, -4 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 3, 4, 4, 1, -4 },
  { 181, 3, 5, 4, 1, -4 },
  { 183, 2, 4, 4, 1, -4 },
  { 184, 2, 6, 4, 1, -5 },
  { 186, 1, 6, 4, 2, -5 },
  { 187, 2, 6, 4, 1, -5 },
  { 189, 4, 1, 4, 0, -3 },
};

const GFXfont IBMPlexMono_Thin7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_THIN7PT7B_H_
