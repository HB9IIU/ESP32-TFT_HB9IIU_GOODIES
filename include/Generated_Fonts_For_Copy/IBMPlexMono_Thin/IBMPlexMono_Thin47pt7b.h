#ifndef _IBMPLEXMONO_THIN47PT7B_H_
#define _IBMPLEXMONO_THIN47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x24, 0x44,
  0x44, 0x00, 0x00, 0x00, 0x6F, 0x60, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x00, 0x10, 0x18, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x08,
  0x04, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00,
  0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x40, 0x40,
  0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x20, 0x10, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x80, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x10, 0x08, 0x00, 0x04, 0x06, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x04, 0x04,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x08,
  0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x00, 0xE1,
  0x1C, 0x06, 0x04, 0x18, 0x30, 0x10, 0x10, 0x80, 0x40, 0x24, 0x01, 0x00,
  0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x01, 0x00, 0x10,
  0x04, 0x00, 0x60, 0x10, 0x00, 0x80, 0x40, 0x01, 0x01, 0x00, 0x02, 0x04,
  0x00, 0x07, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x78, 0x00, 0x04, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x40, 0x60, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00,
  0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x01, 0x00, 0x10,
  0x0E, 0x00, 0x40, 0x24, 0x01, 0x00, 0x88, 0x04, 0x04, 0x18, 0x10, 0x20,
  0x18, 0x47, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x00, 0x46, 0x18,
  0x00, 0x22, 0x01, 0x00, 0x11, 0x80, 0x20, 0x04, 0x40, 0x08, 0x02, 0x10,
  0x02, 0x00, 0x84, 0x00, 0x40, 0x41, 0x00, 0x10, 0x20, 0x40, 0x04, 0x08,
  0x10, 0x01, 0x04, 0x04, 0x00, 0x81, 0x01, 0x00, 0x20, 0x80, 0x60, 0x08,
  0x40, 0x08, 0x04, 0x10, 0x01, 0x86, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x06, 0x18,
  0x00, 0x82, 0x01, 0x00, 0x41, 0x80, 0x20, 0x10, 0x40, 0x08, 0x08, 0x10,
  0x02, 0x04, 0x04, 0x00, 0x81, 0x01, 0x00, 0x10, 0x80, 0x40, 0x04, 0x20,
  0x10, 0x02, 0x10, 0x04, 0x00, 0x88, 0x01, 0x00, 0x22, 0x00, 0x60, 0x09,
  0x00, 0x08, 0x04, 0x40, 0x01, 0x86, 0x20, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0x06, 0x00, 0x04, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0xC0, 0x1F, 0x30, 0x60, 0x10, 0x60, 0x20, 0x10, 0x40, 0x10,
  0x10, 0x40, 0x08, 0x20, 0x80, 0x04, 0x20, 0x80, 0x02, 0x20, 0x80, 0x01,
  0x20, 0x80, 0x01, 0xA0, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0xF0, 0x40, 0x00, 0x90, 0x60, 0x01, 0x08, 0x30, 0x02, 0x04, 0x1C, 0x0C,
  0x02, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x70, 0x08, 0x0E, 0x0E, 0x08, 0x70, 0x01,
  0xEB, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x42, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81, 0x00, 0x01, 0x00, 0x80, 0x03,
  0x00, 0x40, 0x02, 0x00, 0x60, 0x04, 0x00, 0x20, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x33, 0x32, 0x66, 0x44, 0x48, 0x88, 0xFF, 0xF0, 0x6F,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x0C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x10,
  0x00, 0x20, 0x80, 0x00, 0x42, 0x00, 0x01, 0x10, 0x00, 0x02, 0x40, 0x00,
  0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x01, 0x40, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x88, 0x00, 0x04, 0x20, 0x00, 0x10, 0x40, 0x00, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x30, 0x03, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x40, 0x00, 0x19, 0x00, 0x00, 0xC4, 0x00, 0x06, 0x10, 0x00,
  0x30, 0x40, 0x01, 0x01, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0xC0, 0x60, 0x10, 0x01,
  0x82, 0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x60, 0x30, 0x18, 0x00, 0x81,
  0x00, 0x04, 0x20, 0x00, 0x64, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x03, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x43, 0x00, 0x08,
  0x0E, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x02, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x40, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x01,
  0x00, 0x40, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x40, 0x10, 0x00, 0x40, 0x10, 0x00, 0x40, 0x20, 0x00, 0x40, 0x40,
  0x00, 0x40, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xE2, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x23, 0xFC, 0x04, 0xC0, 0x30,
  0x50, 0x00, 0x86, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x80, 0x00, 0x2C, 0x00, 0x04, 0x60,
  0x00, 0xC3, 0x00, 0x18, 0x0C, 0x07, 0x00, 0x3F, 0x80, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x1F, 0xC0, 0x4E, 0x07, 0x05, 0x80,
  0x18, 0x70, 0x00, 0xCA, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x06,
  0x30, 0x00, 0x41, 0x80, 0x18, 0x0E, 0x07, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x08, 0x80, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1C, 0x06, 0x00, 0x80, 0x04, 0x04, 0x00, 0x08, 0x30, 0x00, 0x10, 0x80,
  0x00, 0x42, 0x00, 0x01, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x22, 0x00, 0x01, 0x08, 0x00, 0x04, 0x30, 0x00, 0x10, 0x40, 0x00, 0x80,
  0x80, 0x04, 0x01, 0xC0, 0x60, 0x00, 0xFE, 0x00, 0x1C, 0x06, 0x01, 0x80,
  0x06, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x19, 0x00, 0x00, 0x24, 0x00, 0x00,
  0xB0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x50,
  0x00, 0x03, 0x40, 0x00, 0x08, 0x80, 0x00, 0x63, 0x00, 0x01, 0x06, 0x00,
  0x18, 0x06, 0x01, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x70,
  0x18, 0x00, 0x83, 0x00, 0x04, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x32, 0x00, 0x03, 0x30,
  0x00, 0x51, 0x80, 0x0A, 0x0E, 0x03, 0x20, 0x1F, 0xC2, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x33, 0xCC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18,
  0x84, 0x22, 0x10, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x03, 0x01, 0x83, 0x00, 0x10, 0x80, 0x02, 0x40, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x04, 0x08, 0x00, 0x41,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0x28,
  0x00, 0x05, 0x00, 0xFC, 0xA0, 0x30, 0x54, 0x08, 0x06, 0x83, 0x00, 0x70,
  0x40, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC1,
  0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x41,
  0x00, 0x28, 0x20, 0x05, 0x02, 0x01, 0xA0, 0x60, 0x54, 0x03, 0xF2, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0x80, 0x80, 0x01, 0x00, 0x80,
  0x01, 0x00, 0x80, 0x01, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x10,
  0x0F, 0xFF, 0xF0, 0x08, 0x00, 0x10, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x10, 0x00, 0xC2, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x30, 0xFF, 0xFC, 0x10, 0x00, 0x62, 0x00, 0x02, 0x40, 0x00, 0x28,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xA0,
  0x00, 0x24, 0x00, 0x18, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x70, 0x30,
  0x0C, 0x00, 0xC1, 0x80, 0x06, 0x30, 0x00, 0x22, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x01, 0x20, 0x00, 0x13, 0x00, 0x02, 0x10, 0x00,
  0x60, 0xC0, 0x0C, 0x07, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0xF0, 0x08, 0x00,
  0xE0, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0x88, 0x00, 0x04, 0x80,
  0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80,
  0x03, 0x08, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xD0, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x60, 0x30, 0x08, 0x00, 0x81, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x02,
  0x40, 0x00, 0x14, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x20, 0x00, 0x32, 0x00, 0x03,
  0x10, 0x00, 0x50, 0x80, 0x09, 0x06, 0x03, 0x10, 0x1F, 0xC0, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x28, 0x00, 0x14, 0x00, 0x09, 0x00, 0x08, 0xC0, 0x08,
  0x18, 0x18, 0x03, 0xF0, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x20, 0x00,
  0x11, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00, 0x08, 0x10,
  0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x80,
  0x08, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x0E, 0x00, 0x10, 0xD0, 0x00, 0x84,
  0x40, 0x04, 0x42, 0x00, 0x24, 0x08, 0x01, 0x40, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x04, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x02, 0x04, 0x00,
  0x08, 0x20, 0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x22,
  0x00, 0x00, 0x90, 0x00, 0x02, 0x80, 0x00, 0x18, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xA0, 0x00, 0x3A, 0x00, 0x05, 0xA0, 0x00, 0x59,
  0x00, 0x0D, 0x90, 0x00, 0x98, 0x80, 0x19, 0x88, 0x01, 0x18, 0x40, 0x11,
  0x84, 0x02, 0x18, 0x20, 0x21, 0x82, 0x04, 0x18, 0x20, 0x41, 0x81, 0x08,
  0x18, 0x10, 0x81, 0x80, 0x98, 0x18, 0x09, 0x01, 0x80, 0x50, 0x18, 0x06,
  0x01, 0x80, 0x20, 0x18, 0x04, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x20, 0x00,
  0x64, 0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00, 0x30, 0x80, 0x06, 0x18, 0x00,
  0xC1, 0x00, 0x18, 0x30, 0x03, 0x02, 0x00, 0x60, 0x20, 0x0C, 0x04, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x01, 0x03,
  0x00, 0x20, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x80, 0x04, 0x30, 0x00, 0x86,
  0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0x2C,
  0x00, 0x05, 0x80, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x0C, 0x0E, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x18, 0x10, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90,
  0x00, 0x01, 0x40, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x88, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x81, 0x80, 0x06, 0x03, 0x00, 0x30, 0x03, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0xFF, 0xFE, 0x08, 0x00, 0x38, 0x80, 0x00, 0xC8, 0x00,
  0x04, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x03, 0x8F, 0xFF, 0xE0,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x18, 0x10, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x01, 0x40,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x05,
  0x00, 0x00, 0x14, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x88, 0x00, 0x04, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x30, 0x03, 0x03, 0x80, 0x03, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xF8, 0xFF, 0xFE, 0x08, 0x00, 0x38, 0x80, 0x00, 0xC8,
  0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x03, 0x8F, 0xFF,
  0xE0, 0x80, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x80,
  0x18, 0x08, 0x00, 0x80, 0x80, 0x04, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0x48, 0x00, 0x06,
  0x80, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x38, 0x07, 0x01, 0x80, 0x06, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x09, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x22, 0x00, 0x01, 0x06, 0x00, 0x08, 0x0E, 0x01, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x2C, 0x00,
  0x04, 0x80, 0x01, 0x18, 0x00, 0x21, 0x00, 0x08, 0x18, 0x06, 0x00, 0xFF,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08,
  0x20, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x01, 0x00,
  0x80, 0x06, 0x01, 0x00, 0x08, 0x02, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x08, 0x02, 0x00, 0x10, 0x08, 0x00, 0x20,
  0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x00, 0x82,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x14, 0x03, 0x00, 0x90, 0x0C, 0x02, 0x40, 0x30, 0x09,
  0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x44, 0x09, 0x02,
  0x10, 0x22, 0x08, 0x40, 0x88, 0x20, 0x82, 0x21, 0x02, 0x08, 0x84, 0x08,
  0x42, 0x10, 0x21, 0x08, 0xC0, 0x44, 0x22, 0x01, 0x10, 0x88, 0x04, 0x42,
  0x20, 0x09, 0x09, 0x00, 0x24, 0x24, 0x00, 0x90, 0x50, 0x03, 0x41, 0x80,
  0x05, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x30, 0x00, 0x04, 0x10, 0x00, 0x08, 0x08, 0x00, 0x18, 0x0C, 0x00,
  0x10, 0x04, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00,
  0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x42, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x42, 0x00, 0x00, 0x43, 0x00, 0x00, 0x81,
  0x00, 0x01, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x04, 0x00, 0x30, 0x08, 0x00, 0x10, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x10,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x02, 0x00, 0x02, 0x01,
  0x80, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x20, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x31, 0x00,
  0x00, 0x84, 0x00, 0x04, 0x08, 0x00, 0x10, 0x30, 0x00, 0x80, 0x40, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x04, 0x02, 0x00, 0x18, 0x10, 0x00,
  0x20, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x0E,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFC, 0x41, 0x80, 0x80, 0x81, 0x01, 0x01,
  0x01, 0x03, 0xF0, 0x00, 0xE0, 0x60, 0x0C, 0x00, 0x80, 0xC0, 0x02, 0x04,
  0x00, 0x10, 0x40, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x7F, 0xF8, 0x1C,
  0x00, 0x41, 0x80, 0x02, 0x18, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00,
  0x0A, 0x08, 0x00, 0x90, 0x30, 0x18, 0xF8, 0x7F, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x7F, 0x02, 0x70,
  0x30, 0xB0, 0x02, 0x30, 0x00, 0x4C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01,
  0x2C, 0x00, 0x89, 0xC0, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xC0, 0xC0,
  0x60, 0x06, 0x08, 0x00, 0x42, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x84,
  0x00, 0x20, 0xC0, 0x0C, 0x06, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0x84, 0x38, 0x19,
  0x18, 0x01, 0x48, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0xC6,
  0x00, 0x50, 0xC0, 0x64, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x60, 0x60, 0x08,
  0x01, 0x81, 0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x10, 0x00, 0x40, 0x80, 0x08, 0x06, 0x03, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF8, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF4,
  0x00, 0x60, 0x70, 0x02, 0x00, 0x40, 0x18, 0x00, 0x80, 0x40, 0x01, 0x01,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00,
  0x04, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x40, 0x60, 0x02, 0x00, 0x80, 0x18,
  0x01, 0x81, 0x80, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x08, 0x00, 0x70, 0xC0, 0x00, 0x64, 0x00, 0x00, 0x90, 0x00, 0x02,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00, 0xB0, 0x00, 0x02, 0x40,
  0x00, 0x10, 0x80, 0x00, 0xC1, 0x80, 0x0C, 0x01, 0xFF, 0xC0, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x21, 0xFC, 0x11, 0x03, 0x8B,
  0x00, 0x66, 0x00, 0x13, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0xFF, 0xFE, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x68, 0x00, 0x11, 0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0xC0, 0x80,
  0x30, 0x10, 0x0C, 0x02, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x01, 0x1A,
  0x00, 0x26, 0x20, 0x05, 0x86, 0x00, 0xC0, 0x60, 0x10, 0x04, 0x02, 0x00,
  0x40, 0x40, 0x04, 0x08, 0x00, 0x41, 0x00, 0x04, 0x20, 0x00, 0xC4, 0x00,
  0x08, 0x80, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x00, 0x80, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0x83, 0xE2, 0x41, 0x18, 0x6A, 0x02, 0x80, 0xB0, 0x0C, 0x02,
  0xC0, 0x30, 0x07, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80,
  0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10,
  0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06,
  0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x04, 0x07, 0xF0,
  0x44, 0x0E, 0x2C, 0x01, 0x98, 0x00, 0x4C, 0x00, 0x14, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x01, 0xF8, 0x00, 0x60, 0x60, 0x18, 0x01, 0x81,
  0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x22, 0x00, 0x04, 0x10,
  0x00, 0xC1, 0x80, 0x18, 0x06, 0x06, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x27,
  0x03, 0x0B, 0x00, 0x23, 0x00, 0x04, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xB0, 0x00, 0x2C, 0x00,
  0x12, 0xC0, 0x08, 0x9C, 0x0C, 0x20, 0xFC, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0x81, 0x91, 0x80, 0x14, 0x80, 0x03, 0x60,
  0x00, 0xD0, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0x40,
  0x00, 0x58, 0x00, 0x32, 0x00, 0x0C, 0x60, 0x05, 0x0C, 0x06, 0x40, 0xFE,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0xFF, 0x83, 0xFC, 0x02, 0x30,
  0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFC, 0x00, 0xC0, 0x30, 0x10, 0x00, 0xC2, 0x00, 0x06, 0x20,
  0x00, 0x24, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x01, 0x20, 0x00, 0x21, 0x00,
  0x04, 0x0E, 0x01, 0x80, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xFE, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14,
  0x00, 0x09, 0x00, 0x0C, 0xC0, 0x0A, 0x38, 0x19, 0x07, 0xF0, 0x00, 0xC0,
  0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x10, 0x00, 0x81, 0x00, 0x08, 0x08, 0x00, 0x80, 0x80, 0x10,
  0x08, 0x01, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04,
  0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x09,
  0x00, 0x00, 0x90, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x80, 0x24, 0x01, 0x40,
  0x24, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x02, 0x40, 0x42, 0x02, 0x40,
  0x42, 0x02, 0x20, 0x42, 0x02, 0x20, 0x41, 0x04, 0x20, 0x81, 0x04, 0x20,
  0x81, 0x04, 0x20, 0x81, 0x04, 0x11, 0x00, 0x84, 0x11, 0x00, 0x88, 0x11,
  0x00, 0x88, 0x11, 0x00, 0x48, 0x12, 0x00, 0x48, 0x12, 0x00, 0x48, 0x0A,
  0x00, 0x48, 0x0A, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0xC0,
  0x00, 0x36, 0x00, 0x02, 0x20, 0x00, 0x41, 0x00, 0x08, 0x08, 0x01, 0x00,
  0x40, 0x30, 0x06, 0x02, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00, 0x09, 0x80,
  0x00, 0xD0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x09, 0x00, 0x01, 0x88,
  0x00, 0x10, 0xC0, 0x02, 0x04, 0x00, 0x40, 0x20, 0x0C, 0x01, 0x00, 0x80,
  0x18, 0x10, 0x00, 0x82, 0x00, 0x04, 0x60, 0x00, 0x2C, 0x00, 0x03, 0x80,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x08, 0x18, 0x00, 0x80, 0x80, 0x10,
  0x08, 0x01, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04,
  0x00, 0x30, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x00, 0x90, 0x00, 0x09,
  0x00, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x04, 0xC6,
  0x00, 0x12, 0x04, 0x00, 0x50, 0x08, 0x01, 0x40, 0x10, 0x0A, 0x00, 0x20,
  0x28, 0x00, 0x63, 0x20, 0x00, 0xF8,
};

const GFXglyph IBMPlexMono_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 4, 33, 28, 12, -33 },
  { 18, 8, 12, 28, 10, -35 },
  { 30, 26, 33, 28, 1, -33 },
  { 138, 22, 44, 28, 3, -38 },
  { 259, 26, 34, 28, 1, -33 },
  { 370, 24, 34, 28, 2, -33 },
  { 472, 1, 12, 28, 14, -35 },
  { 474, 11, 42, 28, 11, -36 },
  { 532, 11, 42, 28, 6, -36 },
  { 590, 24, 23, 28, 2, -26 },
  { 659, 22, 23, 28, 3, -26 },
  { 723, 4, 12, 28, 11, -4 },
  { 729, 12, 1, 28, 8, -15 },
  { 731, 4, 3, 28, 12, -3 },
  { 733, 18, 42, 28, 5, -36 },
  { 828, 22, 34, 28, 3, -33 },
  { 922, 22, 33, 28, 4, -33 },
  { 1013, 20, 33, 28, 4, -33 },
  { 1096, 20, 34, 28, 3, -33 },
  { 1181, 24, 33, 28, 2, -33 },
  { 1280, 20, 34, 28, 4, -33 },
  { 1365, 20, 34, 28, 4, -33 },
  { 1450, 20, 33, 28, 4, -33 },
  { 1533, 22, 34, 28, 3, -33 },
  { 1627, 20, 33, 28, 4, -33 },
  { 1710, 4, 25, 28, 12, -25 },
  { 1723, 5, 33, 28, 11, -25 },
  { 1744, 20, 25, 28, 4, -27 },
  { 1807, 22, 9, 28, 3, -19 },
  { 1832, 20, 25, 28, 4, -27 },
  { 1895, 18, 33, 28, 5, -33 },
  { 1970, 19, 38, 28, 4, -33 },
  { 2061, 24, 33, 28, 2, -33 },
  { 2160, 19, 33, 28, 5, -33 },
  { 2239, 20, 34, 28, 4, -33 },
  { 2324, 20, 33, 28, 5, -33 },
  { 2407, 19, 33, 28, 5, -33 },
  { 2486, 19, 33, 28, 5, -33 },
  { 2565, 20, 34, 28, 4, -33 },
  { 2650, 19, 33, 28, 5, -33 },
  { 2729, 20, 33, 28, 4, -33 },
  { 2812, 17, 34, 28, 5, -33 },
  { 2885, 21, 33, 28, 5, -33 },
  { 2972, 18, 33, 28, 7, -33 },
  { 3047, 20, 33, 28, 4, -33 },
  { 3130, 19, 33, 28, 5, -33 },
  { 3209, 22, 34, 28, 3, -33 },
  { 3303, 20, 33, 28, 5, -33 },
  { 3386, 22, 40, 28, 3, -33 },
  { 3496, 20, 33, 28, 5, -33 },
  { 3579, 22, 34, 28, 3, -33 },
  { 3673, 24, 33, 28, 2, -33 },
  { 3772, 19, 34, 28, 5, -33 },
  { 3853, 23, 33, 28, 3, -33 },
  { 3948, 22, 33, 28, 3, -33 },
  { 4039, 24, 33, 28, 2, -33 },
  { 4138, 26, 33, 28, 1, -33 },
  { 4246, 24, 33, 28, 2, -33 },
  { 4345, 12, 42, 28, 12, -36 },
  { 4408, 18, 42, 28, 5, -36 },
  { 4503, 11, 42, 28, 5, -36 },
  { 4561, 22, 18, 28, 3, -33 },
  { 4611, 22, 1, 28, 3, 6 },
  { 4614, 7, 8, 28, 9, -36 },
  { 4621, 21, 26, 28, 4, -25 },
  { 4690, 18, 36, 28, 6, -35 },
  { 4771, 19, 26, 28, 5, -25 },
  { 4833, 18, 36, 28, 4, -35 },
  { 4914, 20, 26, 28, 4, -25 },
  { 4979, 21, 35, 28, 4, -35 },
  { 5071, 22, 36, 28, 4, -26 },
  { 5170, 17, 35, 28, 6, -35 },
  { 5245, 20, 35, 28, 5, -35 },
  { 5333, 16, 44, 28, 5, -35 },
  { 5421, 19, 35, 28, 7, -35 },
  { 5505, 20, 35, 28, 4, -35 },
  { 5593, 22, 25, 28, 3, -25 },
  { 5662, 17, 25, 28, 6, -25 },
  { 5716, 20, 26, 28, 4, -25 },
  { 5781, 18, 34, 28, 6, -25 },
  { 5858, 18, 34, 28, 4, -25 },
  { 5935, 22, 24, 28, 4, -24 },
  { 6001, 20, 26, 28, 4, -25 },
  { 6066, 23, 33, 28, 2, -33 },
  { 6161, 17, 25, 28, 5, -24 },
  { 6215, 20, 24, 28, 4, -24 },
  { 6275, 24, 24, 28, 2, -24 },
  { 6347, 20, 24, 28, 4, -24 },
  { 6407, 20, 33, 28, 4, -24 },
  { 6490, 18, 24, 28, 5, -24 },
  { 6544, 18, 42, 28, 5, -36 },
  { 6639, 1, 42, 28, 14, -36 },
  { 6645, 18, 42, 28, 5, -36 },
  { 6740, 22, 8, 28, 3, -18 },
};

const GFXfont IBMPlexMono_Thin47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_THIN47PT7B_H_
