#ifndef _IBMPLEXMONO_THIN17PT7B_H_
#define _IBMPLEXMONO_THIN17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x10, 0xFF, 0x09, 0x02, 0x81, 0x21, 0xC7, 0x12, 0x04, 0x81,
  0x20, 0x48, 0xE3, 0x89, 0x02, 0x40, 0x90, 0x10, 0x10, 0x3C, 0x52, 0x91,
  0x90, 0x90, 0x78, 0x16, 0x11, 0x11, 0x91, 0x51, 0x3E, 0x10, 0x10, 0x70,
  0xE2, 0x28, 0x92, 0x24, 0x8A, 0x1C, 0x00, 0x38, 0x52, 0x28, 0x52, 0x14,
  0x4A, 0x0E, 0x38, 0x44, 0x80, 0x80, 0x40, 0x23, 0xD2, 0x8A, 0x86, 0x84,
  0x86, 0x79, 0xF0, 0x34, 0x48, 0x88, 0x88, 0x88, 0x88, 0x44, 0x30, 0x84,
  0x22, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x10, 0x10, 0x10, 0xD1, 0x2E,
  0x18, 0x24, 0x42, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0xEA, 0xF0, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x04, 0x10,
  0x82, 0x08, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x89, 0x81, 0x81,
  0x81, 0x42, 0x3C, 0x08, 0x18, 0x68, 0xC8, 0x88, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x7F, 0x3C, 0x42, 0x82, 0x02, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xFF, 0x3C, 0x86, 0x08, 0x10, 0x47, 0x01, 0x81, 0x03, 0x05,
  0x09, 0xE0, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x44, 0x84, 0x84, 0xFF, 0x04,
  0x04, 0x04, 0x7E, 0x40, 0x40, 0x80, 0xBC, 0x42, 0x02, 0x01, 0x01, 0x82,
  0x42, 0x3C, 0x0C, 0x10, 0x20, 0x40, 0x40, 0xBC, 0x42, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0xFF, 0x82, 0x82, 0x84, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x3C, 0x42, 0x81, 0x82, 0x42, 0x3C, 0x62, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0xDF, 0x02, 0x04, 0x10, 0x41,
  0x00, 0x80, 0x80, 0x40, 0x00, 0xEA, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x60,
  0x10, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x06, 0x08, 0x30, 0xC0, 0x7A, 0x18, 0x41, 0x04, 0x62, 0x08, 0x00, 0x00,
  0x08, 0x7A, 0x18, 0x67, 0xA7, 0x1C, 0x71, 0xA6, 0x78, 0x20, 0x41, 0xF0,
  0x08, 0x18, 0x28, 0x24, 0x24, 0x44, 0x42, 0x42, 0x7E, 0x82, 0x81, 0x81,
  0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x17, 0xE0, 0x3C,
  0x42, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x42, 0x3C, 0xF9,
  0x0A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x17, 0xC0, 0xFF, 0x02,
  0x04, 0x08, 0x1F, 0xE0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04,
  0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C, 0x42, 0x82, 0x81,
  0x80, 0x80, 0x8F, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x83, 0x06, 0x0C, 0x18,
  0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xFE, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x87, 0xF0, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x06, 0x18, 0x9E, 0x83, 0x0A, 0x24, 0x8A, 0x1C, 0x24, 0x48, 0x89, 0x0A,
  0x14, 0x10, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07,
  0xF0, 0x81, 0xC1, 0xC3, 0xC5, 0xA5, 0xA9, 0x99, 0x91, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x06, 0x0E, 0x1A, 0x34, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x10,
  0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0xFD, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C,
  0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x10,
  0x10, 0x0E, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x48, 0x91, 0x12, 0x14,
  0x10, 0x3C, 0x42, 0x81, 0x80, 0x80, 0x78, 0x06, 0x01, 0x01, 0x81, 0x41,
  0x3E, 0xFF, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A,
  0x13, 0xC0, 0x81, 0x81, 0x82, 0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x28,
  0x18, 0x08, 0x81, 0x81, 0x81, 0x81, 0x91, 0x99, 0xA9, 0xAA, 0xA6, 0xA6,
  0xC6, 0xC2, 0x81, 0x82, 0x42, 0x24, 0x28, 0x18, 0x18, 0x28, 0x24, 0x42,
  0x82, 0x81, 0x80, 0xD0, 0x24, 0x10, 0x84, 0x12, 0x05, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x80, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x43, 0xE0, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x08, 0x10, 0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08,
  0x38, 0x24, 0x44, 0x42, 0x81, 0xFF, 0x89, 0x80, 0x3C, 0xC4, 0x02, 0x02,
  0x7E, 0x82, 0x82, 0x86, 0x7B, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1,
  0x83, 0x06, 0x0C, 0x2F, 0x80, 0x38, 0x8A, 0x14, 0x08, 0x10, 0x21, 0xA2,
  0x38, 0x02, 0x04, 0x08, 0x13, 0xE8, 0xE0, 0xC1, 0x83, 0x06, 0x0A, 0x33,
  0xE0, 0x79, 0x0A, 0x14, 0x1F, 0xF0, 0x20, 0x43, 0x78, 0x0F, 0x10, 0x10,
  0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x7F, 0x06, 0xF2,
  0x14, 0x28, 0x50, 0x9E, 0x40, 0x81, 0xFE, 0x0C, 0x17, 0xC0, 0x82, 0x08,
  0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x10, 0x00, 0x00, 0x0F,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x04, 0x00, 0x00, 0xF8,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xBE, 0x80, 0x80, 0x80, 0x80,
  0x82, 0x8C, 0x90, 0xA0, 0xD0, 0x88, 0x84, 0x84, 0x83, 0xE0, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x0F, 0xE0, 0xF6, 0x89, 0x91,
  0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x84, 0x79, 0x0A, 0x14, 0x18, 0x30, 0x61, 0x42, 0x78, 0xB9, 0x8A, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04, 0x00, 0x3E, 0x8E, 0x0C, 0x18,
  0x30, 0x60, 0xA3, 0x3E, 0x04, 0x08, 0x10, 0xF7, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x79, 0x0A, 0x04, 0x07, 0xC0, 0x40, 0xC1, 0x7C,
  0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1F,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x7C, 0x87, 0x0A, 0x14, 0x44, 0x89,
  0x14, 0x18, 0x10, 0x91, 0xCC, 0xA6, 0x55, 0x2A, 0x95, 0x2A, 0x99, 0x8C,
  0xC6, 0x00, 0x87, 0x09, 0x21, 0x82, 0x06, 0x12, 0x42, 0x86, 0x81, 0x82,
  0x42, 0x44, 0x24, 0x28, 0x18, 0x08, 0x10, 0x10, 0x20, 0x60, 0xFC, 0x10,
  0x84, 0x21, 0x08, 0x20, 0xFC, 0x3C, 0x82, 0x08, 0x10, 0x41, 0x38, 0x10,
  0x41, 0x08, 0x20, 0x83, 0xC0, 0xFF, 0xFE, 0xF0, 0x41, 0x08, 0x21, 0x02,
  0x07, 0x31, 0x02, 0x08, 0x10, 0x4F, 0x00, 0x61, 0x91, 0x89, 0x86,
};

const GFXglyph IBMPlexMono_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 1, 12, 10, 5, -12 },
  { 3, 2, 4, 10, 4, -13 },
  { 4, 10, 12, 10, 0, -12 },
  { 19, 8, 16, 10, 1, -14 },
  { 35, 10, 12, 10, 0, -12 },
  { 50, 8, 12, 10, 1, -12 },
  { 62, 1, 4, 10, 5, -13 },
  { 63, 4, 15, 10, 4, -13 },
  { 71, 4, 15, 10, 2, -13 },
  { 79, 8, 8, 10, 1, -9 },
  { 87, 8, 9, 10, 1, -10 },
  { 96, 2, 4, 10, 4, -1 },
  { 97, 4, 1, 10, 3, -6 },
  { 98, 1, 1, 10, 5, -1 },
  { 99, 6, 15, 10, 2, -13 },
  { 111, 8, 12, 10, 1, -12 },
  { 123, 8, 12, 10, 1, -12 },
  { 135, 8, 12, 10, 1, -12 },
  { 147, 7, 12, 10, 1, -12 },
  { 158, 8, 12, 10, 1, -12 },
  { 170, 8, 12, 10, 1, -12 },
  { 182, 8, 12, 10, 1, -12 },
  { 194, 8, 12, 10, 1, -12 },
  { 206, 8, 12, 10, 1, -12 },
  { 218, 7, 12, 10, 2, -12 },
  { 229, 1, 9, 10, 5, -9 },
  { 231, 2, 12, 10, 4, -9 },
  { 234, 8, 9, 10, 1, -10 },
  { 243, 8, 4, 10, 1, -7 },
  { 247, 8, 9, 10, 1, -10 },
  { 256, 6, 12, 10, 2, -12 },
  { 265, 6, 14, 10, 2, -12 },
  { 276, 8, 12, 10, 1, -12 },
  { 288, 7, 12, 10, 2, -12 },
  { 299, 8, 12, 10, 1, -12 },
  { 311, 7, 12, 10, 2, -12 },
  { 322, 7, 12, 10, 2, -12 },
  { 333, 7, 12, 10, 2, -12 },
  { 344, 8, 12, 10, 1, -12 },
  { 356, 7, 12, 10, 2, -12 },
  { 367, 7, 12, 10, 2, -12 },
  { 378, 6, 12, 10, 2, -12 },
  { 387, 7, 12, 10, 2, -12 },
  { 398, 7, 12, 10, 2, -12 },
  { 409, 8, 12, 10, 1, -12 },
  { 421, 7, 12, 10, 2, -12 },
  { 432, 8, 12, 10, 1, -12 },
  { 444, 7, 12, 10, 2, -12 },
  { 455, 8, 15, 10, 1, -12 },
  { 470, 7, 12, 10, 2, -12 },
  { 481, 8, 12, 10, 1, -12 },
  { 493, 9, 12, 10, 1, -12 },
  { 507, 7, 12, 10, 2, -12 },
  { 518, 8, 12, 10, 1, -12 },
  { 530, 8, 12, 10, 1, -12 },
  { 542, 8, 12, 10, 1, -12 },
  { 554, 10, 12, 10, 0, -12 },
  { 569, 8, 12, 10, 1, -12 },
  { 581, 5, 15, 10, 4, -13 },
  { 591, 6, 15, 10, 2, -13 },
  { 603, 4, 15, 10, 2, -13 },
  { 611, 8, 6, 10, 1, -12 },
  { 617, 8, 1, 10, 1, 2 },
  { 618, 3, 3, 10, 3, -14 },
  { 620, 8, 9, 10, 1, -9 },
  { 629, 7, 13, 10, 2, -13 },
  { 641, 7, 9, 10, 2, -9 },
  { 649, 7, 13, 10, 1, -13 },
  { 661, 7, 9, 10, 2, -9 },
  { 669, 8, 13, 10, 1, -13 },
  { 682, 7, 13, 10, 2, -10 },
  { 694, 6, 13, 10, 2, -13 },
  { 704, 7, 13, 10, 2, -13 },
  { 716, 6, 16, 10, 2, -13 },
  { 728, 8, 13, 10, 2, -13 },
  { 741, 7, 13, 10, 2, -13 },
  { 753, 8, 9, 10, 1, -9 },
  { 762, 6, 9, 10, 2, -9 },
  { 769, 7, 9, 10, 2, -9 },
  { 777, 7, 12, 10, 2, -9 },
  { 788, 7, 12, 10, 1, -9 },
  { 799, 8, 9, 10, 1, -9 },
  { 808, 7, 9, 10, 2, -9 },
  { 816, 8, 12, 10, 1, -12 },
  { 828, 6, 9, 10, 2, -9 },
  { 835, 7, 9, 10, 2, -9 },
  { 843, 9, 9, 10, 1, -9 },
  { 854, 7, 9, 10, 2, -9 },
  { 862, 8, 12, 10, 1, -9 },
  { 874, 6, 9, 10, 2, -9 },
  { 881, 6, 15, 10, 2, -13 },
  { 893, 1, 15, 10, 5, -13 },
  { 895, 6, 15, 10, 2, -13 },
  { 907, 8, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Thin17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_THIN17PT7B_H_
