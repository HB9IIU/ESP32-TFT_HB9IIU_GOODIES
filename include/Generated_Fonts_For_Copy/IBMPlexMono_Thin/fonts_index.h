#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &IBMPlexMono_Thin6pt7b, 6, "IBMPlexMono_Thin6pt7b" },
  { &IBMPlexMono_Thin7pt7b, 7, "IBMPlexMono_Thin7pt7b" },
  { &IBMPlexMono_Thin8pt7b, 8, "IBMPlexMono_Thin8pt7b" },
  { &IBMPlexMono_Thin9pt7b, 9, "IBMPlexMono_Thin9pt7b" },
  { &IBMPlexMono_Thin10pt7b, 10, "IBMPlexMono_Thin10pt7b" },
  { &IBMPlexMono_Thin11pt7b, 11, "IBMPlexMono_Thin11pt7b" },
  { &IBMPlexMono_Thin12pt7b, 12, "IBMPlexMono_Thin12pt7b" },
  { &IBMPlexMono_Thin13pt7b, 13, "IBMPlexMono_Thin13pt7b" },
  { &IBMPlexMono_Thin14pt7b, 14, "IBMPlexMono_Thin14pt7b" },
  { &IBMPlexMono_Thin15pt7b, 15, "IBMPlexMono_Thin15pt7b" },
  { &IBMPlexMono_Thin16pt7b, 16, "IBMPlexMono_Thin16pt7b" },
  { &IBMPlexMono_Thin17pt7b, 17, "IBMPlexMono_Thin17pt7b" },
  { &IBMPlexMono_Thin18pt7b, 18, "IBMPlexMono_Thin18pt7b" },
  { &IBMPlexMono_Thin19pt7b, 19, "IBMPlexMono_Thin19pt7b" },
  { &IBMPlexMono_Thin20pt7b, 20, "IBMPlexMono_Thin20pt7b" },
  { &IBMPlexMono_Thin21pt7b, 21, "IBMPlexMono_Thin21pt7b" },
  { &IBMPlexMono_Thin22pt7b, 22, "IBMPlexMono_Thin22pt7b" },
  { &IBMPlexMono_Thin23pt7b, 23, "IBMPlexMono_Thin23pt7b" },
  { &IBMPlexMono_Thin24pt7b, 24, "IBMPlexMono_Thin24pt7b" },
  { &IBMPlexMono_Thin25pt7b, 25, "IBMPlexMono_Thin25pt7b" },
  { &IBMPlexMono_Thin26pt7b, 26, "IBMPlexMono_Thin26pt7b" },
  { &IBMPlexMono_Thin27pt7b, 27, "IBMPlexMono_Thin27pt7b" },
  { &IBMPlexMono_Thin28pt7b, 28, "IBMPlexMono_Thin28pt7b" },
  { &IBMPlexMono_Thin29pt7b, 29, "IBMPlexMono_Thin29pt7b" },
  { &IBMPlexMono_Thin30pt7b, 30, "IBMPlexMono_Thin30pt7b" },
  { &IBMPlexMono_Thin31pt7b, 31, "IBMPlexMono_Thin31pt7b" },
  { &IBMPlexMono_Thin32pt7b, 32, "IBMPlexMono_Thin32pt7b" },
  { &IBMPlexMono_Thin33pt7b, 33, "IBMPlexMono_Thin33pt7b" },
  { &IBMPlexMono_Thin34pt7b, 34, "IBMPlexMono_Thin34pt7b" },
  { &IBMPlexMono_Thin35pt7b, 35, "IBMPlexMono_Thin35pt7b" },
  { &IBMPlexMono_Thin36pt7b, 36, "IBMPlexMono_Thin36pt7b" },
  { &IBMPlexMono_Thin37pt7b, 37, "IBMPlexMono_Thin37pt7b" },
  { &IBMPlexMono_Thin38pt7b, 38, "IBMPlexMono_Thin38pt7b" },
  { &IBMPlexMono_Thin39pt7b, 39, "IBMPlexMono_Thin39pt7b" },
  { &IBMPlexMono_Thin40pt7b, 40, "IBMPlexMono_Thin40pt7b" },
  { &IBMPlexMono_Thin41pt7b, 41, "IBMPlexMono_Thin41pt7b" },
  { &IBMPlexMono_Thin42pt7b, 42, "IBMPlexMono_Thin42pt7b" },
  { &IBMPlexMono_Thin43pt7b, 43, "IBMPlexMono_Thin43pt7b" },
  { &IBMPlexMono_Thin44pt7b, 44, "IBMPlexMono_Thin44pt7b" },
  { &IBMPlexMono_Thin45pt7b, 45, "IBMPlexMono_Thin45pt7b" },
  { &IBMPlexMono_Thin46pt7b, 46, "IBMPlexMono_Thin46pt7b" },
  { &IBMPlexMono_Thin47pt7b, 47, "IBMPlexMono_Thin47pt7b" },
  { &IBMPlexMono_Thin48pt7b, 48, "IBMPlexMono_Thin48pt7b" },
  { &IBMPlexMono_Thin49pt7b, 49, "IBMPlexMono_Thin49pt7b" },
  { &IBMPlexMono_Thin50pt7b, 50, "IBMPlexMono_Thin50pt7b" },
  { &IBMPlexMono_Thin51pt7b, 51, "IBMPlexMono_Thin51pt7b" },
  { &IBMPlexMono_Thin52pt7b, 52, "IBMPlexMono_Thin52pt7b" },
  { &IBMPlexMono_Thin53pt7b, 53, "IBMPlexMono_Thin53pt7b" },
  { &IBMPlexMono_Thin54pt7b, 54, "IBMPlexMono_Thin54pt7b" },
  { &IBMPlexMono_Thin55pt7b, 55, "IBMPlexMono_Thin55pt7b" },
  { &IBMPlexMono_Thin56pt7b, 56, "IBMPlexMono_Thin56pt7b" },
  { &IBMPlexMono_Thin57pt7b, 57, "IBMPlexMono_Thin57pt7b" },
  { &IBMPlexMono_Thin58pt7b, 58, "IBMPlexMono_Thin58pt7b" },
  { &IBMPlexMono_Thin59pt7b, 59, "IBMPlexMono_Thin59pt7b" },
  { &IBMPlexMono_Thin60pt7b, 60, "IBMPlexMono_Thin60pt7b" },
  { &IBMPlexMono_Thin61pt7b, 61, "IBMPlexMono_Thin61pt7b" },
  { &IBMPlexMono_Thin62pt7b, 62, "IBMPlexMono_Thin62pt7b" },
  { &IBMPlexMono_Thin63pt7b, 63, "IBMPlexMono_Thin63pt7b" },
  { &IBMPlexMono_Thin64pt7b, 64, "IBMPlexMono_Thin64pt7b" },
  { &IBMPlexMono_Thin65pt7b, 65, "IBMPlexMono_Thin65pt7b" },
  { &IBMPlexMono_Thin66pt7b, 66, "IBMPlexMono_Thin66pt7b" },
  { &IBMPlexMono_Thin67pt7b, 67, "IBMPlexMono_Thin67pt7b" },
  { &IBMPlexMono_Thin68pt7b, 68, "IBMPlexMono_Thin68pt7b" },
  { &IBMPlexMono_Thin69pt7b, 69, "IBMPlexMono_Thin69pt7b" },
  { &IBMPlexMono_Thin70pt7b, 70, "IBMPlexMono_Thin70pt7b" },
  { &IBMPlexMono_Thin71pt7b, 71, "IBMPlexMono_Thin71pt7b" },
  { &IBMPlexMono_Thin72pt7b, 72, "IBMPlexMono_Thin72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
