#ifndef _IBMPLEXMONO_THIN61PT7B_H_
#define _IBMPLEXMONO_THIN61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x00, 0x40, 0x18, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x03, 0x00, 0x40, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x21, 0xE0, 0x06,
  0x02, 0x03, 0x00, 0x80, 0x20, 0x1C, 0x10, 0x02, 0x00, 0x63, 0x00, 0x20,
  0x02, 0x20, 0x02, 0x00, 0x26, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x40, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00, 0x40, 0x02,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x20, 0x02, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x10, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x02, 0x7C,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x20, 0x02, 0x00, 0x02, 0x00, 0x30, 0x00, 0x20,
  0x03, 0x00, 0x02, 0x00, 0x10, 0x00, 0x20, 0x01, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x20, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00, 0x20, 0x03, 0x80, 0x02,
  0x00, 0x3C, 0x00, 0x20, 0x02, 0x60, 0x02, 0x00, 0x63, 0x00, 0x20, 0x04,
  0x18, 0x02, 0x01, 0x80, 0xE0, 0x20, 0x30, 0x03, 0xC2, 0x1C, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0x86, 0x0C, 0x00, 0x00, 0x8C, 0x01, 0x80, 0x00, 0x84,
  0x00, 0x40, 0x00, 0xC4, 0x00, 0x10, 0x00, 0x42, 0x00, 0x08, 0x00, 0x63,
  0x00, 0x06, 0x00, 0x21, 0x80, 0x01, 0x00, 0x20, 0xC0, 0x00, 0x80, 0x10,
  0x40, 0x00, 0x40, 0x10, 0x20, 0x00, 0x20, 0x18, 0x10, 0x00, 0x10, 0x08,
  0x0C, 0x00, 0x08, 0x08, 0x06, 0x00, 0x0C, 0x04, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x80, 0x02, 0x06, 0x00, 0x20, 0x02, 0x02, 0x00, 0x18, 0x03, 0x02,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x06, 0x00, 0x08,
  0x18, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x0C, 0x0C, 0x00, 0x30, 0x04,
  0x04, 0x00, 0x08, 0x04, 0x02, 0x00, 0x04, 0x02, 0x01, 0x00, 0x02, 0x02,
  0x00, 0x80, 0x01, 0x03, 0x00, 0x40, 0x00, 0x81, 0x00, 0x20, 0x00, 0x41,
  0x00, 0x10, 0x00, 0x20, 0x80, 0x08, 0x00, 0x10, 0x80, 0x04, 0x00, 0x08,
  0xC0, 0x03, 0x00, 0x0C, 0x40, 0x00, 0x80, 0x04, 0x40, 0x00, 0x60, 0x06,
  0x20, 0x00, 0x18, 0x06, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x0F, 0xC4, 0x06, 0x00, 0x20, 0x30, 0x0C, 0x00, 0x81, 0x80,
  0x18, 0x02, 0x04, 0x00, 0x20, 0x08, 0x30, 0x00, 0x40, 0x20, 0x80, 0x00,
  0x81, 0x82, 0x00, 0x01, 0x06, 0x08, 0x00, 0x06, 0x10, 0x20, 0x00, 0x0C,
  0x40, 0x80, 0x00, 0x19, 0x02, 0x00, 0x00, 0x24, 0x08, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x12, 0x04,
  0x00, 0x00, 0xCC, 0x18, 0x00, 0x06, 0x18, 0x30, 0x00, 0x30, 0x30, 0x60,
  0x01, 0x80, 0x60, 0x60, 0x18, 0x00, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0x00, 0x08,
  0x00, 0x73, 0xC0, 0x10, 0x07, 0x80, 0xF0, 0x20, 0x78, 0x00, 0x3C, 0x47,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x08, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x61,
  0x8E, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x10, 0x43, 0x08, 0x00, 0xFF, 0xFF,
  0x7F, 0xF7, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x04, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x60, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x10, 0x18, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x02, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x01, 0x00, 0x08, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x04, 0x00, 0x02, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x07, 0xFC, 0x00, 0x8E, 0x01, 0xC0, 0x26,
  0x00, 0x0C, 0x0A, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x08, 0x30, 0x00, 0x04, 0x03, 0x00, 0x06, 0x00, 0x78,
  0x07, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x1F, 0xE0, 0x02, 0x1C, 0x07, 0x00, 0x98, 0x00, 0x60, 0x6C, 0x00,
  0x06, 0x12, 0x00, 0x00, 0x85, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xC0, 0x70, 0x03, 0x00, 0x06, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x29, 0x80, 0x00, 0x34, 0x60, 0x00, 0x36, 0x18, 0x00,
  0x32, 0x03, 0x80, 0xE1, 0x00, 0x7F, 0xC1, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF7, 0x1C, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x18, 0x63, 0x8C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10, 0xC2,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0x80, 0xE0, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0xC0,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04,
  0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x07, 0xE1,
  0x80, 0x18, 0x19, 0x80, 0x30, 0x05, 0x80, 0x60, 0x05, 0x80, 0x40, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01,
  0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01,
  0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01,
  0x80, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x40, 0x03, 0x80, 0x40, 0x03,
  0x80, 0x20, 0x05, 0xC0, 0x10, 0x09, 0xC0, 0x0F, 0xF1, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x20, 0x01, 0x80,
  0x00, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x40, 0x03, 0x00, 0x01, 0x00, 0x08, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x08, 0x01, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x81, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x30, 0x20, 0x00, 0x06,
  0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20,
  0x00, 0x03, 0x10, 0x00, 0x03, 0x08, 0x00, 0x06, 0x07, 0xFF, 0xFE, 0x02,
  0x00, 0x00, 0xE1, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x40,
  0x00, 0x1C, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x60, 0x00, 0x08, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x40, 0x00, 0xE0, 0x20, 0x00, 0x18, 0x10, 0x00, 0x06, 0x08,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x62, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x40, 0x00, 0xE0, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF2, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x10, 0x00, 0x18, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x20,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x80, 0x00, 0x14, 0x20, 0x00, 0x09,
  0x04, 0x00, 0x06, 0x40, 0xC0, 0x03, 0x10, 0x1C, 0x03, 0x04, 0x00, 0xFF,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98, 0x00, 0x04, 0x30, 0x00, 0x20,
  0x60, 0x01, 0x00, 0xE0, 0x38, 0x00, 0x7F, 0x80, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0x20, 0x00, 0x30, 0x08, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0x80,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x40, 0x00,
  0x80, 0x30, 0x00, 0x20, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x07, 0x80,
  0x00, 0x83, 0x30, 0x00, 0x21, 0x84, 0x00, 0x08, 0x41, 0x80, 0x02, 0x20,
  0x30, 0x00, 0x90, 0x04, 0x00, 0x28, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x03,
  0x00, 0x04, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x30, 0x08, 0x00, 0x04,
  0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04, 0x08, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3A, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x05, 0x90, 0x00, 0x03,
  0x66, 0x00, 0x00, 0x98, 0x80, 0x00, 0x26, 0x30, 0x00, 0x11, 0x84, 0x00,
  0x04, 0x61, 0x00, 0x03, 0x18, 0x20, 0x00, 0x86, 0x08, 0x00, 0x61, 0x83,
  0x00, 0x10, 0x60, 0x40, 0x0C, 0x18, 0x18, 0x02, 0x06, 0x02, 0x00, 0x81,
  0x80, 0xC0, 0x40, 0x60, 0x10, 0x10, 0x18, 0x04, 0x0C, 0x06, 0x00, 0x82,
  0x01, 0x80, 0x21, 0x80, 0x60, 0x0C, 0x40, 0x18, 0x01, 0x30, 0x06, 0x00,
  0x68, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x39, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x20,
  0x00, 0x07, 0x18, 0x00, 0x03, 0x84, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x10, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x02, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x40, 0x01, 0xC0, 0x10, 0x00,
  0xE0, 0x08, 0x00, 0x70, 0x02, 0x00, 0x38, 0x01, 0x00, 0x1C, 0x00, 0x40,
  0x0E, 0x00, 0x30, 0x07, 0x00, 0x08, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x01,
  0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x20, 0x38, 0x00, 0x18, 0x1C, 0x00,
  0x04, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x00, 0x83, 0x80, 0x00, 0x61, 0xC0,
  0x00, 0x10, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x02, 0x38, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x4E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x1C, 0x20,
  0x00, 0x03, 0x10, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x83, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x40, 0x00,
  0x1C, 0x20, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x83, 0xFF, 0xFF, 0x01, 0x00, 0x20, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x00,
  0x30, 0x04, 0x00, 0x08, 0x02, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x30, 0x20, 0x00, 0x08, 0x10, 0x00, 0x06, 0x08,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x1C,
  0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x30, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x24, 0x00, 0x00, 0x33, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x08, 0x60, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x01,
  0xC0, 0x1C, 0x00, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x10, 0x00, 0x40, 0x00, 0x40, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0x20, 0x01, 0x80,
  0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x18, 0x02, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x82, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x20,
  0x03, 0x00, 0x09, 0x00, 0x1C, 0x00, 0xC8, 0x00, 0xA0, 0x06, 0x40, 0x0D,
  0x00, 0x23, 0x00, 0x48, 0x01, 0x18, 0x02, 0x60, 0x08, 0xC0, 0x11, 0x00,
  0x42, 0x01, 0x88, 0x02, 0x10, 0x08, 0x60, 0x10, 0x80, 0x41, 0x00, 0x84,
  0x06, 0x08, 0x04, 0x20, 0x20, 0x60, 0x61, 0x01, 0x01, 0x03, 0x08, 0x08,
  0x08, 0x18, 0x40, 0xC0, 0x40, 0x83, 0x04, 0x03, 0x04, 0x18, 0x20, 0x08,
  0x20, 0xC3, 0x00, 0x41, 0x02, 0x10, 0x03, 0x08, 0x10, 0x80, 0x08, 0x40,
  0x8C, 0x00, 0x42, 0x04, 0x40, 0x02, 0x30, 0x22, 0x00, 0x19, 0x81, 0x10,
  0x00, 0x4C, 0x09, 0x80, 0x02, 0x40, 0x68, 0x00, 0x1A, 0x03, 0x40, 0x00,
  0x50, 0x1E, 0x00, 0x02, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x08, 0x00, 0x06, 0x00, 0x20, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x10, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x06, 0x00, 0x08, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x10, 0x08, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0xE0, 0x20, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x10, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x0A, 0x04, 0x00, 0x01, 0x40, 0xC0, 0x00, 0x48, 0x0C,
  0x00, 0x11, 0x00, 0xE0, 0x1C, 0x3F, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x81, 0xFE, 0x00, 0x87, 0x01, 0x80, 0x98, 0x00, 0x60, 0xB0, 0x00,
  0x30, 0xA0, 0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xA0, 0x00, 0x18, 0xB0, 0x00, 0x30, 0x98, 0x00, 0x60, 0x87, 0x01,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x80, 0xE0, 0x06, 0x00,
  0x30, 0x08, 0x00, 0x08, 0x10, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x30, 0x00, 0x02, 0x10, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x06, 0x00,
  0x38, 0x03, 0x80, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x7F,
  0x01, 0x03, 0x80, 0xE1, 0x06, 0x00, 0x31, 0x08, 0x00, 0x09, 0x10, 0x00,
  0x05, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x60, 0x00, 0x03, 0x20, 0x00, 0x03, 0x30, 0x00, 0x03, 0x10, 0x00,
  0x05, 0x08, 0x00, 0x09, 0x06, 0x00, 0x31, 0x03, 0x80, 0xE1, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x70, 0x01, 0x00, 0x0C, 0x01, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x41, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x98, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x41, 0x00, 0x00, 0x40, 0x40, 0x00, 0x60, 0x18,
  0x00, 0x40, 0x07, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xE3, 0x00, 0x01, 0x80,
  0xF8, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x10, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0xFF, 0x02, 0x18, 0x0E, 0x11, 0x00, 0x18, 0xB0, 0x00, 0x25, 0x00,
  0x01, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x7F, 0xFF, 0xF0, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E,
  0x00, 0x03, 0x06, 0xC0, 0x00, 0xC3, 0x10, 0x00, 0x31, 0x02, 0x00, 0x0D,
  0x80, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x1F, 0x8C, 0xC1, 0x86, 0x0C, 0xD0, 0x0C, 0x80, 0x6E, 0x00, 0x50, 0x02,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00,
  0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00,
  0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0,
  0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20,
  0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C,
  0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02,
  0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01,
  0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00,
  0x20, 0x01, 0x01, 0xFE, 0x04, 0x30, 0x1C, 0x22, 0x00, 0x31, 0x60, 0x00,
  0x4A, 0x00, 0x03, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x30, 0x00, 0x10, 0x08, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x02,
  0x03, 0x00, 0x01, 0x00, 0x60, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x87, 0x01, 0x80, 0x98, 0x00, 0x60, 0xB0,
  0x00, 0x30, 0xA0, 0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x08, 0xA0, 0x00, 0x18, 0xB0, 0x00, 0x30, 0x98, 0x00, 0x60, 0x87,
  0x01, 0x80, 0x81, 0xFE, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0xE1, 0x06, 0x00, 0x31, 0x08,
  0x00, 0x09, 0x10, 0x00, 0x05, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x03, 0x20, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x10, 0x00, 0x05, 0x08, 0x00, 0x09, 0x06, 0x00, 0x31, 0x03,
  0x80, 0xE1, 0x00, 0x7F, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x86, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC0,
  0x3C, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x18, 0x20, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x0D, 0x00, 0x00,
  0x36, 0x00, 0x00, 0xC8, 0x00, 0x05, 0x30, 0x00, 0x34, 0x60, 0x01, 0x90,
  0x60, 0x38, 0x40, 0x7F, 0x80, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x66, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x00,
  0x80, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x60, 0x01, 0x80,
  0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x18, 0x08, 0x00, 0x04,
  0x0C, 0x00, 0x03, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02,
  0x40, 0x02, 0x60, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06,
  0x20, 0x02, 0x20, 0x04, 0x30, 0x06, 0x20, 0x04, 0x10, 0x04, 0x30, 0x04,
  0x10, 0x04, 0x10, 0x0C, 0x10, 0x04, 0x10, 0x08, 0x18, 0x04, 0x10, 0x08,
  0x08, 0x04, 0x10, 0x08, 0x08, 0x0C, 0x10, 0x10, 0x08, 0x08, 0x18, 0x10,
  0x0C, 0x08, 0x08, 0x10, 0x04, 0x08, 0x08, 0x30, 0x04, 0x08, 0x08, 0x20,
  0x04, 0x18, 0x08, 0x20, 0x02, 0x10, 0x0C, 0x20, 0x02, 0x10, 0x04, 0x60,
  0x02, 0x10, 0x04, 0x40, 0x02, 0x10, 0x04, 0x40, 0x01, 0x30, 0x04, 0x40,
  0x01, 0x20, 0x06, 0xC0, 0x01, 0x20, 0x02, 0x80, 0x01, 0xA0, 0x02, 0x80,
  0x00, 0xA0, 0x02, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x60, 0x00, 0x08, 0x0C,
  0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x01, 0x80, 0x20, 0x00, 0x30, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x40, 0x40, 0x00, 0x20, 0x18, 0x00, 0x10, 0x03,
  0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x08, 0x01, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x08, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x04,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x08, 0x00, 0x02, 0x01, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x10, 0x02, 0x00, 0x06, 0x00, 0x60, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x30,
  0x00, 0x30, 0x04, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x20, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x68, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x08, 0xC3, 0x00, 0x00, 0x4C, 0x06, 0x00, 0x06, 0x40, 0x18, 0x00, 0x24,
  0x00, 0x60, 0x01, 0x20, 0x01, 0x80, 0x12, 0x00, 0x06, 0x00, 0x90, 0x00,
  0x18, 0x08, 0x80, 0x00, 0x61, 0x84, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 4, 43, 37, 16, -43 },
  { 23, 9, 15, 37, 14, -45 },
  { 40, 34, 43, 37, 1, -43 },
  { 223, 28, 56, 37, 4, -49 },
  { 419, 33, 44, 37, 2, -43 },
  { 601, 30, 44, 37, 3, -43 },
  { 766, 1, 15, 37, 18, -45 },
  { 768, 13, 54, 37, 15, -46 },
  { 856, 14, 54, 37, 8, -46 },
  { 951, 31, 30, 37, 3, -33 },
  { 1068, 29, 29, 37, 4, -33 },
  { 1174, 6, 15, 37, 14, -5 },
  { 1186, 16, 1, 37, 10, -19 },
  { 1188, 4, 4, 37, 16, -4 },
  { 1190, 24, 54, 37, 6, -46 },
  { 1352, 28, 44, 37, 4, -43 },
  { 1506, 29, 43, 37, 5, -43 },
  { 1662, 27, 43, 37, 5, -43 },
  { 1808, 26, 44, 37, 4, -43 },
  { 1951, 31, 43, 37, 3, -43 },
  { 2118, 26, 44, 37, 5, -43 },
  { 2261, 26, 44, 37, 5, -43 },
  { 2404, 26, 43, 37, 5, -43 },
  { 2544, 28, 44, 37, 4, -43 },
  { 2698, 25, 43, 37, 6, -43 },
  { 2833, 4, 32, 37, 16, -32 },
  { 2849, 6, 42, 37, 14, -32 },
  { 2881, 26, 33, 37, 5, -35 },
  { 2989, 29, 12, 37, 4, -25 },
  { 3033, 26, 33, 37, 5, -35 },
  { 3141, 24, 43, 37, 6, -43 },
  { 3270, 24, 49, 37, 6, -43 },
  { 3417, 30, 43, 37, 3, -43 },
  { 3579, 25, 43, 37, 6, -43 },
  { 3714, 27, 44, 37, 5, -43 },
  { 3863, 25, 43, 37, 7, -43 },
  { 3998, 24, 43, 37, 7, -43 },
  { 4127, 25, 43, 37, 7, -43 },
  { 4262, 26, 44, 37, 5, -43 },
  { 4405, 25, 43, 37, 6, -43 },
  { 4540, 25, 43, 37, 6, -43 },
  { 4675, 22, 44, 37, 6, -43 },
  { 4796, 26, 43, 37, 7, -43 },
  { 4936, 23, 43, 37, 9, -43 },
  { 5060, 26, 43, 37, 5, -43 },
  { 5200, 25, 43, 37, 6, -43 },
  { 5335, 28, 44, 37, 4, -43 },
  { 5489, 25, 43, 37, 7, -43 },
  { 5624, 28, 51, 37, 4, -43 },
  { 5803, 25, 43, 37, 7, -43 },
  { 5938, 28, 44, 37, 4, -43 },
  { 6092, 32, 43, 37, 2, -43 },
  { 6264, 25, 44, 37, 6, -43 },
  { 6402, 30, 43, 37, 3, -43 },
  { 6564, 29, 43, 37, 4, -43 },
  { 6720, 31, 43, 37, 3, -43 },
  { 6887, 33, 43, 37, 2, -43 },
  { 7065, 31, 43, 37, 3, -43 },
  { 7232, 15, 54, 37, 16, -46 },
  { 7334, 24, 54, 37, 6, -46 },
  { 7496, 14, 54, 37, 6, -46 },
  { 7591, 28, 23, 37, 4, -43 },
  { 7672, 29, 1, 37, 4, 8 },
  { 7676, 8, 10, 37, 12, -46 },
  { 7686, 27, 33, 37, 5, -32 },
  { 7798, 24, 46, 37, 8, -45 },
  { 7936, 24, 33, 37, 7, -32 },
  { 8035, 24, 46, 37, 5, -45 },
  { 8173, 25, 33, 37, 6, -32 },
  { 8277, 28, 45, 37, 5, -45 },
  { 8435, 29, 47, 37, 5, -34 },
  { 8606, 21, 45, 37, 8, -45 },
  { 8725, 26, 45, 37, 7, -45 },
  { 8872, 21, 57, 37, 6, -45 },
  { 9022, 26, 45, 37, 8, -45 },
  { 9169, 25, 45, 37, 6, -45 },
  { 9310, 28, 32, 37, 4, -32 },
  { 9422, 21, 32, 37, 8, -32 },
  { 9506, 26, 33, 37, 5, -32 },
  { 9614, 24, 44, 37, 8, -32 },
  { 9746, 24, 44, 37, 5, -32 },
  { 9878, 29, 31, 37, 5, -31 },
  { 9991, 26, 33, 37, 6, -32 },
  { 10099, 30, 43, 37, 2, -43 },
  { 10261, 22, 32, 37, 7, -31 },
  { 10349, 25, 31, 37, 6, -31 },
  { 10446, 32, 31, 37, 2, -31 },
  { 10570, 26, 31, 37, 5, -31 },
  { 10671, 27, 43, 37, 5, -31 },
  { 10817, 24, 31, 37, 6, -31 },
  { 10910, 23, 54, 37, 7, -46 },
  { 11066, 1, 54, 37, 18, -46 },
  { 11073, 23, 54, 37, 7, -46 },
  { 11229, 29, 10, 37, 4, -24 },
};

const GFXfont IBMPlexMono_Thin61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_THIN61PT7B_H_
