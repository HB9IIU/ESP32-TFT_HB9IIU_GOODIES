#ifndef _IBMPLEXMONO_THIN32PT7B_H_
#define _IBMPLEXMONO_THIN32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x01, 0x04, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00,
  0x82, 0x00, 0x21, 0x01, 0xF8, 0x3F, 0x02, 0x10, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x04, 0x20, 0x01, 0x08, 0x0F, 0xC3, 0xF0, 0x20, 0x80,
  0x08, 0x20, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04,
  0x10, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0x03, 0x11, 0x8C,
  0x20, 0x90, 0x41, 0xC0, 0x80, 0x81, 0x01, 0x02, 0x01, 0x04, 0x03, 0x08,
  0x03, 0x10, 0x01, 0xF0, 0x00, 0x5C, 0x00, 0x86, 0x01, 0x04, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x98, 0x41, 0x08, 0x8C, 0x0F,
  0xE0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x3E, 0x00, 0xA0, 0x80, 0xA0,
  0x40, 0x50, 0x10, 0x48, 0x08, 0x24, 0x04, 0x22, 0x02, 0x21, 0x01, 0x10,
  0x41, 0x10, 0x1F, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0xE0, 0x23,
  0x08, 0x21, 0x02, 0x21, 0x01, 0x10, 0x80, 0x90, 0x40, 0x48, 0x20, 0x28,
  0x08, 0x18, 0x06, 0x14, 0x00, 0xF0, 0x07, 0xC0, 0x08, 0x20, 0x10, 0x10,
  0x20, 0x10, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x0C, 0x07, 0x32, 0x04, 0x41, 0x04, 0x40, 0x84, 0x80, 0x48,
  0x80, 0x28, 0x80, 0x18, 0x80, 0x08, 0x40, 0x14, 0x40, 0x14, 0x30, 0x62,
  0x0F, 0x81, 0xFF, 0x06, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x30, 0xC0, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xC1, 0x07, 0x3D, 0x38,
  0x03, 0xC0, 0x02, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x08, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x24, 0xA4, 0x94,
  0x80, 0xFF, 0x80, 0xF0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48,
  0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x40, 0x04, 0x80, 0x08,
  0x80, 0x11, 0x00, 0x41, 0x83, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x0A, 0x00,
  0x24, 0x00, 0x88, 0x06, 0x10, 0x18, 0x20, 0x20, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1F,
  0xFF, 0xC0, 0x0F, 0x80, 0xC1, 0x84, 0x01, 0x20, 0x04, 0x80, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x40, 0xC2, 0x01, 0x10, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFC,
  0x00, 0x1C, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x90, 0x02, 0x30, 0x30, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0A, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x40, 0x04, 0x20, 0x04,
  0x10, 0x02, 0x08, 0x02, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x81,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x7F, 0xF2, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x8F, 0xC5, 0x83, 0x10,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x04, 0x80, 0x22, 0x06, 0x0F, 0xC0, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x7E, 0x2C,
  0x19, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x80, 0x23, 0x06, 0x07, 0xC0, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x60, 0x02, 0x80, 0x0A, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xE0,
  0x30, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x20, 0x08, 0x30, 0x20, 0x1F, 0x80, 0xC1, 0x82, 0x00, 0xC8, 0x00,
  0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x13, 0x00, 0x23,
  0x01, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xC1, 0x84, 0x01, 0x20, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80, 0x0A, 0x00, 0x24, 0x01, 0x8C,
  0x0A, 0x0F, 0xC8, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x24, 0x44, 0x48, 0x80,
  0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x08, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x0F, 0xC1,
  0x81, 0x10, 0x04, 0x80, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x0F, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x0F, 0x80,
  0x83, 0x08, 0x0C, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x30, 0x79, 0x86,
  0x1C, 0x20, 0x62, 0x03, 0x10, 0x18, 0x80, 0xC4, 0x06, 0x20, 0x31, 0x01,
  0x88, 0x0C, 0x20, 0xE0, 0xFB, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x0F, 0xF0, 0x01, 0x00, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x08, 0x3F, 0xF8, 0x20, 0x08, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0xFF,
  0xC2, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x8F, 0xFC, 0x20, 0x0C, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x33,
  0xFF, 0x80, 0x0F, 0xC0, 0x60, 0x82, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x34, 0x00, 0x88,
  0x04, 0x18, 0x20, 0x3F, 0x00, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x63, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x3F, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFC, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x0F, 0xFF, 0xA0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07,
  0xC0, 0x60, 0xC3, 0x00, 0x88, 0x02, 0x40, 0x05, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xFE, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x12, 0x00, 0x4C, 0x03, 0x18, 0x14,
  0x1F, 0x90, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x7F, 0xFC, 0x3F, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x24, 0x02, 0x20, 0xC1, 0xF8, 0x80,
  0x05, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08, 0x04, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x28, 0x04, 0x90, 0x0A, 0x10, 0x18,
  0x10, 0x20, 0x20, 0x40, 0x20, 0x80, 0x21, 0x00, 0x62, 0x00, 0x44, 0x00,
  0x48, 0x00, 0x50, 0x00, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x3A, 0x02, 0xD0, 0x16,
  0x41, 0x32, 0x09, 0x88, 0x8C, 0x44, 0x62, 0x43, 0x0A, 0x18, 0x50, 0xC1,
  0x06, 0x08, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x40, 0x19, 0x00, 0xC8, 0x06,
  0x20, 0x31, 0x01, 0x84, 0x0C, 0x20, 0x60, 0x83, 0x04, 0x18, 0x10, 0xC0,
  0x86, 0x02, 0x30, 0x11, 0x80, 0x4C, 0x02, 0x60, 0x0B, 0x00, 0x58, 0x01,
  0xC0, 0x04, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48,
  0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x40, 0x04, 0x80, 0x08,
  0x80, 0x11, 0x00, 0x41, 0x83, 0x00, 0xF8, 0x00, 0xFF, 0xE2, 0x00, 0x48,
  0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A,
  0x00, 0x28, 0x01, 0x3F, 0xF8, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07,
  0xC0, 0x30, 0x60, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x40, 0x04, 0x80, 0x08, 0x80, 0x11, 0x00,
  0x41, 0x83, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xF0,
  0xFF, 0xE2, 0x00, 0x48, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x3F, 0xF8, 0x82, 0x02, 0x04,
  0x08, 0x08, 0x20, 0x20, 0x80, 0x42, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80,
  0x0A, 0x00, 0x30, 0x0F, 0xE0, 0x60, 0x31, 0x00, 0x12, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x13, 0x00, 0x21, 0x01, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x50, 0x04, 0x80, 0x23, 0x02, 0x0F, 0xE0, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20,
  0x08, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x82, 0x01, 0x04, 0x02, 0x08,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x81, 0x82, 0x83, 0x05, 0x09, 0x0A, 0x12, 0x24,
  0x24, 0x44, 0x48, 0x88, 0x91, 0x11, 0x24, 0x12, 0x48, 0x24, 0x90, 0x49,
  0x40, 0x52, 0x80, 0xC3, 0x01, 0x84, 0x01, 0x00, 0x80, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x10, 0x10, 0x08, 0x20, 0x04, 0x40,
  0x04, 0x40, 0x02, 0x80, 0x01, 0x00, 0x01, 0x80, 0x02, 0x80, 0x04, 0x40,
  0x08, 0x20, 0x08, 0x20, 0x10, 0x10, 0x20, 0x08, 0x20, 0x08, 0x40, 0x04,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x44, 0x00,
  0x41, 0x00, 0x40, 0x80, 0x20, 0x20, 0x20, 0x08, 0x20, 0x04, 0x10, 0x01,
  0x10, 0x00, 0x50, 0x00, 0x28, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0xFF, 0x01, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x22,
  0x00, 0x82, 0x01, 0x04, 0x04, 0x04, 0x08, 0x08, 0x20, 0x08, 0x80, 0x09,
  0x00, 0x14, 0x00, 0x10, 0xFF, 0xFE, 0xC2, 0x08, 0x21, 0x80, 0x0F, 0x80,
  0x60, 0xC1, 0x00, 0x42, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x1F, 0xF0, 0x40, 0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02,
  0x10, 0x0C, 0x10, 0x28, 0x1F, 0x8E, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x13, 0xF0, 0xA0, 0x46, 0x01, 0x20, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x28, 0x01, 0x60, 0x12, 0x81, 0x13, 0xF0, 0x0F, 0x83, 0x04,
  0x40, 0x28, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x40, 0x23, 0x04, 0x0F, 0x80, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xF9, 0x30,
  0x54, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x30, 0x51, 0xF9, 0x0F,
  0x81, 0x83, 0x18, 0x04, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x05, 0x00, 0x46,
  0x04, 0x0F, 0xC0, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFE, 0x00, 0x3E, 0x1F,
  0x40, 0x41, 0x81, 0x01, 0x04, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x08,
  0x40, 0x10, 0x40, 0x20, 0x41, 0x80, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x3F, 0xF0, 0xC0, 0x1A, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x50, 0x00, 0x98, 0x06, 0x0F, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x7C, 0xB0, 0xD8, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x5F, 0xF8, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x02, 0x80, 0x32, 0x01, 0x08, 0x08, 0x20, 0x40,
  0x82, 0x02, 0x10, 0x08, 0xC0, 0x24, 0x80, 0xE1, 0x02, 0x02, 0x08, 0x04,
  0x20, 0x10, 0x80, 0x22, 0x00, 0x48, 0x00, 0xA0, 0x01, 0xFE, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF,
  0x9C, 0x39, 0x44, 0x8B, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x8F, 0x96, 0x1B, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0F, 0x81, 0x83, 0x10,
  0x04, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x09, 0x00, 0x46, 0x0C, 0x0F, 0x80,
  0x9F, 0x85, 0x02, 0x30, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x0B, 0x00,
  0x94, 0x08, 0x9F, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x0F, 0x93, 0x05, 0x40, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40,
  0x33, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0xFC, 0x7E, 0x0B, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x1F, 0xC0, 0x80,
  0xC4, 0x00, 0xA0, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x07,
  0xE0, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x06, 0x00, 0x24, 0x00, 0x8C,
  0x0C, 0x0F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x1B, 0x05, 0x1F, 0x20, 0x80,
  0x0C, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x10, 0x10, 0x80, 0x84, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x02, 0x80, 0x14, 0x00,
  0xA0, 0x02, 0x00, 0x80, 0x80, 0xC0, 0xE0, 0x60, 0x50, 0x28, 0x28, 0x24,
  0x14, 0x12, 0x11, 0x09, 0x08, 0x84, 0x84, 0x42, 0x42, 0x22, 0x12, 0x09,
  0x09, 0x04, 0x84, 0x82, 0x42, 0x41, 0x21, 0x40, 0x50, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x04, 0x00, 0x80, 0x0A, 0x00, 0x88, 0x08, 0x40, 0x41, 0x04,
  0x04, 0x40, 0x12, 0x00, 0xA0, 0x02, 0x00, 0x28, 0x01, 0x40, 0x11, 0x01,
  0x04, 0x10, 0x10, 0x80, 0x88, 0x02, 0x80, 0x08, 0x80, 0x0E, 0x00, 0x28,
  0x00, 0x90, 0x04, 0x40, 0x10, 0x80, 0x82, 0x02, 0x08, 0x10, 0x10, 0x40,
  0x41, 0x00, 0x88, 0x02, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x0F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x00, 0xFF, 0xF8, 0x07, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x61, 0xF0,
  0x03, 0x80, 0x08, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x07, 0xC3, 0x80, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x7F, 0x00, 0x3C, 0x02, 0x8C, 0x05, 0x04, 0x0C, 0x0C, 0x28, 0x0C,
  0x50, 0x07, 0x00,
};

const GFXglyph IBMPlexMono_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 2, 22, 19, 9, -22 },
  { 7, 5, 8, 19, 7, -24 },
  { 12, 18, 22, 19, 1, -22 },
  { 62, 15, 28, 19, 2, -25 },
  { 115, 17, 22, 19, 1, -22 },
  { 162, 16, 22, 19, 1, -22 },
  { 206, 1, 8, 19, 9, -24 },
  { 207, 7, 28, 19, 8, -24 },
  { 232, 8, 28, 19, 4, -24 },
  { 260, 16, 16, 19, 2, -18 },
  { 292, 15, 15, 19, 2, -17 },
  { 321, 3, 9, 19, 7, -3 },
  { 325, 9, 1, 19, 5, -10 },
  { 327, 2, 2, 19, 9, -2 },
  { 328, 13, 28, 19, 3, -24 },
  { 374, 15, 22, 19, 2, -22 },
  { 416, 15, 22, 19, 3, -22 },
  { 458, 14, 22, 19, 3, -22 },
  { 497, 14, 22, 19, 2, -22 },
  { 536, 17, 22, 19, 1, -22 },
  { 583, 13, 22, 19, 3, -22 },
  { 619, 13, 22, 19, 3, -22 },
  { 655, 14, 22, 19, 2, -22 },
  { 694, 15, 22, 19, 2, -22 },
  { 736, 14, 22, 19, 3, -22 },
  { 775, 2, 17, 19, 9, -17 },
  { 780, 4, 23, 19, 7, -17 },
  { 792, 13, 17, 19, 3, -18 },
  { 820, 15, 7, 19, 2, -13 },
  { 834, 13, 17, 19, 3, -18 },
  { 862, 13, 22, 19, 3, -22 },
  { 898, 13, 25, 19, 3, -22 },
  { 939, 16, 22, 19, 2, -22 },
  { 983, 14, 22, 19, 3, -22 },
  { 1022, 14, 22, 19, 3, -22 },
  { 1061, 14, 22, 19, 3, -22 },
  { 1100, 13, 22, 19, 3, -22 },
  { 1136, 14, 22, 19, 3, -22 },
  { 1175, 14, 22, 19, 2, -22 },
  { 1214, 13, 22, 19, 3, -22 },
  { 1250, 13, 22, 19, 3, -22 },
  { 1286, 12, 22, 19, 3, -22 },
  { 1319, 15, 22, 19, 3, -22 },
  { 1361, 12, 22, 19, 5, -22 },
  { 1394, 13, 22, 19, 3, -22 },
  { 1430, 13, 22, 19, 3, -22 },
  { 1466, 15, 22, 19, 2, -22 },
  { 1508, 14, 22, 19, 3, -22 },
  { 1547, 15, 26, 19, 2, -22 },
  { 1596, 14, 22, 19, 3, -22 },
  { 1635, 15, 22, 19, 2, -22 },
  { 1677, 17, 22, 19, 1, -22 },
  { 1724, 13, 22, 19, 3, -22 },
  { 1760, 15, 22, 19, 2, -22 },
  { 1802, 15, 22, 19, 2, -22 },
  { 1844, 16, 22, 19, 2, -22 },
  { 1888, 17, 22, 19, 1, -22 },
  { 1935, 16, 22, 19, 2, -22 },
  { 1979, 8, 28, 19, 8, -24 },
  { 2007, 13, 28, 19, 3, -24 },
  { 2053, 8, 28, 19, 3, -24 },
  { 2081, 15, 12, 19, 2, -22 },
  { 2104, 15, 1, 19, 2, 4 },
  { 2106, 5, 5, 19, 6, -24 },
  { 2110, 15, 17, 19, 2, -17 },
  { 2142, 13, 24, 19, 4, -24 },
  { 2181, 12, 17, 19, 4, -17 },
  { 2207, 12, 24, 19, 3, -24 },
  { 2243, 13, 17, 19, 3, -17 },
  { 2271, 14, 24, 19, 3, -24 },
  { 2313, 15, 24, 19, 3, -18 },
  { 2358, 11, 24, 19, 4, -24 },
  { 2391, 13, 25, 19, 4, -25 },
  { 2432, 11, 31, 19, 3, -25 },
  { 2475, 14, 24, 19, 4, -24 },
  { 2517, 13, 24, 19, 3, -24 },
  { 2556, 15, 17, 19, 2, -17 },
  { 2588, 11, 17, 19, 4, -17 },
  { 2612, 13, 17, 19, 3, -17 },
  { 2640, 13, 23, 19, 4, -17 },
  { 2678, 12, 23, 19, 3, -17 },
  { 2713, 15, 17, 19, 3, -17 },
  { 2745, 14, 17, 19, 3, -17 },
  { 2775, 16, 22, 19, 1, -22 },
  { 2819, 11, 17, 19, 4, -17 },
  { 2843, 13, 17, 19, 3, -17 },
  { 2871, 17, 17, 19, 1, -17 },
  { 2908, 13, 17, 19, 3, -17 },
  { 2936, 14, 23, 19, 3, -17 },
  { 2977, 13, 17, 19, 3, -17 },
  { 3005, 11, 28, 19, 4, -24 },
  { 3044, 1, 28, 19, 9, -24 },
  { 3048, 11, 28, 19, 4, -24 },
  { 3087, 15, 6, 19, 2, -13 },
};

const GFXfont IBMPlexMono_Thin32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_THIN32PT7B_H_
