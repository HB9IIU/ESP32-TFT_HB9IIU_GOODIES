#ifndef _IBMPLEXMONO_THIN24PT7B_H_
#define _IBMPLEXMONO_THIN24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x80, 0xC0, 0x99, 0x99, 0x99, 0x04, 0x40, 0x22,
  0x02, 0x10, 0x11, 0x00, 0x88, 0x7C, 0x3C, 0x22, 0x01, 0x10, 0x10, 0x80,
  0x88, 0x04, 0x41, 0xE1, 0xE1, 0x10, 0x08, 0x80, 0x84, 0x04, 0x40, 0x22,
  0x00, 0x04, 0x00, 0x80, 0xFC, 0x22, 0x48, 0x45, 0x08, 0x21, 0x04, 0x20,
  0x84, 0x0E, 0x80, 0x3C, 0x02, 0x60, 0x44, 0x08, 0x41, 0x0C, 0x21, 0x84,
  0x4C, 0x98, 0x7C, 0x02, 0x00, 0x40, 0x78, 0x1C, 0x20, 0xA1, 0x09, 0x08,
  0x48, 0x44, 0x42, 0x42, 0x12, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x04, 0xC4,
  0x44, 0x22, 0x40, 0xA2, 0x05, 0x08, 0x50, 0x62, 0x81, 0xE0, 0x1E, 0x02,
  0x10, 0x20, 0x84, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x28, 0x34,
  0x44, 0x82, 0x48, 0x14, 0x80, 0xC8, 0x08, 0x80, 0xC4, 0x12, 0x3E, 0x10,
  0xFC, 0x08, 0x88, 0x8C, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x82,
  0x08, 0x20, 0x80, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x10, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x84, 0x17, 0x4E, 0x0B, 0x00, 0x60, 0x09, 0x01, 0x08, 0x20, 0x42,
  0x04, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x6A, 0xA0, 0xFC,
  0xC0, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x00, 0x1F, 0x04, 0x31, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01,
  0x84, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0x90, 0x13, 0x0C, 0x1F,
  0x00, 0x04, 0x01, 0x80, 0xD0, 0x32, 0x0C, 0x41, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF,
  0xE0, 0x1E, 0x04, 0x31, 0x02, 0x40, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x00, 0xFF,
  0xE0, 0x1E, 0x18, 0x68, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0xF8, 0x03,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x18, 0x09, 0x06, 0x3E, 0x00, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x28, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x20,
  0x84, 0x08, 0x40, 0x88, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x7F, 0xD0, 0x04, 0x01, 0x00, 0x40, 0x20, 0x09, 0xF1, 0x82, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x09, 0x86, 0x1E, 0x00, 0x02,
  0x03, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x7C, 0xA0, 0xB0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x82, 0x1F, 0x00, 0xFF, 0xE0, 0x18,
  0x0A, 0x02, 0x80, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x1F, 0x0C, 0x12, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x13, 0x04, 0x1F, 0x0C, 0x32, 0x01, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x12, 0x06, 0x3F, 0x00, 0x1F, 0x18, 0x24, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x05, 0x03, 0x60, 0xC7, 0x90, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xAA,
  0x00, 0x40, 0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x00, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x01, 0x03, 0x80, 0x80, 0x20, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x61, 0xD8,
  0x8E, 0x41, 0x90, 0x64, 0x19, 0x06, 0x41, 0x90, 0x62, 0x18, 0x7E, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x7E, 0x02, 0x00, 0x60, 0x06, 0x00, 0x90, 0x09,
  0x00, 0x90, 0x10, 0x81, 0x08, 0x10, 0x82, 0x04, 0x20, 0x43, 0xFC, 0x40,
  0x24, 0x02, 0x40, 0x28, 0x01, 0x80, 0x10, 0xFF, 0x20, 0x28, 0x0A, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x02, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0xFF, 0x00, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x14, 0x04,
  0x82, 0x1F, 0x00, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x0C, 0xFE,
  0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x00, 0x1E, 0x08, 0x64, 0x0A, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x14, 0x04,
  0x83, 0x1F, 0x40, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xFF, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC0, 0x3F,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0C, 0x06, 0x02, 0x82, 0x3E, 0x00, 0x80, 0x60, 0x28, 0x12, 0x08,
  0x84, 0x22, 0x09, 0x02, 0x40, 0xA8, 0x32, 0x08, 0x42, 0x08, 0x82, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0x40, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xC0, 0x80, 0x60, 0x1C, 0x0F, 0x03, 0xA1, 0x68, 0x59, 0x26,
  0x49, 0x8C, 0x63, 0x18, 0x46, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x19, 0x06, 0x21, 0x88,
  0x61, 0x18, 0x46, 0x09, 0x81, 0x60, 0x58, 0x0E, 0x03, 0x80, 0x40, 0x1F,
  0x04, 0x31, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0x90, 0x13, 0x0C, 0x1F, 0x00, 0xFF,
  0x20, 0x68, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0xBF, 0xC8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1F, 0x04, 0x31,
  0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x28, 0x05, 0x00, 0x90, 0x11, 0x0C, 0x1F, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x78, 0xFF, 0x20, 0x68, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x02,
  0x81, 0xBF, 0xC8, 0x82, 0x10, 0x84, 0x20, 0x88, 0x12, 0x04, 0x80, 0xC0,
  0x3F, 0x08, 0x12, 0x01, 0x40, 0x08, 0x01, 0x00, 0x20, 0x03, 0x80, 0x0F,
  0x00, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x13, 0x06, 0x1F, 0x00,
  0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x82, 0x1F, 0x00,
  0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x20, 0x42, 0x04,
  0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x21, 0x46,
  0x24, 0x62, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x50, 0xA5, 0x0A, 0x50,
  0xA6, 0x06, 0x20, 0x40, 0x80, 0x14, 0x02, 0x20, 0x42, 0x04, 0x10, 0x80,
  0x90, 0x09, 0x00, 0x60, 0x02, 0x00, 0x60, 0x09, 0x01, 0x08, 0x10, 0x82,
  0x04, 0x40, 0x24, 0x02, 0x80, 0x10, 0x80, 0x1C, 0x00, 0x90, 0x08, 0x40,
  0x82, 0x04, 0x08, 0x40, 0x24, 0x01, 0x20, 0x06, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x7F, 0xF0,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x04, 0x01, 0x80, 0x48,
  0x10, 0x82, 0x10, 0x81, 0x10, 0x24, 0x02, 0x80, 0x20, 0xFF, 0xF0, 0x91,
  0x10, 0x3E, 0x18, 0x20, 0x02, 0x00, 0x40, 0x08, 0x7F, 0x30, 0x24, 0x04,
  0x80, 0x90, 0x13, 0x0E, 0x3E, 0x70, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0xF9, 0x82, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xC1, 0x5F, 0x00, 0x3E, 0x20, 0xA0, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x50, 0x47, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x7A, 0xC3, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x61,
  0x8F, 0x40, 0x1F, 0x08, 0x28, 0x06, 0x01, 0x80, 0x7F, 0xF8, 0x02, 0x00,
  0x80, 0x10, 0x12, 0x08, 0x7C, 0x07, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x3F, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x1F, 0xF8, 0x00, 0xE0, 0x20, 0x7C, 0x10, 0x44,
  0x08, 0x81, 0x10, 0x22, 0x04, 0x20, 0x83, 0xE1, 0x80, 0x20, 0x04, 0x00,
  0x7F, 0x90, 0x0C, 0x01, 0x80, 0x28, 0x08, 0xFE, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0xF9, 0x82, 0x81, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x13, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x0E, 0x04, 0x82, 0x21, 0x09, 0x82, 0xA0, 0xC4, 0x20, 0x88, 0x22,
  0x04, 0x80, 0xA0, 0x10, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x3F, 0xF0, 0xB1, 0xD9, 0xCA, 0x10, 0xC4, 0x18, 0x83, 0x10, 0x62,
  0x0C, 0x41, 0x88, 0x31, 0x06, 0x20, 0xC4, 0x10, 0xBE, 0x60, 0xA0, 0x50,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x1F, 0x18,
  0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x16, 0x08,
  0x7C, 0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x57, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1E, 0xB0, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x58, 0x63, 0xD0, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xF9, 0xE1, 0xC0, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xE0, 0x3F, 0x10,
  0x28, 0x06, 0x00, 0x40, 0x0F, 0x80, 0x1C, 0x01, 0x00, 0x60, 0x16, 0x0C,
  0x7C, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFF, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x07, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x3D, 0x80, 0x60, 0x14, 0x09, 0x02, 0x41, 0x08, 0x42, 0x10,
  0x48, 0x12, 0x04, 0x80, 0xC0, 0x10, 0x82, 0x18, 0x61, 0x86, 0x18, 0xA1,
  0x89, 0x18, 0x92, 0x49, 0x25, 0x0A, 0x50, 0xA5, 0x0A, 0x60, 0xC2, 0x04,
  0x80, 0x50, 0x22, 0x10, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x48, 0x21, 0x08,
  0x44, 0x0A, 0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x88, 0x42, 0x10,
  0x48, 0x12, 0x03, 0x00, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0,
  0x00, 0x7F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x03, 0xFF, 0x1F, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x04, 0x3C, 0x03, 0x00, 0x40, 0x20, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x08, 0x03, 0xE3, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x38, 0x14, 0x41, 0x42, 0x28,
  0x12, 0x80, 0xC0,
};

const GFXglyph IBMPlexMono_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 17, 14, 6, -17 },
  { 6, 4, 6, 14, 5, -18 },
  { 9, 13, 17, 14, 1, -17 },
  { 37, 11, 21, 14, 2, -19 },
  { 66, 13, 17, 14, 1, -17 },
  { 94, 12, 17, 14, 1, -17 },
  { 120, 1, 6, 14, 7, -18 },
  { 121, 5, 21, 14, 6, -18 },
  { 135, 6, 21, 14, 3, -18 },
  { 151, 12, 12, 14, 1, -13 },
  { 169, 12, 13, 14, 1, -14 },
  { 189, 2, 6, 14, 6, -2 },
  { 191, 6, 1, 14, 4, -8 },
  { 192, 2, 1, 14, 6, -1 },
  { 193, 9, 21, 14, 3, -18 },
  { 217, 11, 17, 14, 2, -17 },
  { 241, 11, 17, 14, 2, -17 },
  { 265, 11, 17, 14, 2, -17 },
  { 289, 10, 17, 14, 2, -17 },
  { 311, 12, 17, 14, 1, -17 },
  { 337, 10, 17, 14, 2, -17 },
  { 359, 10, 17, 14, 2, -17 },
  { 381, 10, 17, 14, 2, -17 },
  { 403, 11, 17, 14, 2, -17 },
  { 427, 10, 17, 14, 2, -17 },
  { 449, 2, 12, 14, 6, -12 },
  { 452, 2, 16, 14, 6, -12 },
  { 456, 10, 13, 14, 2, -14 },
  { 473, 12, 5, 14, 1, -10 },
  { 481, 10, 13, 14, 2, -14 },
  { 498, 10, 17, 14, 2, -17 },
  { 520, 10, 20, 14, 2, -17 },
  { 545, 12, 17, 14, 1, -17 },
  { 571, 10, 17, 14, 2, -17 },
  { 593, 10, 17, 14, 2, -17 },
  { 615, 10, 17, 14, 3, -17 },
  { 637, 9, 17, 14, 3, -17 },
  { 657, 9, 17, 14, 3, -17 },
  { 677, 10, 17, 14, 2, -17 },
  { 699, 10, 17, 14, 2, -17 },
  { 721, 10, 17, 14, 2, -17 },
  { 743, 9, 17, 14, 2, -17 },
  { 763, 10, 17, 14, 3, -17 },
  { 785, 10, 17, 14, 3, -17 },
  { 807, 10, 17, 14, 2, -17 },
  { 829, 10, 17, 14, 2, -17 },
  { 851, 11, 17, 14, 2, -17 },
  { 875, 10, 17, 14, 3, -17 },
  { 897, 11, 21, 14, 2, -17 },
  { 926, 10, 17, 14, 3, -17 },
  { 948, 11, 17, 14, 2, -17 },
  { 972, 12, 17, 14, 1, -17 },
  { 998, 10, 17, 14, 2, -17 },
  { 1020, 12, 17, 14, 1, -17 },
  { 1046, 12, 17, 14, 1, -17 },
  { 1072, 12, 17, 14, 1, -17 },
  { 1098, 13, 17, 14, 1, -17 },
  { 1126, 12, 17, 14, 1, -17 },
  { 1152, 6, 21, 14, 6, -18 },
  { 1168, 9, 21, 14, 3, -18 },
  { 1192, 6, 21, 14, 2, -18 },
  { 1208, 11, 9, 14, 2, -17 },
  { 1221, 12, 1, 14, 1, 3 },
  { 1223, 3, 4, 14, 5, -18 },
  { 1225, 11, 12, 14, 2, -12 },
  { 1242, 9, 18, 14, 3, -18 },
  { 1263, 9, 12, 14, 3, -12 },
  { 1277, 9, 18, 14, 2, -18 },
  { 1298, 10, 12, 14, 2, -12 },
  { 1313, 11, 18, 14, 2, -18 },
  { 1338, 11, 19, 14, 2, -14 },
  { 1365, 9, 18, 14, 3, -18 },
  { 1386, 10, 17, 14, 3, -17 },
  { 1408, 9, 22, 14, 2, -17 },
  { 1433, 10, 18, 14, 3, -18 },
  { 1456, 10, 18, 14, 2, -18 },
  { 1479, 11, 12, 14, 2, -12 },
  { 1496, 9, 12, 14, 3, -12 },
  { 1510, 10, 12, 14, 2, -12 },
  { 1525, 9, 17, 14, 3, -12 },
  { 1545, 9, 17, 14, 2, -12 },
  { 1565, 11, 12, 14, 2, -12 },
  { 1582, 10, 12, 14, 2, -12 },
  { 1597, 12, 17, 14, 1, -17 },
  { 1623, 8, 12, 14, 3, -12 },
  { 1635, 10, 12, 14, 2, -12 },
  { 1650, 12, 12, 14, 1, -12 },
  { 1668, 10, 12, 14, 2, -12 },
  { 1683, 10, 17, 14, 2, -12 },
  { 1705, 10, 12, 14, 2, -12 },
  { 1720, 9, 21, 14, 3, -18 },
  { 1744, 1, 21, 14, 7, -18 },
  { 1747, 9, 21, 14, 3, -18 },
  { 1771, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Thin24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_THIN24PT7B_H_
