#ifndef _IBMPLEXMONO_THIN64PT7B_H_
#define _IBMPLEXMONO_THIN64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x40, 0x08, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x30, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x43,
  0xC0, 0x07, 0x01, 0x01, 0xC0, 0x30, 0x04, 0x01, 0x81, 0x80, 0x10, 0x03,
  0x04, 0x00, 0x40, 0x06, 0x30, 0x01, 0x00, 0x10, 0x80, 0x04, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x01,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x38, 0x10, 0x00,
  0x00, 0x1E, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x04, 0xF8, 0x00,
  0x00, 0x10, 0x38, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x00, 0x40, 0x06, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x30, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x40,
  0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x40, 0x02, 0x40, 0x01, 0x00, 0x0B, 0x00, 0x04, 0x00, 0x66,
  0x00, 0x10, 0x01, 0x0C, 0x00, 0x40, 0x08, 0x1C, 0x01, 0x00, 0x40, 0x1C,
  0x04, 0x06, 0x00, 0x1E, 0x10, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x61, 0x81, 0x80, 0x00, 0x18, 0x40, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x80, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x10, 0x80, 0x01, 0x00, 0x04, 0x10,
  0x00, 0x20, 0x01, 0x86, 0x00, 0x06, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x0C,
  0x18, 0x00, 0x18, 0x01, 0x03, 0x00, 0x03, 0x00, 0x40, 0x60, 0x00, 0x60,
  0x18, 0x0C, 0x00, 0x0C, 0x02, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x10, 0x00,
  0x20, 0x10, 0x02, 0x00, 0x04, 0x04, 0x00, 0x60, 0x01, 0x81, 0x80, 0x04,
  0x00, 0x20, 0x20, 0x00, 0x40, 0x08, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x08, 0x00, 0x18, 0x18, 0x00, 0x80,
  0x02, 0x02, 0x00, 0x18, 0x00, 0x80, 0xC0, 0x01, 0x00, 0x30, 0x10, 0x00,
  0x30, 0x04, 0x02, 0x00, 0x02, 0x01, 0x80, 0x40, 0x00, 0x40, 0x20, 0x08,
  0x00, 0x08, 0x08, 0x03, 0x00, 0x01, 0x03, 0x00, 0x60, 0x00, 0x20, 0x40,
  0x04, 0x00, 0x04, 0x18, 0x00, 0x80, 0x00, 0x82, 0x00, 0x10, 0x00, 0x10,
  0x80, 0x02, 0x00, 0x06, 0x30, 0x00, 0x60, 0x00, 0x84, 0x00, 0x04, 0x00,
  0x31, 0x80, 0x00, 0xC0, 0x04, 0x20, 0x00, 0x0C, 0x01, 0x08, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x03, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x7F, 0x18, 0x0C, 0x00, 0x60, 0x30,
  0x04, 0x00, 0x40, 0x20, 0x02, 0x00, 0x40, 0x60, 0x01, 0x00, 0x40, 0x40,
  0x01, 0x80, 0x40, 0xC0, 0x00, 0xC0, 0x40, 0x80, 0x00, 0x60, 0x40, 0x80,
  0x00, 0x30, 0x40, 0x80, 0x00, 0x10, 0xC0, 0x80, 0x00, 0x08, 0x80, 0x80,
  0x00, 0x04, 0x80, 0x80, 0x00, 0x06, 0x80, 0x80, 0x00, 0x03, 0x80, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0xC0, 0x40, 0x00, 0x02, 0x60, 0x60,
  0x00, 0x06, 0x30, 0x20, 0x00, 0x0C, 0x18, 0x10, 0x00, 0x18, 0x08, 0x0C,
  0x00, 0x30, 0x04, 0x07, 0x01, 0xC0, 0x02, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0xF0, 0x00,
  0x80, 0x0F, 0x1E, 0x00, 0x80, 0x78, 0x03, 0xE0, 0x83, 0xC0, 0x00, 0x7C,
  0x9E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x61, 0x8E, 0x30, 0xC3,
  0x0C, 0x61, 0x86, 0x10, 0xC3, 0x08, 0x20, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x07,
  0x00, 0x03, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x20, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xC1, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x1F, 0xF0, 0x01, 0x1C, 0x03, 0x80, 0x64, 0x00, 0x0C,
  0x0D, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x07,
  0x00, 0x06, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x81,
  0xFE, 0x00, 0x30, 0xC0, 0x38, 0x04, 0x60, 0x01, 0xC0, 0x90, 0x00, 0x0C,
  0x34, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x08, 0xA0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x04, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x02, 0x84, 0x00, 0x00, 0xD0, 0x60, 0x00, 0x32, 0x06, 0x00, 0x0C, 0xC0,
  0x78, 0x0E, 0x18, 0x01, 0xFF, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0x86,
  0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x43, 0x0C, 0x20, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x10, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x40,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x01,
  0x80, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x1F, 0x85, 0x00, 0x38, 0x32, 0x80,
  0x30, 0x05, 0xC0, 0x30, 0x01, 0xE0, 0x10, 0x00, 0xF0, 0x18, 0x00, 0x30,
  0x08, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0xE0, 0x20, 0x00, 0x70, 0x18,
  0x00, 0x38, 0x04, 0x00, 0x3C, 0x01, 0x00, 0x2A, 0x00, 0xC0, 0x35, 0x00,
  0x1E, 0xE2, 0x80, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x3F, 0xFF, 0xF8,
  0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x21, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x3C, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x04, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x70,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFA, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF2, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x71, 0x00, 0x00, 0x07, 0x08, 0x00, 0x00, 0xB0, 0xC0, 0x00,
  0x1B, 0x06, 0x00, 0x03, 0x30, 0x38, 0x00, 0x63, 0x00, 0xE0, 0x18, 0x30,
  0x01, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x30, 0x00, 0x10, 0x1C,
  0x00, 0x20, 0x07, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x10, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00,
  0x0C, 0x00, 0x80, 0x01, 0x80, 0x08, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x08, 0x19, 0x80,
  0x00, 0x83, 0x18, 0x00, 0x08, 0x60, 0xC0, 0x00, 0x8C, 0x06, 0x00, 0x09,
  0x80, 0x60, 0x00, 0xB0, 0x03, 0x00, 0x0A, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x80, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x30, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x18, 0x08, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x5D, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00,
  0x9C, 0x80, 0x00, 0x19, 0xC8, 0x00, 0x01, 0x1C, 0xC0, 0x00, 0x11, 0xC4,
  0x00, 0x03, 0x1C, 0x60, 0x00, 0x21, 0xC2, 0x00, 0x06, 0x1C, 0x30, 0x00,
  0x41, 0xC1, 0x00, 0x0C, 0x1C, 0x18, 0x00, 0x81, 0xC0, 0x80, 0x18, 0x1C,
  0x08, 0x01, 0x01, 0xC0, 0x40, 0x30, 0x1C, 0x04, 0x02, 0x01, 0xC0, 0x60,
  0x20, 0x1C, 0x02, 0x06, 0x01, 0xC0, 0x30, 0x40, 0x1C, 0x01, 0x0C, 0x01,
  0xC0, 0x18, 0x80, 0x1C, 0x00, 0x98, 0x01, 0xC0, 0x0D, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x04, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x40, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x72, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x10, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x70, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x04, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x70, 0x20, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x70, 0x08, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00,
  0x40, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x02, 0x00, 0x1C, 0x00, 0xC0, 0x07,
  0x00, 0x10, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x10,
  0x07, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x80, 0x70, 0x00, 0x30, 0x1C, 0x00,
  0x04, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x20, 0x70, 0x00, 0x0C, 0x1C,
  0x00, 0x01, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x08, 0x70, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x47, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x02, 0x70, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x17, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x10, 0x00, 0x03, 0x82, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x07, 0x07, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x10, 0x00, 0x03, 0x82, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x07, 0x07, 0xFF, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x10,
  0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x30,
  0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0x20, 0x04, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x40, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08,
  0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x04,
  0x01, 0xC0, 0x00, 0x60, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x03, 0x80, 0x38, 0x00, 0x3F, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x10, 0x02, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x01, 0x10, 0x00, 0xC0, 0x02, 0x30, 0x01, 0xC0, 0x04, 0x60, 0x02, 0x80,
  0x08, 0xC0, 0x0D, 0x00, 0x10, 0x80, 0x12, 0x00, 0x21, 0x00, 0x26, 0x00,
  0x42, 0x00, 0xC4, 0x01, 0x84, 0x01, 0x08, 0x03, 0x08, 0x02, 0x18, 0x06,
  0x10, 0x04, 0x10, 0x08, 0x20, 0x18, 0x20, 0x10, 0x60, 0x20, 0x60, 0x20,
  0xC0, 0x40, 0xC0, 0x41, 0x81, 0x80, 0x80, 0x83, 0x02, 0x01, 0x01, 0x02,
  0x04, 0x03, 0x02, 0x04, 0x18, 0x02, 0x0C, 0x08, 0x30, 0x04, 0x18, 0x10,
  0x40, 0x0C, 0x30, 0x20, 0x80, 0x08, 0x40, 0x43, 0x00, 0x10, 0x80, 0x84,
  0x00, 0x31, 0x01, 0x88, 0x00, 0x62, 0x03, 0x30, 0x00, 0x44, 0x06, 0x40,
  0x00, 0x88, 0x04, 0x80, 0x01, 0x90, 0x0B, 0x00, 0x01, 0x60, 0x16, 0x00,
  0x02, 0xC0, 0x28, 0x00, 0x07, 0x80, 0x50, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00,
  0x00, 0xC0, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x20, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x20, 0x00, 0x18, 0x01, 0x80, 0x00, 0x20, 0x04,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x7F, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x10, 0x01, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x70, 0x20, 0x00, 0x03, 0x81, 0x00, 0x00, 0x2C,
  0x04, 0x00, 0x02, 0x60, 0x18, 0x00, 0x23, 0x00, 0x70, 0x0E, 0x0F, 0xC0,
  0x7F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x07, 0xF8, 0x02, 0x0C,
  0x03, 0x01, 0x18, 0x00, 0x60, 0x98, 0x00, 0x18, 0x58, 0x00, 0x06, 0x28,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x01, 0x28, 0x00, 0x01, 0x94, 0x00, 0x01, 0x89, 0x80, 0x01, 0x84,
  0x60, 0x01, 0x82, 0x0E, 0x03, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x02, 0x00, 0x0C, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x01, 0xFC, 0x04, 0x07, 0x01, 0xC2, 0x04, 0x00,
  0x31, 0x0C, 0x00, 0x04, 0x84, 0x00, 0x01, 0x44, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x50, 0xC0, 0x00, 0x48, 0x10, 0x00, 0xC4, 0x07,
  0x01, 0xC2, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x08, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x03, 0xF8, 0x40, 0x00, 0x70, 0x1D, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04, 0x01, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x10, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x1F, 0xE0, 0x21, 0xC0, 0x70, 0x46, 0x00,
  0x30, 0x90, 0x00, 0x11, 0x40, 0x00, 0x12, 0x80, 0x00, 0x36, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x23,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x08, 0x00,
  0x0C, 0x01, 0x00, 0x03, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x60, 0x00,
  0x80, 0x18, 0x00, 0x10, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x40, 0x70,
  0x00, 0x08, 0x13, 0x00, 0x01, 0x0C, 0x20, 0x00, 0x23, 0x06, 0x00, 0x04,
  0xC0, 0x60, 0x00, 0xB0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x18, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F,
  0x84, 0xC1, 0x83, 0x06, 0x2C, 0x02, 0x30, 0x09, 0x40, 0x09, 0x00, 0x6C,
  0x00, 0x50, 0x01, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x40, 0x03, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x80,
  0x07, 0x00, 0x04, 0x00, 0x38, 0x00, 0x20, 0x01, 0xC0, 0x01, 0x00, 0x0E,
  0x00, 0x08, 0x00, 0x70, 0x00, 0x40, 0x03, 0x80, 0x02, 0x00, 0x1C, 0x00,
  0x10, 0x00, 0xE0, 0x00, 0x80, 0x07, 0x00, 0x04, 0x00, 0x38, 0x00, 0x20,
  0x01, 0xC0, 0x01, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x70, 0x00, 0x40, 0x03,
  0x80, 0x02, 0x00, 0x1C, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x80, 0x07, 0x00,
  0x04, 0x00, 0x38, 0x00, 0x20, 0x01, 0xC0, 0x01, 0x00, 0x0E, 0x00, 0x08,
  0x00, 0x70, 0x00, 0x40, 0x03, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0xFF, 0x01, 0x0E, 0x03, 0x82, 0x30, 0x01, 0x84, 0x80, 0x00,
  0x8A, 0x00, 0x00, 0x94, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x20, 0x60, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x20, 0x06, 0x00, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x41, 0x80, 0x60, 0x23, 0x00, 0x0C, 0x13,
  0x00, 0x03, 0x0B, 0x00, 0x00, 0xC5, 0x00, 0x00, 0x33, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x25, 0x00, 0x00, 0x32,
  0x80, 0x00, 0x31, 0x30, 0x00, 0x30, 0x8C, 0x00, 0x30, 0x41, 0xC0, 0x60,
  0x20, 0x3F, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x38, 0x40,
  0x80, 0x06, 0x21, 0x80, 0x00, 0x90, 0x80, 0x00, 0x28, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x24, 0x00, 0x00, 0x13, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x0C, 0x20, 0x00, 0x0A, 0x18, 0x00, 0x09, 0x02, 0x00, 0x18,
  0x80, 0xE0, 0x38, 0x40, 0x1F, 0xE0, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x10, 0xE0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x00, 0x78, 0x03, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00,
  0x05, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x32, 0x00, 0x00, 0x66, 0x00, 0x01,
  0xC6, 0x00, 0x06, 0x86, 0x00, 0x19, 0x07, 0x01, 0xC2, 0x01, 0xFE, 0x00,
  0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x0C, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x40, 0x04, 0x00, 0x10,
  0x03, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00,
  0x0C, 0x04, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x02, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x34, 0x00, 0x0A, 0x00,
  0x0D, 0x00, 0x06, 0x80, 0x02, 0x60, 0x01, 0x20, 0x00, 0x98, 0x00, 0x4C,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x02,
  0x10, 0x01, 0x0C, 0x00, 0x86, 0x00, 0x43, 0x00, 0x60, 0x80, 0x10, 0x40,
  0x10, 0x20, 0x04, 0x10, 0x04, 0x08, 0x03, 0x04, 0x01, 0x01, 0x00, 0x81,
  0x00, 0xC0, 0x40, 0x20, 0x60, 0x20, 0x10, 0x08, 0x08, 0x08, 0x06, 0x02,
  0x02, 0x02, 0x00, 0x81, 0x80, 0x81, 0x80, 0x20, 0x60, 0x20, 0x40, 0x08,
  0x10, 0x0C, 0x10, 0x03, 0x04, 0x03, 0x04, 0x00, 0x41, 0x00, 0x43, 0x00,
  0x10, 0x40, 0x10, 0x80, 0x04, 0x30, 0x04, 0x20, 0x01, 0x88, 0x01, 0x88,
  0x00, 0x22, 0x00, 0x66, 0x00, 0x08, 0x80, 0x09, 0x00, 0x02, 0x20, 0x02,
  0x40, 0x00, 0xD8, 0x00, 0x90, 0x00, 0x14, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x0E, 0x00, 0x01, 0x40, 0x01, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x08, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x20, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x10, 0x00, 0x30, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x60,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x08,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0x18, 0x60, 0x00, 0x08, 0x40, 0x60, 0x00, 0x11, 0x00, 0x20,
  0x00, 0x22, 0x00, 0x20, 0x00, 0xC8, 0x00, 0x60, 0x01, 0x10, 0x00, 0x60,
  0x02, 0x60, 0x00, 0x60, 0x08, 0x80, 0x00, 0x60, 0x31, 0x00, 0x00, 0x70,
  0xC2, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 4, 45, 38, 17, -45 },
  { 24, 10, 16, 38, 14, -47 },
  { 44, 36, 45, 38, 1, -45 },
  { 247, 30, 58, 38, 4, -51 },
  { 465, 35, 46, 38, 2, -45 },
  { 667, 32, 46, 38, 3, -45 },
  { 851, 2, 16, 38, 18, -47 },
  { 855, 15, 58, 38, 15, -49 },
  { 964, 14, 58, 38, 9, -49 },
  { 1066, 32, 32, 38, 3, -35 },
  { 1194, 31, 31, 38, 4, -35 },
  { 1315, 6, 16, 38, 15, -5 },
  { 1327, 17, 1, 38, 11, -20 },
  { 1330, 4, 4, 38, 17, -4 },
  { 1332, 25, 58, 38, 7, -49 },
  { 1514, 29, 46, 38, 5, -45 },
  { 1681, 30, 45, 38, 5, -45 },
  { 1850, 27, 45, 38, 6, -45 },
  { 2002, 27, 46, 38, 4, -45 },
  { 2158, 32, 45, 38, 3, -45 },
  { 2338, 27, 46, 38, 5, -45 },
  { 2494, 27, 46, 38, 6, -45 },
  { 2650, 28, 45, 38, 5, -45 },
  { 2808, 29, 46, 38, 5, -45 },
  { 2975, 27, 45, 38, 6, -45 },
  { 3127, 4, 34, 38, 17, -34 },
  { 3144, 6, 45, 38, 15, -34 },
  { 3178, 28, 34, 38, 5, -37 },
  { 3297, 30, 13, 38, 4, -26 },
  { 3346, 28, 34, 38, 5, -37 },
  { 3465, 26, 45, 38, 6, -45 },
  { 3612, 25, 52, 38, 6, -45 },
  { 3775, 32, 45, 38, 3, -45 },
  { 3955, 27, 45, 38, 6, -45 },
  { 4107, 28, 46, 38, 5, -45 },
  { 4268, 27, 45, 38, 7, -45 },
  { 4420, 26, 45, 38, 7, -45 },
  { 4567, 26, 45, 38, 7, -45 },
  { 4714, 28, 46, 38, 5, -45 },
  { 4875, 26, 45, 38, 6, -45 },
  { 5022, 27, 45, 38, 6, -45 },
  { 5174, 24, 46, 38, 6, -45 },
  { 5312, 28, 45, 38, 7, -45 },
  { 5470, 25, 45, 38, 9, -45 },
  { 5611, 28, 45, 38, 5, -45 },
  { 5769, 26, 45, 38, 6, -45 },
  { 5916, 29, 46, 38, 5, -45 },
  { 6083, 27, 45, 38, 7, -45 },
  { 6235, 29, 54, 38, 5, -45 },
  { 6431, 27, 45, 38, 7, -45 },
  { 6583, 30, 46, 38, 4, -45 },
  { 6756, 33, 45, 38, 3, -45 },
  { 6942, 26, 46, 38, 6, -45 },
  { 7092, 31, 45, 38, 4, -45 },
  { 7267, 31, 45, 38, 4, -45 },
  { 7442, 32, 45, 38, 3, -45 },
  { 7622, 35, 45, 38, 2, -45 },
  { 7819, 32, 45, 38, 3, -45 },
  { 7999, 15, 58, 38, 17, -49 },
  { 8108, 25, 58, 38, 7, -49 },
  { 8290, 15, 58, 38, 6, -49 },
  { 8399, 30, 24, 38, 4, -45 },
  { 8489, 31, 1, 38, 4, 8 },
  { 8493, 8, 11, 38, 13, -49 },
  { 8504, 29, 35, 38, 5, -34 },
  { 8631, 25, 48, 38, 8, -47 },
  { 8781, 25, 35, 38, 7, -34 },
  { 8891, 25, 48, 38, 5, -47 },
  { 9041, 27, 35, 38, 6, -34 },
  { 9160, 29, 47, 38, 5, -47 },
  { 9331, 30, 50, 38, 6, -36 },
  { 9519, 23, 47, 38, 8, -47 },
  { 9655, 27, 47, 38, 7, -47 },
  { 9814, 23, 60, 38, 6, -47 },
  { 9987, 27, 47, 38, 9, -47 },
  { 10146, 27, 47, 38, 6, -47 },
  { 10305, 29, 34, 38, 5, -34 },
  { 10429, 23, 34, 38, 8, -34 },
  { 10527, 27, 35, 38, 6, -34 },
  { 10646, 25, 47, 38, 8, -34 },
  { 10793, 25, 47, 38, 5, -34 },
  { 10940, 31, 33, 38, 5, -33 },
  { 11068, 27, 35, 38, 6, -34 },
  { 11187, 31, 45, 38, 2, -45 },
  { 11362, 23, 34, 38, 7, -33 },
  { 11460, 26, 33, 38, 6, -33 },
  { 11568, 34, 33, 38, 2, -33 },
  { 11709, 27, 33, 38, 6, -33 },
  { 11821, 28, 46, 38, 5, -33 },
  { 11982, 25, 33, 38, 7, -33 },
  { 12086, 24, 58, 38, 7, -49 },
  { 12260, 1, 58, 38, 19, -49 },
  { 12268, 24, 58, 38, 7, -49 },
  { 12442, 31, 11, 38, 4, -25 },
};

const GFXfont IBMPlexMono_Thin64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_THIN64PT7B_H_
