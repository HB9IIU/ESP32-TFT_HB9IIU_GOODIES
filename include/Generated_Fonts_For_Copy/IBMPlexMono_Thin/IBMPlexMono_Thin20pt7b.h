#ifndef _IBMPLEXMONO_THIN20PT7B_H_
#define _IBMPLEXMONO_THIN20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0x30, 0x99, 0x99, 0x90, 0x04, 0x80, 0x88, 0x08,
  0x80, 0x90, 0x78, 0xF0, 0x90, 0x09, 0x01, 0x10, 0x11, 0x0F, 0x1E, 0x12,
  0x01, 0x20, 0x22, 0x02, 0x20, 0x08, 0x02, 0x03, 0xE1, 0x24, 0x88, 0xA2,
  0x08, 0x81, 0x20, 0x3C, 0x02, 0xC0, 0x88, 0x22, 0x08, 0x62, 0x26, 0x88,
  0x7C, 0x08, 0x02, 0x00, 0x70, 0x62, 0x18, 0x8A, 0x24, 0x89, 0x22, 0x87,
  0x00, 0x0E, 0x34, 0x4A, 0x14, 0x86, 0x21, 0x84, 0x60, 0xE0, 0x3C, 0x10,
  0x84, 0x21, 0x00, 0x40, 0x08, 0x03, 0x0D, 0x64, 0x89, 0x21, 0x48, 0x32,
  0x04, 0xC2, 0x9F, 0x30, 0xF8, 0x12, 0x48, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x84, 0x21, 0x84, 0x42, 0x21, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x08,
  0x02, 0x00, 0x80, 0x20, 0xE9, 0xC7, 0x81, 0x40, 0x48, 0x21, 0x10, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0xEA, 0x80, 0xFC, 0xC0, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x31, 0x80, 0x60,
  0x28, 0x09, 0x02, 0x21, 0x07, 0x80, 0x18, 0x1C, 0x1A, 0x19, 0x08, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x3C, 0x42,
  0x81, 0x81, 0x01, 0x01, 0x02, 0x04, 0x04, 0x18, 0x20, 0x40, 0x80, 0xFF,
  0x1E, 0x10, 0x90, 0x40, 0x30, 0x10, 0x08, 0x78, 0x06, 0x00, 0x80, 0x40,
  0x30, 0x14, 0x11, 0xF0, 0x01, 0x00, 0xC0, 0x50, 0x24, 0x11, 0x04, 0x42,
  0x11, 0x04, 0x81, 0x20, 0x4F, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x7F, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xC2, 0x01, 0x01, 0x01, 0x01, 0x81, 0x42, 0x3C,
  0x0C, 0x10, 0x20, 0x40, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0xFF, 0x81, 0x82, 0x82, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x1E, 0x18, 0x64, 0x0A, 0x02, 0x40, 0x88, 0x41,
  0xE0, 0x84, 0xC0, 0xA0, 0x18, 0x06, 0x02, 0x61, 0x87, 0x80, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x02, 0x02, 0x04, 0x08, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0xEA, 0x80, 0x01, 0x02, 0x0C, 0x30, 0x40,
  0x80, 0x40, 0x20, 0x18, 0x06, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x02, 0x0C, 0x10, 0x60, 0x80, 0x3C, 0x42,
  0x81, 0x81, 0x01, 0x02, 0x04, 0x18, 0x10, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x3C, 0x42, 0x81, 0x81, 0x8F, 0x91, 0xA1, 0xA1, 0xA1, 0xA1, 0x91, 0x9F,
  0x80, 0x80, 0x40, 0x3E, 0x08, 0x03, 0x01, 0x40, 0x50, 0x12, 0x08, 0x82,
  0x20, 0x84, 0x41, 0x0F, 0xC4, 0x0A, 0x02, 0x80, 0xA0, 0x10, 0xFC, 0x82,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFE,
  0x3C, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x81,
  0x42, 0x3C, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xA0, 0x50, 0x28, 0x27, 0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x10,
  0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0, 0x60, 0x28, 0x12,
  0x18, 0xF4, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x7E, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0C, 0x14, 0x27, 0x80, 0x81, 0xC0, 0xA0, 0x90, 0x88,
  0x84, 0x82, 0x41, 0xD0, 0x88, 0x42, 0x20, 0x90, 0x48, 0x14, 0x04, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x81, 0x81, 0x83, 0xC3, 0xC5, 0xA5, 0xA9, 0x99, 0x91, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89,
  0x85, 0x85, 0x83, 0x83, 0x81, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0xA0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x09, 0x02, 0x21, 0x07, 0x80, 0xFE,
  0x40, 0xA0, 0x50, 0x28, 0x1C, 0x0A, 0x05, 0xFC, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x28, 0x09, 0x02, 0x21, 0x07, 0x80, 0x80, 0x20, 0x07,
  0x80, 0xFE, 0x40, 0xA0, 0x50, 0x28, 0x1C, 0x0A, 0x05, 0xFC, 0x88, 0x44,
  0x21, 0x10, 0x48, 0x24, 0x08, 0x3E, 0x10, 0x48, 0x0A, 0x00, 0x80, 0x10,
  0x03, 0xC0, 0x0C, 0x00, 0x80, 0x20, 0x06, 0x02, 0x60, 0x87, 0xC0, 0xFF,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x80, 0x60, 0x28, 0x09, 0x02,
  0x41, 0x10, 0x42, 0x10, 0x88, 0x22, 0x04, 0x81, 0x40, 0x50, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x88, 0xA3, 0x29, 0x4A, 0x52, 0x92,
  0x94, 0xA6, 0x29, 0x8A, 0x61, 0x90, 0x20, 0x80, 0x50, 0x24, 0x10, 0x84,
  0x12, 0x05, 0x00, 0xC0, 0x30, 0x14, 0x08, 0x82, 0x11, 0x04, 0x80, 0xA0,
  0x10, 0x80, 0x60, 0x14, 0x09, 0x04, 0x21, 0x08, 0x81, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x3F,
  0xF0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87,
  0xC0, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0xC0, 0x0C, 0x05, 0x01, 0x20, 0x88,
  0x21, 0x10, 0x28, 0x0A, 0x03, 0xFF, 0xC0, 0x89, 0x80, 0x7C, 0x41, 0x00,
  0x80, 0x47, 0xE4, 0x12, 0x09, 0x04, 0x86, 0x3C, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xBC, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xBC,
  0x3C, 0x42, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x42, 0x3C, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x3D, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3,
  0x3D, 0x3C, 0x42, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x41, 0x3E, 0x0F,
  0x88, 0x04, 0x02, 0x01, 0x07, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x83, 0xFC, 0x03, 0x81, 0x0F, 0x88, 0x48, 0x14, 0x0A, 0x08,
  0x84, 0x3C, 0x60, 0x20, 0x0F, 0xE8, 0x0C, 0x06, 0x02, 0xFE, 0x81, 0x02,
  0x04, 0x08, 0x1F, 0x21, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x80,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xFC, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xFC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x83, 0x84, 0x88, 0x90, 0xF0, 0x90, 0x88, 0x84, 0x82, 0x81, 0xF0,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFF, 0xB3, 0xB3, 0x28, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21,
  0x88, 0x62, 0x10, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04,
  0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xBC, 0xC3,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x3D, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x3D, 0x01, 0x01,
  0x01, 0x01, 0xF7, 0x8C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x7F, 0x80, 0x3C, 0xC3, 0x80, 0x80, 0x78, 0x07, 0x01, 0x01, 0x81, 0x7E,
  0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x7C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42,
  0x7C, 0x81, 0x81, 0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x18, 0x10, 0x88,
  0x63, 0x19, 0x46, 0x51, 0x94, 0xA4, 0xAA, 0x29, 0x8A, 0x61, 0x88, 0x40,
  0x81, 0x42, 0x44, 0x28, 0x18, 0x18, 0x24, 0x44, 0x82, 0x81, 0x81, 0x81,
  0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x18, 0x10, 0x10, 0x20, 0x20, 0xE0,
  0xFF, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFF, 0x1F, 0x10,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0xF0, 0x18, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x1F, 0xFF, 0xFF, 0xC0, 0xF8, 0x08, 0x08, 0x08, 0x10,
  0x20, 0x20, 0x10, 0x0F, 0x18, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0xF8, 0x70, 0x52, 0x18, 0x4A, 0x0E,
};

const GFXglyph IBMPlexMono_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 4, 5, 12, 4, -15 },
  { 8, 12, 14, 12, 0, -14 },
  { 29, 10, 18, 12, 1, -16 },
  { 52, 10, 14, 12, 1, -14 },
  { 70, 10, 14, 12, 1, -14 },
  { 88, 1, 5, 12, 6, -15 },
  { 89, 4, 18, 12, 5, -15 },
  { 98, 4, 18, 12, 3, -15 },
  { 107, 10, 10, 12, 1, -11 },
  { 120, 10, 11, 12, 1, -12 },
  { 134, 2, 5, 12, 5, -2 },
  { 136, 6, 1, 12, 3, -7 },
  { 137, 2, 1, 12, 5, -1 },
  { 138, 8, 18, 12, 2, -15 },
  { 156, 10, 14, 12, 1, -14 },
  { 174, 9, 14, 12, 2, -14 },
  { 190, 8, 14, 12, 2, -14 },
  { 204, 9, 14, 12, 1, -14 },
  { 220, 10, 14, 12, 1, -14 },
  { 238, 8, 14, 12, 2, -14 },
  { 252, 8, 14, 12, 2, -14 },
  { 266, 8, 14, 12, 2, -14 },
  { 280, 10, 14, 12, 1, -14 },
  { 298, 8, 14, 12, 2, -14 },
  { 312, 2, 10, 12, 5, -10 },
  { 315, 2, 13, 12, 5, -10 },
  { 319, 8, 11, 12, 2, -12 },
  { 330, 10, 4, 12, 1, -8 },
  { 335, 8, 11, 12, 2, -12 },
  { 346, 8, 14, 12, 2, -14 },
  { 360, 8, 16, 12, 2, -14 },
  { 376, 10, 14, 12, 1, -14 },
  { 394, 8, 14, 12, 2, -14 },
  { 408, 8, 14, 12, 2, -14 },
  { 422, 9, 14, 12, 2, -14 },
  { 438, 8, 14, 12, 2, -14 },
  { 452, 8, 14, 12, 2, -14 },
  { 466, 9, 14, 12, 1, -14 },
  { 482, 8, 14, 12, 2, -14 },
  { 496, 8, 14, 12, 2, -14 },
  { 510, 7, 14, 12, 2, -14 },
  { 523, 9, 14, 12, 2, -14 },
  { 539, 8, 14, 12, 3, -14 },
  { 553, 8, 14, 12, 2, -14 },
  { 567, 8, 14, 12, 2, -14 },
  { 581, 10, 14, 12, 1, -14 },
  { 599, 9, 14, 12, 2, -14 },
  { 615, 10, 17, 12, 1, -14 },
  { 637, 9, 14, 12, 2, -14 },
  { 653, 10, 14, 12, 1, -14 },
  { 671, 10, 14, 12, 1, -14 },
  { 689, 8, 14, 12, 2, -14 },
  { 703, 10, 14, 12, 1, -14 },
  { 721, 10, 14, 12, 1, -14 },
  { 739, 10, 14, 12, 1, -14 },
  { 757, 10, 14, 12, 1, -14 },
  { 775, 10, 14, 12, 1, -14 },
  { 793, 5, 18, 12, 5, -15 },
  { 805, 8, 18, 12, 2, -15 },
  { 823, 5, 18, 12, 2, -15 },
  { 835, 10, 8, 12, 1, -14 },
  { 845, 10, 1, 12, 1, 2 },
  { 847, 3, 3, 12, 4, -15 },
  { 849, 9, 10, 12, 2, -10 },
  { 861, 8, 15, 12, 2, -15 },
  { 876, 8, 10, 12, 2, -10 },
  { 886, 8, 15, 12, 2, -15 },
  { 901, 8, 10, 12, 2, -10 },
  { 911, 9, 15, 12, 2, -15 },
  { 928, 9, 16, 12, 2, -12 },
  { 946, 7, 15, 12, 3, -15 },
  { 960, 9, 14, 12, 2, -14 },
  { 976, 7, 18, 12, 2, -14 },
  { 992, 8, 15, 12, 3, -15 },
  { 1007, 8, 15, 12, 2, -15 },
  { 1022, 10, 10, 12, 1, -10 },
  { 1035, 7, 10, 12, 3, -10 },
  { 1044, 8, 10, 12, 2, -10 },
  { 1054, 8, 14, 12, 2, -10 },
  { 1068, 8, 14, 12, 2, -10 },
  { 1082, 9, 10, 12, 2, -10 },
  { 1094, 8, 10, 12, 2, -10 },
  { 1104, 9, 14, 12, 1, -14 },
  { 1120, 7, 10, 12, 2, -10 },
  { 1129, 8, 10, 12, 2, -10 },
  { 1139, 10, 10, 12, 1, -10 },
  { 1152, 8, 10, 12, 2, -10 },
  { 1162, 8, 14, 12, 2, -10 },
  { 1176, 8, 10, 12, 2, -10 },
  { 1186, 8, 18, 12, 2, -15 },
  { 1204, 1, 18, 12, 6, -15 },
  { 1207, 8, 18, 12, 2, -15 },
  { 1225, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_Thin20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_THIN20PT7B_H_
