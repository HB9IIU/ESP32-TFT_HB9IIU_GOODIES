#ifndef _IBMPLEXMONO_THIN26PT7B_H_
#define _IBMPLEXMONO_THIN26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x80, 0xF0, 0x99, 0x99, 0x99, 0x90, 0x04, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x21, 0x0F, 0x87, 0xC2, 0x10,
  0x08, 0x80, 0x22, 0x00, 0x88, 0x3C, 0x3E, 0x10, 0x80, 0x42, 0x01, 0x10,
  0x04, 0x40, 0x21, 0x00, 0x84, 0x00, 0x04, 0x00, 0x40, 0x04, 0x01, 0xF0,
  0x64, 0xC8, 0x42, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x64, 0x01, 0xE0,
  0x05, 0xC0, 0x42, 0x04, 0x20, 0x41, 0x04, 0x18, 0x41, 0x84, 0x26, 0x44,
  0x1F, 0x80, 0x40, 0x04, 0x00, 0x40, 0x38, 0x05, 0x10, 0x28, 0x21, 0x20,
  0x84, 0x82, 0x22, 0x08, 0x84, 0x44, 0x1F, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x8F, 0x04, 0x42, 0x12, 0x08, 0x88, 0x14, 0x20, 0x50, 0x81, 0x81, 0x0A,
  0x03, 0xC0, 0x0F, 0x00, 0x84, 0x08, 0x10, 0x40, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x39, 0x21, 0x10, 0x89, 0x02, 0x48, 0x0A, 0x40,
  0x22, 0x01, 0x10, 0x0C, 0x61, 0x91, 0xF0, 0x40, 0xFE, 0x04, 0x21, 0x08,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x82, 0x10, 0x41, 0x08, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x44, 0x22, 0x31, 0x10, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x71, 0x1C, 0x77, 0x00, 0x60, 0x05, 0x00, 0x44, 0x04, 0x10,
  0x20, 0x42, 0x02, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x56, 0xA0, 0xFE, 0xF0, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x1F, 0x02,
  0x0C, 0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x41, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x24, 0x04, 0x20, 0xC1,
  0xF0, 0x06, 0x00, 0xE0, 0x12, 0x02, 0x20, 0x42, 0x08, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x07, 0xFF, 0x1F, 0x02, 0x0C, 0x40, 0x48, 0x04, 0x80, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0x1F, 0x04, 0x11, 0x01, 0x40,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x1F, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x02, 0x60, 0x83, 0xE0, 0x00, 0x40, 0x06, 0x00,
  0x50, 0x02, 0x80, 0x24, 0x02, 0x20, 0x11, 0x01, 0x08, 0x10, 0x41, 0x02,
  0x08, 0x10, 0x80, 0x88, 0x04, 0x7F, 0xFC, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x3F, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0xF8, 0x60, 0xC8, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x02,
  0x60, 0xC3, 0xE0, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x02, 0xF8, 0xA0, 0xD8, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A,
  0x01, 0x20, 0xC3, 0xE0, 0xFF, 0xF0, 0x06, 0x01, 0x40, 0x28, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x1F, 0x82, 0x0C, 0x40, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x83, 0x0C, 0xC0, 0x28, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x60, 0x41, 0xF8, 0x1F, 0x04, 0x19, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x64, 0x1C, 0x7C, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x06, 0x03, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x6C, 0x00, 0x00, 0x00, 0x04, 0x94, 0x90, 0x00, 0x20, 0x08, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x10, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x00, 0x1F, 0x18, 0x68,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x08, 0x02, 0x03, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x0F, 0x06, 0x10, 0x81,
  0x20, 0x24, 0x03, 0x07, 0x61, 0x1C, 0x41, 0x88, 0x32, 0x06, 0x40, 0xC8,
  0x19, 0x03, 0x10, 0x62, 0x1C, 0x3D, 0x40, 0x08, 0x00, 0x80, 0x18, 0x00,
  0xFC, 0x02, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x08, 0x3F, 0xC2, 0x02, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x80, 0x0C, 0x00, 0x40, 0xFF, 0x20, 0x68, 0x0A, 0x01,
  0x80, 0x60, 0x28, 0x0A, 0x04, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xBF, 0xC0, 0x0F, 0x86, 0x09, 0x00, 0xA0, 0x18,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x0A, 0x01, 0x30, 0x41, 0xF0, 0xFE, 0x10, 0x32, 0x02, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x00, 0xA0, 0x14, 0x04, 0x81, 0x9F, 0xC0, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0x06, 0x11, 0x01, 0x20, 0x18,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03,
  0x00, 0x50, 0x0A, 0x03, 0x30, 0x63, 0xF4, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0xFC, 0x3F, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x05, 0x02, 0x21, 0x87, 0xC0, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x88,
  0x21, 0x08, 0x22, 0x04, 0x80, 0xA8, 0x14, 0x83, 0x10, 0x41, 0x08, 0x11,
  0x02, 0x20, 0x24, 0x02, 0x80, 0x50, 0x04, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x80, 0x38, 0x07, 0x01, 0xD0, 0x3A,
  0x0B, 0x41, 0x64, 0x4C, 0x89, 0x8A, 0x31, 0x46, 0x10, 0xC2, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x80, 0x60, 0x1C, 0x07, 0x01,
  0xA0, 0x68, 0x19, 0x06, 0x41, 0x88, 0x62, 0x18, 0x46, 0x11, 0x82, 0x60,
  0x98, 0x16, 0x03, 0x80, 0xE0, 0x10, 0x1F, 0x02, 0x0C, 0x40, 0x48, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x24, 0x04, 0x20, 0xC1, 0xF0, 0xFF, 0x10, 0x1A,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xDF, 0xE2, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x02,
  0x0C, 0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x24, 0x04, 0x20, 0xC1,
  0xF0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x3C, 0xFF, 0x10, 0x1A, 0x01, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xDF, 0xE2, 0x10, 0x42, 0x08,
  0x21, 0x02, 0x20, 0x44, 0x04, 0x80, 0x50, 0x0C, 0x1F, 0x86, 0x04, 0x80,
  0x28, 0x00, 0x80, 0x08, 0x00, 0x80, 0x06, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x02, 0x60, 0x41, 0xF8, 0xFF,
  0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x02, 0x41, 0x8F, 0xC0, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x80,
  0x22, 0x01, 0x10, 0x10, 0x80, 0x82, 0x04, 0x10, 0x40, 0x82, 0x02, 0x10,
  0x11, 0x00, 0x88, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x84, 0x28, 0x62,
  0x8A, 0x28, 0xA2, 0x89, 0x29, 0x12, 0x91, 0x29, 0x0A, 0xA0, 0xA6, 0x0A,
  0x60, 0xC4, 0x04, 0x40, 0x0A, 0x00, 0x88, 0x08, 0x20, 0x41, 0x04, 0x04,
  0x40, 0x12, 0x00, 0xA0, 0x02, 0x00, 0x18, 0x01, 0x40, 0x11, 0x00, 0x84,
  0x08, 0x20, 0x80, 0x84, 0x02, 0x40, 0x14, 0x00, 0x40, 0x80, 0x06, 0x00,
  0x24, 0x01, 0x08, 0x04, 0x20, 0x20, 0x41, 0x00, 0x84, 0x02, 0x20, 0x05,
  0x00, 0x14, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0xFC,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x7F, 0x04, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x20,
  0x82, 0x08, 0x40, 0x44, 0x02, 0x80, 0x28, 0x01, 0xFF, 0xF0, 0x84, 0x23,
  0x1F, 0x04, 0x18, 0x80, 0x80, 0x04, 0x00, 0x40, 0x04, 0x3F, 0xC4, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x44, 0x1C, 0x3E, 0x70, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x27, 0xC5, 0x0C, 0xC0, 0x50, 0x0A, 0x01, 0x40,
  0x28, 0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x5C, 0x32, 0x7C, 0x00, 0x1E,
  0x18, 0x64, 0x0A, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x14,
  0x05, 0x82, 0x1F, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x11,
  0xF4, 0x83, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x40, 0x48, 0x31, 0xF4, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x7F, 0xFC, 0x00, 0x80, 0x10, 0x01, 0x00, 0x90, 0x21, 0xF8, 0x07, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0xE0, 0x00, 0x70, 0x08, 0x0F, 0x83, 0x0C, 0x20, 0x44, 0x04,
  0x40, 0x44, 0x04, 0x20, 0x41, 0x08, 0x1F, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x3F, 0xE4, 0x01, 0x80, 0x18, 0x01, 0x40, 0x23, 0xFC, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x09, 0xE2, 0x86, 0xC0, 0xA0, 0x28, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x09, 0xFE, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x34, 0x08, 0x82, 0x10, 0x82, 0x20, 0x58, 0x0C, 0x81,
  0x08, 0x20, 0x84, 0x08, 0x81, 0x10, 0x12, 0x01, 0x80, 0xFC, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80,
  0xB9, 0xEC, 0x62, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41,
  0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x10, 0x9E, 0x28, 0x6C, 0x0A,
  0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x05, 0x01, 0x10, 0x61, 0xF0, 0x9F, 0x14, 0x33, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x0C, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x70, 0xC9,
  0xF1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x48, 0x34, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x04, 0x83, 0x1F,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xF9, 0xF0, 0xA0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0xFF, 0xE0, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x04, 0x00, 0x60, 0x03,
  0xF0, 0x01, 0x00, 0x20, 0x06, 0x00, 0xB0, 0x31, 0xF8, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x3F, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x68, 0x33, 0xE8, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22,
  0x08, 0x41, 0x08, 0x20, 0x88, 0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0x40,
  0x82, 0x06, 0x0C, 0x28, 0x50, 0xA1, 0x42, 0x85, 0x09, 0x22, 0x24, 0x89,
  0x12, 0x24, 0x48, 0x51, 0x41, 0x43, 0x05, 0x0C, 0x18, 0x30, 0x20, 0x80,
  0x28, 0x08, 0x82, 0x08, 0x80, 0x90, 0x14, 0x01, 0x00, 0x50, 0x11, 0x02,
  0x10, 0x82, 0x20, 0x28, 0x02, 0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x04,
  0x41, 0x04, 0x20, 0x88, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x1E, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0x0F,
  0xC4, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x43, 0xE0, 0x0C, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x80, 0x1F, 0x0C,
  0x04, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x43, 0xF0, 0x70, 0x1C, 0x81, 0x84, 0x18, 0x22, 0x81, 0xC0,
};

const GFXglyph IBMPlexMono_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 18, 16, 7, -18 },
  { 6, 4, 7, 16, 6, -19 },
  { 10, 14, 18, 16, 1, -18 },
  { 42, 12, 24, 16, 2, -21 },
  { 78, 14, 18, 16, 1, -18 },
  { 110, 13, 18, 16, 1, -18 },
  { 140, 1, 7, 16, 7, -19 },
  { 141, 6, 24, 16, 6, -20 },
  { 159, 5, 24, 16, 4, -20 },
  { 174, 13, 13, 16, 1, -14 },
  { 196, 12, 13, 16, 2, -14 },
  { 216, 2, 6, 16, 6, -2 },
  { 218, 7, 1, 16, 4, -8 },
  { 219, 2, 2, 16, 7, -2 },
  { 220, 10, 24, 16, 3, -20 },
  { 250, 12, 18, 16, 2, -18 },
  { 277, 12, 18, 16, 2, -18 },
  { 304, 12, 18, 16, 2, -18 },
  { 331, 11, 18, 16, 2, -18 },
  { 356, 13, 18, 16, 1, -18 },
  { 386, 11, 18, 16, 2, -18 },
  { 411, 11, 18, 16, 2, -18 },
  { 436, 11, 18, 16, 2, -18 },
  { 461, 12, 18, 16, 2, -18 },
  { 488, 11, 18, 16, 2, -18 },
  { 513, 2, 14, 16, 7, -14 },
  { 517, 3, 18, 16, 6, -14 },
  { 524, 11, 14, 16, 2, -15 },
  { 544, 12, 6, 16, 2, -11 },
  { 553, 11, 14, 16, 2, -15 },
  { 573, 10, 18, 16, 3, -18 },
  { 596, 11, 21, 16, 2, -18 },
  { 625, 13, 18, 16, 1, -18 },
  { 655, 10, 18, 16, 3, -18 },
  { 678, 11, 18, 16, 2, -18 },
  { 703, 11, 18, 16, 3, -18 },
  { 728, 10, 18, 16, 3, -18 },
  { 751, 10, 18, 16, 3, -18 },
  { 774, 11, 18, 16, 2, -18 },
  { 799, 10, 18, 16, 3, -18 },
  { 822, 11, 18, 16, 2, -18 },
  { 847, 10, 18, 16, 2, -18 },
  { 870, 11, 18, 16, 3, -18 },
  { 895, 10, 18, 16, 4, -18 },
  { 918, 11, 18, 16, 2, -18 },
  { 943, 10, 18, 16, 3, -18 },
  { 966, 12, 18, 16, 2, -18 },
  { 993, 11, 18, 16, 3, -18 },
  { 1018, 12, 22, 16, 2, -18 },
  { 1051, 11, 18, 16, 3, -18 },
  { 1076, 12, 18, 16, 2, -18 },
  { 1103, 14, 18, 16, 1, -18 },
  { 1135, 10, 18, 16, 3, -18 },
  { 1158, 13, 18, 16, 1, -18 },
  { 1188, 12, 18, 16, 2, -18 },
  { 1215, 13, 18, 16, 1, -18 },
  { 1245, 14, 18, 16, 1, -18 },
  { 1277, 13, 18, 16, 1, -18 },
  { 1307, 6, 24, 16, 7, -20 },
  { 1325, 10, 24, 16, 3, -20 },
  { 1355, 6, 24, 16, 3, -20 },
  { 1373, 12, 10, 16, 2, -18 },
  { 1388, 12, 1, 16, 2, 3 },
  { 1390, 4, 4, 16, 5, -19 },
  { 1392, 12, 13, 16, 2, -13 },
  { 1412, 11, 19, 16, 3, -19 },
  { 1439, 10, 13, 16, 3, -13 },
  { 1456, 10, 19, 16, 2, -19 },
  { 1480, 11, 13, 16, 2, -13 },
  { 1498, 12, 19, 16, 2, -19 },
  { 1527, 12, 20, 16, 2, -15 },
  { 1557, 10, 19, 16, 3, -19 },
  { 1581, 11, 19, 16, 3, -19 },
  { 1608, 10, 24, 16, 2, -19 },
  { 1638, 11, 19, 16, 4, -19 },
  { 1665, 11, 19, 16, 2, -19 },
  { 1692, 12, 13, 16, 2, -13 },
  { 1712, 10, 13, 16, 3, -13 },
  { 1729, 11, 13, 16, 2, -13 },
  { 1747, 11, 18, 16, 3, -13 },
  { 1772, 10, 18, 16, 2, -13 },
  { 1795, 12, 13, 16, 2, -13 },
  { 1815, 11, 13, 16, 2, -13 },
  { 1833, 13, 18, 16, 1, -18 },
  { 1863, 9, 13, 16, 3, -13 },
  { 1878, 11, 13, 16, 2, -13 },
  { 1896, 14, 13, 16, 1, -13 },
  { 1919, 11, 13, 16, 2, -13 },
  { 1937, 11, 18, 16, 2, -13 },
  { 1962, 10, 13, 16, 3, -13 },
  { 1979, 10, 24, 16, 3, -20 },
  { 2009, 1, 24, 16, 7, -20 },
  { 2012, 10, 24, 16, 3, -20 },
  { 2042, 12, 5, 16, 2, -10 },
};

const GFXfont IBMPlexMono_Thin26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_THIN26PT7B_H_
