#ifndef _IBMPLEXMONO_THIN28PT7B_H_
#define _IBMPLEXMONO_THIN28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x54, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x1F, 0x0F,
  0x82, 0x10, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x1F,
  0x0F, 0x84, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0x02, 0x26, 0x21, 0x0A, 0x08,
  0x50, 0x40, 0x82, 0x04, 0x10, 0x10, 0x80, 0x44, 0x01, 0xF0, 0x01, 0x70,
  0x08, 0x40, 0x42, 0x02, 0x08, 0x10, 0x40, 0x83, 0x04, 0x14, 0x21, 0x19,
  0x10, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x3C, 0x02, 0x84, 0x0A,
  0x08, 0x14, 0x08, 0x48, 0x11, 0x10, 0x22, 0x20, 0x88, 0x21, 0x10, 0x3C,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x88, 0x42, 0x20, 0x44, 0x40,
  0x90, 0x81, 0x41, 0x02, 0x82, 0x06, 0x02, 0x14, 0x03, 0xC0, 0x0F, 0x00,
  0x43, 0x02, 0x04, 0x08, 0x08, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x70, 0x72, 0x41, 0x10, 0x84, 0x81, 0x12, 0x02, 0x48, 0x06,
  0x20, 0x08, 0x80, 0x21, 0x01, 0x46, 0x08, 0x87, 0xC1, 0xFE, 0x0C, 0x41,
  0x08, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x10, 0x40, 0x81, 0x04, 0x0C, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x10, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0x04, 0x13, 0x97,
  0x81, 0xE0, 0x02, 0x80, 0x12, 0x00, 0x84, 0x02, 0x08, 0x10, 0x10, 0x80,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x25, 0x25, 0x20, 0xFE, 0xF0, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x00, 0x0F, 0x81, 0x82, 0x08, 0x08, 0x80,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x10, 0x60, 0x83,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x40, 0x11, 0x01, 0x0C,
  0x10, 0x1F, 0x00, 0x02, 0x00, 0x30, 0x02, 0x80, 0x24, 0x06, 0x20, 0x61,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFF, 0xF0,
  0x0F, 0x81, 0x82, 0x10, 0x08, 0x80, 0x48, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x0F, 0x83, 0x0C,
  0x40, 0x28, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xC1, 0xF0,
  0x00, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x28, 0x02,
  0x60, 0xC1, 0xF8, 0x00, 0x20, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20,
  0x08, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x40, 0x82, 0x02, 0x08, 0x08,
  0x40, 0x22, 0x00, 0x8F, 0xFF, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x3F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x4F, 0x87, 0x06, 0x40, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x14, 0x02, 0x30, 0x40, 0xF8, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x4F, 0x8B, 0x06, 0x40,
  0x2C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x30,
  0x60, 0xF8, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x0F, 0x81, 0x83, 0x10,
  0x04, 0x80, 0x28, 0x01, 0x40, 0x09, 0x00, 0x48, 0x04, 0x30, 0x60, 0x7C,
  0x0C, 0x38, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x12,
  0x00, 0x8C, 0x18, 0x3F, 0x00, 0x1F, 0x0C, 0x1A, 0x01, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0D, 0x83, 0x8F, 0x90, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x4A, 0x4A, 0x40, 0x00, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x3C, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x1F, 0x04, 0x11,
  0x01, 0x40, 0x28, 0x03, 0x00, 0x61, 0xEC, 0x43, 0x90, 0x32, 0x06, 0x40,
  0xC8, 0x19, 0x03, 0x20, 0x64, 0x0C, 0x43, 0x87, 0xB0, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x07, 0xF0, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20,
  0x04, 0x80, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x20, 0x20, 0x81, 0x02,
  0x04, 0x04, 0x10, 0x10, 0x7F, 0xC2, 0x00, 0x88, 0x02, 0x40, 0x09, 0x00,
  0x14, 0x00, 0x60, 0x01, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x28, 0x03, 0x00,
  0x60, 0x14, 0x02, 0x80, 0x9F, 0xF2, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x7F, 0xC0, 0x0F, 0x80, 0x83, 0x08,
  0x04, 0x80, 0x24, 0x01, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x02, 0x40, 0x19,
  0x00, 0x84, 0x18, 0x1F, 0x00, 0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x8F, 0xF0, 0xFF,
  0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F,
  0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x81, 0x04,
  0x20, 0x24, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x12, 0x03,
  0x10, 0x70, 0xF9, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0xFF, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0x7F,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x24, 0x18, 0xF8,
  0x80, 0x18, 0x02, 0x80, 0x48, 0x08, 0x81, 0x08, 0x20, 0x82, 0x08, 0x40,
  0x88, 0x09, 0x40, 0xA4, 0x0C, 0x20, 0x82, 0x08, 0x10, 0x80, 0x88, 0x08,
  0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xC0, 0x1C,
  0x01, 0xC0, 0x3A, 0x03, 0xA0, 0x59, 0x05, 0x90, 0x98, 0x89, 0x89, 0x18,
  0x51, 0x86, 0x18, 0x21, 0x82, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1A, 0x03, 0x40,
  0x64, 0x0C, 0x81, 0x88, 0x31, 0x06, 0x10, 0xC3, 0x18, 0x23, 0x02, 0x60,
  0x4C, 0x05, 0x80, 0xB0, 0x0E, 0x01, 0xC0, 0x10, 0x0F, 0x81, 0x82, 0x08,
  0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x40, 0x11,
  0x01, 0x0C, 0x10, 0x1F, 0x00, 0xFF, 0x88, 0x06, 0x80, 0x28, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x06, 0xFF, 0x88, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x81, 0x82, 0x08, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50,
  0x02, 0x40, 0x11, 0x01, 0x0C, 0x10, 0x1F, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x7C, 0xFF, 0x88, 0x06, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x06, 0xFF, 0x88, 0x40, 0x82, 0x08, 0x20, 0x81,
  0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x28, 0x03, 0x1F, 0x81, 0x03, 0x10,
  0x05, 0x00, 0x28, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x12,
  0x00, 0x88, 0x08, 0x3F, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x09, 0x83, 0x1F, 0x80, 0x80,
  0x0C, 0x00, 0x60, 0x05, 0x00, 0x24, 0x01, 0x20, 0x09, 0x00, 0x84, 0x04,
  0x20, 0x21, 0x02, 0x04, 0x10, 0x20, 0x81, 0x08, 0x04, 0x40, 0x22, 0x01,
  0x20, 0x09, 0x00, 0x28, 0x01, 0x80, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x08, 0x30, 0xC2, 0x85, 0x14, 0x28,
  0xA2, 0x45, 0x12, 0x28, 0x89, 0x28, 0x49, 0x42, 0x4A, 0x0A, 0x50, 0x53,
  0x02, 0x98, 0x18, 0xC0, 0x40, 0x40, 0x05, 0x00, 0x22, 0x00, 0x84, 0x04,
  0x10, 0x20, 0x20, 0x80, 0x44, 0x01, 0x20, 0x02, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xA0, 0x04, 0x40, 0x21, 0x00, 0x82, 0x04, 0x04, 0x20, 0x10, 0x80,
  0x24, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x09, 0x00, 0x21, 0x00, 0x42,
  0x01, 0x02, 0x02, 0x02, 0x08, 0x04, 0x20, 0x04, 0x40, 0x09, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xFE, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x02, 0x00, 0x28,
  0x02, 0x40, 0x11, 0x01, 0x08, 0x10, 0x20, 0x80, 0x88, 0x04, 0x40, 0x14,
  0x00, 0xA0, 0x06, 0xFF, 0xF8, 0x91, 0x22, 0x1F, 0x03, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0xFF, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20,
  0x11, 0x00, 0x84, 0x0C, 0x1F, 0x1C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x09, 0xF0, 0xA0, 0xCC, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0xC0, 0x2A, 0x0C,
  0x9F, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0xF9, 0x30, 0xE8, 0x05,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x00,
  0x98, 0x31, 0xFA, 0x1F, 0x0C, 0x12, 0x01, 0x40, 0x18, 0x03, 0x00, 0x7F,
  0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x16, 0x04, 0x3F, 0x00, 0x03,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x07, 0xFF, 0x00, 0x00, 0x78,
  0x04, 0x07, 0xE0, 0x41, 0x84, 0x04, 0x20, 0x22, 0x01, 0x10, 0x08, 0x40,
  0x42, 0x02, 0x08, 0x20, 0x7E, 0x04, 0x00, 0x40, 0x01, 0x00, 0x07, 0xFC,
  0xC0, 0x34, 0x00, 0xA0, 0x05, 0x00, 0x2C, 0x02, 0x1F, 0xE0, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0xF8, 0xC1, 0x20, 0x28, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x02, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x7F, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x06, 0x80, 0x88, 0x10, 0x82, 0x08, 0x40, 0x98, 0x0A,
  0x80, 0xC4, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0x48, 0x04, 0x80, 0x30,
  0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x0F, 0xFE, 0xB8, 0xF6, 0x28, 0xA1, 0x83, 0x04, 0x18,
  0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x20, 0xC1, 0x04, 0xBE, 0x30, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x1F, 0x0C,
  0x12, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x26, 0x0C, 0x3E, 0x00, 0x9F, 0x0A, 0x0C, 0xC0, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x2C, 0x02,
  0xA0, 0xC9, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x1F, 0x26, 0x1D, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x05, 0x00, 0xA0, 0x13, 0x06, 0x3F, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0xFC, 0xFC, 0x14, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x03, 0xFF, 0xC0, 0x3F, 0x08, 0x1A, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x0F, 0x80, 0x0E, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x16, 0x04, 0x3F,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F,
  0xFF, 0xC1, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0xFF,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x05, 0x03, 0x60, 0xC7, 0xD0, 0x80, 0x30, 0x06, 0x01, 0x20, 0x24,
  0x08, 0x81, 0x08, 0x21, 0x08, 0x11, 0x02, 0x20, 0x48, 0x05, 0x00, 0xC0,
  0x08, 0x00, 0x81, 0x03, 0x06, 0x0A, 0x0A, 0x14, 0x14, 0x24, 0x48, 0x48,
  0x90, 0x91, 0x12, 0x22, 0x24, 0x48, 0x48, 0x50, 0x50, 0xA0, 0xA1, 0x81,
  0x43, 0x03, 0x02, 0x02, 0x00, 0x40, 0x14, 0x02, 0x20, 0x41, 0x08, 0x08,
  0x80, 0x50, 0x02, 0x00, 0x60, 0x09, 0x00, 0x88, 0x10, 0x42, 0x04, 0x40,
  0x2C, 0x01, 0x80, 0x14, 0x01, 0x40, 0x24, 0x02, 0x20, 0x22, 0x04, 0x10,
  0x41, 0x08, 0x10, 0x80, 0x88, 0x09, 0x00, 0x50, 0x06, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x07, 0x00, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x08, 0x01, 0xFF, 0xC0, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x03, 0x0F, 0x80, 0x1C, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x5E, 0x1C, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0xFC, 0x00, 0x38, 0x0A, 0x20, 0x60, 0x83, 0x02,
  0x28, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 2, 20, 17, 7, -20 },
  { 6, 5, 7, 17, 6, -21 },
  { 11, 15, 20, 17, 1, -20 },
  { 49, 13, 26, 17, 2, -23 },
  { 92, 15, 20, 17, 1, -20 },
  { 130, 14, 20, 17, 1, -20 },
  { 165, 1, 7, 17, 8, -21 },
  { 166, 6, 25, 17, 7, -21 },
  { 185, 6, 25, 17, 4, -21 },
  { 204, 14, 14, 17, 1, -15 },
  { 229, 13, 15, 17, 2, -16 },
  { 254, 3, 7, 17, 6, -2 },
  { 257, 7, 1, 17, 5, -9 },
  { 258, 2, 2, 17, 7, -2 },
  { 259, 11, 25, 17, 3, -21 },
  { 294, 13, 20, 17, 2, -20 },
  { 327, 13, 20, 17, 2, -20 },
  { 360, 13, 20, 17, 2, -20 },
  { 393, 12, 20, 17, 2, -20 },
  { 423, 14, 20, 17, 1, -20 },
  { 458, 12, 20, 17, 2, -20 },
  { 488, 12, 20, 17, 2, -20 },
  { 518, 12, 20, 17, 2, -20 },
  { 548, 13, 20, 17, 2, -20 },
  { 581, 11, 20, 17, 3, -20 },
  { 609, 2, 15, 17, 7, -15 },
  { 613, 3, 20, 17, 6, -15 },
  { 621, 12, 15, 17, 2, -16 },
  { 644, 13, 6, 17, 2, -12 },
  { 654, 12, 15, 17, 2, -16 },
  { 677, 11, 20, 17, 3, -20 },
  { 705, 11, 23, 17, 3, -20 },
  { 737, 14, 20, 17, 1, -20 },
  { 772, 11, 20, 17, 3, -20 },
  { 800, 13, 20, 17, 2, -20 },
  { 833, 12, 20, 17, 3, -20 },
  { 863, 11, 20, 17, 3, -20 },
  { 891, 12, 20, 17, 3, -20 },
  { 921, 12, 20, 17, 2, -20 },
  { 951, 11, 20, 17, 3, -20 },
  { 979, 11, 20, 17, 3, -20 },
  { 1007, 10, 20, 17, 3, -20 },
  { 1032, 12, 20, 17, 3, -20 },
  { 1062, 11, 20, 17, 4, -20 },
  { 1090, 12, 20, 17, 2, -20 },
  { 1120, 11, 20, 17, 3, -20 },
  { 1148, 13, 20, 17, 2, -20 },
  { 1181, 12, 20, 17, 3, -20 },
  { 1211, 13, 24, 17, 2, -20 },
  { 1250, 12, 20, 17, 3, -20 },
  { 1280, 13, 20, 17, 2, -20 },
  { 1313, 15, 20, 17, 1, -20 },
  { 1351, 11, 20, 17, 3, -20 },
  { 1379, 13, 20, 17, 2, -20 },
  { 1412, 13, 20, 17, 2, -20 },
  { 1445, 14, 20, 17, 1, -20 },
  { 1480, 15, 20, 17, 1, -20 },
  { 1518, 14, 20, 17, 1, -20 },
  { 1553, 7, 25, 17, 7, -21 },
  { 1575, 11, 25, 17, 3, -21 },
  { 1610, 6, 25, 17, 3, -21 },
  { 1629, 13, 11, 17, 2, -20 },
  { 1647, 13, 1, 17, 2, 3 },
  { 1649, 3, 5, 17, 6, -22 },
  { 1651, 13, 14, 17, 2, -14 },
  { 1674, 12, 21, 17, 3, -21 },
  { 1706, 11, 14, 17, 3, -14 },
  { 1726, 11, 21, 17, 2, -21 },
  { 1755, 11, 14, 17, 3, -14 },
  { 1775, 13, 21, 17, 2, -21 },
  { 1810, 13, 22, 17, 3, -16 },
  { 1846, 10, 21, 17, 4, -21 },
  { 1873, 12, 21, 17, 3, -21 },
  { 1905, 9, 27, 17, 3, -21 },
  { 1936, 12, 21, 17, 4, -21 },
  { 1968, 11, 21, 17, 3, -21 },
  { 1997, 13, 14, 17, 2, -14 },
  { 2020, 10, 14, 17, 4, -14 },
  { 2038, 11, 14, 17, 3, -14 },
  { 2058, 12, 20, 17, 3, -14 },
  { 2088, 11, 20, 17, 2, -14 },
  { 2116, 14, 14, 17, 2, -14 },
  { 2141, 11, 14, 17, 3, -14 },
  { 2161, 14, 20, 17, 1, -20 },
  { 2196, 10, 14, 17, 3, -14 },
  { 2214, 11, 14, 17, 3, -14 },
  { 2234, 15, 14, 17, 1, -14 },
  { 2261, 12, 14, 17, 2, -14 },
  { 2282, 12, 20, 17, 2, -14 },
  { 2312, 11, 14, 17, 3, -14 },
  { 2332, 11, 25, 17, 3, -21 },
  { 2367, 1, 25, 17, 8, -21 },
  { 2371, 11, 25, 17, 3, -21 },
  { 2406, 13, 5, 17, 2, -11 },
};

const GFXfont IBMPlexMono_Thin28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_THIN28PT7B_H_
