#ifndef _IBMPLEXMONO_THIN35PT7B_H_
#define _IBMPLEXMONO_THIN35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00, 0x3F, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x88, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x7E,
  0x07, 0xE0, 0x41, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x01, 0x04, 0x07, 0xE0, 0x7E, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10,
  0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x07, 0xF0, 0x18,
  0x8C, 0x20, 0x82, 0x40, 0x81, 0x40, 0x80, 0x40, 0x80, 0x40, 0x80, 0x40,
  0x80, 0x40, 0x80, 0x20, 0x80, 0x18, 0x80, 0x07, 0xE0, 0x00, 0xBC, 0x00,
  0x86, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x80,
  0x81, 0x40, 0x81, 0x20, 0x82, 0x18, 0x8C, 0x07, 0xF0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x1E, 0x00, 0x2C, 0x30, 0x09, 0x02, 0x01,
  0x40, 0x20, 0x48, 0x04, 0x11, 0x00, 0x82, 0x20, 0x10, 0x84, 0x02, 0x10,
  0x40, 0x84, 0x0C, 0x31, 0x00, 0x78, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x1E, 0x01, 0x0C, 0x30, 0x21, 0x02, 0x08, 0x40, 0x21, 0x08, 0x04,
  0x41, 0x00, 0x90, 0x20, 0x12, 0x04, 0x02, 0x80, 0x40, 0x90, 0x0C, 0x34,
  0x00, 0x78, 0x03, 0xE0, 0x03, 0x04, 0x00, 0x80, 0x80, 0x40, 0x10, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x38, 0x0F, 0x11, 0x02, 0x08, 0x20, 0x84, 0x04, 0x21,
  0x00, 0x88, 0x80, 0x32, 0x20, 0x06, 0x88, 0x00, 0xC2, 0x00, 0x10, 0x40,
  0x0A, 0x08, 0x02, 0x43, 0x03, 0x08, 0x3F, 0x01, 0xFF, 0x80, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x02, 0x02, 0x02, 0xE1, 0x0E, 0x0E, 0xB8, 0x00, 0xE0, 0x00,
  0x50, 0x00, 0x44, 0x00, 0x22, 0x00, 0x20, 0x80, 0x20, 0x20, 0x20, 0x08,
  0x30, 0x06, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x25, 0xA4, 0xA4, 0x80, 0xFF, 0x80, 0xFC, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x04, 0x00, 0x42,
  0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x50, 0x10, 0x18, 0x08, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x20,
  0x80, 0x20, 0x30, 0x60, 0x0F, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x18, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x0F, 0xC0, 0x20, 0x60, 0x80, 0x22,
  0x00, 0x48, 0x00, 0x50, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0x07, 0xE0, 0x30, 0x30, 0x80, 0x31, 0x00, 0x24, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x3F, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x64, 0x00, 0x86, 0x06, 0x03, 0xF0,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04,
  0x40, 0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x02, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x00, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0x08,
  0x7F, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x3F, 0xFC, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x9F, 0xC1, 0x40, 0xC3,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x28, 0x00, 0x48, 0x01, 0x0C, 0x0C, 0x07, 0xE0,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x8F, 0xC1, 0x60, 0xC5, 0x00, 0x4C, 0x00,
  0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x24, 0x00, 0x44, 0x01, 0x06, 0x0C, 0x07, 0xE0, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x01, 0x20, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x60, 0x31, 0x80, 0x32,
  0x00, 0x28, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x40, 0x04, 0xC0,
  0x18, 0x40, 0x40, 0x7F, 0x03, 0x83, 0x88, 0x00, 0xA0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0x8C,
  0x06, 0x07, 0xF0, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x22, 0x00, 0x28, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x19,
  0x00, 0x51, 0x81, 0x21, 0xFC, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x77, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x26, 0x44, 0x48, 0x88, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0xC1,
  0x81, 0x10, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x78, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0xC0, 0x60, 0xC3, 0x00, 0x88, 0x02, 0x40, 0x05, 0x00, 0x14,
  0x00, 0x60, 0x7D, 0x83, 0x0E, 0x08, 0x38, 0x40, 0x61, 0x01, 0x84, 0x06,
  0x10, 0x18, 0x40, 0x61, 0x01, 0x84, 0x06, 0x10, 0x18, 0x40, 0x60, 0x83,
  0x81, 0xF5, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0xFE, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x22,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x20, 0x04, 0x10, 0x04, 0x08, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x20, 0x40, 0x10, 0x3F, 0xF8,
  0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x24, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xE1, 0x00, 0x22, 0x00, 0x24, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12,
  0x00, 0x47, 0xFF, 0x08, 0x01, 0x90, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x06,
  0x7F, 0xF8, 0x07, 0xE0, 0x30, 0x30, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x12, 0x00, 0x46, 0x00, 0x86, 0x06, 0x03, 0xF0, 0xFF,
  0x82, 0x01, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A,
  0x00, 0x48, 0x06, 0x3F, 0xE0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFE, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x22, 0x00,
  0x24, 0x00, 0x50, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1F, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x64, 0x01, 0x46, 0x04,
  0x83, 0xF1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF,
  0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x3F, 0xF8, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x14, 0x00, 0xA0, 0x08, 0xC1, 0x81, 0xF8, 0x80,
  0x03, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x88, 0x02, 0x10, 0x08, 0x20, 0x20,
  0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x10, 0x04, 0xD0, 0x09, 0x20, 0x14,
  0x20, 0x30, 0x20, 0x40, 0x40, 0x80, 0x41, 0x00, 0x42, 0x00, 0x84, 0x00,
  0x88, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0x1D, 0x00, 0x5A, 0x00, 0xB2, 0x02, 0x64, 0x04,
  0xC4, 0x11, 0x88, 0x23, 0x10, 0x86, 0x11, 0x0C, 0x24, 0x18, 0x28, 0x30,
  0x50, 0x60, 0x40, 0xC0, 0x81, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x80, 0x0D, 0x00, 0x19, 0x00, 0x32, 0x00, 0x62, 0x00, 0xC2, 0x01, 0x84,
  0x03, 0x04, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x10, 0x60, 0x20,
  0xC0, 0x21, 0x80, 0x43, 0x00, 0x46, 0x00, 0x8C, 0x00, 0x98, 0x01, 0x30,
  0x01, 0x60, 0x03, 0xC0, 0x03, 0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x04,
  0x00, 0x42, 0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42,
  0x00, 0x20, 0x80, 0x20, 0x30, 0x60, 0x0F, 0xC0, 0xFF, 0xE2, 0x00, 0x68,
  0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xA0, 0x06, 0xFF, 0xE2, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x04, 0x00, 0x42, 0x00,
  0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02,
  0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x20, 0x80,
  0x20, 0x30, 0x60, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0F, 0xE0, 0xFF, 0xE2, 0x00, 0x68, 0x00, 0xA0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0,
  0x06, 0xFF, 0xE2, 0x08, 0x08, 0x10, 0x20, 0x20, 0x80, 0x82, 0x01, 0x08,
  0x02, 0x20, 0x08, 0x80, 0x12, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x07, 0xF0,
  0x18, 0x0C, 0x20, 0x02, 0x40, 0x01, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x20, 0x02, 0x18, 0x0C, 0x07, 0xF0, 0xFF, 0xFF,
  0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x44, 0x01,
  0x0C, 0x06, 0x07, 0xF0, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x10, 0x04, 0x08,
  0x02, 0x04, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x10, 0x40,
  0x08, 0x20, 0x04, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x04, 0x81, 0x02,
  0x41, 0x81, 0x20, 0xA0, 0x90, 0x50, 0x48, 0x48, 0x24, 0x22, 0x12, 0x11,
  0x09, 0x08, 0x84, 0x88, 0x24, 0x44, 0x12, 0x12, 0x09, 0x0A, 0x04, 0x85,
  0x01, 0x42, 0x80, 0xA1, 0x80, 0x50, 0xC0, 0x18, 0x60, 0x0C, 0x80, 0x00,
  0xA0, 0x00, 0x88, 0x00, 0x84, 0x00, 0x41, 0x00, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x08, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x50, 0x00, 0x10, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x08, 0x80, 0x08, 0x20, 0x04, 0x10, 0x04, 0x04,
  0x04, 0x01, 0x02, 0x00, 0x82, 0x00, 0x22, 0x00, 0x09, 0x00, 0x05, 0x00,
  0x01, 0x80, 0x00, 0x28, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x41, 0x00,
  0x10, 0x20, 0x04, 0x02, 0x00, 0x80, 0x20, 0x20, 0x04, 0x08, 0x00, 0x41,
  0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0xFF, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0xFF, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x90, 0x00,
  0x44, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x20, 0x20, 0x10, 0x10, 0x04,
  0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x28, 0x00, 0x18, 0xFF, 0xFF, 0x80,
  0x82, 0x10, 0x41, 0x04, 0x1F, 0x80, 0x20, 0x60, 0x40, 0x10, 0x80, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x1F, 0xF8, 0x60, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x28,
  0x60, 0x48, 0x1F, 0x0F, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x8F, 0xC2, 0x40, 0x8E, 0x01, 0x30,
  0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xB0, 0x04, 0xB0, 0x22,
  0x3F, 0x00, 0x0F, 0xC0, 0x40, 0x82, 0x01, 0x10, 0x02, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x24, 0x00, 0xC8, 0x04, 0x10, 0x20, 0x3F, 0x00, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x0F, 0xC4, 0xC0, 0x96, 0x01, 0x50, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x14, 0x00, 0xD8, 0x05, 0x30, 0x24, 0x3F, 0x10, 0x07, 0xC0, 0x30, 0x60,
  0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x01,
  0x90, 0x02, 0x18, 0x18, 0x0F, 0xC0, 0x01, 0xFF, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0x00, 0x10, 0x07, 0xD0, 0x18, 0x30, 0x30, 0x08, 0x20, 0x08, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x08, 0x30,
  0x0F, 0xC0, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x1F, 0xFC,
  0x30, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02,
  0x20, 0x0C, 0x0F, 0xF0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x8F, 0xC4, 0x83, 0x38, 0x05, 0x80, 0x28,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x7F, 0xF0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0D, 0x00,
  0x22, 0x00, 0x84, 0x02, 0x08, 0x18, 0x10, 0x40, 0x21, 0x00, 0x46, 0x00,
  0x92, 0x01, 0x42, 0x03, 0x04, 0x04, 0x04, 0x08, 0x04, 0x10, 0x04, 0x20,
  0x04, 0x40, 0x04, 0x80, 0x09, 0x00, 0x0C, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0xBC, 0x3D, 0x84, 0x8E,
  0x0A, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81,
  0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0x81, 0x81, 0x03, 0x02, 0x04, 0x8F, 0xC4, 0x83, 0x38, 0x05, 0x80,
  0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x07, 0xC0, 0x30, 0x60, 0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x10, 0x04, 0x18, 0x30, 0x0F, 0x80, 0x8F, 0xC2,
  0x40, 0x8E, 0x01, 0x30, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0xB0, 0x04, 0xB0, 0x22, 0x3F, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0xC4, 0xC0, 0x96, 0x01, 0x50,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0xD8, 0x05, 0x30, 0x24,
  0x3F, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0xFE, 0x3F, 0x02, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0xFF, 0xFE, 0x0F, 0xE0, 0x60, 0x30, 0x80, 0x12, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xA0, 0x02, 0x38, 0x08, 0x0F, 0xC0,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x03, 0xFF, 0xFE, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x68, 0x05, 0x30, 0x68, 0xFC, 0x40, 0x80, 0x02, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x20, 0x01, 0x40, 0x02, 0x80, 0x02, 0x00, 0x80, 0x40, 0x30, 0x18, 0x09,
  0x02, 0x81, 0x20, 0x50, 0x24, 0x12, 0x04, 0x82, 0x20, 0x90, 0x44, 0x22,
  0x08, 0x84, 0x22, 0x10, 0x84, 0x41, 0x10, 0x88, 0x22, 0x11, 0x04, 0x42,
  0x40, 0x90, 0x28, 0x0A, 0x05, 0x01, 0x40, 0xA0, 0x28, 0x18, 0x05, 0x01,
  0x00, 0x40, 0xC0, 0x06, 0x80, 0x08, 0x80, 0x20, 0x80, 0x80, 0x82, 0x01,
  0x04, 0x01, 0x10, 0x01, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x22,
  0x00, 0x82, 0x02, 0x04, 0x04, 0x04, 0x10, 0x04, 0x40, 0x05, 0x00, 0x04,
  0x80, 0x03, 0x00, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x44,
  0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x0C, 0x1F, 0x80, 0x07, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x18, 0x00, 0x3F, 0x07, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x1F, 0xE0, 0x1C, 0x00, 0x91, 0x80, 0x50, 0x60, 0x50,
  0x18, 0x28, 0x06, 0x24, 0x00, 0xE0,
};

const GFXglyph IBMPlexMono_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 3, 24, 21, 9, -24 },
  { 10, 5, 9, 21, 8, -26 },
  { 16, 19, 24, 21, 1, -24 },
  { 73, 16, 32, 21, 2, -28 },
  { 137, 19, 24, 21, 1, -24 },
  { 194, 18, 24, 21, 1, -24 },
  { 248, 1, 9, 21, 10, -26 },
  { 250, 8, 32, 21, 8, -27 },
  { 282, 8, 32, 21, 5, -27 },
  { 314, 17, 17, 21, 2, -19 },
  { 351, 17, 17, 21, 2, -19 },
  { 388, 3, 9, 21, 8, -3 },
  { 392, 9, 1, 21, 6, -11 },
  { 394, 3, 2, 21, 9, -2 },
  { 395, 13, 32, 21, 4, -27 },
  { 447, 17, 24, 21, 2, -24 },
  { 498, 16, 24, 21, 3, -24 },
  { 546, 15, 24, 21, 3, -24 },
  { 591, 15, 24, 21, 2, -24 },
  { 636, 17, 24, 21, 2, -24 },
  { 687, 15, 24, 21, 3, -24 },
  { 732, 15, 24, 21, 3, -24 },
  { 777, 15, 24, 21, 3, -24 },
  { 822, 15, 24, 21, 3, -24 },
  { 867, 15, 24, 21, 3, -24 },
  { 912, 3, 18, 21, 9, -18 },
  { 919, 4, 24, 21, 8, -18 },
  { 931, 15, 19, 21, 3, -20 },
  { 967, 17, 7, 21, 2, -14 },
  { 982, 15, 19, 21, 3, -20 },
  { 1018, 13, 24, 21, 4, -24 },
  { 1057, 14, 28, 21, 3, -24 },
  { 1106, 17, 24, 21, 2, -24 },
  { 1157, 15, 24, 21, 3, -24 },
  { 1202, 15, 24, 21, 3, -24 },
  { 1247, 14, 24, 21, 4, -24 },
  { 1289, 14, 24, 21, 4, -24 },
  { 1331, 14, 24, 21, 4, -24 },
  { 1373, 15, 24, 21, 3, -24 },
  { 1418, 15, 24, 21, 3, -24 },
  { 1463, 15, 24, 21, 3, -24 },
  { 1508, 13, 24, 21, 3, -24 },
  { 1547, 15, 24, 21, 4, -24 },
  { 1592, 13, 24, 21, 5, -24 },
  { 1631, 15, 24, 21, 3, -24 },
  { 1676, 15, 24, 21, 3, -24 },
  { 1721, 17, 24, 21, 2, -24 },
  { 1772, 14, 24, 21, 4, -24 },
  { 1814, 17, 29, 21, 2, -24 },
  { 1876, 14, 24, 21, 4, -24 },
  { 1918, 16, 24, 21, 2, -24 },
  { 1966, 19, 24, 21, 1, -24 },
  { 2023, 15, 24, 21, 3, -24 },
  { 2068, 17, 24, 21, 2, -24 },
  { 2119, 17, 24, 21, 2, -24 },
  { 2170, 17, 24, 21, 2, -24 },
  { 2221, 19, 24, 21, 1, -24 },
  { 2278, 17, 24, 21, 2, -24 },
  { 2329, 9, 32, 21, 9, -27 },
  { 2365, 13, 32, 21, 4, -27 },
  { 2417, 9, 32, 21, 3, -27 },
  { 2453, 17, 13, 21, 2, -24 },
  { 2481, 17, 1, 21, 2, 4 },
  { 2484, 5, 6, 21, 7, -27 },
  { 2488, 16, 18, 21, 3, -18 },
  { 2524, 14, 26, 21, 4, -26 },
  { 2570, 14, 18, 21, 4, -18 },
  { 2602, 14, 26, 21, 3, -26 },
  { 2648, 15, 18, 21, 3, -18 },
  { 2682, 16, 26, 21, 3, -26 },
  { 2734, 16, 27, 21, 3, -20 },
  { 2788, 13, 26, 21, 4, -26 },
  { 2831, 15, 26, 21, 4, -26 },
  { 2880, 13, 33, 21, 3, -26 },
  { 2934, 15, 26, 21, 5, -26 },
  { 2983, 15, 26, 21, 3, -26 },
  { 3032, 15, 18, 21, 3, -18 },
  { 3066, 13, 18, 21, 4, -18 },
  { 3096, 15, 18, 21, 3, -18 },
  { 3130, 14, 25, 21, 4, -18 },
  { 3174, 14, 25, 21, 3, -18 },
  { 3218, 16, 18, 21, 3, -18 },
  { 3254, 15, 18, 21, 3, -18 },
  { 3288, 17, 24, 21, 1, -24 },
  { 3339, 13, 18, 21, 4, -18 },
  { 3369, 15, 18, 21, 3, -18 },
  { 3403, 19, 18, 21, 1, -18 },
  { 3446, 15, 18, 21, 3, -18 },
  { 3480, 15, 25, 21, 3, -18 },
  { 3527, 13, 18, 21, 4, -18 },
  { 3557, 13, 32, 21, 4, -27 },
  { 3609, 1, 32, 21, 10, -27 },
  { 3613, 13, 32, 21, 4, -27 },
  { 3665, 17, 6, 21, 2, -14 },
};

const GFXfont IBMPlexMono_Thin35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_THIN35PT7B_H_
