#ifndef _IBMPLEXMONO_THIN15PT7B_H_
#define _IBMPLEXMONO_THIN15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xB6, 0xD0, 0x12, 0x09, 0x05, 0x0E, 0x72, 0x41, 0x23,
  0x9C, 0x48, 0x28, 0x14, 0x00, 0x10, 0x21, 0xE4, 0xA9, 0x32, 0x1C, 0x0E,
  0x13, 0x26, 0x4B, 0xE1, 0x02, 0x00, 0x71, 0xC4, 0xA2, 0x91, 0x87, 0x41,
  0x38, 0xA4, 0x92, 0x49, 0x43, 0x80, 0x71, 0x12, 0x04, 0x04, 0x34, 0xA5,
  0x46, 0x8C, 0xE4, 0xF0, 0x72, 0x49, 0x24, 0x92, 0x46, 0x89, 0x12, 0x49,
  0x25, 0x28, 0x10, 0x20, 0x46, 0xB3, 0x85, 0x11, 0x00, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x10, 0x6A, 0xE0, 0x80, 0x08, 0x44, 0x22, 0x10,
  0x88, 0x44, 0x21, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x32, 0x60, 0xC1,
  0x44, 0x70, 0x10, 0x61, 0x44, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x38,
  0x8A, 0x10, 0x20, 0x41, 0x04, 0x10, 0xC1, 0xFC, 0x39, 0x18, 0x41, 0x38,
  0x30, 0x41, 0x85, 0xE0, 0x04, 0x38, 0x51, 0x24, 0x50, 0xA1, 0x7F, 0x04,
  0x08, 0x7D, 0x02, 0x05, 0xC4, 0x40, 0x80, 0x82, 0x84, 0xF0, 0x18, 0x41,
  0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x84, 0xF0, 0xFF, 0x0A, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x80, 0x7D, 0x0A, 0x0C, 0x27, 0x98, 0xA0, 0xC1, 0x82,
  0xF8, 0x38, 0x8A, 0x0C, 0x14, 0x27, 0x81, 0x04, 0x08, 0x60, 0x81, 0x40,
  0x01, 0xA8, 0x06, 0x10, 0xC6, 0x08, 0x0C, 0x06, 0x03, 0xFE, 0x03, 0xF8,
  0x80, 0xC0, 0x40, 0x60, 0x63, 0x08, 0x60, 0x7C, 0x62, 0x11, 0x31, 0x00,
  0x01, 0x00, 0x39, 0x18, 0x67, 0xA6, 0x9A, 0x69, 0x9E, 0x04, 0x0F, 0x30,
  0x60, 0xA2, 0x44, 0x88, 0x9F, 0x42, 0x83, 0x04, 0xFD, 0x0A, 0x14, 0x2F,
  0x90, 0xA0, 0xC1, 0x85, 0xF8, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x20, 0x41,
  0x44, 0x70, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0xFE, 0x08,
  0x20, 0xFE, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20,
  0x82, 0x00, 0x38, 0x8A, 0x14, 0x18, 0x11, 0xE0, 0xC1, 0x42, 0x7C, 0x83,
  0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x04, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x11, 0xFC, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x61, 0x85,
  0xE0, 0x86, 0x29, 0x28, 0xC2, 0x89, 0x24, 0x8A, 0x10, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x83, 0xF0, 0x83, 0x07, 0x3E, 0x5B, 0x36, 0x60, 0xC1,
  0x83, 0x04, 0x83, 0x87, 0x0D, 0x1A, 0x32, 0x62, 0xC5, 0x87, 0x04, 0x38,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0x70, 0xFA, 0x18, 0x61, 0x87,
  0xE8, 0x20, 0x82, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44,
  0x70, 0x40, 0x81, 0xC0, 0xFA, 0x18, 0x61, 0x87, 0xEA, 0x24, 0x8A, 0x30,
  0x79, 0x0A, 0x0C, 0x07, 0x01, 0x80, 0xC1, 0x82, 0xF8, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC2, 0x44, 0xF8, 0x83, 0x06, 0x14, 0x24, 0x49, 0x12, 0x14, 0x30, 0x60,
  0x83, 0x06, 0x0D, 0x9B, 0x36, 0x6B, 0x66, 0xCC, 0x88, 0x83, 0x09, 0x21,
  0x43, 0x06, 0x0A, 0x22, 0x85, 0x04, 0x81, 0xA1, 0x08, 0x84, 0x81, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0xFE, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x40, 0x81, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x84, 0x21,
  0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x80, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x30, 0x51, 0x22, 0x28, 0x50, 0x40, 0xFE, 0x90, 0x79, 0x08,
  0x13, 0xE8, 0x50, 0xA1, 0x3F, 0x82, 0x08, 0x3C, 0x8A, 0x18, 0x61, 0x86,
  0x2F, 0x00, 0x72, 0x28, 0x20, 0x82, 0x28, 0xDC, 0x04, 0x10, 0x4F, 0x46,
  0x18, 0x61, 0x85, 0x13, 0xC0, 0x39, 0x8A, 0x0F, 0xF8, 0x10, 0x11, 0x9C,
  0x1E, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x06, 0x79,
  0x14, 0x28, 0x48, 0x9E, 0x40, 0x7F, 0x06, 0x0B, 0xE0, 0x84, 0x21, 0xE8,
  0xC6, 0x31, 0x8C, 0x62, 0x20, 0x00, 0x38, 0x20, 0x82, 0x08, 0x20, 0x8F,
  0xC0, 0x04, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x09, 0xE0,
  0x82, 0x08, 0x23, 0x92, 0x8A, 0x34, 0x92, 0x28, 0x40, 0xF0, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0xEF, 0x26, 0x4C, 0x99, 0x32,
  0x64, 0xC9, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x38, 0x8A, 0x0C, 0x18, 0x30,
  0x51, 0x1C, 0xF2, 0x28, 0x61, 0x86, 0x18, 0xBC, 0x82, 0x08, 0x00, 0x3D,
  0x18, 0x61, 0x86, 0x14, 0x4F, 0x04, 0x10, 0x40, 0xEE, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x7F, 0x39, 0x8A, 0x03, 0x80, 0xC0, 0x60, 0xBE, 0x20, 0x43,
  0xF9, 0x02, 0x04, 0x08, 0x10, 0x20, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x2F,
  0x87, 0x09, 0x12, 0x44, 0x85, 0x0C, 0x18, 0xB3, 0x66, 0xCD, 0x5C, 0xB9,
  0xB3, 0x22, 0x86, 0x88, 0xA1, 0x83, 0x05, 0x11, 0x43, 0x83, 0x09, 0x12,
  0x44, 0x85, 0x0C, 0x08, 0x20, 0x43, 0x00, 0xF8, 0x44, 0x44, 0x42, 0x1F,
  0x3A, 0x10, 0x42, 0x0B, 0x86, 0x21, 0x10, 0x83, 0x80, 0xFF, 0xF8, 0xE1,
  0x08, 0x44, 0x20, 0xEC, 0x42, 0x08, 0x4E, 0x00, 0x63, 0x26, 0x30,
};

const GFXglyph IBMPlexMono_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 10, 9, 4, -10 },
  { 3, 3, 4, 9, 3, -11 },
  { 5, 9, 10, 9, 0, -10 },
  { 17, 7, 14, 9, 1, -12 },
  { 30, 9, 10, 9, 0, -10 },
  { 42, 7, 10, 9, 1, -10 },
  { 51, 1, 4, 9, 4, -11 },
  { 52, 3, 13, 9, 4, -11 },
  { 57, 3, 13, 9, 2, -11 },
  { 62, 7, 7, 9, 1, -8 },
  { 69, 7, 9, 9, 1, -9 },
  { 77, 2, 4, 9, 3, -1 },
  { 78, 3, 1, 9, 3, -5 },
  { 79, 1, 1, 9, 4, -1 },
  { 80, 5, 13, 9, 2, -11 },
  { 89, 7, 10, 9, 1, -10 },
  { 98, 7, 10, 9, 1, -10 },
  { 107, 7, 10, 9, 1, -10 },
  { 116, 6, 10, 9, 1, -10 },
  { 124, 7, 10, 9, 1, -10 },
  { 133, 7, 10, 9, 1, -10 },
  { 142, 7, 10, 9, 1, -10 },
  { 151, 7, 10, 9, 1, -10 },
  { 160, 7, 10, 9, 1, -10 },
  { 169, 7, 10, 9, 1, -10 },
  { 178, 1, 8, 9, 4, -8 },
  { 179, 2, 11, 9, 3, -8 },
  { 182, 7, 8, 9, 1, -9 },
  { 189, 7, 3, 9, 1, -6 },
  { 192, 7, 8, 9, 1, -9 },
  { 199, 5, 10, 9, 2, -10 },
  { 206, 6, 12, 9, 1, -10 },
  { 215, 7, 10, 9, 1, -10 },
  { 224, 7, 10, 9, 1, -10 },
  { 233, 7, 10, 9, 1, -10 },
  { 242, 6, 10, 9, 2, -10 },
  { 250, 6, 10, 9, 2, -10 },
  { 258, 6, 10, 9, 2, -10 },
  { 266, 7, 10, 9, 1, -10 },
  { 275, 7, 10, 9, 1, -10 },
  { 284, 7, 10, 9, 1, -10 },
  { 293, 6, 10, 9, 1, -10 },
  { 301, 6, 10, 9, 2, -10 },
  { 309, 6, 10, 9, 2, -10 },
  { 317, 7, 10, 9, 1, -10 },
  { 326, 7, 10, 9, 1, -10 },
  { 335, 7, 10, 9, 1, -10 },
  { 344, 6, 10, 9, 2, -10 },
  { 352, 7, 13, 9, 1, -10 },
  { 364, 6, 10, 9, 2, -10 },
  { 372, 7, 10, 9, 1, -10 },
  { 381, 7, 10, 9, 1, -10 },
  { 390, 7, 10, 9, 1, -10 },
  { 399, 7, 10, 9, 1, -10 },
  { 408, 7, 10, 9, 1, -10 },
  { 417, 7, 10, 9, 1, -10 },
  { 426, 9, 10, 9, 0, -10 },
  { 438, 7, 10, 9, 1, -10 },
  { 447, 4, 13, 9, 4, -11 },
  { 454, 5, 13, 9, 2, -11 },
  { 463, 4, 13, 9, 1, -11 },
  { 470, 7, 6, 9, 1, -10 },
  { 476, 7, 1, 9, 1, 1 },
  { 477, 2, 2, 9, 3, -12 },
  { 478, 7, 8, 9, 1, -8 },
  { 485, 6, 11, 9, 2, -11 },
  { 494, 6, 8, 9, 2, -8 },
  { 500, 6, 11, 9, 1, -11 },
  { 509, 7, 8, 9, 1, -8 },
  { 516, 7, 11, 9, 1, -11 },
  { 526, 7, 12, 9, 1, -9 },
  { 537, 5, 11, 9, 2, -11 },
  { 544, 6, 11, 9, 2, -11 },
  { 553, 6, 14, 9, 1, -11 },
  { 564, 6, 11, 9, 2, -11 },
  { 573, 7, 11, 9, 1, -11 },
  { 583, 7, 8, 9, 1, -8 },
  { 590, 5, 8, 9, 2, -8 },
  { 595, 7, 8, 9, 1, -8 },
  { 602, 6, 11, 9, 2, -8 },
  { 611, 6, 11, 9, 1, -8 },
  { 620, 7, 8, 9, 1, -8 },
  { 627, 7, 8, 9, 1, -8 },
  { 634, 7, 10, 9, 1, -10 },
  { 643, 5, 8, 9, 2, -8 },
  { 648, 7, 8, 9, 1, -8 },
  { 655, 7, 8, 9, 1, -8 },
  { 662, 7, 8, 9, 1, -8 },
  { 669, 7, 11, 9, 1, -8 },
  { 679, 5, 8, 9, 2, -8 },
  { 684, 5, 13, 9, 2, -11 },
  { 693, 1, 13, 9, 4, -11 },
  { 695, 5, 13, 9, 2, -11 },
  { 704, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_Thin15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_THIN15PT7B_H_
