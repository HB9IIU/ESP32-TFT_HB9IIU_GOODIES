#ifndef _IBMPLEXMONO_THIN52PT7B_H_
#define _IBMPLEXMONO_THIN52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x1F, 0xF0, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x60, 0x10, 0x00, 0x02, 0x01, 0x80, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x10, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x10, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x01, 0x00, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x80, 0x60, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x04,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x08, 0x70,
  0x0C, 0x08, 0x18, 0x18, 0x08, 0x06, 0x30, 0x08, 0x02, 0x20, 0x08, 0x03,
  0x20, 0x08, 0x00, 0x60, 0x08, 0x00, 0x40, 0x08, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x08, 0x00, 0x60, 0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x08, 0x00,
  0x10, 0x08, 0x00, 0x18, 0x08, 0x00, 0x06, 0x08, 0x00, 0x03, 0xC8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x09, 0xE0, 0x00, 0x08, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x08, 0x06, 0x00, 0x08, 0x02, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01,
  0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01,
  0x00, 0x08, 0x01, 0x80, 0x08, 0x01, 0x40, 0x08, 0x03, 0x20, 0x08, 0x02,
  0x10, 0x08, 0x04, 0x0C, 0x08, 0x18, 0x07, 0x08, 0x70, 0x00, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xCC, 0x02,
  0x00, 0x04, 0x40, 0x08, 0x00, 0x46, 0x00, 0x60, 0x02, 0x20, 0x01, 0x00,
  0x21, 0x00, 0x08, 0x02, 0x08, 0x00, 0x40, 0x10, 0x40, 0x02, 0x01, 0x02,
  0x00, 0x10, 0x08, 0x10, 0x00, 0x80, 0x80, 0x80, 0x04, 0x08, 0x06, 0x00,
  0x60, 0x40, 0x10, 0x02, 0x04, 0x00, 0xC0, 0x30, 0x20, 0x03, 0x07, 0x02,
  0x00, 0x07, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x1F, 0x80, 0x01,
  0x01, 0x83, 0x00, 0x18, 0x10, 0x0C, 0x00, 0x81, 0x00, 0x20, 0x08, 0x08,
  0x00, 0x80, 0x40, 0x80, 0x04, 0x04, 0x04, 0x00, 0x20, 0x20, 0x20, 0x01,
  0x02, 0x01, 0x00, 0x08, 0x20, 0x08, 0x00, 0x41, 0x00, 0x40, 0x02, 0x10,
  0x02, 0x00, 0x10, 0x80, 0x08, 0x00, 0x88, 0x00, 0x40, 0x08, 0x80, 0x01,
  0x00, 0xC4, 0x00, 0x06, 0x0C, 0x40, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x02, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x20,
  0x80, 0x1F, 0x10, 0x30, 0x04, 0x08, 0x06, 0x01, 0x06, 0x00, 0x80, 0x41,
  0x00, 0x10, 0x10, 0x40, 0x02, 0x04, 0x30, 0x00, 0x43, 0x08, 0x00, 0x08,
  0x82, 0x00, 0x03, 0x20, 0x80, 0x00, 0x68, 0x20, 0x00, 0x0A, 0x0C, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x60, 0x40, 0x00, 0x24, 0x18, 0x00, 0x18, 0x82,
  0x00, 0x0C, 0x10, 0x60, 0x06, 0x06, 0x0E, 0x07, 0x00, 0xC0, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x30, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x30, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x0F, 0xE0,
  0x10, 0x0F, 0x03, 0x82, 0x0F, 0x00, 0x0E, 0x4E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x58, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x30, 0x00, 0x08, 0x02, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x40, 0x06, 0x00, 0x10, 0x00, 0x40, 0x04, 0x00,
  0x04, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x19, 0x8C, 0x63, 0x11, 0x8C, 0x42, 0x31, 0x08, 0x00, 0xFF, 0xF8, 0xFF,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x10, 0x00, 0x10, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0xC0,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x38, 0x02, 0x80,
  0x38, 0x03, 0x80, 0x18, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x10, 0x00, 0x10, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x20, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x38, 0x0C, 0x01, 0x80, 0x0C,
  0x08, 0x00, 0x10, 0x40, 0x00, 0x21, 0x00, 0x00, 0x88, 0x00, 0x01, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x30, 0x1C, 0x06, 0x00, 0x30, 0x60, 0x00, 0xC2, 0x00, 0x03, 0x20,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x98, 0x00, 0x08, 0x60, 0x01, 0x80, 0xE0, 0x38, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00,
  0x20, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x01,
  0x80, 0x10, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF8, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x3F, 0xC0,
  0x27, 0x01, 0xC0, 0xA0, 0x01, 0x83, 0x00, 0x01, 0x08, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x40, 0x00, 0x18, 0xC0,
  0x00, 0xC1, 0x80, 0x06, 0x01, 0x80, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x7F, 0x00, 0x4E, 0x03, 0x82, 0x60, 0x03, 0x0B,
  0x00, 0x02, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x80, 0x0C, 0x03, 0x80,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00, 0x04,
  0x40, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80, 0x80, 0x00, 0x82,
  0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x44, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x08, 0x0C, 0x00,
  0x20, 0x0E, 0x03, 0x80, 0x03, 0xF8, 0x00, 0x38, 0x0E, 0x01, 0x80, 0x03,
  0x06, 0x00, 0x01, 0x18, 0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x04, 0xC0,
  0x00, 0x08, 0xC0, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x70, 0x1C, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x0C, 0x0C, 0x00,
  0x08, 0x20, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x00, 0xA0, 0x00, 0x02,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00,
  0x1D, 0x80, 0x00, 0x63, 0x00, 0x02, 0x86, 0x00, 0x32, 0x06, 0x03, 0x88,
  0x07, 0xF8, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x31, 0x8C,
  0x62, 0x31, 0x88, 0x46, 0x21, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x30,
  0x1C, 0x06, 0x00, 0x30, 0x60, 0x00, 0x42, 0x00, 0x03, 0x20, 0x00, 0x09,
  0x00, 0x00, 0x50, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x38, 0x18, 0x03, 0x00, 0x20, 0x30, 0x00, 0x81, 0x00, 0x02, 0x10,
  0x00, 0x10, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x90, 0x00, 0x05, 0x80, 0x3F, 0x38, 0x06, 0x0C, 0xC0, 0x60, 0x16, 0x02,
  0x00, 0xB0, 0x30, 0x03, 0x81, 0x00, 0x1C, 0x08, 0x00, 0x60, 0x40, 0x03,
  0x02, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x30, 0x20,
  0x01, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x40, 0x07, 0x02, 0x00, 0x38,
  0x08, 0x01, 0xC0, 0x40, 0x16, 0x01, 0x81, 0x38, 0x07, 0xF1, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02,
  0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x10,
  0x00, 0x10, 0x04, 0x00, 0x04, 0x01, 0x80, 0x02, 0x00, 0x20, 0x00, 0x80,
  0x08, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x40, 0x04, 0x00, 0x10, 0x01,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x3F, 0xFF, 0xE0, 0x08, 0x00, 0x0C,
  0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x20, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x02, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x80,
  0x00, 0x22, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x30, 0x80, 0x01, 0x83, 0xFF,
  0xFC, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x0C,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0x01, 0xC0, 0x18, 0x00, 0xC0,
  0x60, 0x00, 0xC1, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x88, 0x00, 0x01, 0x90,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10,
  0x00, 0x04, 0x30, 0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x30, 0x20, 0x00,
  0x61, 0x00, 0x01, 0x88, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0xD0,
  0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x1A,
  0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0xC4, 0x00, 0x0C, 0x20, 0x01,
  0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xA0, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x03, 0x80, 0x18, 0x01, 0x80, 0x40,
  0x00, 0x81, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x01, 0x10, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x68, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x03, 0x30, 0x00,
  0x0A, 0x20, 0x00, 0x14, 0x20, 0x00, 0x48, 0x30, 0x01, 0x10, 0x38, 0x0C,
  0x20, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xE0, 0x00, 0x16, 0x00, 0x02, 0x40, 0x00, 0xCC, 0x00, 0x10, 0xC0,
  0x04, 0x06, 0x03, 0x00, 0x3F, 0x80, 0x80, 0x00, 0x05, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10, 0x00, 0x10, 0x20,
  0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x06, 0x01, 0x00, 0x18, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x08, 0x02, 0x00, 0x10, 0x08, 0x00, 0x20, 0x20,
  0x00, 0x40, 0xC0, 0x00, 0x82, 0x80, 0x01, 0x08, 0x80, 0x02, 0x21, 0x80,
  0x04, 0xC1, 0x00, 0x0B, 0x01, 0x00, 0x1C, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x02, 0x00, 0x80, 0x06, 0x01, 0x00, 0x04, 0x02, 0x00, 0x04, 0x04,
  0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20, 0x00, 0x18, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x11, 0x00, 0x00, 0x32, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x17, 0x80, 0x00,
  0x2E, 0x80, 0x00, 0x9D, 0x00, 0x01, 0x3B, 0x00, 0x02, 0x72, 0x00, 0x08,
  0xE6, 0x00, 0x11, 0xC4, 0x00, 0x43, 0x8C, 0x00, 0x87, 0x08, 0x02, 0x0E,
  0x10, 0x04, 0x1C, 0x10, 0x10, 0x38, 0x20, 0x20, 0x70, 0x20, 0x80, 0xE0,
  0x41, 0x01, 0xC0, 0x46, 0x03, 0x80, 0x88, 0x07, 0x00, 0x90, 0x0E, 0x01,
  0x40, 0x1C, 0x03, 0x80, 0x38, 0x02, 0x00, 0x70, 0x04, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x68, 0x00, 0x03, 0x60, 0x00, 0x19, 0x00,
  0x00, 0xCC, 0x00, 0x06, 0x20, 0x00, 0x31, 0x80, 0x01, 0x84, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0x80, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x40,
  0x06, 0x02, 0x00, 0x30, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x20, 0x18, 0x01, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x30,
  0x30, 0x00, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x60, 0x00, 0xC3, 0x00,
  0x02, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x30, 0x00, 0x09,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0xFE, 0x00, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x30, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x03,
  0x01, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x04, 0x00, 0x0E, 0x20, 0x00,
  0x19, 0x00, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80,
  0x00, 0x64, 0x00, 0x0E, 0x3F, 0xFF, 0xC1, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x10, 0x00, 0x10, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x10, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0x04, 0x00, 0x0E, 0x20, 0x00, 0x19,
  0x00, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80, 0x00,
  0x64, 0x00, 0x0E, 0x3F, 0xFF, 0xC1, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x60, 0x10, 0x01, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x20,
  0x20, 0x00, 0x81, 0x00, 0x06, 0x08, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00,
  0x03, 0x10, 0x00, 0x08, 0x80, 0x00, 0x24, 0x00, 0x01, 0xA0, 0x00, 0x05,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x70, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x40, 0x00, 0x03, 0x20, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x07, 0x80, 0x70, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x48, 0x00, 0x02, 0x20,
  0x00, 0x31, 0x00, 0x01, 0x04, 0x00, 0x10, 0x1C, 0x07, 0x00, 0x3F, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x60,
  0x00, 0x04, 0x10, 0x00, 0x06, 0x08, 0x00, 0x02, 0x06, 0x00, 0x01, 0x01,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x60, 0x00, 0x40, 0x10, 0x00, 0x60,
  0x08, 0x00, 0x20, 0x06, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08,
  0x00, 0x60, 0x04, 0x00, 0x10, 0x06, 0x00, 0x08, 0x02, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00, 0x60, 0x40, 0x00, 0x10,
  0x60, 0x00, 0x08, 0x20, 0x00, 0x06, 0x10, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x48, 0x01, 0x00, 0x24, 0x01, 0xC0, 0x12, 0x00,
  0xA0, 0x09, 0x80, 0x50, 0x04, 0x40, 0x24, 0x02, 0x20, 0x22, 0x01, 0x10,
  0x11, 0x01, 0x08, 0x08, 0xC0, 0x84, 0x08, 0x20, 0x42, 0x04, 0x10, 0x21,
  0x02, 0x08, 0x10, 0x83, 0x02, 0x08, 0x41, 0x01, 0x04, 0x30, 0x80, 0x82,
  0x08, 0x40, 0x21, 0x04, 0x40, 0x10, 0x82, 0x20, 0x08, 0x81, 0x10, 0x06,
  0x40, 0x90, 0x01, 0x20, 0x48, 0x00, 0x90, 0x24, 0x00, 0x48, 0x16, 0x00,
  0x14, 0x0A, 0x00, 0x0A, 0x07, 0x00, 0x05, 0x03, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x10, 0x00, 0x04, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x10, 0x04, 0x00, 0x02,
  0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04,
  0x18, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x40, 0x18, 0x00,
  0x20, 0x02, 0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x18, 0x02, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x40, 0x40, 0x00, 0x18, 0x20, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x20, 0x02, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0xFF, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x28, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x44, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x82, 0x00, 0x01, 0x01, 0x00, 0x03, 0x01, 0x80, 0x02,
  0x00, 0x80, 0x06, 0x00, 0x40, 0x04, 0x00, 0x60, 0x08, 0x00, 0x20, 0x18,
  0x00, 0x30, 0x10, 0x00, 0x10, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x40,
  0x00, 0x04, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x41, 0x80, 0x81, 0x81, 0x01, 0x01, 0x03, 0x02, 0x01,
  0xFC, 0x00, 0x0E, 0x03, 0x00, 0x18, 0x01, 0x80, 0x20, 0x00, 0x40, 0x60,
  0x00, 0x40, 0x40, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x03, 0xFF, 0xE0, 0x1C, 0x00, 0x20, 0x30, 0x00, 0x20, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40,
  0x00, 0xA0, 0x20, 0x01, 0x20, 0x18, 0x06, 0x3F, 0x07, 0xF8, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x83, 0xF8, 0x0C, 0x60, 0x70, 0x6C, 0x00, 0x43,
  0xC0, 0x01, 0x1C, 0x00, 0x04, 0xC0, 0x00, 0x26, 0x00, 0x00, 0xB0, 0x00,
  0x05, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0,
  0x00, 0x16, 0x00, 0x01, 0x38, 0x00, 0x09, 0xE0, 0x00, 0x8D, 0x80, 0x08,
  0x63, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x30, 0x08,
  0x00, 0xC1, 0x00, 0x06, 0x20, 0x00, 0x26, 0x00, 0x03, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x12, 0x00, 0x02, 0x10, 0x00, 0x60, 0x80, 0x0C, 0x06,
  0x03, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x03, 0xF8, 0x10,
  0x70, 0x38, 0x86, 0x00, 0x64, 0x40, 0x00, 0xA6, 0x00, 0x05, 0x20, 0x00,
  0x1A, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00,
  0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x19, 0x00, 0x00, 0xCC, 0x00, 0x0A,
  0x20, 0x00, 0x50, 0xC0, 0x0C, 0x83, 0x81, 0xC4, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x18, 0x20, 0x00,
  0x21, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x02, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x26,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x10, 0x00, 0x20, 0x20, 0x01, 0x00, 0x60,
  0x38, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x40, 0x00, 0xFC, 0x40, 0x07, 0x03, 0x40, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0x40, 0x10, 0x00, 0x20, 0x30, 0x00, 0x20, 0x20, 0x00,
  0x30, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x20, 0x00, 0x30, 0x30, 0x00, 0x20, 0x10, 0x00, 0x20, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x03, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x08, 0x00, 0x18, 0x30, 0x00,
  0x04, 0x40, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x40, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x07, 0xFF, 0x80, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x0F,
  0xC0, 0x8C, 0x0E, 0x2C, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x02, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x7F, 0xFF, 0x80, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x80, 0x00, 0x22, 0x00, 0x03, 0x08, 0x00, 0x18, 0x20, 0x00, 0xC0, 0x80,
  0x04, 0x02, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x18, 0x00, 0x80, 0xC0,
  0x02, 0x06, 0x00, 0x08, 0x38, 0x00, 0x21, 0x10, 0x00, 0x88, 0x20, 0x02,
  0x40, 0xC0, 0x0A, 0x01, 0x80, 0x30, 0x03, 0x00, 0x80, 0x04, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x20, 0x00, 0x60, 0x80, 0x00, 0xC2, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x20, 0x00, 0x04, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x30,
  0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xF0, 0x8F, 0x81, 0xF1,
  0x20, 0x84, 0x1A, 0x80, 0x90, 0x1E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x08, 0x83, 0xF0, 0x23, 0x03, 0x8B, 0x00, 0x33, 0x00, 0x06,
  0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x0C,
  0x04, 0x00, 0x18, 0x20, 0x00, 0x21, 0x00, 0x00, 0x44, 0x00, 0x01, 0x30,
  0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0xC0,
  0x00, 0x09, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x60, 0x60, 0x03, 0x00, 0x60, 0x30, 0x00, 0x7F, 0x00, 0xC1, 0xFC, 0x06,
  0x30, 0x38, 0x36, 0x00, 0x21, 0xE0, 0x00, 0x8E, 0x00, 0x02, 0x60, 0x00,
  0x13, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x9C, 0x00, 0x04,
  0xF0, 0x00, 0x46, 0xC0, 0x04, 0x31, 0x80, 0xC1, 0x83, 0xF8, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x08, 0x38, 0x1C, 0x43, 0x00, 0x32, 0x20, 0x00, 0x53, 0x00, 0x02,
  0x90, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0C, 0x80, 0x00, 0x66,
  0x00, 0x05, 0x10, 0x00, 0x28, 0x60, 0x06, 0x41, 0xC0, 0xE2, 0x03, 0xF8,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0xFF, 0xE0, 0xFF, 0x80, 0x31, 0x80, 0x00, 0x19, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x38, 0x0E, 0x01, 0x00, 0x06, 0x08, 0x00,
  0x0C, 0x60, 0x00, 0x19, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x60, 0x00, 0x18, 0x60,
  0x00, 0xC0, 0xE0, 0x0C, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x20, 0x00, 0xE6,
  0x00, 0x2C, 0x30, 0x39, 0x81, 0xFC, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x50, 0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x40, 0xC0, 0x02, 0x02, 0x00, 0x20,
  0x10, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x40,
  0x60, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00,
  0x18, 0x40, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x09, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x08, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x40,
  0x06, 0x00, 0x28, 0x00, 0xA0, 0x05, 0x00, 0x14, 0x00, 0x90, 0x04, 0x80,
  0x22, 0x00, 0x90, 0x04, 0x40, 0x12, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80,
  0x44, 0x04, 0x10, 0x10, 0x80, 0x82, 0x02, 0x10, 0x10, 0x40, 0x42, 0x02,
  0x04, 0x08, 0x60, 0x80, 0x81, 0x04, 0x10, 0x10, 0x60, 0x82, 0x02, 0x08,
  0x10, 0x40, 0x21, 0x02, 0x10, 0x04, 0x20, 0x42, 0x00, 0x84, 0x04, 0x40,
  0x10, 0x80, 0x90, 0x01, 0x20, 0x12, 0x00, 0x24, 0x02, 0x40, 0x04, 0x80,
  0x48, 0x00, 0x50, 0x06, 0x00, 0x0A, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x42, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x40, 0x20, 0x02, 0x00, 0x40, 0x18, 0x01, 0x80, 0xC0,
  0x03, 0x02, 0x00, 0x04, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x80, 0x00, 0x05, 0x00, 0x00, 0x32, 0x00, 0x00, 0x8C,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x20, 0x01, 0x80, 0x40, 0x04, 0x01, 0x80,
  0x20, 0x02, 0x01, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x31, 0x00,
  0x00, 0x48, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x09, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x42, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04, 0x00,
  0x04, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x10, 0x01,
  0x80, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x20,
  0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x38, 0x07, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x8C, 0x60, 0x00, 0x48,
  0x08, 0x00, 0x24, 0x02, 0x00, 0x24, 0x00, 0x80, 0x12, 0x00, 0x20, 0x1B,
  0x00, 0x08, 0x09, 0x00, 0x03, 0x08, 0x80, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 3, 36, 31, 14, -36 },
  { 15, 8, 13, 31, 12, -38 },
  { 28, 29, 36, 31, 1, -36 },
  { 159, 24, 48, 31, 3, -42 },
  { 303, 29, 38, 31, 1, -37 },
  { 441, 26, 38, 31, 2, -37 },
  { 565, 1, 13, 31, 15, -38 },
  { 567, 12, 47, 31, 12, -40 },
  { 638, 12, 47, 31, 7, -40 },
  { 709, 27, 26, 31, 2, -29 },
  { 797, 25, 25, 31, 3, -28 },
  { 876, 5, 13, 31, 12, -4 },
  { 885, 13, 1, 31, 9, -16 },
  { 887, 3, 3, 31, 14, -3 },
  { 889, 21, 47, 31, 5, -40 },
  { 1013, 24, 38, 31, 4, -37 },
  { 1127, 25, 36, 31, 4, -36 },
  { 1240, 22, 37, 31, 5, -37 },
  { 1342, 21, 38, 31, 4, -37 },
  { 1442, 27, 36, 31, 2, -36 },
  { 1564, 22, 37, 31, 4, -36 },
  { 1666, 22, 37, 31, 5, -36 },
  { 1768, 23, 36, 31, 4, -36 },
  { 1872, 23, 38, 31, 4, -37 },
  { 1982, 22, 37, 31, 5, -37 },
  { 2084, 3, 27, 31, 14, -27 },
  { 2095, 5, 36, 31, 12, -27 },
  { 2118, 23, 28, 31, 4, -30 },
  { 2199, 25, 10, 31, 3, -21 },
  { 2231, 23, 28, 31, 4, -30 },
  { 2312, 21, 37, 31, 5, -37 },
  { 2410, 21, 43, 31, 5, -37 },
  { 2523, 26, 36, 31, 3, -36 },
  { 2640, 22, 36, 31, 5, -36 },
  { 2739, 23, 38, 31, 4, -37 },
  { 2849, 21, 36, 31, 6, -36 },
  { 2944, 21, 36, 31, 6, -36 },
  { 3039, 21, 36, 31, 6, -36 },
  { 3134, 23, 38, 31, 4, -37 },
  { 3244, 21, 36, 31, 5, -36 },
  { 3339, 21, 36, 31, 5, -36 },
  { 3434, 19, 37, 31, 5, -36 },
  { 3522, 23, 36, 31, 6, -36 },
  { 3626, 19, 36, 31, 8, -36 },
  { 3712, 23, 36, 31, 4, -36 },
  { 3816, 21, 36, 31, 5, -36 },
  { 3911, 24, 38, 31, 4, -37 },
  { 4025, 21, 36, 31, 6, -36 },
  { 4120, 24, 44, 31, 4, -37 },
  { 4252, 21, 36, 31, 6, -36 },
  { 4347, 24, 38, 31, 3, -37 },
  { 4461, 27, 36, 31, 2, -36 },
  { 4583, 21, 37, 31, 5, -36 },
  { 4681, 25, 36, 31, 3, -36 },
  { 4794, 25, 36, 31, 3, -36 },
  { 4907, 26, 36, 31, 3, -36 },
  { 5024, 29, 36, 31, 1, -36 },
  { 5155, 27, 36, 31, 2, -36 },
  { 5277, 12, 47, 31, 14, -40 },
  { 5348, 21, 47, 31, 5, -40 },
  { 5472, 12, 47, 31, 5, -40 },
  { 5543, 24, 20, 31, 4, -36 },
  { 5603, 25, 1, 31, 3, 6 },
  { 5607, 7, 9, 31, 10, -40 },
  { 5615, 24, 28, 31, 4, -27 },
  { 5699, 21, 39, 31, 6, -38 },
  { 5802, 20, 28, 31, 6, -27 },
  { 5872, 21, 39, 31, 4, -38 },
  { 5975, 22, 28, 31, 5, -27 },
  { 6052, 24, 38, 31, 4, -38 },
  { 6166, 24, 40, 31, 5, -29 },
  { 6286, 18, 38, 31, 7, -38 },
  { 6372, 22, 39, 31, 6, -39 },
  { 6480, 18, 49, 31, 5, -39 },
  { 6591, 22, 38, 31, 7, -38 },
  { 6696, 22, 38, 31, 5, -38 },
  { 6801, 23, 27, 31, 4, -27 },
  { 6879, 18, 27, 31, 7, -27 },
  { 6940, 22, 28, 31, 5, -27 },
  { 7017, 21, 37, 31, 6, -27 },
  { 7115, 21, 37, 31, 4, -27 },
  { 7213, 25, 27, 31, 4, -27 },
  { 7298, 22, 28, 31, 5, -27 },
  { 7375, 25, 36, 31, 2, -36 },
  { 7488, 19, 28, 31, 6, -27 },
  { 7555, 21, 27, 31, 5, -27 },
  { 7626, 27, 27, 31, 2, -27 },
  { 7718, 22, 27, 31, 5, -27 },
  { 7793, 23, 37, 31, 4, -27 },
  { 7900, 21, 27, 31, 5, -27 },
  { 7971, 19, 47, 31, 6, -40 },
  { 8083, 1, 47, 31, 15, -40 },
  { 8089, 19, 47, 31, 6, -40 },
  { 8201, 25, 9, 31, 3, -20 },
};

const GFXfont IBMPlexMono_Thin52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_THIN52PT7B_H_
