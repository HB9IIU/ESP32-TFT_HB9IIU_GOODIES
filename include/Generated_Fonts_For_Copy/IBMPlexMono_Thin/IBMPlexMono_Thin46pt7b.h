#ifndef _IBMPLEXMONO_THIN46PT7B_H_
#define _IBMPLEXMONO_THIN46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x01,
  0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10,
  0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x20, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x10, 0x18, 0x00, 0x04, 0x04, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x04, 0x04,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x08,
  0x08, 0x00, 0x02, 0x02, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x40, 0x40, 0x00,
  0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x20, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00,
  0x38, 0x46, 0x03, 0x02, 0x0C, 0x20, 0x10, 0x33, 0x00, 0x80, 0xD0, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x20,
  0x00, 0x71, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x5E, 0x00, 0x02, 0x18, 0x00,
  0x10, 0x20, 0x00, 0x80, 0x80, 0x04, 0x06, 0x00, 0x20, 0x10, 0x01, 0x00,
  0x80, 0x08, 0x04, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00, 0x10, 0x0C, 0x00,
  0x80, 0x50, 0x04, 0x04, 0x40, 0x20, 0x61, 0x81, 0x06, 0x07, 0x08, 0xC0,
  0x07, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x48, 0x04,
  0x00, 0x4C, 0x02, 0x00, 0x24, 0x00, 0x80, 0x22, 0x00, 0x40, 0x11, 0x00,
  0x20, 0x10, 0x80, 0x10, 0x10, 0x40, 0x08, 0x08, 0x20, 0x04, 0x08, 0x10,
  0x02, 0x04, 0x08, 0x01, 0x04, 0x06, 0x01, 0x04, 0x01, 0x00, 0x82, 0x00,
  0x61, 0x82, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x10, 0x20, 0xC0, 0x08, 0x20, 0x30, 0x08, 0x20,
  0x08, 0x04, 0x10, 0x02, 0x04, 0x10, 0x01, 0x04, 0x08, 0x00, 0x82, 0x04,
  0x00, 0x42, 0x02, 0x00, 0x21, 0x01, 0x00, 0x11, 0x00, 0x80, 0x09, 0x00,
  0x20, 0x04, 0x80, 0x10, 0x04, 0x80, 0x04, 0x06, 0x40, 0x01, 0x06, 0x40,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x0C, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x21, 0x80, 0x7C, 0x81, 0x00, 0x83, 0x01, 0x01,
  0x04, 0x01, 0x02, 0x18, 0x01, 0x04, 0x20, 0x03, 0x08, 0x40, 0x03, 0x10,
  0x80, 0x02, 0x21, 0x00, 0x02, 0x82, 0x00, 0x03, 0x04, 0x00, 0x02, 0x08,
  0x00, 0x0A, 0x08, 0x00, 0x36, 0x18, 0x00, 0x46, 0x18, 0x03, 0x06, 0x1C,
  0x0C, 0x06, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0x60, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x40, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x10, 0x02, 0x70, 0x20,
  0x38, 0x1C, 0x43, 0x80, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x21, 0x00, 0x00, 0x83, 0x00, 0x02, 0x02, 0x00,
  0x04, 0x02, 0x00, 0x10, 0x02, 0x00, 0x40, 0x06, 0x01, 0x80, 0x04, 0x02,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x33, 0x26, 0x64, 0x4C, 0x88,
  0x88, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x18, 0x03, 0x00, 0x20, 0x30, 0x00,
  0x81, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40,
  0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x05,
  0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00,
  0x04, 0x40, 0x00, 0x22, 0x00, 0x02, 0x08, 0x00, 0x10, 0x60, 0x01, 0x01,
  0x80, 0x10, 0x07, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x80, 0x00, 0x64, 0x00, 0x06, 0x20, 0x00, 0x41, 0x00, 0x0C, 0x08, 0x00,
  0xC0, 0x40, 0x0C, 0x02, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xC0,
  0x60, 0x10, 0x01, 0x02, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x04, 0x80,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xE0, 0x70,
  0x18, 0x01, 0x83, 0x00, 0x0C, 0x20, 0x00, 0x44, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x03,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00,
  0x43, 0x00, 0x18, 0x0C, 0x07, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x10, 0x40, 0x00, 0x40,
  0x80, 0x01, 0x81, 0x00, 0x02, 0x02, 0x00, 0x08, 0x04, 0x00, 0x20, 0x08,
  0x00, 0x40, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x20, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x20, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xC4, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x87,
  0xF0, 0x13, 0x01, 0xC2, 0x80, 0x0C, 0x60, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00,
  0x04, 0x80, 0x01, 0x0C, 0x00, 0x40, 0xE0, 0x30, 0x03, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x3F, 0x80, 0x4E, 0x06,
  0x05, 0x00, 0x18, 0xA0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x2C, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80,
  0x00, 0x28, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x42,
  0x00, 0x08, 0x18, 0x01, 0x80, 0xE0, 0x60, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x1C, 0x02,
  0x00, 0x30, 0x20, 0x00, 0xC2, 0x00, 0x02, 0x10, 0x00, 0x08, 0x80, 0x00,
  0x4C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40,
  0x00, 0x22, 0x00, 0x02, 0x08, 0x00, 0x30, 0x20, 0x03, 0x00, 0xC0, 0x70,
  0x01, 0xFC, 0x00, 0x30, 0x1C, 0x06, 0x00, 0x10, 0x60, 0x00, 0x46, 0x00,
  0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00,
  0x08, 0x80, 0x00, 0xC3, 0x00, 0x0C, 0x0E, 0x03, 0x80, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x20, 0x00,
  0x44, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0xE1, 0x80, 0x1A, 0x0E, 0x06, 0x20,
  0x3F, 0x84, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x77, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x26, 0x64, 0x4C, 0x88, 0x88,
  0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x07, 0x03, 0x83, 0x00, 0x31, 0x80, 0x06, 0x40, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x78, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x04, 0x08, 0x00, 0x43, 0x00,
  0x08, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x05, 0x00, 0xF8, 0xA0, 0x20, 0x94, 0x08, 0x0B, 0x02, 0x00, 0xE0, 0x40,
  0x1C, 0x08, 0x01, 0x82, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0xC1, 0x00,
  0x18, 0x20, 0x03, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x81, 0x00,
  0x30, 0x20, 0x0D, 0x06, 0x02, 0xA0, 0x60, 0x54, 0x07, 0xF2, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x08,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x82, 0x00, 0x01, 0x02,
  0x00, 0x02, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x80, 0x20, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x00, 0x80, 0x20, 0x01, 0x00, 0xFF, 0xFE, 0x01, 0x00, 0x02, 0x02,
  0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x21, 0x00, 0x00, 0x22, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x10, 0x00, 0xC2, 0x00, 0x0C, 0x40,
  0x00, 0x88, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00,
  0x06, 0x20, 0x01, 0x07, 0xFF, 0xE0, 0x80, 0x03, 0x10, 0x00, 0x32, 0x00,
  0x03, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00,
  0x0D, 0x00, 0x03, 0x20, 0x00, 0xC7, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x60,
  0x30, 0x08, 0x00, 0x81, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x02, 0x40,
  0x00, 0x14, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x02, 0x10,
  0x00, 0x40, 0x80, 0x08, 0x07, 0x03, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x10,
  0x01, 0x82, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04, 0x20, 0x03, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x07, 0xFF, 0xFE, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x18, 0x18, 0x01, 0x00, 0x30, 0x10, 0x00, 0xC1, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x3F, 0xF4, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x32, 0x00,
  0x01, 0x88, 0x00, 0x14, 0x20, 0x00, 0xA0, 0x80, 0x19, 0x03, 0x03, 0x88,
  0x07, 0xF0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x14, 0x00, 0x13, 0x00, 0x18, 0xC0,
  0x18, 0x38, 0x18, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80,
  0x00, 0x48, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x04, 0x08,
  0x00, 0x80, 0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x60, 0x08, 0x0C, 0x00,
  0x80, 0x80, 0x08, 0x10, 0x00, 0x83, 0x80, 0x08, 0x48, 0x00, 0x88, 0x40,
  0x09, 0x06, 0x00, 0xA0, 0x20, 0x0C, 0x01, 0x00, 0xC0, 0x18, 0x08, 0x00,
  0x80, 0x80, 0x04, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x28,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x05, 0xA0, 0x00, 0x5A, 0x00, 0x09, 0xA0, 0x00, 0x99, 0x00,
  0x09, 0x90, 0x01, 0x18, 0x80, 0x11, 0x88, 0x02, 0x18, 0x40, 0x21, 0x84,
  0x04, 0x18, 0x20, 0x41, 0x82, 0x08, 0x18, 0x10, 0x81, 0x81, 0x08, 0x18,
  0x09, 0x01, 0x80, 0x90, 0x18, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x80, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x19, 0x00, 0x06, 0x20, 0x01,
  0x88, 0x00, 0x61, 0x00, 0x18, 0x40, 0x06, 0x08, 0x01, 0x83, 0x00, 0x60,
  0x40, 0x18, 0x18, 0x06, 0x02, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x02,
  0x06, 0x00, 0x81, 0x80, 0x10, 0x60, 0x04, 0x18, 0x00, 0x86, 0x00, 0x21,
  0x80, 0x04, 0x60, 0x01, 0x18, 0x00, 0x26, 0x00, 0x09, 0x80, 0x01, 0x60,
  0x00, 0x58, 0x00, 0x0E, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x38, 0x18, 0x03,
  0x00, 0x20, 0x30, 0x00, 0x81, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x90, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x60, 0x01, 0x01, 0x80, 0x10, 0x07, 0x03, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFC, 0x10, 0x00, 0x62, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x24,
  0x00, 0x18, 0xFF, 0xFE, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x18, 0x03, 0x00, 0x20,
  0x30, 0x00, 0x81, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x90, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x02, 0x08, 0x00, 0x10, 0x60,
  0x01, 0x01, 0x80, 0x10, 0x07, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x62, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00,
  0x24, 0x00, 0x18, 0xFF, 0xFE, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x03, 0x01, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x60, 0x80, 0x04,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x14, 0x00, 0x03, 0x01, 0xFE, 0x00, 0x70, 0x0C, 0x06, 0x00,
  0x18, 0x40, 0x00, 0x62, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xA0, 0x00, 0x08,
  0x80, 0x00, 0xC3, 0x00, 0x0C, 0x0E, 0x01, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x62, 0x00, 0x30, 0x60, 0x38, 0x07,
  0xF8, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x90, 0x00,
  0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x10, 0x08,
  0x00, 0x40, 0x20, 0x01, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x09, 0x00, 0x00, 0x24, 0x03, 0x00,
  0x90, 0x0C, 0x02, 0x40, 0x50, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90,
  0x12, 0x04, 0x40, 0x88, 0x11, 0x02, 0x10, 0x44, 0x08, 0x41, 0x08, 0x41,
  0x04, 0x21, 0x02, 0x10, 0x84, 0x08, 0x42, 0x20, 0x21, 0x08, 0x80, 0x44,
  0x22, 0x01, 0x10, 0x98, 0x04, 0x82, 0x40, 0x12, 0x09, 0x00, 0x28, 0x24,
  0x00, 0xA0, 0x60, 0x02, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x20, 0x80, 0x00, 0xC0, 0x80, 0x01,
  0x01, 0x80, 0x04, 0x01, 0x00, 0x18, 0x01, 0x00, 0x20, 0x03, 0x00, 0x80,
  0x02, 0x03, 0x00, 0x02, 0x04, 0x00, 0x06, 0x10, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x58, 0x00, 0x01, 0x10, 0x00, 0x02, 0x10, 0x00, 0x08, 0x30, 0x00, 0x20,
  0x20, 0x00, 0x40, 0x20, 0x01, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x20, 0x00, 0xC0, 0x80, 0x00, 0x81, 0x00, 0x00, 0x84, 0x00, 0x01,
  0x90, 0x00, 0x01, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x42, 0x00, 0x00, 0x41, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x20, 0x10, 0x00, 0x20, 0x08, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x10, 0x00, 0x40, 0x10, 0x00, 0x10, 0x08, 0x00, 0x04, 0x08, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x24, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0xFF, 0xE0, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x02, 0x80, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x81,
  0x00, 0x08, 0x08, 0x00, 0x40, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x02,
  0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x48, 0x00, 0x01, 0x80, 0x00, 0x08, 0xFF, 0xFF, 0xFC, 0x81, 0x06, 0x08,
  0x10, 0x20, 0xC1, 0x07, 0xF0, 0x01, 0xC0, 0xC0, 0x30, 0x06, 0x06, 0x00,
  0x30, 0x40, 0x01, 0x08, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x0F, 0xFF, 0x83,
  0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08,
  0x80, 0x01, 0x88, 0x00, 0x18, 0x80, 0x02, 0x88, 0x00, 0x28, 0x40, 0x04,
  0x83, 0x01, 0x8F, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x7F, 0x02, 0x60, 0x70, 0xA0, 0x06, 0x30,
  0x00, 0xC8, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x13, 0x00, 0x0C, 0xA0, 0x06, 0x26, 0x07, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x03, 0x81, 0x81, 0x80, 0x10, 0xC0, 0x02, 0x20, 0x00,
  0x90, 0x00, 0x34, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x01, 0x20, 0x00,
  0x4C, 0x00, 0x21, 0x80, 0x10, 0x38, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0x04, 0x30,
  0x31, 0x10, 0x03, 0x48, 0x00, 0x54, 0x00, 0x0D, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0C, 0x80, 0x05, 0x10, 0x03,
  0x43, 0x03, 0x10, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x60, 0x18, 0x01,
  0x03, 0x00, 0x08, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x2F, 0xFF, 0xFE, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x26, 0x00, 0x02, 0x20, 0x00, 0x43, 0x00, 0x08,
  0x18, 0x01, 0x80, 0x60, 0x60, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x1F, 0x90, 0x01, 0x81,
  0xC0, 0x08, 0x01, 0x00, 0x40, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x10,
  0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20,
  0x00, 0x40, 0x40, 0x02, 0x01, 0x00, 0x08, 0x02, 0x00, 0x40, 0x06, 0x06,
  0x00, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xE0,
  0x01, 0x86, 0x00, 0x01, 0x10, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x40, 0x00, 0x11, 0x80, 0x00, 0x81,
  0x80, 0x1C, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x87, 0xF0, 0x98, 0x18, 0xA0, 0x04, 0xC0, 0x02, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x9F, 0xFF, 0x80, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x68, 0x00, 0x08, 0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x08, 0x08,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x08, 0x30, 0x00,
  0x87, 0x80, 0x08, 0x8C, 0x00, 0x90, 0x40, 0x0A, 0x02, 0x00, 0xC0, 0x10,
  0x08, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00,
  0x10, 0x80, 0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x8F, 0x83, 0xE4, 0x86,
  0x21, 0xA8, 0x1A, 0x07, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x87,
  0xF0, 0x98, 0x18, 0xA0, 0x04, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x03,
  0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x04, 0x18, 0x00, 0x42, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x22, 0x00,
  0x04, 0x60, 0x01, 0x06, 0x00, 0x40, 0x70, 0x30, 0x03, 0xF8, 0x00, 0x87,
  0xF0, 0x26, 0x07, 0x0A, 0x00, 0x63, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x30, 0x00,
  0xCA, 0x00, 0x62, 0x60, 0x70, 0x87, 0xF0, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x43, 0x03, 0x11, 0x00, 0x34, 0x80, 0x05, 0x40,
  0x00, 0xD0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0x40,
  0x00, 0xC8, 0x00, 0x51, 0x00, 0x34, 0x30, 0x31, 0x03, 0xF0, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0xFF, 0x87, 0xFC, 0x02, 0x60, 0x00, 0x0A,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xC0, 0x70, 0x10, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x64,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x26, 0x00, 0x02, 0x30, 0x00, 0x40, 0xE0, 0x38, 0x03,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x34, 0x00, 0x19, 0x00, 0x14, 0xC0, 0x1A, 0x30, 0x19, 0x07, 0xF0, 0x00,
  0x80, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x01, 0x00, 0x20,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x08, 0x00, 0x81, 0x00,
  0x10, 0x20, 0x02, 0x08, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x44, 0x02, 0x40, 0x44, 0x04, 0x40, 0x42, 0x04,
  0x40, 0x42, 0x04, 0x20, 0x82, 0x04, 0x20, 0x81, 0x04, 0x20, 0x81, 0x04,
  0x20, 0x81, 0x08, 0x21, 0x01, 0x08, 0x11, 0x00, 0x88, 0x11, 0x00, 0x88,
  0x12, 0x00, 0x88, 0x12, 0x00, 0x90, 0x12, 0x00, 0x50, 0x0A, 0x00, 0x50,
  0x0C, 0x00, 0x50, 0x0C, 0x00, 0x50, 0x0C, 0x00, 0x20, 0xC0, 0x00, 0x26,
  0x00, 0x04, 0x20, 0x00, 0xC1, 0x00, 0x08, 0x08, 0x01, 0x00, 0xC0, 0x20,
  0x04, 0x06, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00, 0x19, 0x00, 0x00, 0xB0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0B, 0x00, 0x01, 0x10, 0x00, 0x10,
  0x80, 0x02, 0x04, 0x00, 0x40, 0x60, 0x08, 0x02, 0x01, 0x80, 0x10, 0x10,
  0x00, 0x82, 0x00, 0x0C, 0x40, 0x00, 0x4C, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C,
  0x30, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x00, 0x80, 0x10, 0x08, 0x02,
  0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x40, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00,
  0xA0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x0F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x04, 0xC6, 0x00, 0x16, 0x04, 0x00,
  0x90, 0x08, 0x02, 0x80, 0x10, 0x0A, 0x00, 0x20, 0x48, 0x00, 0x42, 0x20,
  0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 3, 32, 28, 12, -32 },
  { 13, 7, 12, 28, 10, -34 },
  { 24, 26, 32, 28, 1, -32 },
  { 128, 21, 44, 28, 3, -38 },
  { 244, 25, 34, 28, 1, -33 },
  { 351, 23, 34, 28, 2, -33 },
  { 449, 1, 12, 28, 13, -34 },
  { 451, 10, 41, 28, 11, -35 },
  { 503, 11, 41, 28, 6, -35 },
  { 560, 23, 23, 28, 2, -25 },
  { 627, 22, 23, 28, 3, -26 },
  { 691, 4, 12, 28, 11, -4 },
  { 697, 12, 1, 28, 8, -15 },
  { 699, 3, 3, 28, 12, -3 },
  { 701, 18, 41, 28, 5, -35 },
  { 794, 21, 34, 28, 3, -33 },
  { 884, 21, 32, 28, 4, -32 },
  { 968, 20, 33, 28, 4, -33 },
  { 1051, 20, 34, 28, 3, -33 },
  { 1136, 23, 32, 28, 2, -32 },
  { 1228, 19, 33, 28, 4, -32 },
  { 1307, 20, 33, 28, 4, -32 },
  { 1390, 20, 32, 28, 4, -32 },
  { 1470, 21, 34, 28, 3, -33 },
  { 1560, 20, 33, 28, 4, -33 },
  { 1643, 3, 24, 28, 12, -24 },
  { 1652, 4, 32, 28, 11, -24 },
  { 1668, 20, 25, 28, 4, -27 },
  { 1731, 22, 10, 28, 3, -19 },
  { 1759, 20, 25, 28, 4, -27 },
  { 1822, 18, 33, 28, 5, -33 },
  { 1897, 19, 38, 28, 4, -33 },
  { 1988, 23, 32, 28, 2, -32 },
  { 2080, 19, 32, 28, 5, -32 },
  { 2156, 20, 34, 28, 4, -33 },
  { 2241, 19, 32, 28, 5, -32 },
  { 2317, 19, 32, 28, 5, -32 },
  { 2393, 19, 32, 28, 5, -32 },
  { 2469, 21, 34, 28, 3, -33 },
  { 2559, 18, 32, 28, 5, -32 },
  { 2631, 19, 32, 28, 4, -32 },
  { 2707, 17, 33, 28, 4, -32 },
  { 2778, 20, 32, 28, 5, -32 },
  { 2858, 17, 32, 28, 7, -32 },
  { 2926, 20, 32, 28, 4, -32 },
  { 3006, 18, 32, 28, 5, -32 },
  { 3078, 21, 34, 28, 3, -33 },
  { 3168, 19, 32, 28, 5, -32 },
  { 3244, 21, 40, 28, 3, -33 },
  { 3349, 19, 32, 28, 5, -32 },
  { 3425, 21, 34, 28, 3, -33 },
  { 3515, 24, 32, 28, 2, -32 },
  { 3611, 18, 33, 28, 5, -32 },
  { 3686, 22, 32, 28, 3, -32 },
  { 3774, 22, 32, 28, 3, -32 },
  { 3862, 23, 32, 28, 2, -32 },
  { 3954, 25, 32, 28, 1, -32 },
  { 4054, 23, 32, 28, 2, -32 },
  { 4146, 11, 41, 28, 12, -35 },
  { 4203, 18, 41, 28, 5, -35 },
  { 4296, 11, 41, 28, 4, -35 },
  { 4353, 21, 17, 28, 3, -32 },
  { 4398, 22, 1, 28, 3, 6 },
  { 4401, 6, 8, 28, 9, -35 },
  { 4407, 20, 25, 28, 4, -24 },
  { 4470, 18, 35, 28, 6, -34 },
  { 4549, 18, 25, 28, 5, -24 },
  { 4606, 18, 35, 28, 4, -34 },
  { 4685, 20, 25, 28, 4, -24 },
  { 4748, 21, 34, 28, 4, -34 },
  { 4838, 22, 36, 28, 4, -26 },
  { 4937, 16, 34, 28, 6, -34 },
  { 5005, 20, 34, 28, 5, -34 },
  { 5090, 17, 43, 28, 4, -34 },
  { 5182, 20, 34, 28, 6, -34 },
  { 5267, 19, 34, 28, 4, -34 },
  { 5348, 21, 24, 28, 3, -24 },
  { 5411, 16, 24, 28, 6, -24 },
  { 5459, 19, 25, 28, 4, -24 },
  { 5519, 18, 33, 28, 6, -24 },
  { 5594, 18, 33, 28, 4, -24 },
  { 5669, 22, 24, 28, 4, -24 },
  { 5735, 20, 25, 28, 4, -24 },
  { 5798, 22, 32, 28, 2, -32 },
  { 5886, 17, 25, 28, 5, -24 },
  { 5940, 19, 24, 28, 4, -24 },
  { 5997, 24, 24, 28, 2, -24 },
  { 6069, 20, 24, 28, 4, -24 },
  { 6129, 20, 33, 28, 4, -24 },
  { 6212, 18, 24, 28, 5, -24 },
  { 6266, 17, 41, 28, 5, -35 },
  { 6354, 1, 41, 28, 13, -35 },
  { 6360, 17, 41, 28, 5, -35 },
  { 6448, 22, 8, 28, 3, -18 },
};

const GFXfont IBMPlexMono_Thin46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_THIN46PT7B_H_
