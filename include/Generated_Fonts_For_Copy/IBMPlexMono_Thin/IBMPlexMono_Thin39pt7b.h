#ifndef _IBMPLEXMONO_THIN39PT7B_H_
#define _IBMPLEXMONO_THIN39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x00, 0x1F, 0x80,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x00, 0x40, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x10, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0x82, 0x01, 0xFC, 0x0F, 0xF0,
  0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x03, 0xF8, 0x1F, 0xC0, 0x20, 0x40,
  0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x06, 0x23,
  0x82, 0x08, 0x31, 0x02, 0x02, 0x80, 0x80, 0xA0, 0x20, 0x08, 0x08, 0x02,
  0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x06, 0x08, 0x00, 0xC2, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x08, 0x60, 0x02, 0x04, 0x00, 0x80, 0x80, 0x20,
  0x20, 0x08, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x28, 0x08, 0x09,
  0x02, 0x02, 0x20, 0x81, 0x06, 0x21, 0x80, 0x7F, 0x80, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x09, 0x86, 0x00, 0x90,
  0x10, 0x04, 0x80, 0x40, 0x48, 0x02, 0x02, 0x40, 0x10, 0x22, 0x00, 0x82,
  0x10, 0x04, 0x10, 0x80, 0x21, 0x02, 0x01, 0x08, 0x10, 0x10, 0x80, 0x61,
  0x88, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x21, 0x04,
  0x02, 0x10, 0x10, 0x10, 0x80, 0x41, 0x08, 0x02, 0x10, 0x40, 0x10, 0x82,
  0x00, 0x88, 0x10, 0x04, 0x40, 0x80, 0x24, 0x02, 0x01, 0x40, 0x10, 0x12,
  0x00, 0x41, 0x20, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0x82, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00,
  0x26, 0x03, 0xC8, 0x40, 0x42, 0x04, 0x08, 0x80, 0x41, 0x10, 0x04, 0x22,
  0x00, 0x44, 0x40, 0x05, 0x08, 0x00, 0xE1, 0x00, 0x0C, 0x20, 0x00, 0x84,
  0x00, 0x28, 0x40, 0x08, 0x86, 0x06, 0x08, 0x3F, 0x00, 0x80, 0xFF, 0xC0,
  0x00, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x60, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x30, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x0C, 0x04, 0x07, 0x38, 0x43, 0x80, 0x75, 0xC0, 0x00, 0xE0, 0x00,
  0x0A, 0x00, 0x00, 0x90, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x40, 0x40,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x01, 0x80, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x32, 0x26, 0x44, 0x48, 0x88, 0xFF,
  0xC0, 0xFC, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x03,
  0x01, 0x00, 0x60, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x44, 0x00, 0x10,
  0x80, 0x0C, 0x10, 0x06, 0x03, 0x03, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x34, 0x00, 0x11, 0x00, 0x18, 0x40, 0x0C, 0x10, 0x06, 0x04,
  0x03, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x07, 0xFF, 0xFC, 0x07, 0xF0,
  0x0C, 0x0E, 0x0C, 0x01, 0x04, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x18, 0x18,
  0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x0F, 0xE0, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x02, 0x60, 0x04, 0x18, 0x18,
  0x07, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x09, 0x00,
  0x01, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00,
  0x20, 0x40, 0x08, 0x08, 0x01, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x40,
  0x01, 0x0F, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0xFE, 0x04, 0x80, 0xC2, 0x80,
  0x11, 0x80, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x06, 0x20, 0x06,
  0x0C, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x7E, 0x04, 0xC0, 0xC3, 0x80, 0x12, 0x80,
  0x05, 0x80, 0x02, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x40, 0x02, 0x30, 0x02, 0x0E, 0x06,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xF0, 0x06, 0x03, 0x02, 0x00, 0x21, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x42,
  0x00, 0x20, 0x60, 0x30, 0x07, 0xF0, 0x07, 0x03, 0x02, 0x00, 0x31, 0x00,
  0x04, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x28, 0x00, 0x09, 0x00, 0x04, 0x20, 0x03, 0x06, 0x03, 0x80,
  0x7F, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x40, 0x03, 0x60, 0x05, 0x18, 0x1A, 0x0F, 0xE2, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x22, 0x64, 0x44, 0x88, 0x80, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x30, 0x80,
  0x12, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x01, 0x80, 0x3C, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x07, 0xE0,
  0x30, 0x60, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0xF3, 0x06, 0x1E, 0x08, 0x0C, 0x20, 0x18, 0x40, 0x30, 0x80,
  0x61, 0x00, 0xC2, 0x01, 0x84, 0x03, 0x08, 0x06, 0x10, 0x0C, 0x20, 0x18,
  0x40, 0x30, 0x40, 0xE0, 0x7E, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x10, 0x10, 0x02,
  0x02, 0x00, 0x40, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x08, 0x10,
  0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0xFF, 0xE0, 0x80, 0x18, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x18, 0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x0C, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0x06,
  0x06, 0x00, 0x84, 0x00, 0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x18,
  0x02, 0x06, 0x06, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x40, 0x1C, 0x20, 0x03,
  0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x12, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x80, 0x0C, 0x40,
  0x1C, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84, 0x00,
  0x22, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x04, 0x80, 0x06, 0x40, 0x03, 0x10, 0x02, 0x86, 0x06, 0x40,
  0xFC, 0x20, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0x3F, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x40, 0x18, 0xC0, 0xC0,
  0xFC, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x88, 0x00,
  0x84, 0x00, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20,
  0x40, 0x10, 0x40, 0x08, 0x50, 0x04, 0x48, 0x02, 0x42, 0x01, 0x40, 0x80,
  0xC0, 0x40, 0x40, 0x10, 0x20, 0x04, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x20,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x03, 0xFF, 0xF8, 0xC0, 0x00, 0xE0, 0x00, 0xE8, 0x00, 0x74, 0x00, 0x59,
  0x00, 0x2C, 0x80, 0x26, 0x20, 0x13, 0x10, 0x11, 0x88, 0x08, 0xC2, 0x08,
  0x61, 0x04, 0x30, 0x44, 0x18, 0x22, 0x0C, 0x09, 0x06, 0x05, 0x03, 0x01,
  0x81, 0x80, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xA0, 0x01, 0xA0, 0x01, 0x90,
  0x01, 0x90, 0x01, 0x88, 0x01, 0x84, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82,
  0x01, 0x81, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0x81, 0x80, 0x41, 0x80,
  0x41, 0x80, 0x21, 0x80, 0x21, 0x80, 0x11, 0x80, 0x11, 0x80, 0x09, 0x80,
  0x09, 0x80, 0x05, 0x80, 0x05, 0x80, 0x03, 0x03, 0xF0, 0x03, 0x03, 0x01,
  0x00, 0x60, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x44, 0x00, 0x10, 0x80,
  0x0C, 0x10, 0x06, 0x03, 0x03, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x40, 0x06,
  0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x01, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24,
  0x00, 0x63, 0xFF, 0xE1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00,
  0x60, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x44, 0x00, 0x10, 0x80, 0x0C,
  0x10, 0x06, 0x03, 0x03, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0xFC, 0xFF, 0xF8, 0x40, 0x06, 0x20, 0x00,
  0x90, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x63,
  0xFF, 0xE1, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x08, 0x10, 0x04,
  0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x40,
  0x01, 0x20, 0x00, 0x40, 0x07, 0xF0, 0x06, 0x03, 0x82, 0x00, 0x31, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x28, 0x00, 0x09, 0x00, 0x02, 0x20, 0x01,
  0x06, 0x03, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40,
  0x06, 0x60, 0x04, 0x30, 0x18, 0x0F, 0xE0, 0x80, 0x00, 0x28, 0x00, 0x05,
  0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x20,
  0x80, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x20, 0x04, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x01, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00,
  0x41, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x14, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x40, 0x48, 0x0C, 0x09,
  0x02, 0x81, 0x20, 0x50, 0x24, 0x09, 0x04, 0x82, 0x20, 0x88, 0x44, 0x11,
  0x08, 0x82, 0x21, 0x08, 0x44, 0x41, 0x10, 0x88, 0x22, 0x11, 0x02, 0x42,
  0x40, 0x48, 0x48, 0x09, 0x09, 0x00, 0xA1, 0x40, 0x14, 0x28, 0x02, 0x83,
  0x00, 0x50, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x08, 0x80, 0x02,
  0x08, 0x00, 0x41, 0x00, 0x10, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x20,
  0x02, 0x08, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x50, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x41, 0x00,
  0x08, 0x10, 0x02, 0x02, 0x00, 0x80, 0x20, 0x10, 0x02, 0x04, 0x00, 0x41,
  0x00, 0x04, 0x20, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x41, 0x00, 0x04, 0x04,
  0x00, 0x20, 0x20, 0x02, 0x00, 0x80, 0x10, 0x06, 0x01, 0x00, 0x10, 0x10,
  0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x08, 0x80, 0x00, 0x24, 0x00, 0x01,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F,
  0xFC, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0xFF, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xE0, 0x00,
  0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x08, 0x80, 0x04, 0x10, 0x01, 0x04,
  0x00, 0x80, 0x80, 0x20, 0x10, 0x10, 0x04, 0x08, 0x00, 0x82, 0x00, 0x21,
  0x00, 0x04, 0x40, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0C, 0xFF, 0xFF, 0xE0,
  0x82, 0x08, 0x41, 0x04, 0x0F, 0xE0, 0x0C, 0x04, 0x04, 0x00, 0x81, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x03, 0xFF, 0x03, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x10, 0x03, 0x03, 0x03, 0x40, 0x7F,
  0x0F, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x1F, 0x82, 0xC0, 0xC6, 0x00, 0x4C,
  0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x05,
  0x00, 0x0B, 0x00, 0x25, 0x81, 0x88, 0xFC, 0x00, 0x07, 0xE0, 0x0C, 0x18,
  0x30, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x01, 0x20, 0x02, 0x30, 0x04, 0x0C, 0x18, 0x03, 0xE0,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x07, 0xE1, 0x18, 0x19, 0x30, 0x05,
  0x20, 0x03, 0x40, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x03, 0x20, 0x03, 0x30, 0x05, 0x18, 0x19, 0x07, 0xE1, 0x07, 0xE0,
  0x18, 0x18, 0x20, 0x04, 0x40, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x40, 0x02, 0x20, 0x04, 0x18, 0x18,
  0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x02,
  0x00, 0x7E, 0x80, 0x60, 0x60, 0x20, 0x0C, 0x08, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x40, 0x80, 0x10, 0x30,
  0x08, 0x06, 0x04, 0x00, 0x7E, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFC, 0x18, 0x00, 0xCC, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0B, 0x00, 0x04, 0x60,
  0x06, 0x07, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x3F, 0x09, 0x03, 0x38,
  0x06, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x1F, 0xFF, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x01, 0xA0, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x03, 0x02,
  0x02, 0x01, 0x02, 0x00, 0x82, 0x00, 0x43, 0x00, 0x22, 0x40, 0x12, 0x10,
  0x0E, 0x04, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0x40,
  0x02, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x18, 0xFF, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x9E, 0x1F, 0x28, 0x48, 0x6C, 0x0C,
  0x0A, 0x02, 0x02, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01,
  0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60,
  0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08,
  0x06, 0x02, 0x01, 0x8F, 0xC2, 0x40, 0xCE, 0x01, 0xA0, 0x02, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x0C, 0x40, 0x04, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x04,
  0x20, 0x0C, 0x18, 0x18, 0x07, 0xE0, 0x8F, 0xC1, 0x60, 0x63, 0x00, 0x26,
  0x00, 0x28, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x02,
  0x80, 0x05, 0x80, 0x12, 0xC0, 0xC4, 0x7E, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xE1, 0x18, 0x19, 0x30, 0x05, 0x20, 0x03, 0x40, 0x03, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x03, 0x20, 0x03, 0x30, 0x05, 0x18,
  0x19, 0x07, 0xE1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x26, 0x00,
  0x05, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x30, 0x18, 0x40,
  0x06, 0x40, 0x02, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x40, 0x02, 0x38, 0x0C, 0x07, 0xF0, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0xFF, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1A, 0x00, 0xCC, 0x1A, 0x3F,
  0x10, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20,
  0x04, 0x20, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10, 0x10, 0x10, 0x08,
  0x20, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x02, 0x80, 0x01, 0x00, 0x80, 0x20, 0x0A, 0x02, 0x80, 0x50, 0x14,
  0x04, 0x80, 0xA0, 0x24, 0x04, 0x81, 0x20, 0x44, 0x08, 0x82, 0x20, 0x44,
  0x11, 0x02, 0x20, 0x84, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08,
  0x41, 0x10, 0x22, 0x09, 0x01, 0x20, 0x48, 0x09, 0x02, 0x40, 0x48, 0x12,
  0x01, 0x40, 0x60, 0x0A, 0x03, 0x00, 0x60, 0x18, 0x01, 0x00, 0x40, 0x01,
  0x90, 0x00, 0x8C, 0x00, 0x82, 0x00, 0x80, 0x80, 0x80, 0x20, 0x40, 0x08,
  0x40, 0x04, 0x40, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00,
  0x22, 0x00, 0x20, 0x80, 0x10, 0x20, 0x10, 0x10, 0x10, 0x04, 0x10, 0x01,
  0x08, 0x00, 0x58, 0x00, 0x10, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x40, 0x10, 0x20, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x00, 0x82, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08,
  0x80, 0x02, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x03,
  0x03, 0xF0, 0x00, 0x70, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x06, 0x00, 0x07, 0xF0, 0x78, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x26, 0x20, 0x04, 0x82, 0x00, 0xA0,
  0x20, 0x24, 0x02, 0x05, 0x00, 0x31, 0x20, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 27, 23, 10, -27 },
  { 12, 6, 10, 23, 9, -29 },
  { 20, 22, 27, 23, 1, -27 },
  { 95, 18, 35, 23, 3, -31 },
  { 174, 21, 27, 23, 1, -27 },
  { 245, 19, 27, 23, 2, -27 },
  { 310, 1, 10, 23, 11, -29 },
  { 312, 9, 35, 23, 9, -30 },
  { 352, 9, 35, 23, 5, -30 },
  { 392, 20, 19, 23, 2, -21 },
  { 440, 19, 19, 23, 2, -21 },
  { 486, 4, 10, 23, 9, -3 },
  { 491, 10, 1, 23, 7, -12 },
  { 493, 3, 2, 23, 10, -2 },
  { 494, 15, 35, 23, 4, -30 },
  { 560, 18, 27, 23, 3, -27 },
  { 621, 18, 27, 23, 3, -27 },
  { 682, 17, 27, 23, 3, -27 },
  { 740, 16, 27, 23, 3, -27 },
  { 794, 19, 27, 23, 2, -27 },
  { 859, 17, 27, 23, 3, -27 },
  { 917, 17, 27, 23, 3, -27 },
  { 975, 17, 27, 23, 3, -27 },
  { 1033, 18, 27, 23, 3, -27 },
  { 1094, 16, 27, 23, 4, -27 },
  { 1148, 3, 20, 23, 10, -20 },
  { 1156, 4, 27, 23, 9, -20 },
  { 1170, 17, 21, 23, 3, -22 },
  { 1215, 19, 8, 23, 2, -16 },
  { 1234, 17, 21, 23, 3, -22 },
  { 1279, 15, 27, 23, 4, -27 },
  { 1330, 15, 31, 23, 4, -27 },
  { 1389, 19, 27, 23, 2, -27 },
  { 1454, 16, 27, 23, 4, -27 },
  { 1508, 17, 27, 23, 3, -27 },
  { 1566, 17, 27, 23, 4, -27 },
  { 1624, 16, 27, 23, 4, -27 },
  { 1678, 16, 27, 23, 4, -27 },
  { 1732, 17, 27, 23, 3, -27 },
  { 1790, 16, 27, 23, 4, -27 },
  { 1844, 16, 27, 23, 4, -27 },
  { 1898, 14, 27, 23, 4, -27 },
  { 1946, 17, 27, 23, 4, -27 },
  { 2004, 15, 27, 23, 6, -27 },
  { 2055, 17, 27, 23, 3, -27 },
  { 2113, 16, 27, 23, 4, -27 },
  { 2167, 18, 27, 23, 3, -27 },
  { 2228, 17, 27, 23, 4, -27 },
  { 2286, 18, 32, 23, 3, -27 },
  { 2358, 17, 27, 23, 4, -27 },
  { 2416, 18, 27, 23, 3, -27 },
  { 2477, 20, 27, 23, 2, -27 },
  { 2545, 16, 27, 23, 4, -27 },
  { 2599, 19, 27, 23, 2, -27 },
  { 2664, 19, 27, 23, 2, -27 },
  { 2729, 19, 27, 23, 2, -27 },
  { 2794, 21, 27, 23, 1, -27 },
  { 2865, 20, 27, 23, 2, -27 },
  { 2933, 10, 35, 23, 10, -30 },
  { 2977, 15, 35, 23, 4, -30 },
  { 3043, 9, 35, 23, 4, -30 },
  { 3083, 18, 15, 23, 3, -27 },
  { 3117, 19, 1, 23, 2, 5 },
  { 3120, 5, 6, 23, 8, -29 },
  { 3124, 18, 20, 23, 3, -20 },
  { 3169, 15, 29, 23, 5, -29 },
  { 3224, 16, 20, 23, 4, -20 },
  { 3264, 16, 29, 23, 3, -29 },
  { 3322, 16, 20, 23, 4, -20 },
  { 3362, 18, 29, 23, 3, -29 },
  { 3428, 18, 30, 23, 4, -22 },
  { 3496, 14, 29, 23, 5, -29 },
  { 3547, 16, 29, 23, 5, -29 },
  { 3605, 13, 37, 23, 4, -29 },
  { 3666, 17, 29, 23, 5, -29 },
  { 3728, 16, 29, 23, 4, -29 },
  { 3786, 18, 20, 23, 3, -20 },
  { 3831, 14, 20, 23, 5, -20 },
  { 3866, 16, 20, 23, 4, -20 },
  { 3906, 15, 28, 23, 5, -20 },
  { 3959, 16, 28, 23, 3, -20 },
  { 4015, 19, 20, 23, 3, -20 },
  { 4063, 16, 20, 23, 4, -20 },
  { 4103, 19, 27, 23, 1, -27 },
  { 4168, 13, 20, 23, 5, -20 },
  { 4201, 16, 20, 23, 4, -20 },
  { 4241, 21, 20, 23, 1, -20 },
  { 4294, 17, 20, 23, 3, -20 },
  { 4337, 17, 28, 23, 3, -20 },
  { 4397, 15, 20, 23, 4, -20 },
  { 4435, 14, 35, 23, 5, -30 },
  { 4497, 1, 35, 23, 11, -30 },
  { 4502, 14, 35, 23, 5, -30 },
  { 4564, 19, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_Thin39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_THIN39PT7B_H_
