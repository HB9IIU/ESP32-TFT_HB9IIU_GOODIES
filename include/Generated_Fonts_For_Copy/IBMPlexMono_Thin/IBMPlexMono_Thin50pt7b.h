#ifndef _IBMPLEXMONO_THIN50PT7B_H_
#define _IBMPLEXMONO_THIN50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0x64, 0x44, 0x44,
  0x44, 0x44, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10,
  0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x10, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02,
  0x01, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x02, 0x01, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x04,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x08, 0x04, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x08, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x10, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xF0, 0x01, 0xC2, 0x38, 0x04, 0x04, 0x0C, 0x10, 0x08,
  0x0C, 0x40, 0x10, 0x0C, 0x80, 0x20, 0x12, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x10, 0x00, 0x80, 0x20, 0x00, 0x80, 0x40, 0x00, 0x80, 0x80, 0x00,
  0xE1, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0xE0, 0x00,
  0x10, 0x30, 0x00, 0x20, 0x30, 0x00, 0x40, 0x20, 0x00, 0x80, 0x60, 0x01,
  0x00, 0x40, 0x02, 0x00, 0x80, 0x04, 0x01, 0x00, 0x08, 0x02, 0x00, 0x10,
  0x04, 0x00, 0x20, 0x08, 0x00, 0x40, 0x1C, 0x00, 0x80, 0x6C, 0x01, 0x00,
  0x8C, 0x02, 0x02, 0x0C, 0x04, 0x08, 0x07, 0x08, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x03, 0x30, 0x08,
  0x00, 0x22, 0x00, 0xC0, 0x04, 0x40, 0x04, 0x00, 0xC4, 0x00, 0x40, 0x08,
  0x40, 0x04, 0x01, 0x04, 0x00, 0x60, 0x10, 0x40, 0x06, 0x02, 0x04, 0x00,
  0x60, 0x60, 0x40, 0x04, 0x04, 0x04, 0x00, 0x40, 0x80, 0x40, 0x04, 0x08,
  0x02, 0x00, 0xC1, 0x00, 0x30, 0x08, 0x30, 0x01, 0x83, 0x02, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0xC0,
  0x08, 0x30, 0x04, 0x01, 0x02, 0x00, 0x20, 0x10, 0x20, 0x02, 0x02, 0x02,
  0x00, 0x20, 0x60, 0x60, 0x02, 0x04, 0x06, 0x00, 0x20, 0x80, 0x60, 0x02,
  0x08, 0x02, 0x00, 0x21, 0x00, 0x20, 0x02, 0x30, 0x02, 0x00, 0x22, 0x00,
  0x30, 0x04, 0x40, 0x01, 0x00, 0xC4, 0x00, 0x0C, 0x18, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x20, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x06, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x40, 0x00, 0x03, 0x10, 0x03,
  0xE2, 0x04, 0x01, 0x03, 0x03, 0x00, 0x81, 0x00, 0xC0, 0x41, 0x00, 0x20,
  0x20, 0x80, 0x08, 0x10, 0xC0, 0x02, 0x08, 0x40, 0x00, 0x88, 0x20, 0x00,
  0x64, 0x10, 0x00, 0x1A, 0x08, 0x00, 0x05, 0x04, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0xD0, 0x40, 0x00, 0x44, 0x10, 0x00, 0x41, 0x04,
  0x00, 0x40, 0xC1, 0x80, 0xC0, 0x30, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x06, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x71, 0xC0, 0xC0, 0xE0, 0x0E, 0x31, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00,
  0x20, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x20, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x18, 0xC6, 0x63, 0x18, 0x84, 0x62,
  0x10, 0x8C, 0x00, 0xFF, 0xFC, 0x6F, 0x60, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x02, 0x40, 0x00,
  0x0B, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x40, 0x00, 0x09, 0x00, 0x00, 0x26, 0x00,
  0x01, 0x88, 0x00, 0x04, 0x30, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0, 0x0C,
  0x01, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x68, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0x88, 0x00, 0x03, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x18, 0x08, 0x00, 0x30, 0x08, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x0C, 0x04,
  0x00, 0x18, 0x20, 0x00, 0x21, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x1C, 0x06, 0x00,
  0xC0, 0x04, 0x04, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x90, 0x00, 0x06, 0xC0, 0x00,
  0x10, 0x80, 0x00, 0x81, 0x80, 0x04, 0x03, 0x80, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x01, 0x10, 0x00, 0x00, 0x44, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x04, 0x00, 0x01, 0x01, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x20, 0x10, 0x00, 0x10, 0x04, 0x00, 0x08, 0x01,
  0x00, 0x02, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x01, 0x00, 0x10, 0x00, 0x40, 0x08, 0x00, 0x10, 0x06, 0x00, 0x04, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x10, 0x10, 0x00, 0x04,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x87, 0xF8, 0x04, 0xC0, 0x70,
  0x28, 0x00, 0x41, 0x80, 0x01, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x48, 0x00, 0x06, 0x20, 0x00, 0x60, 0x80, 0x06, 0x03,
  0x80, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x1F, 0xE0, 0x19, 0xC0,
  0xE0, 0x48, 0x00, 0xC1, 0x40, 0x00, 0x86, 0x00, 0x01, 0x18, 0x00, 0x04,
  0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00,
  0x09, 0x00, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10, 0x00, 0x20,
  0x30, 0x03, 0x00, 0x70, 0x38, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x12, 0x00, 0x00,
  0xC8, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x18, 0x06, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x11, 0x80,
  0x00, 0x64, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00, 0x43,
  0x00, 0x03, 0x06, 0x00, 0x18, 0x06, 0x01, 0x80, 0x07, 0xF8, 0x00, 0xE0,
  0x1C, 0x06, 0x00, 0x18, 0x20, 0x00, 0x11, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0xA0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x50, 0x00,
  0x02, 0x40, 0x00, 0x08, 0x80, 0x00, 0x41, 0x80, 0x06, 0x03, 0x80, 0x70,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x38, 0x06, 0x00, 0x20, 0x40,
  0x00, 0x86, 0x00, 0x02, 0x20, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x40, 0x00, 0x33,
  0x00, 0x01, 0x88, 0x00, 0x14, 0x30, 0x01, 0x20, 0xE0, 0x31, 0x00, 0xFE,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0xF6, 0x18, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x18, 0xC3, 0x0C,
  0x20, 0x86, 0x10, 0x41, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x30, 0x18,
  0x00, 0x82, 0x00, 0x04, 0x60, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xF8, 0x00, 0x60, 0x60, 0x08, 0x01, 0x81, 0x00, 0x08, 0x20, 0x00,
  0x42, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x80, 0x00, 0x38, 0x03, 0xF1, 0x80, 0x60, 0x98, 0x08, 0x05, 0x81,
  0x00, 0x38, 0x10, 0x03, 0x81, 0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x18,
  0x20, 0x01, 0x82, 0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x18, 0x20, 0x01,
  0x82, 0x00, 0x18, 0x30, 0x01, 0x81, 0x00, 0x38, 0x10, 0x03, 0x80, 0x80,
  0x58, 0x0C, 0x0D, 0x80, 0x3F, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x83, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x81, 0x00, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x08, 0x00, 0x10, 0x08, 0x00,
  0x10, 0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x18, 0x20, 0x00, 0x21,
  0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00,
  0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48,
  0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80, 0x03,
  0x07, 0xFF, 0xF0, 0x20, 0x00, 0x61, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00,
  0x00, 0x50, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x0E, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x0E, 0x07, 0x00, 0x60, 0x06, 0x02, 0x00, 0x04, 0x10,
  0x00, 0x18, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x58, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x4C, 0x00, 0x02, 0x10, 0x00, 0x18, 0x20, 0x00, 0x40, 0x60, 0x06,
  0x00, 0xE0, 0x70, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x06, 0x00, 0x38, 0x30,
  0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00,
  0xD8, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00,
  0x13, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x38, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xB0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xB0, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x06, 0x00,
  0xC0, 0x04, 0x06, 0x00, 0x08, 0x10, 0x00, 0x10, 0x80, 0x00, 0x62, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x50, 0x00, 0x03, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x05, 0x10, 0x00,
  0x14, 0x60, 0x00, 0x90, 0xC0, 0x04, 0x40, 0xC0, 0x61, 0x00, 0xFE, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0B, 0x00, 0x02, 0x40, 0x01, 0x0C, 0x00,
  0x81, 0xC0, 0xC0, 0x1F, 0xC0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00,
  0x01, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x43, 0x00, 0x02, 0x0C, 0x00, 0x10,
  0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0xC0, 0x20, 0x03, 0x01, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60,
  0x00, 0xC2, 0x40, 0x03, 0x19, 0x80, 0x0C, 0xC2, 0x00, 0x36, 0x04, 0x00,
  0xF0, 0x18, 0x03, 0x80, 0x20, 0x0C, 0x00, 0x40, 0x30, 0x01, 0x80, 0xC0,
  0x02, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00,
  0x43, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7A,
  0x00, 0x01, 0x68, 0x00, 0x05, 0x90, 0x00, 0x26, 0x40, 0x00, 0x98, 0x80,
  0x06, 0x62, 0x00, 0x11, 0x84, 0x00, 0xC6, 0x10, 0x02, 0x18, 0x40, 0x08,
  0x60, 0x80, 0x41, 0x82, 0x01, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60,
  0x21, 0x01, 0x80, 0x84, 0x06, 0x01, 0x30, 0x18, 0x04, 0x80, 0x60, 0x12,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xA0, 0x00, 0x1A, 0x00, 0x01, 0x90, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00,
  0x18, 0x80, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00, 0x18, 0x20,
  0x01, 0x81, 0x00, 0x18, 0x18, 0x01, 0x80, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x18, 0x03, 0x01, 0x80, 0x10, 0x18,
  0x01, 0x81, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x04, 0x18, 0x00, 0x21,
  0x80, 0x02, 0x18, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x09, 0x80, 0x00,
  0x98, 0x00, 0x05, 0x80, 0x00, 0x58, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0xFC, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x02, 0x40, 0x00, 0x0B,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x40, 0x00, 0x09, 0x00, 0x00, 0x26, 0x00, 0x01,
  0x88, 0x00, 0x04, 0x30, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01,
  0xC0, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x06, 0x00, 0x0E, 0x30, 0x00,
  0x19, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x58, 0x00, 0x06, 0xC0,
  0x00, 0x66, 0x00, 0x06, 0x3F, 0xFF, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x02, 0x40,
  0x00, 0x0B, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x40, 0x00, 0x09, 0x00, 0x00, 0x26,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x30, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0,
  0x0C, 0x01, 0xC0, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0x06, 0x00, 0x0E, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00,
  0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x58, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x3F,
  0xFF, 0xC1, 0x80, 0x40, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x20,
  0x18, 0x01, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x80,
  0x02, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x0C,
  0xC0, 0x00, 0x26, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x00, 0xFF, 0x00, 0x0E,
  0x01, 0xC0, 0x20, 0x00, 0x60, 0x80, 0x00, 0x62, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x04, 0x60, 0x00, 0x10, 0x60, 0x00,
  0x40, 0x38, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x43,
  0x00, 0x0C, 0x0C, 0x03, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00,
  0x10, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x81,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x02, 0x40, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x20, 0x24, 0x06, 0x20, 0x42, 0x04, 0x20, 0x42,
  0x04, 0x20, 0x42, 0x04, 0x20, 0xC3, 0x04, 0x20, 0x81, 0x04, 0x20, 0x81,
  0x04, 0x20, 0x81, 0x04, 0x21, 0x00, 0x84, 0x21, 0x00, 0x84, 0x21, 0x00,
  0x84, 0x12, 0x00, 0x48, 0x12, 0x00, 0x48, 0x12, 0x00, 0x48, 0x16, 0x00,
  0x68, 0x14, 0x00, 0x28, 0x14, 0x00, 0x28, 0x14, 0x00, 0x28, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x18, 0x08, 0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0x60, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0x60, 0x08, 0x00, 0x08, 0x04,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x40, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x04, 0x08, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x40,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x08, 0x02,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x08, 0x20, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00, 0x20, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x01, 0x00, 0x08, 0x00, 0x08, 0x01,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x00,
  0x80, 0x03, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0C, 0x00,
  0x20, 0x08, 0x00, 0x10, 0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x81, 0x81, 0x01, 0x01, 0x03, 0x03, 0xF8, 0x00, 0x1C,
  0x0C, 0x00, 0x40, 0x04, 0x01, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x08, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xF8,
  0x06, 0x00, 0x10, 0x30, 0x00, 0x20, 0x40, 0x00, 0x41, 0x00, 0x00, 0x82,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x30, 0x20, 0x00, 0xA0, 0x60, 0x02, 0x40, 0x70, 0x18, 0x7C, 0x1F,
  0xC0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x3F, 0x80, 0x8C, 0x06, 0x09, 0x00,
  0x10, 0xA0, 0x00, 0x8C, 0x00, 0x04, 0xC0, 0x00, 0x68, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0xC0, 0x00,
  0x6C, 0x00, 0x04, 0xA0, 0x00, 0x89, 0x00, 0x10, 0x8C, 0x06, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x70, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0x06, 0x30,
  0x00, 0x22, 0x00, 0x01, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x01, 0x30, 0x00, 0x21, 0x80,
  0x06, 0x0C, 0x00, 0xC0, 0x70, 0x38, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x1F, 0xC1, 0x06, 0x03, 0x10, 0x80, 0x09, 0x10, 0x00, 0x52, 0x00,
  0x03, 0x60, 0x00, 0x34, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x32, 0x00, 0x03, 0x10, 0x00,
  0x50, 0x80, 0x09, 0x06, 0x03, 0x10, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x70,
  0x38, 0x06, 0x00, 0x60, 0x60, 0x00, 0x82, 0x00, 0x06, 0x20, 0x00, 0x11,
  0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x05, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x24, 0x00, 0x01, 0x20, 0x00, 0x10, 0x80, 0x00, 0x86, 0x00, 0x08, 0x18,
  0x01, 0x80, 0x70, 0x18, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x40,
  0x00, 0xFE, 0x40, 0x03, 0x03, 0xC0, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x60,
  0x18, 0x00, 0x20, 0x10, 0x00, 0x30, 0x10, 0x00, 0x30, 0x10, 0x00, 0x10,
  0x10, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x18, 0x00, 0x20, 0x08, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x03, 0x03, 0x80,
  0x01, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x04, 0x00, 0x18, 0x18, 0x00, 0x04, 0x20, 0x00, 0x06, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x60,
  0x03, 0xFF, 0x80, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x0F, 0xE0, 0x8C, 0x06, 0x24, 0x00, 0xCA, 0x00,
  0x1B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0xFF,
  0xFE, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x68, 0x00, 0x04, 0x40,
  0x00, 0xC2, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0x80, 0x08, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x02, 0x1A,
  0x00, 0x11, 0x08, 0x00, 0x90, 0x60, 0x05, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x00, 0x10, 0x08, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00, 0x0C, 0x10, 0x00,
  0x30, 0x80, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x09, 0x00, 0x00, 0x68,
  0x00, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x8F, 0x01, 0xF2, 0xC3, 0x18, 0x6C, 0x06,
  0x80, 0xF0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x83, 0xF8, 0x23, 0x01, 0x89, 0x00, 0x32,
  0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0C,
  0x04, 0x00, 0x18, 0x30, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00, 0x01, 0x10,
  0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00,
  0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00, 0x02,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x18, 0x0C, 0x00,
  0xC0, 0x1C, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0x83, 0xF8, 0x08, 0xC0, 0x60,
  0x90, 0x01, 0x0A, 0x00, 0x08, 0xC0, 0x00, 0x4C, 0x00, 0x06, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x2C,
  0x00, 0x06, 0xC0, 0x00, 0x4A, 0x00, 0x08, 0x90, 0x01, 0x08, 0xC0, 0x60,
  0x83, 0xF8, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFC, 0x10, 0x60, 0x31, 0x08, 0x00, 0x91, 0x00, 0x05, 0x20,
  0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00, 0x03, 0x20, 0x00, 0x31, 0x00,
  0x05, 0x08, 0x00, 0x90, 0x60, 0x31, 0x01, 0xFC, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x46,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x50, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x30, 0x40, 0x00, 0x44,
  0x00, 0x03, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x4C, 0x00, 0x06, 0x30, 0x00, 0x60, 0x70, 0x0C, 0x00, 0x7F, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x34, 0x00,
  0x0D, 0x80, 0x05, 0x30, 0x02, 0x46, 0x03, 0x10, 0x7F, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00,
  0x04, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x08,
  0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00,
  0x60, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x05, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x84, 0x02, 0x60, 0x21, 0x00, 0x88, 0x08, 0x40, 0x42,
  0x06, 0x08, 0x10, 0x81, 0x02, 0x04, 0x20, 0x40, 0x81, 0x08, 0x10, 0x20,
  0x41, 0x08, 0x04, 0x20, 0x42, 0x01, 0x08, 0x10, 0x80, 0x42, 0x04, 0x20,
  0x10, 0x81, 0x10, 0x02, 0x20, 0x24, 0x00, 0x90, 0x09, 0x00, 0x24, 0x02,
  0x40, 0x09, 0x00, 0xA0, 0x01, 0x40, 0x28, 0x00, 0x50, 0x0E, 0x00, 0x14,
  0x01, 0x80, 0x06, 0x00, 0x40, 0x00, 0x08, 0x80, 0x00, 0x43, 0x00, 0x03,
  0x06, 0x00, 0x18, 0x08, 0x00, 0x40, 0x10, 0x02, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0xC0, 0x01, 0x02, 0x00, 0x02, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x84, 0x00, 0x04, 0x08, 0x00, 0x20, 0x10, 0x01, 0x80, 0x60, 0x04,
  0x00, 0x80, 0x20, 0x01, 0x01, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0x13, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x88, 0x00, 0x04, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC1, 0x00, 0x02, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x40, 0x20, 0x01, 0x00, 0xC0, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x40, 0x80,
  0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x03, 0x80,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x01, 0x10, 0xC0, 0x01, 0x20, 0x60, 0x01, 0x60, 0x30, 0x02,
  0x40, 0x18, 0x02, 0x40, 0x0C, 0x06, 0x80, 0x06, 0x04, 0x80, 0x03, 0x08,
  0x80, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 4, 35, 30, 13, -35 },
  { 19, 8, 13, 30, 11, -37 },
  { 32, 28, 35, 30, 1, -35 },
  { 155, 23, 47, 30, 3, -41 },
  { 291, 28, 37, 30, 1, -36 },
  { 421, 25, 37, 30, 2, -36 },
  { 537, 2, 13, 30, 14, -37 },
  { 541, 11, 45, 30, 12, -38 },
  { 603, 11, 45, 30, 7, -38 },
  { 665, 26, 25, 30, 2, -27 },
  { 747, 24, 25, 30, 3, -28 },
  { 822, 5, 13, 30, 11, -4 },
  { 831, 14, 1, 30, 8, -16 },
  { 833, 4, 3, 30, 13, -3 },
  { 835, 20, 45, 30, 5, -38 },
  { 948, 22, 37, 30, 4, -36 },
  { 1050, 24, 35, 30, 4, -35 },
  { 1155, 22, 36, 30, 4, -36 },
  { 1254, 22, 37, 30, 3, -36 },
  { 1356, 26, 35, 30, 2, -35 },
  { 1470, 21, 36, 30, 4, -35 },
  { 1565, 22, 36, 30, 4, -35 },
  { 1664, 22, 35, 30, 4, -35 },
  { 1761, 22, 37, 30, 4, -36 },
  { 1863, 21, 36, 30, 5, -36 },
  { 1958, 4, 26, 30, 13, -26 },
  { 1971, 6, 35, 30, 11, -26 },
  { 1998, 22, 27, 30, 4, -29 },
  { 2073, 24, 10, 30, 3, -20 },
  { 2103, 22, 27, 30, 4, -29 },
  { 2178, 20, 36, 30, 5, -36 },
  { 2268, 20, 41, 30, 5, -36 },
  { 2371, 24, 35, 30, 3, -35 },
  { 2476, 21, 35, 30, 5, -35 },
  { 2568, 22, 37, 30, 4, -36 },
  { 2670, 21, 35, 30, 5, -35 },
  { 2762, 21, 35, 30, 5, -35 },
  { 2854, 21, 35, 30, 5, -35 },
  { 2946, 22, 37, 30, 4, -36 },
  { 3048, 20, 35, 30, 5, -35 },
  { 3136, 20, 35, 30, 5, -35 },
  { 3224, 18, 36, 30, 5, -35 },
  { 3305, 22, 35, 30, 5, -35 },
  { 3402, 19, 35, 30, 7, -35 },
  { 3486, 22, 35, 30, 4, -35 },
  { 3583, 20, 35, 30, 5, -35 },
  { 3671, 22, 37, 30, 4, -36 },
  { 3773, 21, 35, 30, 5, -35 },
  { 3865, 22, 43, 30, 4, -36 },
  { 3984, 21, 35, 30, 5, -35 },
  { 4076, 23, 37, 30, 3, -36 },
  { 4183, 26, 35, 30, 2, -35 },
  { 4297, 20, 36, 30, 5, -35 },
  { 4387, 24, 35, 30, 3, -35 },
  { 4492, 24, 35, 30, 3, -35 },
  { 4597, 26, 35, 30, 2, -35 },
  { 4711, 28, 35, 30, 1, -35 },
  { 4834, 26, 35, 30, 2, -35 },
  { 4948, 12, 45, 30, 13, -38 },
  { 5016, 20, 45, 30, 5, -38 },
  { 5129, 12, 45, 30, 5, -38 },
  { 5197, 24, 19, 30, 3, -35 },
  { 5254, 24, 1, 30, 3, 6 },
  { 5257, 7, 8, 30, 10, -38 },
  { 5264, 23, 27, 30, 4, -26 },
  { 5342, 20, 38, 30, 6, -37 },
  { 5437, 20, 27, 30, 5, -26 },
  { 5505, 20, 38, 30, 4, -37 },
  { 5600, 21, 27, 30, 5, -26 },
  { 5671, 23, 37, 30, 4, -37 },
  { 5778, 24, 39, 30, 4, -28 },
  { 5895, 18, 37, 30, 6, -37 },
  { 5979, 21, 38, 30, 6, -38 },
  { 6079, 17, 48, 30, 5, -38 },
  { 6181, 21, 37, 30, 7, -37 },
  { 6279, 21, 37, 30, 5, -37 },
  { 6377, 22, 26, 30, 4, -26 },
  { 6449, 18, 26, 30, 6, -26 },
  { 6508, 22, 27, 30, 4, -26 },
  { 6583, 20, 36, 30, 6, -26 },
  { 6673, 20, 36, 30, 4, -26 },
  { 6763, 24, 26, 30, 4, -26 },
  { 6841, 21, 27, 30, 5, -26 },
  { 6912, 24, 35, 30, 2, -35 },
  { 7017, 18, 27, 30, 6, -26 },
  { 7078, 20, 26, 30, 5, -26 },
  { 7143, 26, 26, 30, 2, -26 },
  { 7228, 22, 26, 30, 4, -26 },
  { 7300, 22, 36, 30, 4, -26 },
  { 7399, 20, 26, 30, 5, -26 },
  { 7464, 18, 45, 30, 6, -38 },
  { 7566, 2, 45, 30, 14, -38 },
  { 7578, 18, 45, 30, 6, -38 },
  { 7680, 24, 9, 30, 3, -20 },
};

const GFXfont IBMPlexMono_Thin50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_THIN50PT7B_H_
