#ifndef _IBMPLEXMONO_THIN13PT7B_H_
#define _IBMPLEXMONO_THIN13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xFC, 0x14, 0x24, 0x67, 0x28, 0x28, 0x28, 0xE6, 0x48,
  0x48, 0x21, 0xCA, 0xA9, 0xA1, 0xE2, 0x49, 0xA5, 0xE2, 0x00, 0x73, 0x26,
  0x53, 0xC0, 0x05, 0xD4, 0xA9, 0x8E, 0x72, 0x48, 0x10, 0x66, 0xA9, 0xA2,
  0xF4, 0xE0, 0x6A, 0x49, 0x24, 0x91, 0x30, 0x91, 0x22, 0x49, 0x4A, 0x40,
  0x20, 0x8A, 0x5E, 0x51, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xE0,
  0xF0, 0x80, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x21, 0x00, 0x7A, 0x28,
  0x61, 0xA6, 0x18, 0x62, 0x78, 0x21, 0x8E, 0x28, 0x20, 0x82, 0x08, 0xFC,
  0x72, 0x28, 0x82, 0x08, 0x42, 0x30, 0xFC, 0x7C, 0x42, 0xE0, 0x84, 0x31,
  0x70, 0x08, 0xE2, 0x92, 0x8A, 0x2F, 0xC2, 0x08, 0x7A, 0x08, 0x1E, 0x88,
  0x10, 0x62, 0x70, 0x31, 0x04, 0x20, 0xFA, 0x28, 0x62, 0x78, 0xFE, 0x28,
  0x84, 0x10, 0x82, 0x10, 0x40, 0x7A, 0x28, 0x62, 0x73, 0x28, 0x61, 0x78,
  0x7A, 0x28, 0x61, 0x7C, 0x20, 0x84, 0x20, 0x82, 0x83, 0x80, 0x0C, 0x46,
  0x20, 0x40, 0xC0, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x03, 0x18, 0x8C,
  0x00, 0x3E, 0x62, 0x13, 0x10, 0x00, 0x20, 0x74, 0x63, 0x7C, 0xE7, 0x37,
  0x83, 0xC0, 0x20, 0xC5, 0x14, 0x4A, 0x27, 0xA1, 0x84, 0xFA, 0x28, 0xA2,
  0xFA, 0x18, 0x61, 0xF8, 0x72, 0x28, 0x60, 0x82, 0x08, 0x62, 0x70, 0xFA,
  0x28, 0x61, 0x86, 0x18, 0x62, 0xF8, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20,
  0xFC, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x72, 0x28, 0x60, 0x9E,
  0x18, 0x61, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xFC, 0x82,
  0x08, 0x20, 0x82, 0x08, 0xFC, 0x78, 0x42, 0x10, 0x86, 0x31, 0x70, 0x86,
  0x29, 0x28, 0xE2, 0x49, 0x22, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8,
  0x86, 0x1D, 0xF5, 0xA6, 0x18, 0x61, 0x84, 0x86, 0x1C, 0x69, 0xA6, 0x59,
  0x63, 0x84, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78, 0xFA, 0x18, 0x61,
  0x87, 0xE8, 0x20, 0x80, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78, 0x81,
  0x80, 0xFA, 0x18, 0x61, 0x87, 0xE9, 0x24, 0x8C, 0x72, 0x28, 0x60, 0x78,
  0x10, 0x61, 0x78, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x18,
  0x61, 0x86, 0x18, 0xA2, 0x78, 0x86, 0x18, 0xA2, 0x49, 0x45, 0x0C, 0x20,
  0x86, 0x18, 0x69, 0xB7, 0x5D, 0xB6, 0x88, 0x86, 0x25, 0x14, 0x21, 0x45,
  0x22, 0x84, 0x82, 0x89, 0x11, 0x41, 0x82, 0x04, 0x08, 0x10, 0xFC, 0x20,
  0x84, 0x21, 0x08, 0x20, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x84,
  0x10, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0xE4, 0x92, 0x49, 0x24, 0xF0,
  0x21, 0x44, 0xA2, 0x84, 0xFC, 0xC0, 0x72, 0x20, 0x9E, 0x8A, 0x67, 0x40,
  0x84, 0x21, 0xE9, 0x46, 0x31, 0x97, 0x80, 0x33, 0x28, 0x20, 0x82, 0x37,
  0x00, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8B, 0xC0, 0x72, 0x28, 0x7F, 0x82,
  0x07, 0xC0, 0x1C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x0D, 0xE8,
  0xA2, 0x89, 0xCC, 0x1F, 0x86, 0x17, 0x80, 0x88, 0x8F, 0x99, 0x99, 0x99,
  0x20, 0x01, 0x84, 0x21, 0x08, 0x47, 0xC0, 0x08, 0x01, 0xF0, 0x84, 0x21,
  0x08, 0x42, 0x1F, 0x80, 0x84, 0x21, 0x3A, 0x62, 0x94, 0x94, 0x40, 0xE0,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0xF0, 0xEE, 0xDA, 0x69, 0xA6, 0x9A,
  0x40, 0xF9, 0x99, 0x99, 0x90, 0x7A, 0x28, 0x61, 0x86, 0x27, 0x80, 0xF4,
  0xA3, 0x18, 0xCB, 0xD0, 0x84, 0x00, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x08,
  0x40, 0xFC, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0x7A, 0x28, 0x1E, 0x06, 0x17,
  0x80, 0x20, 0x43, 0xF9, 0x02, 0x04, 0x08, 0x10, 0x1E, 0x99, 0x99, 0x99,
  0xF0, 0x8E, 0x28, 0x94, 0x51, 0x42, 0x00, 0x93, 0x26, 0xAD, 0x56, 0xCD,
  0x91, 0x00, 0x8D, 0x25, 0x08, 0x51, 0x28, 0xC0, 0x86, 0x28, 0x94, 0x51,
  0x42, 0x08, 0x43, 0x00, 0xF8, 0x44, 0x44, 0x43, 0xE0, 0x74, 0x44, 0x2C,
  0x22, 0x44, 0x47, 0xFF, 0xF0, 0xC4, 0x44, 0x87, 0x48, 0x44, 0x4C, 0x46,
  0x99, 0x80,
};

const GFXglyph IBMPlexMono_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 9, 8, 3, -9 },
  { 3, 2, 3, 8, 3, -10 },
  { 4, 8, 9, 8, 0, -9 },
  { 13, 6, 11, 8, 1, -10 },
  { 22, 7, 9, 8, 0, -9 },
  { 30, 6, 9, 8, 1, -9 },
  { 37, 1, 3, 8, 3, -10 },
  { 38, 3, 12, 8, 3, -10 },
  { 43, 3, 12, 8, 2, -10 },
  { 48, 6, 6, 8, 1, -7 },
  { 53, 6, 7, 8, 1, -7 },
  { 59, 1, 3, 8, 3, -1 },
  { 60, 4, 1, 8, 2, -4 },
  { 61, 1, 1, 8, 3, -1 },
  { 62, 5, 12, 8, 1, -10 },
  { 70, 6, 9, 8, 1, -9 },
  { 77, 6, 9, 8, 1, -9 },
  { 84, 6, 9, 8, 1, -9 },
  { 91, 5, 9, 8, 1, -9 },
  { 97, 6, 9, 8, 1, -9 },
  { 104, 6, 9, 8, 1, -9 },
  { 111, 6, 9, 8, 1, -9 },
  { 118, 6, 9, 8, 1, -9 },
  { 125, 6, 9, 8, 1, -9 },
  { 132, 6, 9, 8, 1, -9 },
  { 139, 1, 7, 8, 3, -7 },
  { 140, 1, 9, 8, 3, -7 },
  { 142, 6, 7, 8, 1, -7 },
  { 148, 6, 4, 8, 1, -6 },
  { 151, 6, 7, 8, 1, -7 },
  { 157, 5, 9, 8, 1, -9 },
  { 163, 5, 10, 8, 1, -9 },
  { 170, 6, 9, 8, 1, -9 },
  { 177, 6, 9, 8, 1, -9 },
  { 184, 6, 9, 8, 1, -9 },
  { 191, 6, 9, 8, 1, -9 },
  { 198, 6, 9, 8, 1, -9 },
  { 205, 6, 9, 8, 1, -9 },
  { 212, 6, 9, 8, 1, -9 },
  { 219, 6, 9, 8, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 5, 9, 8, 1, -9 },
  { 239, 6, 9, 8, 1, -9 },
  { 246, 5, 9, 8, 2, -9 },
  { 252, 6, 9, 8, 1, -9 },
  { 259, 6, 9, 8, 1, -9 },
  { 266, 6, 9, 8, 1, -9 },
  { 273, 6, 9, 8, 1, -9 },
  { 280, 6, 11, 8, 1, -9 },
  { 289, 6, 9, 8, 1, -9 },
  { 296, 6, 9, 8, 1, -9 },
  { 303, 6, 9, 8, 1, -9 },
  { 310, 6, 9, 8, 1, -9 },
  { 317, 6, 9, 8, 1, -9 },
  { 324, 6, 9, 8, 1, -9 },
  { 331, 6, 9, 8, 1, -9 },
  { 338, 7, 9, 8, 0, -9 },
  { 346, 6, 9, 8, 1, -9 },
  { 353, 4, 12, 8, 3, -10 },
  { 359, 5, 12, 8, 1, -10 },
  { 367, 3, 12, 8, 1, -10 },
  { 372, 6, 5, 8, 1, -9 },
  { 376, 6, 1, 8, 1, 1 },
  { 377, 1, 2, 8, 3, -11 },
  { 378, 6, 7, 8, 1, -7 },
  { 384, 5, 10, 8, 2, -10 },
  { 391, 6, 7, 8, 1, -7 },
  { 397, 5, 10, 8, 1, -10 },
  { 404, 6, 7, 8, 1, -7 },
  { 410, 6, 10, 8, 1, -10 },
  { 418, 6, 11, 8, 1, -8 },
  { 427, 4, 10, 8, 2, -10 },
  { 432, 5, 10, 8, 2, -10 },
  { 439, 5, 13, 8, 1, -10 },
  { 448, 5, 10, 8, 2, -10 },
  { 455, 6, 10, 8, 1, -10 },
  { 463, 6, 7, 8, 1, -7 },
  { 469, 4, 7, 8, 2, -7 },
  { 473, 6, 7, 8, 1, -7 },
  { 479, 5, 10, 8, 2, -7 },
  { 486, 5, 10, 8, 1, -7 },
  { 493, 6, 7, 8, 1, -7 },
  { 499, 6, 7, 8, 1, -7 },
  { 505, 7, 9, 8, 0, -9 },
  { 513, 4, 7, 8, 2, -7 },
  { 517, 6, 7, 8, 1, -7 },
  { 523, 7, 7, 8, 0, -7 },
  { 530, 6, 7, 8, 1, -7 },
  { 536, 6, 10, 8, 1, -7 },
  { 544, 5, 7, 8, 1, -7 },
  { 549, 4, 12, 8, 2, -10 },
  { 555, 1, 12, 8, 3, -10 },
  { 557, 4, 12, 8, 2, -10 },
  { 563, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_Thin13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_THIN13PT7B_H_
