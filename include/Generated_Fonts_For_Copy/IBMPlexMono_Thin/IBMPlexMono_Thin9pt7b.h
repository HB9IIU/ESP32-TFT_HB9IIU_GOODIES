#ifndef _IBMPLEXMONO_THIN9PT7B_H_
#define _IBMPLEXMONO_THIN9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x72, 0x54, 0xAD, 0xB0, 0x4E, 0xDC, 0x3D, 0x64, 0x6D,
  0x9C, 0xBA, 0xCC, 0x64, 0x93, 0x69, 0x34, 0xC0, 0x6A, 0xA9, 0x95, 0x56,
  0x21, 0x3E, 0xA0, 0x44, 0xF4, 0x40, 0xE0, 0xC0, 0x80, 0x25, 0x25, 0x24,
  0xE9, 0x9D, 0x9E, 0x4C, 0xC4, 0x4F, 0x6A, 0x22, 0xCF, 0x75, 0x1A, 0xC0,
  0x31, 0x95, 0x27, 0xC8, 0xE8, 0xE9, 0x96, 0x68, 0xE9, 0x9E, 0xFA, 0x24,
  0x48, 0xE9, 0x69, 0x9E, 0xE9, 0x9E, 0x24, 0x88, 0x8E, 0x34, 0x84, 0x30,
  0xF0, 0xF0, 0x84, 0x36, 0x80, 0x74, 0xA0, 0x80, 0xF7, 0xDF, 0x18, 0x23,
  0x14, 0xA7, 0x44, 0xEA, 0xE9, 0x9E, 0xEA, 0x98, 0xBE, 0xE9, 0x99, 0x9E,
  0xF8, 0xF8, 0x8F, 0xF8, 0xE8, 0x88, 0xEA, 0x9B, 0x9F, 0x99, 0xF9, 0x99,
  0xF4, 0x44, 0x4F, 0xE4, 0x9A, 0xC0, 0xBC, 0xCC, 0xA9, 0x88, 0x88, 0x8F,
  0x99, 0xFD, 0x99, 0x99, 0xDD, 0xB9, 0xE9, 0x99, 0x9E, 0xE9, 0x9E, 0x88,
  0xE9, 0x99, 0x9E, 0x42, 0xE9, 0x9E, 0xCB, 0xE9, 0xC3, 0x96, 0xF9, 0x08,
  0x42, 0x10, 0x99, 0x99, 0xAE, 0x8C, 0x94, 0xA6, 0x10, 0x99, 0xDD, 0xAA,
  0x8A, 0x98, 0xC5, 0x44, 0x8A, 0x98, 0x42, 0x10, 0x78, 0x88, 0x88, 0x7C,
  0xF2, 0x49, 0x27, 0x92, 0x24, 0x89, 0xD5, 0x57, 0x4A, 0xB0, 0xF0, 0x80,
  0xE2, 0xEA, 0xD0, 0x88, 0xE9, 0x99, 0xE0, 0x6A, 0x8B, 0x40, 0x27, 0xDB,
  0x78, 0xEA, 0xF8, 0xF0, 0x34, 0xF4, 0x44, 0xF0, 0x16, 0xAE, 0x87, 0x9E,
  0x93, 0xDB, 0x68, 0x40, 0xC4, 0x44, 0xF0, 0x23, 0x92, 0x49, 0xE0, 0x88,
  0xBC, 0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xBD, 0xDD, 0xD0, 0xF6, 0xDA,
  0xEA, 0x9A, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0xF6, 0xDE, 0x48, 0xF4, 0x44,
  0xF0, 0xE8, 0xE1, 0xE0, 0x47, 0xD0, 0x84, 0x1C, 0xB6, 0xDE, 0xBA, 0xAC,
  0x40, 0xAF, 0x7B, 0xAD, 0x00, 0xBA, 0x4C, 0xB0, 0xBA, 0xAC, 0x44, 0x80,
  0xE5, 0x4E, 0x69, 0x64, 0x93, 0xFF, 0xCA, 0x3C, 0x96, 0xDA,
};

const GFXglyph IBMPlexMono_Thin9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 5, 2, -7 },
  { 20, 2, 8, 5, 2, -7 },
  { 22, 2, 8, 5, 1, -7 },
  { 24, 5, 4, 5, 0, -5 },
  { 27, 4, 5, 5, 1, -5 },
  { 30, 1, 3, 5, 2, -1 },
  { 31, 2, 1, 5, 2, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 3, 8, 5, 1, -7 },
  { 36, 4, 6, 5, 1, -6 },
  { 39, 4, 6, 5, 1, -6 },
  { 42, 4, 6, 5, 1, -6 },
  { 45, 3, 6, 5, 1, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 1, 5, 5, 2, -5 },
  { 68, 1, 7, 5, 2, -5 },
  { 69, 4, 5, 5, 1, -5 },
  { 72, 4, 3, 5, 1, -4 },
  { 74, 4, 5, 5, 1, -5 },
  { 77, 3, 6, 5, 1, -6 },
  { 80, 3, 7, 5, 1, -6 },
  { 83, 5, 6, 5, 0, -6 },
  { 87, 4, 6, 5, 1, -6 },
  { 90, 4, 6, 5, 1, -6 },
  { 93, 4, 6, 5, 1, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 4, 6, 5, 1, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 4, 8, 5, 1, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 4, 6, 5, 1, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 3, 8, 5, 2, -7 },
  { 171, 3, 8, 5, 1, -7 },
  { 174, 2, 8, 5, 1, -7 },
  { 176, 4, 3, 5, 1, -6 },
  { 178, 4, 1, 5, 1, 1 },
  { 179, 1, 1, 5, 2, -7 },
  { 180, 4, 5, 5, 1, -5 },
  { 183, 4, 7, 5, 1, -7 },
  { 187, 4, 5, 5, 1, -5 },
  { 190, 3, 7, 5, 1, -7 },
  { 193, 4, 5, 5, 1, -5 },
  { 196, 4, 7, 5, 1, -7 },
  { 200, 4, 8, 5, 1, -6 },
  { 204, 3, 7, 5, 1, -7 },
  { 207, 4, 7, 5, 1, -7 },
  { 211, 3, 9, 5, 1, -7 },
  { 215, 4, 7, 5, 1, -7 },
  { 219, 4, 7, 5, 1, -7 },
  { 223, 4, 5, 5, 1, -5 },
  { 226, 3, 5, 5, 1, -5 },
  { 228, 4, 5, 5, 1, -5 },
  { 231, 4, 7, 5, 1, -5 },
  { 235, 3, 7, 5, 1, -5 },
  { 238, 4, 5, 5, 1, -5 },
  { 241, 4, 5, 5, 1, -5 },
  { 244, 5, 6, 5, 0, -6 },
  { 248, 3, 5, 5, 1, -5 },
  { 250, 4, 5, 5, 1, -5 },
  { 253, 5, 5, 5, 0, -5 },
  { 257, 4, 5, 5, 1, -5 },
  { 260, 4, 7, 5, 1, -5 },
  { 264, 3, 5, 5, 1, -5 },
  { 266, 3, 8, 5, 1, -7 },
  { 269, 1, 8, 5, 2, -7 },
  { 270, 3, 8, 5, 1, -7 },
  { 273, 4, 2, 5, 1, -4 },
};

const GFXfont IBMPlexMono_Thin9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_THIN9PT7B_H_
