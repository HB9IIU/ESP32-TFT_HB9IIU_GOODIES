#ifndef _IBMPLEXMONO_THIN19PT7B_H_
#define _IBMPLEXMONO_THIN19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x88, 0xB6, 0xDA, 0x08, 0x81, 0x20, 0x24, 0x04, 0x87, 0x8E,
  0x22, 0x04, 0x40, 0x90, 0xF1, 0xC2, 0x40, 0x48, 0x11, 0x02, 0x20, 0x08,
  0x04, 0x0F, 0x89, 0x28, 0x8C, 0x42, 0x20, 0xD0, 0x1E, 0x04, 0xC2, 0x21,
  0x18, 0x8A, 0x48, 0xF8, 0x10, 0x08, 0x00, 0x70, 0x62, 0x28, 0x92, 0x24,
  0x8A, 0x1C, 0x80, 0x00, 0x9E, 0x28, 0x92, 0x18, 0x86, 0x22, 0x87, 0x80,
  0x3C, 0x22, 0x10, 0x88, 0x04, 0x01, 0x01, 0xC7, 0x12, 0x85, 0x41, 0x20,
  0x90, 0x67, 0xC8, 0xF8, 0x34, 0x48, 0x88, 0x88, 0x88, 0x88, 0x88, 0x44,
  0x30, 0x84, 0x42, 0x21, 0x11, 0x11, 0x11, 0x22, 0x44, 0x80, 0x08, 0x02,
  0x00, 0x82, 0x22, 0x7B, 0x43, 0x01, 0x40, 0x88, 0x41, 0x00, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x5A, 0xF8, 0x80,
  0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08,
  0x20, 0x40, 0x80, 0x1E, 0x30, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x23, 0x01,
  0x80, 0xC0, 0x50, 0x44, 0x21, 0xE0, 0x10, 0x30, 0x50, 0x90, 0x90, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x3C, 0x42, 0x82, 0x82, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x30, 0x40, 0x80, 0xFF, 0x1E, 0x61, 0x81, 0x01,
  0x02, 0x1C, 0x02, 0x01, 0x01, 0x01, 0x81, 0x43, 0x3E, 0x02, 0x03, 0x02,
  0x81, 0x41, 0x21, 0x11, 0x09, 0x04, 0x82, 0x7F, 0xC0, 0x80, 0x40, 0x20,
  0x7E, 0x80, 0x80, 0x80, 0x80, 0xFC, 0xC2, 0x02, 0x01, 0x01, 0x82, 0x82,
  0x7C, 0x08, 0x30, 0x40, 0x40, 0x80, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x82,
  0xC2, 0x3C, 0xFF, 0xC0, 0xA0, 0x50, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x00, 0x3E, 0x20, 0xA0, 0x50, 0x18, 0x12, 0x08,
  0xF8, 0xC6, 0x80, 0xC0, 0x60, 0x28, 0x23, 0xE0, 0x3C, 0x42, 0x81, 0x81,
  0x81, 0x81, 0xC3, 0x3E, 0x02, 0x04, 0x04, 0x08, 0x30, 0x80, 0x40, 0x40,
  0x00, 0x16, 0x80, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x03,
  0x04, 0x18, 0x60, 0x80, 0x3C, 0x86, 0x0C, 0x10, 0x20, 0x86, 0x08, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x3C, 0x86, 0x0C, 0x19, 0xF4, 0x68, 0xD1, 0xA3,
  0x46, 0x7C, 0x08, 0x08, 0x0F, 0x80, 0x08, 0x0C, 0x05, 0x02, 0x82, 0x21,
  0x10, 0x88, 0x82, 0x3F, 0x20, 0xA0, 0x30, 0x18, 0x08, 0xFC, 0x82, 0x82,
  0x82, 0x82, 0x82, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x1E, 0x10,
  0x90, 0x50, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x64, 0x21,
  0xE0, 0xFC, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0xFC, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1E, 0x10, 0x90, 0x50, 0x18, 0x04, 0x02, 0x01,
  0x0F, 0x80, 0xC0, 0x50, 0x24, 0x31, 0xE8, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x7E, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x27, 0x80, 0x81, 0x82, 0x84,
  0x88, 0x90, 0xA0, 0xD0, 0x88, 0x88, 0x84, 0x82, 0x82, 0x81, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x81, 0x83,
  0x85, 0xC5, 0xC9, 0xA9, 0xB1, 0x91, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x85, 0x85, 0x83, 0x81,
  0x1E, 0x30, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50,
  0x44, 0x21, 0xE0, 0xFE, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFE, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1E, 0x30, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x50, 0x4C, 0x21, 0xE0, 0x40, 0x20, 0x1E, 0xFE, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x82, 0xFE, 0x90, 0x88, 0x84, 0x82, 0x81, 0x3E,
  0x20, 0xA0, 0x30, 0x08, 0x03, 0x00, 0x78, 0x02, 0x00, 0x80, 0x60, 0x28,
  0x23, 0xE0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x7C, 0x80, 0xC0, 0x60, 0x28,
  0x24, 0x12, 0x08, 0x88, 0x44, 0x24, 0x0A, 0x05, 0x03, 0x00, 0x80, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x8C, 0xC6, 0x53, 0x29, 0xA5, 0x51, 0x98, 0xCC,
  0x64, 0x10, 0x80, 0xA0, 0x90, 0x44, 0x41, 0x40, 0xA0, 0x20, 0x28, 0x24,
  0x11, 0x10, 0x50, 0x28, 0x08, 0x80, 0x60, 0x24, 0x11, 0x04, 0x22, 0x05,
  0x01, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0xFF, 0x80,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x0F,
  0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8,
  0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x81, 0x01, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0,
  0x08, 0x0A, 0x09, 0x04, 0x44, 0x12, 0x0A, 0x02, 0xFF, 0x80, 0xA4, 0x3C,
  0x21, 0x00, 0x80, 0x43, 0xE2, 0x12, 0x09, 0x04, 0x46, 0x1C, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2,
  0xBC, 0x3C, 0x42, 0x82, 0x80, 0x80, 0x80, 0x80, 0x83, 0x42, 0x3C, 0x02,
  0x04, 0x08, 0x17, 0xB0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x6F, 0x40,
  0x3C, 0x42, 0x82, 0x81, 0xFF, 0x80, 0x80, 0x83, 0x42, 0x3C, 0x1F, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0x03, 0x9E, 0x11, 0x10, 0x48, 0x24, 0x11, 0x08, 0x78, 0xC0, 0x40, 0x1F,
  0x90, 0x28, 0x14, 0x09, 0xF8, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x04, 0x00, 0x00, 0xFC,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x80, 0x80,
  0x80, 0x80, 0x82, 0x8C, 0x90, 0xA0, 0xE0, 0x90, 0x88, 0x84, 0x84, 0x83,
  0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFF, 0xB3, 0x66, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88,
  0xC4, 0x40, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x3C,
  0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0xBC, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x7B,
  0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0xF4, 0x08, 0x10, 0x20, 0x40,
  0xE7, 0x9C, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x7F, 0x80,
  0x7C, 0x82, 0x80, 0x80, 0x78, 0x06, 0x01, 0x01, 0x82, 0x7C, 0x10, 0x08,
  0x04, 0x1F, 0xF1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0xF8, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0x74, 0x83, 0x82,
  0x82, 0x84, 0x44, 0x44, 0x28, 0x28, 0x28, 0x10, 0x88, 0x66, 0x29, 0x4A,
  0x52, 0x94, 0xA9, 0x2A, 0x32, 0x8C, 0x63, 0x10, 0xC0, 0x83, 0x82, 0x44,
  0x28, 0x10, 0x10, 0x28, 0x44, 0x82, 0x83, 0x81, 0x82, 0x82, 0x84, 0x44,
  0x44, 0x28, 0x28, 0x30, 0x10, 0x10, 0x20, 0x20, 0xC0, 0xFE, 0x04, 0x10,
  0x41, 0x04, 0x08, 0x20, 0x81, 0xFC, 0x1E, 0x40, 0x81, 0x01, 0x01, 0x02,
  0x04, 0xF0, 0x30, 0x20, 0x81, 0x04, 0x08, 0x10, 0x1E, 0xFF, 0xFF, 0x80,
  0xF0, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x1E, 0x60, 0x81, 0x01, 0x02,
  0x04, 0x08, 0xF0, 0x70, 0xC4, 0x61, 0x30, 0x60,
};

const GFXglyph IBMPlexMono_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 13, 11, 5, -13 },
  { 3, 3, 5, 11, 4, -14 },
  { 5, 11, 13, 11, 0, -13 },
  { 23, 9, 17, 11, 1, -15 },
  { 43, 10, 13, 11, 1, -13 },
  { 60, 9, 13, 11, 1, -13 },
  { 75, 1, 5, 11, 5, -14 },
  { 76, 4, 17, 11, 5, -14 },
  { 85, 4, 17, 11, 3, -14 },
  { 94, 10, 9, 11, 1, -10 },
  { 106, 9, 9, 11, 1, -10 },
  { 117, 2, 4, 11, 4, -1 },
  { 118, 5, 1, 11, 3, -6 },
  { 119, 1, 1, 11, 5, -1 },
  { 120, 7, 17, 11, 2, -14 },
  { 135, 9, 13, 11, 1, -13 },
  { 150, 8, 13, 11, 2, -13 },
  { 163, 8, 13, 11, 2, -13 },
  { 176, 8, 13, 11, 1, -13 },
  { 189, 9, 13, 11, 1, -13 },
  { 204, 8, 13, 11, 2, -13 },
  { 217, 8, 13, 11, 2, -13 },
  { 230, 9, 13, 11, 1, -13 },
  { 245, 9, 13, 11, 1, -13 },
  { 260, 8, 13, 11, 2, -13 },
  { 273, 1, 10, 11, 5, -10 },
  { 275, 2, 13, 11, 4, -10 },
  { 279, 8, 10, 11, 2, -11 },
  { 289, 9, 4, 11, 1, -8 },
  { 294, 8, 10, 11, 2, -11 },
  { 304, 7, 13, 11, 2, -13 },
  { 316, 7, 15, 11, 2, -13 },
  { 330, 9, 13, 11, 1, -13 },
  { 345, 8, 13, 11, 2, -13 },
  { 358, 9, 13, 11, 1, -13 },
  { 373, 8, 13, 11, 2, -13 },
  { 386, 8, 13, 11, 2, -13 },
  { 399, 8, 13, 11, 2, -13 },
  { 412, 9, 13, 11, 1, -13 },
  { 427, 8, 13, 11, 2, -13 },
  { 440, 8, 13, 11, 2, -13 },
  { 453, 7, 13, 11, 2, -13 },
  { 465, 8, 13, 11, 2, -13 },
  { 478, 7, 13, 11, 3, -13 },
  { 490, 8, 13, 11, 2, -13 },
  { 503, 8, 13, 11, 2, -13 },
  { 516, 9, 13, 11, 1, -13 },
  { 531, 8, 13, 11, 2, -13 },
  { 544, 9, 16, 11, 1, -13 },
  { 562, 8, 13, 11, 2, -13 },
  { 575, 9, 13, 11, 1, -13 },
  { 590, 10, 13, 11, 1, -13 },
  { 607, 8, 13, 11, 2, -13 },
  { 620, 9, 13, 11, 1, -13 },
  { 635, 9, 13, 11, 1, -13 },
  { 650, 9, 13, 11, 1, -13 },
  { 665, 10, 13, 11, 1, -13 },
  { 682, 9, 13, 11, 1, -13 },
  { 697, 5, 17, 11, 5, -14 },
  { 708, 7, 17, 11, 2, -14 },
  { 723, 4, 17, 11, 2, -14 },
  { 732, 9, 7, 11, 1, -13 },
  { 740, 9, 1, 11, 1, 2 },
  { 742, 2, 3, 11, 4, -15 },
  { 743, 9, 10, 11, 1, -10 },
  { 755, 8, 14, 11, 2, -14 },
  { 769, 8, 10, 11, 2, -10 },
  { 779, 7, 14, 11, 2, -14 },
  { 792, 8, 10, 11, 2, -10 },
  { 802, 8, 14, 11, 2, -14 },
  { 816, 9, 15, 11, 2, -11 },
  { 833, 7, 14, 11, 2, -14 },
  { 846, 8, 14, 11, 2, -14 },
  { 860, 6, 18, 11, 2, -14 },
  { 874, 8, 14, 11, 3, -14 },
  { 888, 8, 14, 11, 2, -14 },
  { 902, 9, 10, 11, 1, -10 },
  { 914, 7, 10, 11, 2, -10 },
  { 923, 8, 10, 11, 2, -10 },
  { 933, 8, 14, 11, 2, -10 },
  { 947, 7, 14, 11, 2, -10 },
  { 960, 9, 10, 11, 2, -10 },
  { 972, 8, 10, 11, 2, -10 },
  { 982, 9, 13, 11, 1, -13 },
  { 997, 7, 10, 11, 2, -10 },
  { 1006, 8, 10, 11, 2, -10 },
  { 1016, 10, 10, 11, 1, -10 },
  { 1029, 8, 10, 11, 2, -10 },
  { 1039, 8, 14, 11, 2, -10 },
  { 1053, 7, 10, 11, 2, -10 },
  { 1062, 7, 17, 11, 2, -14 },
  { 1077, 1, 17, 11, 5, -14 },
  { 1080, 7, 17, 11, 2, -14 },
  { 1095, 9, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_Thin19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_THIN19PT7B_H_
