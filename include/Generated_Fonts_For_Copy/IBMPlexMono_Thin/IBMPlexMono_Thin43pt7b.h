#ifndef _IBMPLEXMONO_THIN43PT7B_H_
#define _IBMPLEXMONO_THIN43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x00, 0x3E,
  0xC0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x00, 0x20,
  0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x40,
  0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x40, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x80, 0x80, 0x00, 0x80,
  0x80, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x01,
  0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0x02,
  0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x03, 0xFC, 0x00, 0xC2, 0x30, 0x30, 0x20, 0xC6, 0x02, 0x06,
  0x40, 0x20, 0x24, 0x02, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x40, 0x20,
  0x04, 0x02, 0x00, 0x40, 0x20, 0x02, 0x02, 0x00, 0x10, 0x20, 0x00, 0xE2,
  0x00, 0x01, 0xF0, 0x00, 0x02, 0xF0, 0x00, 0x21, 0x80, 0x02, 0x04, 0x00,
  0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x01, 0x00, 0x20, 0x10,
  0x02, 0x01, 0x80, 0x20, 0x2C, 0x02, 0x02, 0x60, 0x20, 0x63, 0x02, 0x0C,
  0x0C, 0x23, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x0F, 0x80, 0x03, 0x30, 0x40, 0x02, 0x20, 0x20, 0x04,
  0x40, 0x10, 0x04, 0x40, 0x10, 0x08, 0x40, 0x10, 0x10, 0x80, 0x10, 0x10,
  0x80, 0x10, 0x20, 0x80, 0x10, 0x20, 0x40, 0x10, 0x40, 0x40, 0x10, 0x80,
  0x20, 0x20, 0x80, 0x30, 0x41, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x86, 0x08, 0x01, 0x0C, 0x04,
  0x02, 0x08, 0x02, 0x02, 0x08, 0x02, 0x04, 0x10, 0x02, 0x04, 0x10, 0x02,
  0x08, 0x10, 0x02, 0x10, 0x10, 0x02, 0x10, 0x08, 0x02, 0x20, 0x08, 0x02,
  0x20, 0x0C, 0x04, 0x40, 0x06, 0x08, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x30, 0x60, 0x02, 0x01, 0x80, 0x20, 0x06, 0x01, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x34, 0x01,
  0xE2, 0x30, 0x08, 0x20, 0xC0, 0x42, 0x03, 0x02, 0x30, 0x0C, 0x11, 0x00,
  0x21, 0x08, 0x00, 0x88, 0x40, 0x02, 0x42, 0x00, 0x0A, 0x10, 0x00, 0x30,
  0x80, 0x01, 0x84, 0x00, 0x0A, 0x10, 0x00, 0x90, 0x40, 0x08, 0x41, 0x81,
  0x81, 0x03, 0xF0, 0x04, 0xFF, 0xE0, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x0C, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x20, 0x1C, 0x70, 0x87, 0x80,
  0x3E, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x41, 0x80, 0x01, 0x02, 0x00, 0x08, 0x04, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x20, 0x18, 0x00, 0x40, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x33,
  0x26, 0x64, 0x48, 0x88, 0xFF, 0xF0, 0x7D, 0x80, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x60, 0x18, 0x01, 0x01, 0x00, 0x08,
  0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00, 0x81, 0x80, 0x10,
  0x06, 0x06, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x1A, 0x00, 0x03, 0x20,
  0x00, 0x62, 0x00, 0x08, 0x20, 0x01, 0x02, 0x00, 0x60, 0x20, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x07, 0xF0, 0x06, 0x03,
  0x03, 0x00, 0x21, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x68, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0x03, 0x81, 0x00, 0x30, 0x80,
  0x04, 0x40, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x7F, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x24, 0x00, 0x08, 0x80, 0x0C, 0x1C, 0x0E, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x01, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x01, 0x02, 0x00, 0x08, 0x08, 0x00, 0x40, 0x20, 0x01, 0x00, 0x80,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x80, 0x40,
  0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x40, 0x00, 0x82, 0x00, 0x02,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0x88, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x47, 0xF0, 0x16, 0x03, 0x06, 0x00, 0x31, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0xA0, 0x00, 0x2C, 0x00, 0x11,
  0x80, 0x08, 0x18, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x43, 0xF0,
  0x13, 0x03, 0x09, 0x00, 0x32, 0x80, 0x04, 0xC0, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x90, 0x00, 0x26, 0x00, 0x10, 0xC0, 0x0C, 0x1C, 0x0C,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00,
  0x28, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x70, 0x10, 0x01, 0x82, 0x00,
  0x0C, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x01, 0x80,
  0xC0, 0x70, 0x03, 0xF8, 0x00, 0xE0, 0x70, 0x30, 0x00, 0x86, 0x00, 0x04,
  0x40, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x43, 0x00,
  0x08, 0x0C, 0x03, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x03, 0x03, 0x83, 0x00,
  0x30, 0x80, 0x04, 0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x50,
  0x00, 0x36, 0x00, 0x14, 0xC0, 0x09, 0x1C, 0x0C, 0x80, 0xFC, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xD8, 0x37,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x26, 0x64,
  0x48, 0x88, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x06, 0x07, 0x04, 0x00,
  0xC4, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x40, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0xF0,
  0x06, 0x06, 0x04, 0x00, 0x86, 0x00, 0x62, 0x00, 0x12, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x3E, 0x60, 0x20, 0xB0, 0x20, 0x38,
  0x20, 0x0C, 0x10, 0x06, 0x08, 0x03, 0x04, 0x01, 0x82, 0x00, 0xC2, 0x00,
  0x61, 0x00, 0x30, 0x40, 0x18, 0x20, 0x0C, 0x10, 0x06, 0x08, 0x03, 0x02,
  0x01, 0x81, 0x83, 0xC0, 0x7F, 0x50, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x48, 0x00, 0x02, 0x20, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x01,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x80, 0x80, 0x02, 0x01,
  0x00, 0x08, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x02, 0x00, 0x80, 0x04, 0x03, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x44, 0x00, 0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x30,
  0xFF, 0xF8, 0x20, 0x01, 0x88, 0x00, 0x22, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x02, 0x20, 0x01, 0x0F, 0xFF, 0x82, 0x00, 0x18,
  0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0A, 0x00, 0x06, 0x80, 0x03, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xE0,
  0x60, 0x30, 0x02, 0x08, 0x00, 0x23, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x08, 0x40, 0x01,
  0x06, 0x00, 0x40, 0x70, 0x30, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x20, 0x06,
  0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x10, 0x80,
  0x18, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xFD, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x04, 0x08, 0x00, 0x42, 0x00, 0x04,
  0x40, 0x00, 0x90, 0x00, 0x1A, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x20, 0x00, 0x24,
  0x00, 0x0C, 0x40, 0x02, 0x84, 0x00, 0xD0, 0x60, 0x72, 0x03, 0xF8, 0x40,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x20, 0x04,
  0x18, 0x18, 0x07, 0xE0, 0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x04, 0x40,
  0x01, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x06, 0x04, 0x00, 0x80, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x01, 0x0E,
  0x00, 0x22, 0x40, 0x04, 0x84, 0x00, 0xB0, 0xC0, 0x14, 0x08, 0x03, 0x00,
  0x80, 0x40, 0x18, 0x08, 0x01, 0x01, 0x00, 0x10, 0x20, 0x03, 0x04, 0x00,
  0x20, 0x80, 0x02, 0x10, 0x00, 0x62, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00,
  0x0D, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x16, 0x80, 0x05, 0xA0, 0x01, 0x64, 0x00, 0x99, 0x00, 0x26,
  0x40, 0x11, 0x88, 0x04, 0x62, 0x02, 0x18, 0x40, 0x86, 0x10, 0x41, 0x82,
  0x10, 0x60, 0x88, 0x18, 0x12, 0x06, 0x04, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x06, 0x80,
  0x01, 0x90, 0x00, 0x64, 0x00, 0x18, 0x80, 0x06, 0x30, 0x01, 0x84, 0x00,
  0x60, 0x80, 0x18, 0x20, 0x06, 0x04, 0x01, 0x81, 0x00, 0x60, 0x20, 0x18,
  0x08, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60, 0x08, 0x18, 0x02, 0x06, 0x00,
  0x41, 0x80, 0x10, 0x60, 0x02, 0x18, 0x00, 0x86, 0x00, 0x11, 0x80, 0x04,
  0x60, 0x00, 0x98, 0x00, 0x26, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0x30,
  0x01, 0xF8, 0x00, 0x60, 0x60, 0x18, 0x01, 0x01, 0x00, 0x08, 0x20, 0x00,
  0x46, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x20, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00, 0x81, 0x80, 0x10, 0x06, 0x06,
  0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x20, 0x01, 0x88, 0x00, 0x12, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00,
  0x63, 0xFF, 0xE0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x60, 0x60, 0x18, 0x01, 0x01, 0x00, 0x08, 0x20, 0x00, 0x46,
  0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x20,
  0x00, 0x42, 0x00, 0x04, 0x10, 0x00, 0x81, 0x80, 0x10, 0x06, 0x06, 0x00,
  0x3F, 0x80, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x20, 0x01, 0x88, 0x00, 0x12, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00,
  0x63, 0xFF, 0xE0, 0x80, 0x80, 0x20, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x80, 0x20, 0x20, 0x04, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x04, 0x20,
  0x01, 0x88, 0x00, 0x22, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x20, 0x03,
  0xFC, 0x00, 0xC0, 0x30, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x40, 0x00, 0x24,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x2C, 0x00, 0x02, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x0C, 0x03, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x28, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x26,
  0x00, 0x10, 0x80, 0x0C, 0x18, 0x06, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x0A,
  0x00, 0x00, 0x50, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00,
  0x08, 0xC0, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x02, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x10, 0x08, 0x00, 0x80, 0x80, 0x02,
  0x04, 0x00, 0x10, 0x20, 0x00, 0x82, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x88, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0xA0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x40, 0x00, 0x12, 0x01, 0x80, 0x90, 0x0C, 0x04, 0x40, 0x60, 0x22,
  0x04, 0x81, 0x10, 0x24, 0x08, 0x81, 0x20, 0x44, 0x11, 0x02, 0x20, 0x84,
  0x11, 0x04, 0x20, 0x88, 0x41, 0x04, 0x42, 0x04, 0x42, 0x10, 0x22, 0x10,
  0x81, 0x10, 0x48, 0x0C, 0x82, 0x40, 0x24, 0x12, 0x01, 0x20, 0xA0, 0x09,
  0x05, 0x00, 0x28, 0x28, 0x01, 0x41, 0x40, 0x0A, 0x0C, 0x00, 0x20, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x42, 0x00, 0x01, 0x04, 0x00, 0x08, 0x18, 0x00,
  0x40, 0x20, 0x01, 0x00, 0x40, 0x08, 0x01, 0x80, 0x40, 0x02, 0x01, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x40, 0x00, 0x21, 0x00, 0x00, 0x48, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x40, 0x80, 0x03, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x20, 0x08, 0x00, 0x40, 0x40, 0x00, 0x83, 0x00,
  0x02, 0x08, 0x00, 0x04, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x20, 0x00, 0x04, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x03, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x24, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x1F, 0xFC, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x90, 0x00,
  0x11, 0x00, 0x01, 0x08, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x40, 0x20,
  0x08, 0x03, 0x00, 0x80, 0x10, 0x10, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00,
  0x44, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x86,
  0x10, 0x41, 0x08, 0x20, 0x07, 0xF0, 0x01, 0x80, 0xC0, 0x20, 0x02, 0x04,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x07, 0xFF, 0x03, 0x80, 0x10, 0x60, 0x01,
  0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x40, 0x03, 0x06, 0x00, 0x50, 0x30, 0x19, 0x00, 0xFE, 0x0F, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x21, 0xFC, 0x13, 0x03,
  0x8A, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x2C, 0x00,
  0x35, 0x00, 0x32, 0x60, 0x71, 0x0F, 0xE0, 0x03, 0xF0, 0x06, 0x06, 0x0C,
  0x00, 0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0xC8, 0x00, 0x46,
  0x00, 0x40, 0xC0, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0xFC, 0x21, 0x81, 0x91, 0x80, 0x29, 0x00, 0x0C,
  0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x24, 0x00, 0x12, 0x00, 0x18, 0x80, 0x1C, 0x30, 0x32,
  0x07, 0xF1, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x04, 0x40,
  0x00, 0x90, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x12, 0x00, 0x08, 0x40, 0x04, 0x0C,
  0x06, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x20, 0x03, 0xF2, 0x00, 0xC0, 0xE0, 0x18, 0x02, 0x03, 0x00, 0x10, 0x20,
  0x01, 0x02, 0x00, 0x10, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x02,
  0x00, 0x10, 0x20, 0x01, 0x01, 0x00, 0x10, 0x08, 0x02, 0x00, 0x40, 0xC0,
  0x0F, 0xF0, 0x01, 0x80, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0x00, 0x0C, 0x40, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x40,
  0x00, 0x43, 0x00, 0x38, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x87, 0xF0, 0x98, 0x18, 0xA0, 0x04, 0xC0, 0x02, 0xC0,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x7F, 0xFC, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x1A, 0x00, 0x08, 0x80, 0x04, 0x20, 0x02, 0x08,
  0x03, 0x02, 0x01, 0x80, 0x80, 0x80, 0x20, 0x40, 0x08, 0x20, 0x02, 0x14,
  0x00, 0x99, 0x80, 0x2C, 0x20, 0x0C, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10,
  0x20, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x48,
  0x00, 0x0A, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x03, 0xFF, 0xFF, 0x8F, 0x07, 0x8B, 0x08, 0x86, 0xC0, 0x50, 0x2C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01,
  0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40,
  0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04,
  0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x87,
  0xF0, 0x98, 0x18, 0xA0, 0x04, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x03, 0xF0, 0x03, 0x03, 0x03,
  0x00, 0x20, 0x80, 0x04, 0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x22,
  0x00, 0x10, 0xC0, 0x08, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x87, 0xF0, 0x4C,
  0x0E, 0x28, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x14, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xB0,
  0x00, 0xD4, 0x00, 0xC9, 0x81, 0xC4, 0x3F, 0x82, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xF0, 0x86, 0x06, 0x46, 0x00, 0xA4, 0x00, 0x32,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0x90, 0x00, 0x48, 0x00, 0x62, 0x00, 0x70, 0xC0, 0xC8,
  0x1F, 0xC4, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0xFF, 0x87, 0xF8,
  0x04, 0xC0, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x06, 0x03, 0x82,
  0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x14,
  0x00, 0x04, 0x80, 0x02, 0x1C, 0x07, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x05, 0x00, 0x19,
  0x00, 0x53, 0x81, 0x21, 0xFC, 0x40, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x40, 0x08,
  0x10, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x04, 0x08, 0x01,
  0x02, 0x00, 0x41, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x05, 0x00, 0x60, 0x12, 0x01, 0x80, 0x48, 0x09, 0x01, 0x20,
  0x24, 0x08, 0x80, 0x90, 0x21, 0x02, 0x40, 0x84, 0x09, 0x02, 0x10, 0x42,
  0x10, 0x41, 0x08, 0x40, 0x84, 0x21, 0x02, 0x10, 0x84, 0x08, 0x42, 0x20,
  0x22, 0x08, 0x80, 0x48, 0x12, 0x01, 0x20, 0x50, 0x04, 0x81, 0x40, 0x0A,
  0x05, 0x00, 0x30, 0x14, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x00, 0xD0,
  0x00, 0x22, 0x00, 0x10, 0x40, 0x08, 0x18, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x80, 0x08, 0x40, 0x03, 0x20, 0x00, 0x58, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x20, 0x00, 0x88, 0x00, 0x21, 0x00, 0x10, 0x20, 0x08, 0x04, 0x04,
  0x01, 0x81, 0x00, 0x20, 0x80, 0x04, 0x40, 0x00, 0xA0, 0x00, 0x30, 0x80,
  0x00, 0x60, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x08, 0x00,
  0x42, 0x00, 0x10, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02,
  0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x01,
  0xC0, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF,
  0x80, 0x0F, 0x00, 0x08, 0x84, 0x00, 0x48, 0x10, 0x02, 0x40, 0x40, 0x14,
  0x01, 0x01, 0x20, 0x04, 0x09, 0x00, 0x10, 0x90, 0x00, 0x78,
};

const GFXglyph IBMPlexMono_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 3, 30, 26, 11, -30 },
  { 13, 6, 11, 26, 10, -32 },
  { 22, 24, 30, 26, 1, -30 },
  { 112, 20, 38, 26, 3, -34 },
  { 207, 24, 30, 26, 1, -30 },
  { 297, 21, 30, 26, 2, -30 },
  { 376, 1, 11, 26, 12, -32 },
  { 378, 10, 39, 26, 10, -33 },
  { 427, 10, 39, 26, 6, -33 },
  { 476, 22, 21, 26, 2, -24 },
  { 534, 20, 21, 26, 3, -24 },
  { 587, 4, 10, 26, 10, -3 },
  { 592, 12, 1, 26, 7, -14 },
  { 594, 3, 3, 26, 11, -3 },
  { 596, 16, 39, 26, 5, -33 },
  { 674, 20, 30, 26, 3, -30 },
  { 749, 20, 30, 26, 4, -30 },
  { 824, 18, 30, 26, 4, -30 },
  { 892, 18, 30, 26, 3, -30 },
  { 960, 22, 30, 26, 2, -30 },
  { 1043, 18, 30, 26, 4, -30 },
  { 1111, 18, 30, 26, 4, -30 },
  { 1179, 19, 30, 26, 3, -30 },
  { 1251, 20, 30, 26, 3, -30 },
  { 1326, 18, 30, 26, 4, -30 },
  { 1394, 3, 23, 26, 11, -23 },
  { 1403, 4, 30, 26, 10, -23 },
  { 1418, 18, 23, 26, 4, -25 },
  { 1470, 20, 8, 26, 3, -17 },
  { 1490, 18, 23, 26, 4, -25 },
  { 1542, 17, 30, 26, 4, -30 },
  { 1606, 17, 35, 26, 4, -30 },
  { 1681, 22, 30, 26, 2, -30 },
  { 1764, 18, 30, 26, 4, -30 },
  { 1832, 19, 30, 26, 3, -30 },
  { 1904, 18, 30, 26, 5, -30 },
  { 1972, 17, 30, 26, 5, -30 },
  { 2036, 17, 30, 26, 5, -30 },
  { 2100, 19, 30, 26, 3, -30 },
  { 2172, 18, 30, 26, 4, -30 },
  { 2240, 18, 30, 26, 4, -30 },
  { 2308, 16, 30, 26, 4, -30 },
  { 2368, 19, 30, 26, 5, -30 },
  { 2440, 17, 30, 26, 6, -30 },
  { 2504, 18, 30, 26, 4, -30 },
  { 2572, 18, 30, 26, 4, -30 },
  { 2640, 20, 30, 26, 3, -30 },
  { 2715, 18, 30, 26, 5, -30 },
  { 2783, 20, 35, 26, 3, -30 },
  { 2871, 18, 30, 26, 5, -30 },
  { 2939, 20, 30, 26, 3, -30 },
  { 3014, 22, 30, 26, 2, -30 },
  { 3097, 18, 30, 26, 4, -30 },
  { 3165, 21, 30, 26, 2, -30 },
  { 3244, 21, 30, 26, 2, -30 },
  { 3323, 22, 30, 26, 2, -30 },
  { 3406, 24, 30, 26, 1, -30 },
  { 3496, 22, 30, 26, 2, -30 },
  { 3579, 11, 39, 26, 11, -33 },
  { 3633, 16, 39, 26, 5, -33 },
  { 3711, 10, 39, 26, 4, -33 },
  { 3760, 20, 16, 26, 3, -30 },
  { 3800, 20, 1, 26, 3, 5 },
  { 3803, 5, 7, 26, 9, -33 },
  { 3808, 20, 22, 26, 3, -22 },
  { 3863, 17, 32, 26, 5, -32 },
  { 3931, 17, 22, 26, 5, -22 },
  { 3978, 17, 32, 26, 3, -32 },
  { 4046, 18, 22, 26, 4, -22 },
  { 4096, 19, 32, 26, 4, -32 },
  { 4172, 20, 33, 26, 4, -24 },
  { 4255, 16, 32, 26, 5, -32 },
  { 4319, 18, 32, 26, 5, -32 },
  { 4391, 15, 41, 26, 4, -32 },
  { 4468, 18, 32, 26, 6, -32 },
  { 4540, 18, 32, 26, 4, -32 },
  { 4612, 20, 22, 26, 3, -22 },
  { 4667, 16, 22, 26, 5, -22 },
  { 4711, 18, 22, 26, 4, -22 },
  { 4761, 17, 31, 26, 5, -22 },
  { 4827, 17, 31, 26, 3, -22 },
  { 4893, 21, 22, 26, 3, -22 },
  { 4951, 18, 22, 26, 4, -22 },
  { 5001, 20, 30, 26, 2, -30 },
  { 5076, 15, 22, 26, 5, -22 },
  { 5118, 18, 22, 26, 4, -22 },
  { 5168, 22, 22, 26, 2, -22 },
  { 5229, 18, 22, 26, 4, -22 },
  { 5279, 18, 31, 26, 4, -22 },
  { 5349, 17, 22, 26, 4, -22 },
  { 5396, 16, 39, 26, 5, -33 },
  { 5474, 1, 39, 26, 12, -33 },
  { 5479, 16, 39, 26, 5, -33 },
  { 5557, 21, 8, 26, 2, -17 },
};

const GFXfont IBMPlexMono_Thin43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_THIN43PT7B_H_
