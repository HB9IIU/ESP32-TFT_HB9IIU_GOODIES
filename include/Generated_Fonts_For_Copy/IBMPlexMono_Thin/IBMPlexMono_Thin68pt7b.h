#ifndef _IBMPLEXMONO_THIN68PT7B_H_
#define _IBMPLEXMONO_THIN68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0xFD, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x01, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xF0, 0x87, 0x80, 0x03, 0x80, 0x80, 0xE0, 0x06, 0x00, 0x80, 0x38, 0x0C,
  0x00, 0x80, 0x1C, 0x18, 0x00, 0x80, 0x06, 0x10, 0x00, 0x80, 0x06, 0x30,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00,
  0xF0, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x83, 0x80, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x80, 0x02, 0x40, 0x00, 0x80, 0x06, 0xE0, 0x00, 0x80, 0x04, 0x30,
  0x00, 0x80, 0x0C, 0x18, 0x00, 0x80, 0x18, 0x0E, 0x00, 0x80, 0x30, 0x03,
  0x80, 0x80, 0x60, 0x01, 0xF0, 0x83, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0xC0, 0x00, 0x04, 0x60, 0x03, 0x00, 0x00, 0x42, 0x00, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x20, 0x00, 0x21, 0x00, 0x01, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x20, 0x01, 0x06, 0x00, 0x01, 0x00,
  0x18, 0x30, 0x00, 0x08, 0x00, 0x81, 0x80, 0x00, 0x40, 0x0C, 0x0C, 0x00,
  0x02, 0x00, 0x40, 0x60, 0x00, 0x10, 0x04, 0x01, 0x00, 0x00, 0x80, 0x60,
  0x08, 0x00, 0x0C, 0x02, 0x00, 0x40, 0x00, 0x40, 0x30, 0x03, 0x00, 0x02,
  0x01, 0x00, 0x08, 0x00, 0x30, 0x10, 0x00, 0x60, 0x03, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x08, 0x00, 0x03, 0x03, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0x40, 0x08, 0x00, 0x08, 0x04, 0x00, 0x20, 0x00, 0xC0,
  0x60, 0x01, 0x80, 0x04, 0x02, 0x00, 0x04, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x02, 0x01, 0x00, 0x00, 0x80, 0x20, 0x08, 0x00, 0x04, 0x03, 0x00, 0x40,
  0x00, 0x20, 0x10, 0x02, 0x00, 0x01, 0x01, 0x80, 0x10, 0x00, 0x08, 0x08,
  0x00, 0x80, 0x00, 0x40, 0x80, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x20, 0x00,
  0x10, 0x40, 0x01, 0x00, 0x00, 0x86, 0x00, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0x20, 0x00, 0x42, 0x00, 0x01, 0x80, 0x06, 0x30, 0x00, 0x04, 0x00, 0x21,
  0x00, 0x00, 0x10, 0x02, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x08, 0x00, 0x1F,
  0xC3, 0x03, 0x00, 0x04, 0x01, 0x80, 0x60, 0x01, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x20, 0x01, 0x80, 0x10, 0x18, 0x00, 0x30, 0x04, 0x04, 0x00, 0x04,
  0x01, 0x03, 0x00, 0x00, 0x80, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x30, 0x00,
  0x06, 0x0C, 0x08, 0x00, 0x00, 0xC2, 0x02, 0x00, 0x00, 0x18, 0x80, 0x80,
  0x00, 0x02, 0x20, 0x20, 0x00, 0x00, 0x58, 0x08, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0x2C,
  0x06, 0x00, 0x00, 0x19, 0x80, 0x80, 0x00, 0x0C, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x18, 0x0E, 0x03,
  0x80, 0x02, 0x00, 0xFF, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x04, 0x00, 0x05, 0xF0,
  0x00, 0x80, 0x0F, 0xC3, 0xE0, 0x10, 0x0F, 0x80, 0x0F, 0x82, 0x0F, 0x80,
  0x00, 0x3E, 0x4F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1C, 0x71, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x43, 0x0C, 0x20,
  0x80, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x72, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x80,
  0x40, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x0E, 0x00, 0x06,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x10, 0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x04,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x3F, 0xE0, 0x02, 0x1C, 0x01, 0xC0, 0x22, 0x00, 0x06,
  0x02, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x03, 0xC0, 0x38,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x7F, 0xC0, 0x02, 0x1C, 0x03, 0xC0, 0x31, 0x80, 0x03, 0x01,
  0x30, 0x00, 0x0E, 0x0B, 0x00, 0x00, 0x10, 0x50, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0A, 0x18, 0x00, 0x00, 0x90,
  0x70, 0x00, 0x0C, 0x80, 0xC0, 0x01, 0x8C, 0x03, 0xC0, 0x38, 0x40, 0x03,
  0xFE, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x77,
  0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0x1C, 0x7C,
  0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x82,
  0x0C, 0x18, 0x20, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x18, 0x00, 0x30, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x32, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x00, 0x10,
  0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x10, 0x18, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x58, 0x00, 0x7F, 0x0A, 0x00, 0x38, 0x19, 0x40, 0x0C, 0x01, 0xA8,
  0x03, 0x00, 0x15, 0x00, 0x40, 0x01, 0xA0, 0x18, 0x00, 0x34, 0x02, 0x00,
  0x03, 0x80, 0x40, 0x00, 0x70, 0x08, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0x80, 0x00,
  0xA0, 0x10, 0x00, 0x14, 0x03, 0x00, 0x02, 0x80, 0x20, 0x00, 0xD0, 0x06,
  0x00, 0x1A, 0x00, 0x40, 0x05, 0x60, 0x06, 0x01, 0x2C, 0x00, 0x7B, 0xC5,
  0x80, 0x01, 0x80, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xE0, 0x08, 0x00, 0x03, 0x80, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x08,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0x00, 0x80, 0x00,
  0x0E, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x08,
  0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x80, 0x80, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x70, 0x80, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0B, 0x06, 0x00, 0x00, 0x4C, 0x0C, 0x00, 0x03,
  0x30, 0x1C, 0x00, 0x38, 0xC0, 0x1C, 0x03, 0x83, 0x00, 0x0F, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x07, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x01, 0x60, 0x00, 0x0C, 0x0C, 0xC0, 0x00, 0x30, 0x61, 0x80, 0x00,
  0xC3, 0x06, 0x00, 0x03, 0x18, 0x0C, 0x00, 0x0C, 0xC0, 0x18, 0x00, 0x36,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x0B, 0x60,
  0x00, 0x00, 0xDB, 0x00, 0x00, 0x04, 0xC8, 0x00, 0x00, 0x66, 0x60, 0x00,
  0x02, 0x31, 0x00, 0x00, 0x31, 0x8C, 0x00, 0x01, 0x0C, 0x20, 0x00, 0x08,
  0x61, 0x80, 0x00, 0xC3, 0x04, 0x00, 0x04, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x80, 0x02, 0x06, 0x06, 0x00, 0x30, 0x30, 0x30, 0x01, 0x01, 0x80, 0x80,
  0x18, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x40,
  0x18, 0x02, 0x02, 0x00, 0xC0, 0x18, 0x30, 0x06, 0x00, 0x41, 0x00, 0x30,
  0x03, 0x18, 0x01, 0x80, 0x08, 0x80, 0x0C, 0x00, 0x6C, 0x00, 0x60, 0x03,
  0x40, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x10, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x04, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF8, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x80, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40,
  0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x03,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x80, 0x00, 0xE0, 0x01,
  0xF0, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x01, 0xE0, 0x0E, 0x00,
  0x07, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x04, 0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x07, 0x00, 0x08, 0xC0, 0x03, 0x80, 0x04, 0x20,
  0x01, 0x40, 0x02, 0x10, 0x01, 0xA0, 0x01, 0x08, 0x00, 0xD8, 0x00, 0x84,
  0x00, 0x44, 0x00, 0x42, 0x00, 0x22, 0x00, 0x61, 0x00, 0x31, 0x80, 0x30,
  0xC0, 0x10, 0xC0, 0x18, 0x60, 0x08, 0x20, 0x0C, 0x30, 0x0C, 0x10, 0x04,
  0x18, 0x06, 0x0C, 0x02, 0x04, 0x02, 0x02, 0x01, 0x02, 0x03, 0x01, 0x00,
  0x81, 0x01, 0x80, 0xC0, 0x40, 0x80, 0x80, 0x60, 0x20, 0x40, 0x40, 0x10,
  0x30, 0x20, 0x60, 0x0C, 0x18, 0x18, 0x20, 0x06, 0x0C, 0x0C, 0x10, 0x01,
  0x06, 0x06, 0x18, 0x00, 0x82, 0x03, 0x0C, 0x00, 0x61, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x46, 0x00, 0x08, 0x40, 0x23, 0x00, 0x06, 0x20, 0x11, 0x00,
  0x03, 0x10, 0x08, 0x80, 0x00, 0x98, 0x04, 0xC0, 0x00, 0x6C, 0x03, 0x40,
  0x00, 0x36, 0x01, 0xA0, 0x00, 0x0B, 0x00, 0xF0, 0x00, 0x05, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x20, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x20, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0xFF,
  0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0x20, 0x06, 0x00, 0x00, 0x20, 0x08,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xA0,
  0x30, 0x00, 0x01, 0x40, 0x20, 0x00, 0x04, 0x80, 0x60, 0x00, 0x11, 0x00,
  0x60, 0x00, 0x42, 0x00, 0x38, 0x07, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x1F, 0xE0, 0x06, 0x0E, 0x03, 0x80, 0xC6, 0x00, 0x18, 0x19, 0x80, 0x00,
  0xC3, 0x40, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x19, 0xE0, 0x00, 0x02, 0x34,
  0x00, 0x00, 0xC6, 0x40, 0x00, 0x30, 0xC6, 0x00, 0x18, 0x18, 0x38, 0x0E,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x10, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF8,
  0x08, 0x07, 0x01, 0xC1, 0x03, 0x00, 0x06, 0x20, 0xC0, 0x00, 0x64, 0x30,
  0x00, 0x06, 0x84, 0x00, 0x00, 0x51, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x43, 0x00, 0x00,
  0x68, 0x30, 0x00, 0x19, 0x03, 0x00, 0x06, 0x20, 0x1C, 0x07, 0x04, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xE3, 0x00, 0x00, 0xE0, 0x3B, 0x00, 0x01, 0x80, 0x07, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0xFF, 0x00, 0x87, 0x00, 0xE0, 0x8C, 0x00, 0x30, 0x90, 0x00, 0x18,
  0xA0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x7F, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x06, 0x60, 0x00, 0x18, 0x61,
  0x80, 0x00, 0xC6, 0x06, 0x00, 0x06, 0x60, 0x10, 0x00, 0x36, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x07, 0xE1, 0x18, 0x38, 0x30, 0x62, 0x40, 0x10, 0x80, 0x25, 0x00, 0x12,
  0x00, 0x6A, 0x00, 0x28, 0x00, 0x58, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x40,
  0x01, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x01, 0x00, 0x07, 0x00, 0x02, 0x00,
  0x0E, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x70, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x40, 0x01, 0xC0, 0x00, 0x80, 0x03,
  0x80, 0x01, 0x00, 0x07, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x38, 0x00, 0x10, 0x00, 0x70, 0x00, 0x20, 0x00, 0xE0,
  0x00, 0x40, 0x01, 0xC0, 0x00, 0x80, 0x03, 0x80, 0x01, 0x00, 0x07, 0x00,
  0x02, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x70, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x40, 0x01, 0xC0, 0x00,
  0x80, 0x03, 0x80, 0x01, 0x00, 0x07, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x04,
  0x00, 0x1C, 0x00, 0x08, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x87, 0x00, 0xE0,
  0x8C, 0x00, 0x30, 0x90, 0x00, 0x18, 0xA0, 0x00, 0x0C, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x18, 0x38, 0x0E, 0x03, 0x18, 0x00, 0x60, 0x66, 0x00, 0x03, 0x0D, 0x00,
  0x00, 0x31, 0xE0, 0x00, 0x02, 0x38, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0x38, 0x00, 0x00, 0x67, 0x80, 0x00, 0x08, 0xD0, 0x00, 0x03,
  0x19, 0x00, 0x00, 0xC3, 0x18, 0x00, 0x60, 0x60, 0xE0, 0x38, 0x0C, 0x07,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1C, 0x07, 0x04, 0x0C, 0x00, 0x18, 0x83, 0x00, 0x01, 0x90,
  0xC0, 0x00, 0x1A, 0x10, 0x00, 0x01, 0x44, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x05, 0x0C, 0x00,
  0x01, 0xA0, 0xC0, 0x00, 0x64, 0x0C, 0x00, 0x18, 0x80, 0x70, 0x1C, 0x10,
  0x03, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x60, 0x03, 0xC0, 0x1E, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x05, 0x30, 0x00, 0x05, 0x18,
  0x00, 0x09, 0x0C, 0x00, 0x31, 0x07, 0x00, 0xE1, 0x00, 0xFF, 0x00, 0xC0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20,
  0x02, 0x00, 0x02, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x14, 0x00, 0x06, 0x00,
  0x02, 0x80, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x04,
  0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x12, 0x00, 0x18, 0x80,
  0x06, 0x60, 0x02, 0x18, 0x00, 0xCC, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08,
  0x20, 0x02, 0x10, 0x03, 0x04, 0x00, 0x42, 0x00, 0x40, 0xC0, 0x08, 0x40,
  0x08, 0x08, 0x03, 0x0C, 0x01, 0x01, 0x00, 0x60, 0x80, 0x60, 0x30, 0x08,
  0x10, 0x08, 0x06, 0x01, 0x02, 0x01, 0x00, 0x40, 0x20, 0x40, 0x20, 0x08,
  0x0C, 0x0C, 0x0C, 0x01, 0x81, 0x81, 0x81, 0x00, 0x10, 0x20, 0x10, 0x20,
  0x02, 0x04, 0x02, 0x04, 0x00, 0x40, 0x80, 0x41, 0x80, 0x0C, 0x30, 0x0C,
  0x20, 0x00, 0x86, 0x01, 0x84, 0x00, 0x10, 0x80, 0x11, 0x80, 0x02, 0x10,
  0x02, 0x20, 0x00, 0x62, 0x00, 0x44, 0x00, 0x04, 0x40, 0x08, 0x80, 0x00,
  0x98, 0x01, 0xB0, 0x00, 0x12, 0x00, 0x14, 0x00, 0x03, 0x40, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x50, 0x00, 0x05, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x03, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x08, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x00, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x86, 0x0C, 0x00, 0x00, 0xC6, 0x03, 0x00, 0x00, 0x46, 0x00,
  0x40, 0x00, 0x22, 0x00, 0x10, 0x00, 0x33, 0x00, 0x04, 0x00, 0x11, 0x00,
  0x01, 0x00, 0x08, 0x80, 0x00, 0x40, 0x08, 0xC0, 0x00, 0x10, 0x0C, 0x40,
  0x00, 0x06, 0x18, 0x20, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 5, 47, 41, 18, -47 },
  { 31, 11, 17, 41, 15, -50 },
  { 55, 38, 47, 41, 1, -47 },
  { 279, 32, 63, 41, 4, -55 },
  { 531, 37, 49, 41, 2, -48 },
  { 758, 34, 49, 41, 3, -48 },
  { 967, 1, 17, 41, 20, -50 },
  { 970, 16, 61, 41, 16, -52 },
  { 1092, 16, 61, 41, 9, -52 },
  { 1214, 35, 34, 41, 3, -37 },
  { 1363, 33, 33, 41, 4, -37 },
  { 1500, 6, 17, 41, 16, -5 },
  { 1513, 18, 1, 41, 11, -21 },
  { 1516, 5, 4, 41, 18, -4 },
  { 1519, 27, 61, 41, 7, -52 },
  { 1725, 31, 49, 41, 5, -48 },
  { 1915, 31, 47, 41, 6, -47 },
  { 2098, 29, 48, 41, 6, -48 },
  { 2272, 28, 49, 41, 5, -48 },
  { 2444, 34, 47, 41, 3, -47 },
  { 2644, 28, 48, 41, 6, -47 },
  { 2812, 29, 48, 41, 6, -47 },
  { 2986, 30, 47, 41, 5, -47 },
  { 3163, 31, 49, 41, 5, -48 },
  { 3353, 29, 48, 41, 6, -48 },
  { 3527, 5, 36, 41, 18, -36 },
  { 3550, 7, 48, 41, 16, -36 },
  { 3592, 29, 36, 41, 6, -39 },
  { 3723, 33, 13, 41, 4, -27 },
  { 3777, 29, 36, 41, 6, -39 },
  { 3908, 27, 48, 41, 7, -48 },
  { 4070, 27, 55, 41, 6, -48 },
  { 4256, 33, 47, 41, 4, -47 },
  { 4450, 28, 47, 41, 7, -47 },
  { 4615, 30, 49, 41, 5, -48 },
  { 4799, 29, 47, 41, 7, -47 },
  { 4970, 28, 47, 41, 7, -47 },
  { 5135, 28, 47, 41, 7, -47 },
  { 5300, 30, 49, 41, 5, -48 },
  { 5484, 27, 47, 41, 7, -47 },
  { 5643, 29, 47, 41, 6, -47 },
  { 5814, 24, 48, 41, 7, -47 },
  { 5958, 30, 47, 41, 7, -47 },
  { 6135, 26, 47, 41, 10, -47 },
  { 6288, 29, 47, 41, 6, -47 },
  { 6459, 27, 47, 41, 7, -47 },
  { 6618, 31, 49, 41, 5, -48 },
  { 6808, 29, 47, 41, 7, -47 },
  { 6979, 31, 57, 41, 5, -48 },
  { 7200, 29, 47, 41, 7, -47 },
  { 7371, 32, 49, 41, 4, -48 },
  { 7567, 35, 47, 41, 3, -47 },
  { 7773, 27, 48, 41, 7, -47 },
  { 7935, 33, 47, 41, 4, -47 },
  { 8129, 33, 47, 41, 4, -47 },
  { 8323, 34, 47, 41, 3, -47 },
  { 8523, 37, 47, 41, 2, -47 },
  { 8741, 35, 47, 41, 3, -47 },
  { 8947, 16, 61, 41, 18, -52 },
  { 9069, 27, 61, 41, 7, -52 },
  { 9275, 16, 61, 41, 7, -52 },
  { 9397, 31, 26, 41, 5, -47 },
  { 9498, 33, 1, 41, 4, 8 },
  { 9503, 9, 11, 41, 14, -52 },
  { 9516, 31, 37, 41, 5, -36 },
  { 9660, 27, 51, 41, 8, -50 },
  { 9833, 27, 37, 41, 7, -36 },
  { 9958, 27, 51, 41, 5, -50 },
  { 10131, 29, 37, 41, 6, -36 },
  { 10266, 30, 50, 41, 6, -50 },
  { 10454, 32, 52, 41, 6, -38 },
  { 10662, 24, 50, 41, 9, -50 },
  { 10812, 28, 51, 41, 8, -51 },
  { 10991, 23, 65, 41, 7, -51 },
  { 11178, 29, 50, 41, 9, -50 },
  { 11360, 29, 50, 41, 6, -50 },
  { 11542, 31, 36, 41, 5, -36 },
  { 11682, 24, 36, 41, 9, -36 },
  { 11790, 29, 37, 41, 6, -36 },
  { 11925, 27, 50, 41, 8, -36 },
  { 12094, 27, 50, 41, 5, -36 },
  { 12263, 33, 35, 41, 5, -35 },
  { 12408, 29, 37, 41, 6, -36 },
  { 12543, 34, 47, 41, 2, -47 },
  { 12743, 24, 36, 41, 8, -35 },
  { 12851, 28, 35, 41, 6, -35 },
  { 12974, 35, 35, 41, 3, -35 },
  { 13128, 29, 35, 41, 6, -35 },
  { 13255, 29, 49, 41, 6, -35 },
  { 13433, 27, 35, 41, 7, -35 },
  { 13552, 25, 61, 41, 8, -52 },
  { 13743, 1, 61, 41, 20, -52 },
  { 13751, 25, 61, 41, 8, -52 },
  { 13942, 33, 11, 41, 4, -26 },
};

const GFXfont IBMPlexMono_Thin68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_THIN68PT7B_H_
