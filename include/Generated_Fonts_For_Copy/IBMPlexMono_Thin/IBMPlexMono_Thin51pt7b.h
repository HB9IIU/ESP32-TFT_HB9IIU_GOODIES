#ifndef _IBMPLEXMONO_THIN51PT7B_H_
#define _IBMPLEXMONO_THIN51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x1F, 0xF0, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x80, 0x40, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x03, 0x01, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x02, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x60,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x80, 0x40, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x08,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x10, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0x08, 0xF0, 0x0C, 0x08, 0x18, 0x10, 0x08,
  0x0C, 0x30, 0x08, 0x02, 0x20, 0x08, 0x02, 0x60, 0x08, 0x00, 0x40, 0x08,
  0x00, 0x40, 0x08, 0x00, 0x40, 0x08, 0x00, 0x40, 0x08, 0x00, 0x60, 0x08,
  0x00, 0x20, 0x08, 0x00, 0x30, 0x08, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x08,
  0x00, 0x07, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x08,
  0x70, 0x00, 0x08, 0x18, 0x00, 0x08, 0x04, 0x00, 0x08, 0x06, 0x00, 0x08,
  0x02, 0x00, 0x08, 0x03, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08,
  0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x02, 0xC0, 0x08,
  0x02, 0x60, 0x08, 0x06, 0x30, 0x08, 0x0C, 0x0C, 0x08, 0x18, 0x07, 0x08,
  0x60, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x00, 0x11, 0x83,
  0x00, 0x02, 0x30, 0x08, 0x00, 0x22, 0x00, 0x40, 0x04, 0x40, 0x04, 0x00,
  0xC4, 0x00, 0x60, 0x08, 0x40, 0x02, 0x01, 0x04, 0x00, 0x20, 0x10, 0x40,
  0x02, 0x02, 0x04, 0x00, 0x20, 0x60, 0x40, 0x02, 0x04, 0x04, 0x00, 0x60,
  0x80, 0x40, 0x04, 0x08, 0x02, 0x00, 0x41, 0x00, 0x30, 0x08, 0x30, 0x01,
  0x83, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x40, 0x08, 0x10, 0x02, 0x01, 0x02, 0x00, 0x20, 0x10,
  0x20, 0x02, 0x02, 0x02, 0x00, 0x10, 0x60, 0x20, 0x01, 0x04, 0x02, 0x00,
  0x10, 0x80, 0x20, 0x01, 0x08, 0x02, 0x00, 0x11, 0x00, 0x20, 0x03, 0x30,
  0x02, 0x00, 0x22, 0x00, 0x10, 0x02, 0x40, 0x01, 0x80, 0x44, 0x00, 0x0C,
  0x18, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x20, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0xC4, 0x00, 0x7C, 0x60, 0x80, 0x30, 0x30, 0x10,
  0x08, 0x08, 0x06, 0x02, 0x04, 0x00, 0xC0, 0x81, 0x00, 0x18, 0x20, 0xC0,
  0x02, 0x08, 0x20, 0x00, 0x42, 0x08, 0x00, 0x08, 0x82, 0x00, 0x01, 0x20,
  0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x00, 0x00,
  0xB0, 0x60, 0x00, 0x46, 0x08, 0x00, 0x30, 0x81, 0x80, 0x18, 0x10, 0x38,
  0x18, 0x02, 0x03, 0xF8, 0x00, 0x40, 0xFF, 0xF8, 0x00, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x03, 0xC0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x10, 0x01, 0x00, 0x3B, 0x80, 0x40, 0x78, 0x1E, 0x10, 0xE0,
  0x00, 0xF5, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x18, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x39, 0x8C,
  0x66, 0x31, 0x88, 0x46, 0x21, 0x08, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x06, 0x03, 0x00,
  0x30, 0x01, 0x00, 0xC0, 0x01, 0x01, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18,
  0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x01, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x10, 0x00, 0x10, 0x30, 0x00, 0x40, 0x30, 0x01, 0x00, 0x38,
  0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xC8, 0x00, 0x01, 0x88, 0x00, 0x03, 0x08, 0x00, 0x06, 0x08, 0x00, 0x0C,
  0x08, 0x00, 0x10, 0x08, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0C, 0x07, 0x00, 0x20,
  0x03, 0x00, 0x80, 0x01, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00,
  0x04, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x70, 0x18, 0x06, 0x00, 0x30, 0x60, 0x00, 0xC6,
  0x00, 0x02, 0x20, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x50, 0x00,
  0x02, 0xC0, 0x00, 0x33, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x1C, 0x07, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x04, 0x10, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x40, 0x40, 0x00, 0x20, 0x10, 0x00, 0x08, 0x04,
  0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0x40, 0x01, 0x80, 0x10, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x10, 0x02,
  0x00, 0x04, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40, 0x20, 0x00, 0x10,
  0x18, 0x00, 0x04, 0x04, 0x00, 0x01, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0xF8, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x7F, 0x80, 0x26, 0x01, 0x80, 0xA0,
  0x01, 0x83, 0x00, 0x03, 0x08, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xB0, 0x00, 0x06, 0x40, 0x00, 0x10, 0x80, 0x00, 0x81, 0x80, 0x04,
  0x03, 0x80, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x3F, 0x80, 0x47, 0x01, 0x81, 0x30, 0x01, 0x85, 0x00, 0x03, 0x18, 0x00,
  0x04, 0x60, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40,
  0x00, 0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0x88, 0x00, 0x02, 0x30, 0x00,
  0x10, 0x40, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0, 0x60, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x22, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x0E, 0x03, 0x80, 0x20, 0x01, 0x80,
  0x80, 0x01, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20,
  0x00, 0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x84, 0x00, 0x03, 0x04, 0x00, 0x04, 0x04, 0x00,
  0x30, 0x07, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x1C, 0x07, 0x00, 0xC0, 0x01,
  0x83, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x01, 0x40, 0x00, 0x02,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x60,
  0x00, 0x08, 0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x70, 0x0E, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x18, 0x06, 0x00, 0x30, 0x60, 0x00,
  0xC6, 0x00, 0x02, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00,
  0x01, 0xCC, 0x00, 0x1A, 0x30, 0x01, 0xA0, 0xE0, 0x39, 0x00, 0xFE, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x31, 0x8C, 0xC6, 0x31, 0x08, 0xC4, 0x21, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x60, 0x38, 0x18, 0x00, 0xC3, 0x00, 0x06, 0x20, 0x00, 0x24,
  0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x30, 0x08, 0x01,
  0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00,
  0x03, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x01, 0xF1, 0x80,
  0x60, 0xD8, 0x08, 0x05, 0x81, 0x80, 0x38, 0x10, 0x01, 0x81, 0x00, 0x18,
  0x10, 0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x18, 0x20, 0x01,
  0x82, 0x00, 0x18, 0x20, 0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x81, 0x00,
  0x18, 0x18, 0x01, 0x80, 0x80, 0x38, 0x04, 0x05, 0x80, 0x3F, 0x94, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x02, 0x60, 0x00, 0x01, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0x60, 0x00, 0x10,
  0x10, 0x00, 0x18, 0x08, 0x00, 0x08, 0x06, 0x00, 0x04, 0x01, 0x00, 0x06,
  0x00, 0x80, 0x02, 0x00, 0x60, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x06, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00, 0x80, 0x20, 0x00, 0x60,
  0x1F, 0xFF, 0xF0, 0x18, 0x00, 0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x10, 0xFF, 0xFE, 0x04, 0x00, 0x1C, 0x20, 0x00,
  0x31, 0x00, 0x00, 0x88, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80,
  0x03, 0x07, 0xFF, 0xF0, 0x20, 0x00, 0x71, 0x00, 0x00, 0xC8, 0x00, 0x03,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x80, 0x00, 0x34, 0x00, 0x03, 0x20, 0x00,
  0x71, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x03, 0x00, 0x60, 0x02,
  0x02, 0x00, 0x04, 0x18, 0x00, 0x08, 0x40, 0x00, 0x12, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x40, 0x60, 0x02, 0x00, 0xE0, 0x30, 0x00, 0x7F, 0x00, 0xFF, 0xF8,
  0x04, 0x00, 0x70, 0x20, 0x00, 0xC1, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40,
  0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x14, 0x00, 0x00,
  0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28,
  0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00,
  0x84, 0x00, 0x18, 0x20, 0x03, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0E, 0x06, 0x00, 0x40, 0x06, 0x02, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x90, 0x00, 0x03, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50,
  0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00,
  0x03, 0x10, 0x00, 0x14, 0x20, 0x00, 0xD0, 0x40, 0x06, 0x40, 0xE0, 0x71,
  0x00, 0xFF, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x06, 0x40, 0x00, 0x8C, 0x00, 0x30, 0xC0, 0x0C,
  0x0E, 0x07, 0x00, 0x3F, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x48, 0x00,
  0x03, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x10,
  0x20, 0x00, 0x80, 0x80, 0x04, 0x02, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x00, 0x80, 0x60, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x40,
  0x00, 0x82, 0x80, 0x02, 0x13, 0x00, 0x08, 0x84, 0x00, 0x24, 0x08, 0x00,
  0xA0, 0x30, 0x03, 0x80, 0x40, 0x0C, 0x00, 0x80, 0x20, 0x03, 0x00, 0x80,
  0x04, 0x02, 0x00, 0x08, 0x08, 0x00, 0x30, 0x20, 0x00, 0x40, 0x80, 0x00,
  0x82, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x08, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x48, 0x00, 0x00, 0xA0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3A, 0x00, 0x00, 0xEC, 0x00,
  0x05, 0x90, 0x00, 0x16, 0x40, 0x00, 0x98, 0x80, 0x02, 0x62, 0x00, 0x19,
  0x84, 0x00, 0x46, 0x10, 0x03, 0x18, 0x20, 0x08, 0x60, 0x80, 0x21, 0x82,
  0x01, 0x06, 0x04, 0x04, 0x18, 0x10, 0x20, 0x60, 0x20, 0x81, 0x80, 0x84,
  0x06, 0x01, 0x10, 0x18, 0x04, 0xC0, 0x60, 0x0A, 0x01, 0x80, 0x28, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x60, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x68, 0x00,
  0x03, 0x40, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x20, 0x00, 0x31,
  0x00, 0x01, 0x84, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x03, 0x06, 0x00,
  0x18, 0x10, 0x00, 0xC0, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x18, 0x01, 0x80,
  0x40, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x01, 0x00,
  0xC0, 0x04, 0x06, 0x00, 0x20, 0x30, 0x00, 0x81, 0x80, 0x04, 0x0C, 0x00,
  0x10, 0x60, 0x00, 0x83, 0x00, 0x02, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x46,
  0x00, 0x02, 0x30, 0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x01, 0x60, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x06, 0x03, 0x00, 0x30, 0x01,
  0x00, 0xC0, 0x01, 0x01, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18, 0x00, 0x02,
  0x20, 0x00, 0x04, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x48, 0x00, 0x01, 0x18, 0x00, 0x02, 0x10, 0x00, 0x0C,
  0x10, 0x00, 0x10, 0x30, 0x00, 0x40, 0x30, 0x01, 0x00, 0x38, 0x0C, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x19, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x04, 0x80, 0x00, 0x64,
  0x00, 0x0C, 0x3F, 0xFF, 0x81, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x06, 0x03, 0x00, 0x30, 0x01, 0x00, 0xC0,
  0x01, 0x01, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x18, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x10, 0x00,
  0x10, 0x30, 0x00, 0x40, 0x30, 0x01, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFE, 0x04, 0x00, 0x0C, 0x20,
  0x00, 0x19, 0x00, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x04,
  0x80, 0x00, 0x64, 0x00, 0x0C, 0x3F, 0xFF, 0x81, 0x00, 0x80, 0x08, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x08, 0x04,
  0x00, 0x20, 0x20, 0x01, 0x81, 0x00, 0x04, 0x08, 0x00, 0x10, 0x40, 0x00,
  0xC2, 0x00, 0x02, 0x10, 0x00, 0x18, 0x80, 0x00, 0x44, 0x00, 0x01, 0x20,
  0x00, 0x0D, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x07, 0x00, 0x60, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x28,
  0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x06, 0x60, 0x00,
  0x21, 0x00, 0x03, 0x04, 0x00, 0x30, 0x18, 0x07, 0x00, 0x3F, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0x80, 0x10, 0x00, 0x40, 0x08,
  0x00, 0x20, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x08, 0x00, 0x30, 0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x02, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x08, 0x20, 0x00, 0x04, 0x30, 0x00, 0x03, 0x10, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x16, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x48, 0x03, 0x00, 0x64, 0x01, 0x80, 0x22, 0x00, 0xA0,
  0x11, 0x00, 0x50, 0x08, 0xC0, 0x48, 0x04, 0x20, 0x22, 0x02, 0x10, 0x11,
  0x01, 0x08, 0x18, 0x80, 0x84, 0x08, 0x60, 0x42, 0x04, 0x10, 0x21, 0x02,
  0x08, 0x10, 0x82, 0x04, 0x10, 0x41, 0x01, 0x08, 0x20, 0x80, 0x84, 0x10,
  0x80, 0x42, 0x04, 0x40, 0x31, 0x02, 0x20, 0x08, 0x81, 0x30, 0x04, 0x40,
  0x90, 0x02, 0x20, 0x48, 0x00, 0x90, 0x24, 0x00, 0x48, 0x14, 0x00, 0x2C,
  0x0A, 0x00, 0x0C, 0x05, 0x00, 0x06, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x60, 0x00, 0x08, 0x08,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0x80, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x10, 0x00, 0x60, 0x08, 0x00, 0x08, 0x06, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08, 0x60, 0x00, 0x06, 0x08,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x60, 0x08, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x06, 0x00, 0x08, 0x01, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x08, 0x10, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x02,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x80, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x43, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01,
  0x00, 0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x20, 0x04, 0x00, 0x10, 0x08,
  0x00, 0x10, 0x08, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0xC0, 0x80, 0x80, 0x81, 0x81, 0x01, 0x03, 0xFC, 0x00, 0x1C, 0x0E,
  0x00, 0x60, 0x06, 0x01, 0x00, 0x04, 0x06, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFC, 0x07,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x40, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00,
  0x18, 0x60, 0x00, 0x50, 0x40, 0x00, 0xA0, 0x40, 0x06, 0x40, 0x60, 0x38,
  0xF8, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x03, 0xF0, 0x08,
  0xE0, 0x60, 0x4C, 0x00, 0xC2, 0x80, 0x03, 0x14, 0x00, 0x08, 0xC0, 0x00,
  0x26, 0x00, 0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00,
  0x00, 0x50, 0x00, 0x02, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x28, 0x00, 0x11,
  0x40, 0x01, 0x89, 0x80, 0x18, 0x47, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x60, 0x30, 0x18, 0x00, 0x83, 0x00, 0x04, 0x20, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x32, 0x00, 0x02, 0x30,
  0x00, 0x41, 0x80, 0x08, 0x06, 0x03, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x1F, 0xC1, 0x07, 0x03, 0x10, 0x80, 0x09, 0x10, 0x00, 0x52, 0x00,
  0x03, 0x20, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00,
  0x31, 0x00, 0x05, 0x08, 0x00, 0x90, 0x60, 0x31, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x30, 0x18, 0x06, 0x00, 0x20, 0x60, 0x00, 0x82, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x00, 0x58, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x44,
  0x00, 0x06, 0x10, 0x00, 0x20, 0xC0, 0x06, 0x01, 0x80, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x07, 0xF2, 0x00,
  0x30, 0x1C, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x08, 0x04, 0x00, 0x10, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00,
  0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x18, 0x00, 0x40, 0x18, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x3F, 0xE0,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x40, 0x01, 0xC3,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x8C, 0x00, 0x02, 0x06, 0x00, 0x38, 0x03, 0xFF, 0x80, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x61, 0xFC, 0x0C, 0xC0, 0x61, 0xA0, 0x02, 0x38, 0x00, 0x26, 0x00, 0x06,
  0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x09, 0xFF, 0xFC, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x32, 0x00, 0x01, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x40, 0x80, 0x06, 0x02, 0x00, 0x30, 0x08, 0x01,
  0x80, 0x20, 0x08, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00, 0x08, 0x38, 0x00,
  0x21, 0xA0, 0x00, 0x8C, 0x40, 0x02, 0x40, 0x80, 0x0A, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x10, 0x08, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x80, 0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x06, 0x20, 0x00, 0x0C,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x30, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0x81,
  0xF1, 0x61, 0x84, 0x12, 0x80, 0x90, 0x16, 0x01, 0x40, 0x38, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x03, 0xF8, 0x19, 0x80, 0xC3, 0x40, 0x04, 0x70,
  0x00, 0x4C, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x00,
  0x30, 0x18, 0x06, 0x00, 0x20, 0x60, 0x00, 0x82, 0x00, 0x02, 0x20, 0x00,
  0x11, 0x00, 0x00, 0x58, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x28, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x84, 0x00, 0x04,
  0x30, 0x00, 0x40, 0xC0, 0x04, 0x01, 0x80, 0xC0, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x04, 0x70, 0x30, 0x26, 0x00, 0x61, 0x40, 0x01, 0x8A, 0x00, 0x04,
  0x60, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00,
  0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x60, 0x00, 0x13, 0x00, 0x00, 0x94,
  0x00, 0x08, 0xA0, 0x00, 0xC4, 0xC0, 0x0C, 0x23, 0x81, 0xC1, 0x03, 0xF0,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x70, 0x31, 0x08, 0x00, 0x91, 0x00, 0x05, 0x20,
  0x00, 0x32, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00,
  0x03, 0x10, 0x00, 0x50, 0x80, 0x09, 0x06, 0x03, 0x10, 0x1F, 0xC1, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0xFF, 0xC1,
  0xFF, 0x00, 0x46, 0x00, 0x00, 0x48, 0x00, 0x00, 0x50, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x60, 0x1C, 0x04, 0x00, 0x10,
  0x40, 0x00, 0x64, 0x00, 0x01, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0x60, 0x00, 0x10, 0x80, 0x01,
  0x03, 0x80, 0x70, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x0D, 0x80, 0x07, 0x30, 0x03, 0x47, 0x03, 0x90, 0x7F, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x66, 0x00,
  0x02, 0x10, 0x00, 0x10, 0x80, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40,
  0x80, 0x04, 0x02, 0x00, 0x20, 0x10, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x20, 0x00,
  0x41, 0x00, 0x02, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x40, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x05, 0x00, 0x24, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x00, 0x90, 0x04, 0x40, 0x22, 0x00, 0x88, 0x04,
  0x20, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x80, 0x82, 0x02, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x80, 0x82, 0x04, 0x10, 0x10, 0x40,
  0x84, 0x02, 0x08, 0x10, 0x80, 0x61, 0x02, 0x10, 0x04, 0x40, 0x62, 0x00,
  0x88, 0x04, 0x80, 0x11, 0x00, 0x90, 0x01, 0x20, 0x12, 0x00, 0x24, 0x02,
  0x40, 0x05, 0x00, 0x50, 0x00, 0xA0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x80, 0x00, 0x1A, 0x00, 0x01, 0x88, 0x00, 0x08, 0x60, 0x00, 0x81,
  0x00, 0x08, 0x04, 0x00, 0xC0, 0x10, 0x04, 0x00, 0xC0, 0x40, 0x03, 0x04,
  0x00, 0x08, 0x60, 0x00, 0x22, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x40, 0x00, 0x11, 0x00, 0x01, 0x04, 0x00, 0x10, 0x30,
  0x01, 0x80, 0x80, 0x08, 0x02, 0x00, 0x80, 0x08, 0x08, 0x00, 0x60, 0xC0,
  0x01, 0x0C, 0x00, 0x04, 0x40, 0x00, 0x14, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10,
  0x40, 0x00, 0x41, 0x00, 0x01, 0x06, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20,
  0x01, 0x00, 0x40, 0x04, 0x01, 0x00, 0x30, 0x06, 0x00, 0x80, 0x08, 0x02,
  0x00, 0x20, 0x10, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00, 0x02, 0x08, 0x00,
  0x08, 0x60, 0x00, 0x31, 0x00, 0x00, 0x44, 0x00, 0x01, 0x20, 0x00, 0x02,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x3F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x88, 0x60, 0x00, 0x88, 0x08,
  0x00, 0x4C, 0x02, 0x00, 0x24, 0x00, 0x80, 0x32, 0x00, 0x60, 0x12, 0x00,
  0x18, 0x11, 0x00, 0x02, 0x18, 0x80, 0x00, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 3, 36, 31, 14, -36 },
  { 15, 8, 13, 31, 11, -38 },
  { 28, 28, 36, 31, 1, -36 },
  { 154, 24, 47, 31, 3, -41 },
  { 295, 28, 37, 31, 1, -36 },
  { 425, 26, 37, 31, 2, -36 },
  { 546, 1, 13, 31, 15, -38 },
  { 548, 12, 46, 31, 12, -39 },
  { 617, 11, 46, 31, 7, -39 },
  { 681, 26, 25, 31, 2, -28 },
  { 763, 24, 25, 31, 3, -28 },
  { 838, 5, 13, 31, 12, -4 },
  { 847, 13, 1, 31, 9, -16 },
  { 849, 3, 3, 31, 14, -3 },
  { 851, 20, 46, 31, 5, -39 },
  { 966, 23, 37, 31, 4, -36 },
  { 1073, 24, 36, 31, 4, -36 },
  { 1181, 23, 36, 31, 4, -36 },
  { 1285, 21, 37, 31, 4, -36 },
  { 1383, 26, 36, 31, 2, -36 },
  { 1500, 22, 37, 31, 4, -36 },
  { 1602, 22, 37, 31, 4, -36 },
  { 1704, 22, 36, 31, 4, -36 },
  { 1803, 23, 37, 31, 4, -36 },
  { 1910, 21, 36, 31, 5, -36 },
  { 2005, 3, 27, 31, 14, -27 },
  { 2016, 5, 36, 31, 12, -27 },
  { 2039, 22, 27, 31, 4, -29 },
  { 2114, 24, 10, 31, 3, -21 },
  { 2144, 22, 27, 31, 4, -29 },
  { 2219, 20, 36, 31, 5, -36 },
  { 2309, 20, 41, 31, 5, -36 },
  { 2412, 25, 36, 31, 3, -36 },
  { 2525, 21, 36, 31, 5, -36 },
  { 2620, 22, 37, 31, 4, -36 },
  { 2722, 21, 36, 31, 6, -36 },
  { 2817, 20, 36, 31, 6, -36 },
  { 2907, 20, 36, 31, 6, -36 },
  { 2997, 22, 37, 31, 4, -36 },
  { 3099, 21, 36, 31, 5, -36 },
  { 3194, 21, 36, 31, 5, -36 },
  { 3289, 19, 37, 31, 5, -36 },
  { 3377, 22, 36, 31, 6, -36 },
  { 3476, 20, 36, 31, 7, -36 },
  { 3566, 22, 36, 31, 4, -36 },
  { 3665, 21, 36, 31, 5, -36 },
  { 3760, 23, 37, 31, 4, -36 },
  { 3867, 21, 36, 31, 6, -36 },
  { 3962, 23, 43, 31, 4, -36 },
  { 4086, 21, 36, 31, 6, -36 },
  { 4181, 24, 37, 31, 3, -36 },
  { 4292, 27, 36, 31, 2, -36 },
  { 4414, 21, 37, 31, 5, -36 },
  { 4512, 25, 36, 31, 3, -36 },
  { 4625, 25, 36, 31, 3, -36 },
  { 4738, 26, 36, 31, 2, -36 },
  { 4855, 28, 36, 31, 1, -36 },
  { 4981, 26, 36, 31, 2, -36 },
  { 5098, 12, 46, 31, 14, -39 },
  { 5167, 20, 46, 31, 5, -39 },
  { 5282, 12, 46, 31, 5, -39 },
  { 5351, 24, 19, 31, 3, -36 },
  { 5408, 25, 1, 31, 3, 6 },
  { 5412, 7, 8, 31, 10, -38 },
  { 5419, 23, 28, 31, 4, -27 },
  { 5500, 21, 39, 31, 6, -38 },
  { 5603, 20, 28, 31, 6, -27 },
  { 5673, 20, 39, 31, 4, -38 },
  { 5771, 21, 28, 31, 5, -27 },
  { 5845, 23, 38, 31, 4, -38 },
  { 5955, 23, 40, 31, 5, -29 },
  { 6070, 19, 38, 31, 6, -38 },
  { 6161, 21, 38, 31, 6, -38 },
  { 6261, 18, 48, 31, 5, -38 },
  { 6369, 22, 38, 31, 7, -38 },
  { 6474, 21, 38, 31, 5, -38 },
  { 6574, 23, 27, 31, 4, -27 },
  { 6652, 19, 27, 31, 6, -27 },
  { 6717, 21, 28, 31, 5, -27 },
  { 6791, 21, 37, 31, 6, -27 },
  { 6889, 20, 37, 31, 4, -27 },
  { 6982, 24, 26, 31, 4, -26 },
  { 7060, 21, 28, 31, 5, -27 },
  { 7134, 25, 36, 31, 2, -36 },
  { 7247, 18, 27, 31, 6, -26 },
  { 7308, 21, 26, 31, 5, -26 },
  { 7377, 27, 26, 31, 2, -26 },
  { 7465, 21, 26, 31, 5, -26 },
  { 7534, 22, 36, 31, 4, -26 },
  { 7633, 20, 26, 31, 5, -26 },
  { 7698, 19, 46, 31, 6, -39 },
  { 7808, 1, 46, 31, 15, -39 },
  { 7814, 19, 46, 31, 6, -39 },
  { 7924, 25, 9, 31, 3, -20 },
};

const GFXfont IBMPlexMono_Thin51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_THIN51PT7B_H_
