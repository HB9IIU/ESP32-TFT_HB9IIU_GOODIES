#ifndef _IBMPLEXMONO_THIN53PT7B_H_
#define _IBMPLEXMONO_THIN53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x00, 0x00, 0x00, 0xEF, 0xE0, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x10, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0x00, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x40, 0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFE, 0x00, 0x0E,
  0x11, 0xC0, 0x18, 0x08, 0x18, 0x18, 0x04, 0x06, 0x18, 0x02, 0x01, 0x88,
  0x01, 0x00, 0x44, 0x00, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01,
  0x80, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x04, 0x00, 0x10, 0x02, 0x00,
  0x08, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x20,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x02,
  0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00,
  0x20, 0x08, 0x00, 0x10, 0x06, 0x00, 0x08, 0x01, 0x00, 0x04, 0x00, 0x80,
  0x02, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0x80, 0x10, 0x00, 0x40, 0x1A,
  0x00, 0x20, 0x0B, 0x00, 0x10, 0x04, 0x40, 0x08, 0x04, 0x18, 0x04, 0x06,
  0x06, 0x02, 0x06, 0x00, 0xE1, 0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x44, 0x03, 0x00,
  0x04, 0x40, 0x08, 0x00, 0x22, 0x00, 0x20, 0x02, 0x20, 0x01, 0x00, 0x11,
  0x00, 0x08, 0x01, 0x08, 0x00, 0x40, 0x10, 0x40, 0x02, 0x00, 0x82, 0x00,
  0x10, 0x08, 0x10, 0x00, 0x80, 0x40, 0x80, 0x04, 0x04, 0x04, 0x00, 0x20,
  0x40, 0x10, 0x01, 0x02, 0x00, 0x80, 0x10, 0x20, 0x02, 0x01, 0x81, 0x00,
  0x0C, 0x18, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x81,
  0x83, 0x00, 0x08, 0x18, 0x04, 0x00, 0x41, 0x80, 0x10, 0x04, 0x08, 0x00,
  0x80, 0x40, 0x40, 0x06, 0x02, 0x06, 0x00, 0x10, 0x20, 0x30, 0x00, 0x81,
  0x01, 0x00, 0x04, 0x10, 0x08, 0x00, 0x21, 0x00, 0x60, 0x01, 0x08, 0x03,
  0x00, 0x08, 0x80, 0x08, 0x00, 0xC4, 0x00, 0x40, 0x04, 0x40, 0x03, 0x00,
  0x24, 0x00, 0x0C, 0x02, 0x20, 0x00, 0x30, 0x62, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0x30, 0x03, 0xF1, 0x83, 0x00, 0x40, 0x20,
  0x20, 0x08, 0x08, 0x02, 0x01, 0x03, 0x00, 0x20, 0x20, 0x40, 0x02, 0x04,
  0x08, 0x00, 0x60, 0x83, 0x00, 0x06, 0x10, 0x40, 0x00, 0x42, 0x08, 0x00,
  0x04, 0xC1, 0x00, 0x00, 0x50, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x1C, 0x08, 0x00, 0x06, 0xC0, 0x80, 0x00, 0x8C, 0x18, 0x00,
  0x20, 0xC1, 0x80, 0x18, 0x08, 0x1C, 0x0E, 0x00, 0x80, 0xFF, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x30, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x20, 0x02, 0x00, 0x1E, 0x00,
  0x80, 0x3C, 0x78, 0x20, 0x78, 0x03, 0xC8, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x04, 0x08, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x40,
  0x08, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x08, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0xCC, 0x63, 0x18, 0x8C, 0x62, 0x11, 0x88, 0x00, 0xFF, 0xFC,
  0xEF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0x81, 0xC0, 0x04, 0x00, 0x60, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x04, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x19, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40,
  0x00, 0x30, 0x20, 0x00, 0x30, 0x10, 0x00, 0x30, 0x08, 0x00, 0x30, 0x04,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x1C, 0x07, 0x00, 0x60,
  0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x02, 0x08, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x18, 0x0E,
  0x01, 0x80, 0x04, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x11, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x60, 0x38, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x40, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x04, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00,
  0x40, 0x00, 0xC0, 0x08, 0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00, 0x10, 0x02, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x08, 0x04, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x20, 0x20, 0x00, 0x04, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0xFC, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x7F, 0x80, 0x23, 0x00,
  0xC0, 0x58, 0x00, 0x40, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x10, 0xC0, 0x00, 0x40, 0xC0, 0x03, 0x00, 0x70, 0x1C, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x7F, 0x80, 0x46, 0x03,
  0x81, 0x20, 0x03, 0x09, 0x00, 0x02, 0x28, 0x00, 0x04, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x18, 0x80, 0x00, 0x43,
  0x00, 0x02, 0x06, 0x00, 0x10, 0x06, 0x03, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x06, 0x40, 0x00, 0x08, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x07, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x08, 0x20, 0x00, 0x04, 0x40, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x20, 0x00, 0x04, 0x30, 0x00, 0x08, 0x18, 0x00,
  0x30, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x0E,
  0x00, 0x80, 0x06, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x11, 0x00, 0x00, 0x24,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00, 0x01, 0x4C,
  0x00, 0x0B, 0x18, 0x00, 0x48, 0x1C, 0x06, 0x20, 0x1F, 0xE0, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0x38, 0xF3, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x63, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x04, 0x30, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x38, 0x0C, 0x02, 0x00, 0x10, 0x20, 0x00, 0x42,
  0x00, 0x01, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x38, 0x18, 0x03, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0x00, 0x02, 0x18, 0x00, 0x08, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x3F,
  0x1C, 0x03, 0x04, 0xC0, 0x20, 0x16, 0x02, 0x00, 0x70, 0x10, 0x01, 0x81,
  0x80, 0x0C, 0x08, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0x80, 0x06, 0x04, 0x00, 0x30, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x08,
  0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x40, 0x0E,
  0x03, 0x00, 0xB8, 0x0C, 0x05, 0x40, 0x3F, 0xCA, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x18,
  0x06, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x18, 0x01, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x80, 0x30, 0x00, 0x30, 0x0F, 0xFF, 0xFC, 0x02, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x40, 0xFF, 0xFE, 0x02, 0x00, 0x06, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x32, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x06,
  0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x42, 0x00, 0x06, 0x0F, 0xFF, 0xF0, 0x20, 0x00, 0x38, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x68, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68,
  0x00, 0x03, 0x20, 0x00, 0x38, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x03,
  0x81, 0xC0, 0x18, 0x00, 0x40, 0x60, 0x00, 0x40, 0x80, 0x00, 0x42, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x30, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x40, 0x60, 0x01, 0x00, 0x38, 0x0C, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x02, 0x00, 0x1C, 0x08, 0x00, 0x18, 0x20, 0x00, 0x10,
  0x80, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00,
  0x18, 0x20, 0x01, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80,
  0x00, 0x82, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00, 0x06, 0x20, 0x00,
  0x0C, 0x60, 0x00, 0x28, 0x60, 0x00, 0x90, 0x60, 0x02, 0x20, 0x70, 0x18,
  0x40, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0xFF, 0xFF,
  0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x68, 0x00,
  0x08, 0x80, 0x02, 0x18, 0x00, 0xC0, 0xC0, 0x60, 0x07, 0xF0, 0x00, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x64, 0x00, 0x01, 0x88, 0x00,
  0x06, 0x10, 0x00, 0x08, 0x20, 0x00, 0x20, 0x40, 0x00, 0x80, 0x80, 0x02,
  0x01, 0x00, 0x08, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x10, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x80, 0x01,
  0x04, 0x80, 0x02, 0x11, 0x80, 0x04, 0x41, 0x00, 0x09, 0x01, 0x00, 0x14,
  0x03, 0x00, 0x38, 0x02, 0x00, 0x60, 0x02, 0x00, 0x80, 0x06, 0x01, 0x00,
  0x04, 0x02, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x18, 0x40, 0x00, 0x10, 0x80, 0x00, 0x11, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x24, 0x00, 0x00, 0x28, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x80, 0x00, 0x5D, 0x00, 0x00, 0xBB, 0x00, 0x02,
  0x72, 0x00, 0x04, 0xE6, 0x00, 0x19, 0xC4, 0x00, 0x23, 0x88, 0x00, 0xC7,
  0x08, 0x01, 0x0E, 0x10, 0x06, 0x1C, 0x10, 0x08, 0x38, 0x20, 0x10, 0x70,
  0x20, 0x40, 0xE0, 0x40, 0x81, 0xC0, 0xC2, 0x03, 0x80, 0x84, 0x07, 0x01,
  0x18, 0x0E, 0x01, 0x20, 0x1C, 0x02, 0x40, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x08, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3A,
  0x00, 0x00, 0xEC, 0x00, 0x03, 0x90, 0x00, 0x0E, 0x60, 0x00, 0x38, 0x80,
  0x00, 0xE1, 0x00, 0x03, 0x84, 0x00, 0x0E, 0x08, 0x00, 0x38, 0x20, 0x00,
  0xE0, 0x40, 0x03, 0x81, 0x00, 0x0E, 0x02, 0x00, 0x38, 0x08, 0x00, 0xE0,
  0x10, 0x03, 0x80, 0x40, 0x0E, 0x00, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x04,
  0x03, 0x80, 0x18, 0x0E, 0x00, 0x20, 0x38, 0x00, 0xC0, 0xE0, 0x01, 0x03,
  0x80, 0x06, 0x0E, 0x00, 0x08, 0x38, 0x00, 0x30, 0xE0, 0x00, 0x43, 0x80,
  0x01, 0x8E, 0x00, 0x02, 0x38, 0x00, 0x04, 0xE0, 0x00, 0x13, 0x80, 0x00,
  0x2E, 0x00, 0x00, 0xB8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0xFE, 0x00, 0x03, 0x81, 0xC0, 0x04, 0x00, 0x60, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x04, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x02,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x20, 0x00, 0x04, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28,
  0x00, 0x00, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00,
  0x0C, 0x3F, 0xFF, 0xC0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x81, 0xC0, 0x04, 0x00, 0x60,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18,
  0x08, 0x00, 0x10, 0x04, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0x02,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x20, 0x00, 0x04, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28,
  0x00, 0x00, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00,
  0x0C, 0x3F, 0xFF, 0xC0, 0x80, 0x20, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x10, 0x08, 0x00, 0x60, 0x20,
  0x00, 0x80, 0x80, 0x01, 0x02, 0x00, 0x06, 0x08, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x62, 0x00, 0x00, 0x88, 0x00, 0x01, 0x20, 0x00, 0x06,
  0x80, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x40, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x88, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x09, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x60, 0x00, 0x10, 0x80, 0x00,
  0x43, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0E, 0x01, 0xC0, 0x07, 0xF8, 0x00,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40,
  0x20, 0x00, 0x10, 0x08, 0x00, 0x04, 0x03, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x80, 0x10, 0x00, 0x20, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x40, 0x08, 0x00,
  0x18, 0x04, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x20,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x09, 0x00, 0x30, 0x02, 0x40, 0x0C, 0x01, 0x98, 0x07, 0x00, 0x46, 0x01,
  0x20, 0x10, 0x80, 0x48, 0x04, 0x20, 0x12, 0x01, 0x08, 0x08, 0xC0, 0x42,
  0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x61, 0x01, 0x08, 0x10, 0x20,
  0x42, 0x04, 0x08, 0x30, 0x81, 0x02, 0x08, 0x30, 0x80, 0xC2, 0x04, 0x20,
  0x10, 0x81, 0x08, 0x04, 0x20, 0x44, 0x01, 0x88, 0x11, 0x00, 0x22, 0x04,
  0x40, 0x08, 0x81, 0x30, 0x02, 0x20, 0x48, 0x00, 0x48, 0x12, 0x00, 0x16,
  0x04, 0x80, 0x05, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x08, 0x10, 0x00, 0x06, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x80, 0x10, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x10,
  0x06, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x02, 0x10, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x12, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x60, 0x18, 0x00, 0x10, 0x02, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x01, 0x00, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x10, 0x00,
  0x02, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x41, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x02, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x01, 0x00, 0x01, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0xFF, 0xF8,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x42, 0x00, 0x00, 0x81, 0x00, 0x01, 0x81, 0x00,
  0x01, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x0C, 0x00, 0x20, 0x08, 0x00, 0x10, 0x10, 0x00, 0x18, 0x10, 0x00, 0x08,
  0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x81, 0x81, 0x01, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x01, 0xFC, 0x00, 0x06, 0x03, 0x00, 0x08, 0x00, 0x80,
  0x10, 0x00, 0x40, 0x20, 0x00, 0x60, 0x60, 0x00, 0x20, 0x40, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x03, 0xFF, 0xF0,
  0x1C, 0x00, 0x10, 0x30, 0x00, 0x10, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10,
  0xC0, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x30, 0x40, 0x00, 0x50, 0x40, 0x00, 0x90, 0x20, 0x01, 0x10,
  0x1C, 0x06, 0x1F, 0x07, 0xF8, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x07,
  0xF0, 0x08, 0xC0, 0x60, 0x48, 0x00, 0xC2, 0x80, 0x03, 0x18, 0x00, 0x08,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00,
  0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x34, 0x00, 0x01, 0x20,
  0x00, 0x09, 0x80, 0x00, 0x8A, 0x00, 0x0C, 0x48, 0x00, 0xC2, 0x30, 0x18,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x30, 0x20,
  0x00, 0x42, 0x00, 0x03, 0x10, 0x00, 0x09, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x03, 0x20, 0x00, 0x10, 0x80, 0x01, 0x03,
  0x00, 0x30, 0x0E, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x01, 0xFC, 0x10, 0x30, 0x38, 0x86, 0x00, 0x24, 0x60, 0x00, 0xA6,
  0x00, 0x03, 0x20, 0x00, 0x1B, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0B, 0x00,
  0x00, 0x48, 0x00, 0x06, 0x20, 0x00, 0x31, 0x80, 0x02, 0x86, 0x00, 0x24,
  0x0C, 0x06, 0x20, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0x80,
  0x04, 0x04, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80, 0x00, 0x44, 0x00, 0x00,
  0x90, 0x00, 0x02, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x34, 0x00, 0x00, 0x88, 0x00, 0x02, 0x30,
  0x00, 0x10, 0x40, 0x00, 0x80, 0xC0, 0x04, 0x01, 0xC0, 0x60, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x40, 0x03, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x60, 0x10, 0x00, 0x20, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x20, 0x00, 0x10, 0x30, 0x00, 0x10, 0x10, 0x00, 0x20, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x03, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x18, 0x00,
  0x1C, 0x20, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0x40, 0x00, 0x04, 0x20, 0x00, 0x08, 0x1C, 0x00, 0x70, 0x03, 0xFF,
  0x80, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x41, 0xFC, 0x08, 0xC0, 0xE1, 0x20, 0x06, 0x28, 0x00,
  0x26, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x4F, 0xFF, 0xF0, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x01, 0x90, 0x00,
  0x06, 0x20, 0x00, 0x10, 0x40, 0x00, 0x40, 0x80, 0x03, 0x01, 0x00, 0x0C,
  0x02, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x10, 0x08, 0x00,
  0x20, 0x60, 0x00, 0x41, 0xE0, 0x00, 0x86, 0x60, 0x01, 0x18, 0x40, 0x02,
  0x40, 0x40, 0x05, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x20,
  0x00, 0xC0, 0x40, 0x00, 0x80, 0x80, 0x00, 0x81, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x88, 0x00, 0x01, 0x90, 0x00, 0x01, 0x20, 0x00,
  0x01, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x90, 0x63, 0x0C, 0xA0, 0x24, 0x02, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x01, 0x03, 0xF8, 0x11, 0x81, 0xC2, 0x40, 0x0C, 0x50, 0x00, 0x4C,
  0x00, 0x09, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x01, 0xFE, 0x00,
  0x18, 0x0E, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x08, 0x20, 0x00, 0x31, 0x80,
  0x00, 0x44, 0x00, 0x00, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0A, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x98, 0x00, 0x04, 0x20, 0x00, 0x30, 0x40, 0x00, 0x80, 0x80, 0x0C, 0x01,
  0xC0, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x04, 0x60, 0x30, 0x24, 0x00,
  0x61, 0x40, 0x01, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x06, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00,
  0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x45, 0x00,
  0x06, 0x24, 0x00, 0x61, 0x18, 0x0C, 0x08, 0x3F, 0x80, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x18, 0x1C, 0x43, 0x00, 0x12, 0x30, 0x00, 0x53, 0x00,
  0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x80, 0x00,
  0x24, 0x00, 0x03, 0x10, 0x00, 0x18, 0xC0, 0x01, 0x43, 0x00, 0x12, 0x06,
  0x03, 0x10, 0x0F, 0xE0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0xFF, 0xE0, 0xFF, 0x80, 0x11,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x38,
  0x07, 0x01, 0x80, 0x06, 0x08, 0x00, 0x04, 0x20, 0x00, 0x09, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x21, 0x80, 0x03, 0x01, 0xC0,
  0x38, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A,
  0x00, 0x03, 0x20, 0x00, 0xA2, 0x00, 0x24, 0x30, 0x18, 0x81, 0xFC, 0x00,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x06, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x43, 0x00, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x10, 0x00, 0x80, 0x40, 0x02, 0x03, 0x00, 0x04,
  0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00, 0x58, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x0A,
  0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x40, 0x11, 0x00, 0x26, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01,
  0x08, 0x04, 0x20, 0x20, 0xC0, 0x42, 0x02, 0x04, 0x04, 0x20, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x20, 0x81, 0x04, 0x02, 0x08, 0x10,
  0x40, 0x20, 0x81, 0x08, 0x02, 0x10, 0x08, 0x80, 0x11, 0x00, 0x88, 0x01,
  0x10, 0x08, 0x80, 0x11, 0x00, 0x90, 0x01, 0x10, 0x09, 0x00, 0x0B, 0x00,
  0xD0, 0x00, 0xA0, 0x05, 0x00, 0x0A, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x62, 0x00, 0x01, 0x04, 0x00,
  0x08, 0x18, 0x00, 0x40, 0x20, 0x03, 0x00, 0x40, 0x08, 0x00, 0x80, 0x40,
  0x03, 0x02, 0x00, 0x06, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x12, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x12, 0x00, 0x00, 0x84,
  0x00, 0x04, 0x18, 0x00, 0x30, 0x30, 0x01, 0x80, 0x40, 0x04, 0x00, 0x80,
  0x20, 0x01, 0x01, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x11, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x18, 0x00, 0x40, 0x10, 0x00,
  0x80, 0x20, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x20,
  0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x46,
  0x18, 0x00, 0x23, 0x03, 0x00, 0x08, 0x80, 0x60, 0x02, 0x40, 0x0C, 0x01,
  0x90, 0x01, 0x80, 0x44, 0x00, 0x30, 0x22, 0x00, 0x06, 0x18, 0x80, 0x00,
  0x78, 0x00,
};

const GFXglyph IBMPlexMono_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 4, 37, 32, 14, -37 },
  { 20, 8, 13, 32, 12, -39 },
  { 33, 30, 37, 32, 1, -37 },
  { 172, 25, 49, 32, 3, -43 },
  { 326, 29, 39, 32, 1, -38 },
  { 468, 27, 39, 32, 2, -38 },
  { 600, 2, 13, 32, 15, -39 },
  { 604, 12, 47, 32, 13, -40 },
  { 675, 12, 47, 32, 7, -40 },
  { 746, 26, 26, 32, 3, -29 },
  { 831, 26, 25, 32, 3, -29 },
  { 913, 5, 13, 32, 12, -4 },
  { 922, 14, 1, 32, 9, -17 },
  { 924, 4, 3, 32, 14, -3 },
  { 926, 20, 47, 32, 6, -40 },
  { 1044, 24, 39, 32, 4, -38 },
  { 1161, 25, 37, 32, 4, -37 },
  { 1277, 23, 38, 32, 5, -38 },
  { 1387, 22, 39, 32, 4, -38 },
  { 1495, 27, 37, 32, 2, -37 },
  { 1620, 23, 38, 32, 4, -37 },
  { 1730, 22, 38, 32, 5, -37 },
  { 1835, 23, 37, 32, 4, -37 },
  { 1942, 24, 39, 32, 4, -38 },
  { 2059, 22, 38, 32, 5, -38 },
  { 2164, 4, 28, 32, 14, -28 },
  { 2178, 6, 37, 32, 12, -28 },
  { 2206, 23, 28, 32, 4, -30 },
  { 2287, 26, 10, 32, 3, -21 },
  { 2320, 23, 28, 32, 4, -30 },
  { 2401, 21, 38, 32, 5, -38 },
  { 2501, 21, 44, 32, 5, -38 },
  { 2617, 26, 37, 32, 3, -37 },
  { 2738, 22, 37, 32, 5, -37 },
  { 2840, 23, 39, 32, 4, -38 },
  { 2953, 22, 37, 32, 6, -37 },
  { 3055, 21, 37, 32, 6, -37 },
  { 3153, 21, 37, 32, 6, -37 },
  { 3251, 23, 39, 32, 4, -38 },
  { 3364, 22, 37, 32, 5, -37 },
  { 3466, 22, 37, 32, 5, -37 },
  { 3568, 19, 38, 32, 5, -37 },
  { 3659, 23, 37, 32, 6, -37 },
  { 3766, 20, 37, 32, 8, -37 },
  { 3859, 23, 37, 32, 4, -37 },
  { 3966, 22, 37, 32, 5, -37 },
  { 4068, 24, 39, 32, 4, -38 },
  { 4185, 22, 37, 32, 6, -37 },
  { 4287, 24, 46, 32, 4, -38 },
  { 4425, 22, 37, 32, 6, -37 },
  { 4527, 25, 39, 32, 3, -38 },
  { 4649, 28, 37, 32, 2, -37 },
  { 4779, 22, 38, 32, 5, -37 },
  { 4884, 26, 37, 32, 3, -37 },
  { 5005, 26, 37, 32, 3, -37 },
  { 5126, 26, 37, 32, 3, -37 },
  { 5247, 29, 37, 32, 1, -37 },
  { 5382, 26, 37, 32, 3, -37 },
  { 5503, 13, 47, 32, 14, -40 },
  { 5580, 20, 47, 32, 6, -40 },
  { 5698, 13, 47, 32, 5, -40 },
  { 5775, 24, 20, 32, 4, -37 },
  { 5835, 26, 1, 32, 3, 6 },
  { 5839, 7, 9, 32, 11, -41 },
  { 5847, 24, 29, 32, 4, -28 },
  { 5934, 21, 40, 32, 7, -39 },
  { 6039, 21, 29, 32, 6, -28 },
  { 6116, 21, 40, 32, 4, -39 },
  { 6221, 22, 29, 32, 5, -28 },
  { 6301, 24, 39, 32, 4, -39 },
  { 6418, 24, 41, 32, 5, -30 },
  { 6541, 19, 39, 32, 7, -39 },
  { 6634, 22, 39, 32, 6, -39 },
  { 6742, 19, 50, 32, 5, -39 },
  { 6861, 23, 39, 32, 7, -39 },
  { 6974, 22, 39, 32, 5, -39 },
  { 7082, 24, 28, 32, 4, -28 },
  { 7166, 19, 28, 32, 7, -28 },
  { 7233, 22, 29, 32, 5, -28 },
  { 7313, 21, 39, 32, 7, -28 },
  { 7416, 21, 39, 32, 4, -28 },
  { 7519, 25, 27, 32, 4, -27 },
  { 7604, 22, 29, 32, 5, -28 },
  { 7684, 26, 37, 32, 2, -37 },
  { 7805, 19, 28, 32, 6, -27 },
  { 7872, 22, 27, 32, 5, -27 },
  { 7947, 28, 27, 32, 2, -27 },
  { 8042, 22, 27, 32, 5, -27 },
  { 8117, 23, 38, 32, 4, -27 },
  { 8227, 21, 27, 32, 5, -27 },
  { 8298, 20, 47, 32, 6, -40 },
  { 8416, 1, 47, 32, 15, -40 },
  { 8422, 20, 47, 32, 6, -40 },
  { 8540, 26, 9, 32, 3, -21 },
};

const GFXfont IBMPlexMono_Thin53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_THIN53PT7B_H_
