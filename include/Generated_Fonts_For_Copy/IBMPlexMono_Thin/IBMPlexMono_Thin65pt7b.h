#ifndef _IBMPLEXMONO_THIN65PT7B_H_
#define _IBMPLEXMONO_THIN65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin65pt7bBitmaps[] PROGMEM = {
  0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xBF, 0xF7, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xE1, 0x8F, 0x00, 0x0C, 0x06, 0x07, 0x00, 0xC0,
  0x18, 0x06, 0x06, 0x00, 0x60, 0x0C, 0x10, 0x01, 0x80, 0x18, 0xC0, 0x06,
  0x00, 0x32, 0x00, 0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x80, 0x06, 0x00, 0x02, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06,
  0x00, 0x34, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x60, 0x02, 0x30, 0x01, 0x80,
  0x18, 0x60, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x60, 0x70,
  0x01, 0xE1, 0x87, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x60, 0x08, 0x00, 0x01, 0x18,
  0x00, 0x80, 0x00, 0x62, 0x00, 0x18, 0x00, 0x08, 0x80, 0x01, 0x00, 0x03,
  0x10, 0x00, 0x30, 0x00, 0x42, 0x00, 0x02, 0x00, 0x10, 0xC0, 0x00, 0x40,
  0x06, 0x18, 0x00, 0x08, 0x00, 0x83, 0x00, 0x01, 0x00, 0x30, 0x60, 0x00,
  0x20, 0x04, 0x0C, 0x00, 0x04, 0x01, 0x01, 0x80, 0x00, 0x80, 0x60, 0x10,
  0x00, 0x10, 0x08, 0x02, 0x00, 0x06, 0x03, 0x00, 0x40, 0x00, 0x80, 0x40,
  0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x0C, 0x01, 0x00,
  0x80, 0x00, 0xC0, 0xC0, 0x30, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x18, 0x18, 0x00, 0x08, 0x04, 0x01,
  0x80, 0x03, 0x01, 0x00, 0x18, 0x00, 0x40, 0x40, 0x01, 0x00, 0x10, 0x08,
  0x00, 0x30, 0x06, 0x03, 0x00, 0x02, 0x00, 0x80, 0x40, 0x00, 0x40, 0x30,
  0x08, 0x00, 0x0C, 0x04, 0x01, 0x00, 0x01, 0x81, 0x00, 0x20, 0x00, 0x30,
  0x60, 0x04, 0x00, 0x06, 0x08, 0x00, 0x80, 0x00, 0xC3, 0x00, 0x10, 0x00,
  0x18, 0x40, 0x02, 0x00, 0x02, 0x10, 0x00, 0x60, 0x00, 0x46, 0x00, 0x04,
  0x00, 0x18, 0x80, 0x00, 0x80, 0x02, 0x30, 0x00, 0x08, 0x00, 0xC4, 0x00,
  0x00, 0x80, 0x31, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x3F,
  0x0C, 0x08, 0x00, 0x20, 0x18, 0x04, 0x00, 0x20, 0x30, 0x02, 0x00, 0x60,
  0x60, 0x03, 0x00, 0x60, 0x60, 0x01, 0x80, 0x60, 0x40, 0x00, 0xC0, 0x60,
  0xC0, 0x00, 0x40, 0x40, 0x80, 0x00, 0x20, 0x40, 0x80, 0x00, 0x10, 0x40,
  0x80, 0x00, 0x18, 0x40, 0x80, 0x00, 0x0C, 0x40, 0x80, 0x00, 0x06, 0xC0,
  0x80, 0x00, 0x03, 0x80, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x01, 0x60, 0x40, 0x00, 0x03, 0x20, 0x60, 0x00, 0x06, 0x10,
  0x30, 0x00, 0x0C, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x0C, 0x00, 0x30, 0x06,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x1F, 0x00, 0x08, 0x00, 0x79, 0xF0, 0x04, 0x01, 0xF0, 0x0F, 0x02,
  0x07, 0x80, 0x00, 0xF1, 0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1C, 0x71, 0x86, 0x38, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x43, 0x0C,
  0x20, 0xFF, 0xFF, 0x80, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x18, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x04, 0x00, 0x10, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x20,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x03, 0xFE,
  0x00, 0x11, 0xC0, 0x1C, 0x01, 0x20, 0x00, 0x60, 0x14, 0x00, 0x01, 0x03,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x60, 0x03, 0xC0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x81, 0xFF, 0x00,
  0x30, 0xE0, 0x38, 0x04, 0x60, 0x00, 0xC0, 0x90, 0x00, 0x0C, 0x34, 0x00,
  0x00, 0xC7, 0x80, 0x00, 0x0C, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x03,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x46, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x20, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x0A, 0x30, 0x00, 0x00, 0xA1, 0x80, 0x00,
  0x16, 0x0C, 0x00, 0x02, 0x40, 0x60, 0x00, 0xC4, 0x01, 0xC0, 0x30, 0xC0,
  0x07, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xDF, 0xFB, 0x80, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x83,
  0x04, 0x18, 0x30, 0x60, 0x83, 0x06, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x83, 0x00, 0x00, 0x23, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x30, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x14, 0x00, 0x3F, 0x85, 0x00, 0x38, 0x11, 0x40, 0x18, 0x02,
  0x70, 0x0C, 0x00, 0x5C, 0x02, 0x00, 0x0F, 0x01, 0x80, 0x03, 0xC0, 0x60,
  0x00, 0xF0, 0x10, 0x00, 0x1C, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x04, 0x00, 0x07, 0x01, 0x00,
  0x01, 0xC0, 0x40, 0x00, 0x70, 0x10, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0x00,
  0x80, 0x03, 0xC0, 0x30, 0x01, 0x50, 0x04, 0x00, 0x54, 0x00, 0xC0, 0x25,
  0x00, 0x1F, 0xF1, 0x40, 0x00, 0x40, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x20, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x1C, 0x02, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x06, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0xE0, 0x40, 0x00,
  0x70, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE4, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x20, 0x00, 0x10, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x50, 0x80, 0x00, 0x05, 0x04, 0x00, 0x00, 0x90, 0x20,
  0x00, 0x11, 0x01, 0x80, 0x06, 0x10, 0x0F, 0x01, 0xC1, 0x00, 0x1F, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x80,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x08, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x08,
  0x0F, 0x00, 0x00, 0x40, 0xCC, 0x00, 0x02, 0x0C, 0x30, 0x00, 0x10, 0xC0,
  0x80, 0x00, 0x8C, 0x06, 0x00, 0x04, 0x40, 0x18, 0x00, 0x24, 0x00, 0x40,
  0x01, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x02,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x10, 0x04, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xD0, 0x00, 0x00, 0x5B, 0x00, 0x00, 0x1B, 0x20, 0x00, 0x02,
  0x66, 0x00, 0x00, 0xCC, 0x40, 0x00, 0x11, 0x88, 0x00, 0x02, 0x31, 0x80,
  0x00, 0xC6, 0x10, 0x00, 0x10, 0xC3, 0x00, 0x06, 0x18, 0x20, 0x00, 0x83,
  0x06, 0x00, 0x30, 0x60, 0x40, 0x04, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x80,
  0x20, 0x30, 0x18, 0x04, 0x06, 0x01, 0x01, 0x00, 0xC0, 0x20, 0x20, 0x18,
  0x06, 0x0C, 0x03, 0x00, 0x41, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x00, 0x88,
  0x01, 0x80, 0x1B, 0x00, 0x30, 0x01, 0x40, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE8, 0x00,
  0x00, 0x3D, 0x80, 0x00, 0x07, 0x90, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1E,
  0x20, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x78, 0x40, 0x00, 0x0F, 0x0C, 0x00,
  0x01, 0xE0, 0x80, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x81, 0x80, 0x00, 0xF0,
  0x10, 0x00, 0x1E, 0x03, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x78, 0x06, 0x00,
  0x0F, 0x00, 0x40, 0x01, 0xE0, 0x0C, 0x00, 0x3C, 0x00, 0x80, 0x07, 0x80,
  0x18, 0x00, 0xF0, 0x01, 0x00, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x02, 0x00,
  0x78, 0x00, 0x60, 0x0F, 0x00, 0x04, 0x01, 0xE0, 0x00, 0xC0, 0x3C, 0x00,
  0x08, 0x07, 0x80, 0x01, 0x80, 0xF0, 0x00, 0x10, 0x1E, 0x00, 0x03, 0x03,
  0xC0, 0x00, 0x30, 0x78, 0x00, 0x02, 0x0F, 0x00, 0x00, 0x61, 0xE0, 0x00,
  0x04, 0x3C, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x08, 0xF0, 0x00, 0x01, 0x9E,
  0x00, 0x00, 0x13, 0xC0, 0x00, 0x03, 0x78, 0x00, 0x00, 0x2F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x10, 0x00, 0x03, 0x82, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x07, 0x07, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x03, 0x82, 0x00, 0x00,
  0x1C, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x06, 0x20, 0x00, 0x07, 0x07, 0xFF, 0xFF, 0x80,
  0x80, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x80, 0x08, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x04,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x02, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x30, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x04, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x38, 0x03, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x02, 0x00, 0x18, 0x00, 0x04, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x80, 0x02, 0x00, 0x01, 0x80, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x00, 0x98, 0x00, 0xE0, 0x03, 0x30, 0x01, 0xC0, 0x06, 0x60,
  0x02, 0x80, 0x0C, 0xC0, 0x05, 0x00, 0x18, 0x80, 0x1B, 0x00, 0x21, 0x00,
  0x22, 0x00, 0x42, 0x00, 0x44, 0x00, 0x84, 0x01, 0x8C, 0x01, 0x08, 0x02,
  0x08, 0x02, 0x10, 0x04, 0x10, 0x04, 0x30, 0x18, 0x30, 0x18, 0x60, 0x30,
  0x60, 0x30, 0xC0, 0x40, 0x40, 0x61, 0x80, 0x80, 0xC0, 0xC1, 0x03, 0x01,
  0x81, 0x02, 0x04, 0x01, 0x02, 0x04, 0x08, 0x02, 0x04, 0x08, 0x30, 0x06,
  0x08, 0x10, 0x40, 0x04, 0x10, 0x20, 0x80, 0x08, 0x20, 0x63, 0x00, 0x18,
  0x40, 0xC6, 0x00, 0x31, 0x81, 0x88, 0x00, 0x23, 0x03, 0x10, 0x00, 0x66,
  0x02, 0x60, 0x00, 0xC8, 0x04, 0x80, 0x00, 0x90, 0x09, 0x00, 0x01, 0x20,
  0x16, 0x00, 0x03, 0x40, 0x28, 0x00, 0x02, 0x80, 0x50, 0x00, 0x05, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x08, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x70, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x14, 0x04, 0x00, 0x00,
  0xD0, 0x08, 0x00, 0x06, 0x40, 0x18, 0x00, 0x31, 0x00, 0x38, 0x07, 0x07,
  0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x0F, 0xF0, 0x02, 0x0E, 0x03, 0x80, 0x8C, 0x00, 0x30,
  0x26, 0x00, 0x02, 0x0B, 0x00, 0x00, 0x42, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x12, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x32, 0x80, 0x00, 0x08, 0xB0, 0x00, 0x04, 0x26, 0x00, 0x02, 0x08, 0xC0,
  0x03, 0x02, 0x0E, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x08, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x30, 0x10, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x03, 0xFC, 0x04, 0x07, 0x01, 0xC1, 0x03, 0x00, 0x0C, 0x41, 0x00,
  0x01, 0x90, 0x80, 0x00, 0x34, 0x40, 0x00, 0x05, 0x30, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x05, 0x08, 0x00, 0x03, 0x41, 0x00, 0x01, 0x90, 0x30, 0x00, 0xC4,
  0x07, 0x01, 0xC1, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0x20, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x06, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x03, 0xFC, 0x40, 0x00, 0x30, 0x1D, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x20, 0x02, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x00, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x80, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x3F, 0xC0, 0x61, 0x80, 0x70,
  0xCC, 0x00, 0x31, 0xA0, 0x00, 0x33, 0x80, 0x00, 0x37, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xCF, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x74, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10,
  0x08, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x40, 0x70, 0x00, 0x08, 0x1B, 0x00, 0x01, 0x06, 0x20, 0x00, 0x21, 0x86,
  0x00, 0x04, 0x60, 0x60, 0x00, 0x98, 0x06, 0x00, 0x16, 0x00, 0x60, 0x03,
  0x00, 0x04, 0x00, 0x40, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x10,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0x84, 0x40, 0xC1, 0x83,
  0x24, 0x03, 0x10, 0x0D, 0x40, 0x09, 0x00, 0x2C, 0x00, 0x70, 0x01, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0xC0, 0xFF, 0x01,
  0x86, 0x01, 0xC3, 0x30, 0x00, 0xC6, 0x80, 0x00, 0xCE, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00,
  0x7F, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x80, 0xFF,
  0x00, 0x20, 0xE0, 0x38, 0x08, 0xC0, 0x03, 0x02, 0x60, 0x00, 0x20, 0xB0,
  0x00, 0x04, 0x28, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x28, 0x00, 0x00, 0x8B,
  0x00, 0x00, 0x42, 0x60, 0x00, 0x20, 0x8C, 0x00, 0x30, 0x20, 0xE0, 0x38,
  0x08, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x70,
  0x1C, 0x10, 0x30, 0x00, 0xC4, 0x10, 0x00, 0x19, 0x08, 0x00, 0x03, 0x44,
  0x00, 0x00, 0x53, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x58, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x50, 0x80, 0x00, 0x34,
  0x10, 0x00, 0x19, 0x03, 0x00, 0x0C, 0x40, 0x70, 0x1C, 0x10, 0x03, 0xFC,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x01, 0xC8, 0x00, 0x07,
  0x98, 0x00, 0x0B, 0x18, 0x00, 0x66, 0x0C, 0x03, 0x8C, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x08, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x08, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x40, 0x08, 0x00, 0x08, 0x01,
  0x80, 0x03, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x20, 0x02,
  0x00, 0x04, 0x00, 0x40, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x02, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x30, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x68,
  0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00,
  0x26, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x02, 0x20, 0x01, 0x88, 0x00, 0x44,
  0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x20, 0x03, 0x18, 0x00, 0x86, 0x00,
  0x41, 0x00, 0x10, 0xC0, 0x08, 0x20, 0x06, 0x08, 0x01, 0x04, 0x00, 0x81,
  0x00, 0x60, 0xC0, 0x10, 0x20, 0x08, 0x08, 0x02, 0x04, 0x01, 0x01, 0x00,
  0x40, 0xC0, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x40, 0x40, 0x20, 0x20, 0x08, 0x08, 0x04, 0x04, 0x01, 0x81, 0x00, 0xC1,
  0x00, 0x10, 0x60, 0x18, 0x20, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x21, 0x80, 0x0C, 0x20, 0x04, 0x20, 0x00, 0x84, 0x00, 0x84, 0x00, 0x10,
  0x80, 0x18, 0x80, 0x02, 0x30, 0x01, 0x30, 0x00, 0x64, 0x00, 0x24, 0x00,
  0x04, 0x80, 0x04, 0x80, 0x00, 0x90, 0x00, 0x90, 0x00, 0x12, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x20, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x18, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x02, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x20, 0x01, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x20, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x18, 0x60, 0x00, 0x04, 0x40,
  0x20, 0x00, 0x09, 0x80, 0x20, 0x00, 0x22, 0x00, 0x20, 0x00, 0x48, 0x00,
  0x20, 0x00, 0x90, 0x00, 0x20, 0x02, 0x60, 0x00, 0x20, 0x0C, 0x80, 0x00,
  0x20, 0x11, 0x00, 0x00, 0x30, 0xC2, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph IBMPlexMono_Thin65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 5, 45, 39, 17, -45 },
  { 30, 11, 16, 39, 14, -48 },
  { 52, 37, 45, 39, 1, -45 },
  { 261, 30, 61, 39, 4, -53 },
  { 490, 35, 47, 39, 2, -46 },
  { 696, 32, 47, 39, 3, -46 },
  { 884, 1, 16, 39, 19, -48 },
  { 886, 15, 58, 39, 15, -49 },
  { 995, 15, 58, 39, 9, -49 },
  { 1104, 33, 32, 39, 3, -36 },
  { 1236, 31, 31, 39, 4, -35 },
  { 1357, 6, 16, 39, 15, -5 },
  { 1369, 17, 1, 39, 11, -20 },
  { 1372, 5, 4, 39, 17, -4 },
  { 1375, 25, 58, 39, 7, -49 },
  { 1557, 29, 47, 39, 5, -46 },
  { 1728, 30, 45, 39, 6, -45 },
  { 1897, 28, 46, 39, 6, -46 },
  { 2058, 27, 47, 39, 5, -46 },
  { 2217, 33, 45, 39, 3, -45 },
  { 2403, 28, 46, 39, 5, -45 },
  { 2564, 27, 46, 39, 6, -45 },
  { 2720, 28, 45, 39, 5, -45 },
  { 2878, 29, 47, 39, 5, -46 },
  { 3049, 28, 46, 39, 6, -46 },
  { 3210, 5, 34, 39, 17, -34 },
  { 3232, 7, 45, 39, 15, -34 },
  { 3272, 27, 35, 39, 6, -37 },
  { 3391, 31, 12, 39, 4, -26 },
  { 3438, 27, 35, 39, 6, -37 },
  { 3557, 25, 46, 39, 7, -46 },
  { 3701, 26, 53, 39, 6, -46 },
  { 3874, 33, 45, 39, 3, -45 },
  { 4060, 28, 45, 39, 6, -45 },
  { 4218, 29, 47, 39, 5, -46 },
  { 4389, 27, 45, 39, 7, -45 },
  { 4541, 26, 45, 39, 7, -45 },
  { 4688, 27, 45, 39, 7, -45 },
  { 4840, 28, 47, 39, 5, -46 },
  { 5005, 27, 45, 39, 6, -45 },
  { 5157, 27, 45, 39, 6, -45 },
  { 5309, 24, 46, 39, 6, -45 },
  { 5447, 29, 45, 39, 7, -45 },
  { 5611, 25, 45, 39, 9, -45 },
  { 5752, 27, 45, 39, 6, -45 },
  { 5904, 27, 45, 39, 6, -45 },
  { 6056, 29, 47, 39, 5, -46 },
  { 6227, 27, 45, 39, 7, -45 },
  { 6379, 29, 55, 39, 5, -46 },
  { 6579, 27, 45, 39, 7, -45 },
  { 6731, 30, 47, 39, 4, -46 },
  { 6908, 33, 45, 39, 3, -45 },
  { 7094, 27, 46, 39, 6, -45 },
  { 7250, 31, 45, 39, 4, -45 },
  { 7425, 31, 45, 39, 4, -45 },
  { 7600, 33, 45, 39, 3, -45 },
  { 7786, 35, 45, 39, 2, -45 },
  { 7983, 33, 45, 39, 3, -45 },
  { 8169, 16, 58, 39, 17, -49 },
  { 8285, 25, 58, 39, 7, -49 },
  { 8467, 16, 58, 39, 6, -49 },
  { 8583, 31, 24, 39, 4, -45 },
  { 8676, 31, 1, 39, 4, 8 },
  { 8680, 9, 11, 39, 13, -50 },
  { 8693, 30, 35, 39, 5, -34 },
  { 8825, 26, 49, 39, 8, -48 },
  { 8985, 26, 35, 39, 7, -34 },
  { 9099, 26, 49, 39, 5, -48 },
  { 9259, 27, 35, 39, 6, -34 },
  { 9378, 30, 48, 39, 5, -48 },
  { 9558, 30, 50, 39, 6, -36 },
  { 9746, 23, 48, 39, 8, -48 },
  { 9884, 27, 49, 39, 8, -49 },
  { 10050, 23, 62, 39, 6, -49 },
  { 10229, 27, 48, 39, 9, -48 },
  { 10391, 27, 48, 39, 6, -48 },
  { 10553, 29, 34, 39, 5, -34 },
  { 10677, 23, 34, 39, 8, -34 },
  { 10775, 27, 35, 39, 6, -34 },
  { 10894, 26, 47, 39, 8, -34 },
  { 11047, 26, 47, 39, 5, -34 },
  { 11200, 31, 34, 39, 5, -34 },
  { 11332, 28, 35, 39, 6, -34 },
  { 11455, 32, 45, 39, 2, -45 },
  { 11635, 23, 35, 39, 8, -34 },
  { 11736, 27, 34, 39, 6, -34 },
  { 11851, 35, 34, 39, 2, -34 },
  { 12000, 27, 34, 39, 6, -34 },
  { 12115, 29, 47, 39, 5, -34 },
  { 12286, 25, 34, 39, 7, -34 },
  { 12393, 23, 58, 39, 8, -49 },
  { 12560, 1, 58, 39, 19, -49 },
  { 12568, 23, 58, 39, 8, -49 },
  { 12735, 31, 11, 39, 4, -25 },
};

const GFXfont IBMPlexMono_Thin65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_THIN65PT7B_H_
