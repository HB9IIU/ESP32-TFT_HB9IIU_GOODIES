#ifndef _IBMPLEXMONO_THIN66PT7B_H_
#define _IBMPLEXMONO_THIN66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin66pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x30, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xE0, 0x87, 0x80, 0x06, 0x01, 0x01, 0x80, 0x10, 0x02,
  0x01, 0xC0, 0x40, 0x04, 0x00, 0xC1, 0x00, 0x08, 0x00, 0xC6, 0x00, 0x10,
  0x00, 0x8C, 0x00, 0x20, 0x00, 0x10, 0x00, 0x40, 0x00, 0x20, 0x00, 0x80,
  0x00, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x02, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x04, 0x00, 0x10, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x10, 0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x38, 0x04, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x00,
  0x0F, 0x90, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x4F, 0x00, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x80, 0x06, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x18, 0x00, 0x04, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x60, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x20, 0x00, 0x40,
  0x06, 0xE0, 0x00, 0x80, 0x0C, 0x60, 0x01, 0x00, 0x30, 0x60, 0x02, 0x00,
  0x40, 0x60, 0x04, 0x03, 0x00, 0x70, 0x08, 0x0C, 0x00, 0x3C, 0x10, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x18, 0x03, 0x00, 0x00, 0x63, 0x00, 0x18,
  0x00, 0x04, 0x20, 0x00, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x08, 0x40,
  0x00, 0x40, 0x01, 0x04, 0x00, 0x04, 0x00, 0x30, 0xC0, 0x00, 0x40, 0x02,
  0x0C, 0x00, 0x04, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x04, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0xC0, 0x00, 0x40, 0x18, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x40,
  0x00, 0x40, 0x30, 0x04, 0x00, 0x04, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x60,
  0x02, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x80, 0x01, 0x80, 0x30,
  0x18, 0x00, 0x0E, 0x0E, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80,
  0x60, 0x60, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x30, 0x00, 0x40, 0x06, 0x02, 0x00, 0x04, 0x00, 0xC0, 0x20, 0x00,
  0x60, 0x08, 0x06, 0x00, 0x02, 0x01, 0x80, 0x60, 0x00, 0x20, 0x10, 0x06,
  0x00, 0x02, 0x03, 0x00, 0x60, 0x00, 0x20, 0x60, 0x06, 0x00, 0x02, 0x04,
  0x00, 0x60, 0x00, 0x20, 0xC0, 0x06, 0x00, 0x02, 0x08, 0x00, 0x60, 0x00,
  0x21, 0x80, 0x02, 0x00, 0x06, 0x10, 0x00, 0x20, 0x00, 0x42, 0x00, 0x03,
  0x00, 0x04, 0x60, 0x00, 0x10, 0x00, 0x84, 0x00, 0x00, 0xC0, 0x18, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x08, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x3F, 0x8C, 0x06, 0x00, 0x10, 0x04, 0x01, 0x80, 0x08, 0x06,
  0x00, 0x60, 0x04, 0x06, 0x00, 0x18, 0x02, 0x02, 0x00, 0x04, 0x01, 0x01,
  0x00, 0x01, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x40, 0xC0, 0x00, 0x30, 0x60,
  0x40, 0x00, 0x0C, 0x30, 0x20, 0x00, 0x03, 0x10, 0x10, 0x00, 0x00, 0x88,
  0x08, 0x00, 0x00, 0x24, 0x04, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x60, 0x20, 0x00, 0x01,
  0x98, 0x18, 0x00, 0x00, 0x86, 0x06, 0x00, 0x00, 0x81, 0x81, 0x80, 0x00,
  0x80, 0x60, 0x60, 0x01, 0x80, 0x10, 0x0E, 0x03, 0x80, 0x04, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x8F, 0x00, 0x30, 0x07,
  0xD0, 0x7C, 0x0C, 0x0F, 0x80, 0x03, 0xE3, 0x1E, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x10, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x38, 0x70, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x04, 0x08, 0x30, 0x40, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0xE1, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xC2, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x3F, 0xE0, 0x02, 0x18,
  0x03, 0x80, 0x4C, 0x00, 0x1C, 0x0A, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x04, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x0F,
  0x00, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x03, 0xFC, 0x00, 0x61, 0xC0, 0x38, 0x04, 0x60, 0x00, 0xE0, 0x4C,
  0x00, 0x03, 0x0D, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x8E, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x72, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xA1, 0x80,
  0x00, 0x1A, 0x0C, 0x00, 0x03, 0x20, 0x70, 0x00, 0x46, 0x01, 0xC0, 0x38,
  0x60, 0x03, 0xFC, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x1C, 0x30, 0x61,
  0xC3, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x44, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x18, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x14, 0x00, 0x1F, 0x85, 0x00, 0x18, 0x19, 0x40, 0x08, 0x01,
  0x50, 0x04, 0x00, 0x7C, 0x03, 0x00, 0x0F, 0x00, 0x80, 0x01, 0xC0, 0x60,
  0x00, 0x70, 0x18, 0x00, 0x1C, 0x04, 0x00, 0x07, 0x01, 0x00, 0x01, 0xC0,
  0x40, 0x00, 0x70, 0x10, 0x00, 0x1C, 0x04, 0x00, 0x07, 0x01, 0x00, 0x01,
  0xC0, 0x40, 0x00, 0x70, 0x10, 0x00, 0x1C, 0x04, 0x00, 0x07, 0x01, 0x00,
  0x01, 0xC0, 0x40, 0x00, 0x70, 0x10, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00,
  0x80, 0x01, 0xC0, 0x20, 0x00, 0xD0, 0x04, 0x00, 0x34, 0x01, 0x80, 0x15,
  0x00, 0x30, 0x09, 0x40, 0x07, 0xFC, 0x58, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x10, 0x01, 0x80, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x02, 0x00, 0x04, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x20, 0x00, 0x04, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x30, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE6, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x16, 0x0C, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x19, 0x80, 0xC0,
  0x01, 0x8C, 0x01, 0xC0, 0x70, 0x60, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x60, 0x6C, 0x00, 0x03, 0x06, 0x30, 0x00, 0x18, 0x61,
  0x80, 0x00, 0xC6, 0x06, 0x00, 0x06, 0x60, 0x18, 0x00, 0x36, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x0D,
  0xB0, 0x00, 0x00, 0x99, 0x00, 0x00, 0x19, 0x98, 0x00, 0x01, 0x18, 0x80,
  0x00, 0x31, 0x8C, 0x00, 0x02, 0x18, 0x40, 0x00, 0x21, 0x84, 0x00, 0x06,
  0x18, 0x60, 0x00, 0x41, 0x82, 0x00, 0x0C, 0x18, 0x30, 0x00, 0x81, 0x81,
  0x00, 0x18, 0x18, 0x18, 0x01, 0x01, 0x80, 0x80, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x06, 0x06, 0x01, 0x80, 0x20, 0x40, 0x18,
  0x02, 0x0C, 0x01, 0x80, 0x30, 0x80, 0x18, 0x01, 0x18, 0x01, 0x80, 0x19,
  0x00, 0x18, 0x00, 0xB0, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xE8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x90, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x08, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x70, 0x10, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x20, 0x00,
  0x38, 0x06, 0x00, 0x07, 0x00, 0x40, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x00,
  0x80, 0x03, 0x80, 0x18, 0x00, 0x70, 0x01, 0x00, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x02, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x04, 0x00, 0xE0, 0x00,
  0xC0, 0x1C, 0x00, 0x08, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x04, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x08, 0x70,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x11, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x27, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x0F,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x0F, 0xFF,
  0xFF, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x03, 0x80, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x11, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x60, 0x01, 0x80, 0x04,
  0x60, 0x03, 0x80, 0x04, 0x60, 0x03, 0x80, 0x04, 0x20, 0x02, 0xC0, 0x04,
  0x20, 0x02, 0x40, 0x04, 0x20, 0x06, 0x40, 0x04, 0x20, 0x04, 0x60, 0x0C,
  0x20, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08,
  0x30, 0x08, 0x30, 0x08, 0x30, 0x18, 0x10, 0x08, 0x30, 0x18, 0x10, 0x08,
  0x10, 0x10, 0x18, 0x08, 0x10, 0x10, 0x08, 0x08, 0x10, 0x30, 0x08, 0x08,
  0x10, 0x20, 0x0C, 0x18, 0x10, 0x20, 0x04, 0x18, 0x10, 0x60, 0x04, 0x18,
  0x10, 0x60, 0x06, 0x18, 0x18, 0x40, 0x06, 0x10, 0x18, 0x40, 0x02, 0x10,
  0x18, 0xC0, 0x02, 0x10, 0x18, 0x80, 0x03, 0x10, 0x08, 0x80, 0x01, 0x10,
  0x09, 0x80, 0x01, 0x10, 0x09, 0x00, 0x01, 0xB0, 0x09, 0x00, 0x01, 0xB0,
  0x0B, 0x00, 0x00, 0xB0, 0x0B, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x08, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x01, 0x00, 0x18, 0x00, 0x06, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x70, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x70, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x40, 0x30, 0x00, 0x09, 0x00, 0x60, 0x00, 0xC4,
  0x00, 0xE0, 0x1E, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x07, 0xF8, 0x03, 0x0E, 0x03, 0x80,
  0xC6, 0x00, 0x18, 0x36, 0x00, 0x03, 0x0D, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x08, 0xE0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x13, 0x80, 0x00, 0x04, 0xE0, 0x00, 0x02, 0x34, 0x00,
  0x01, 0x8D, 0x80, 0x00, 0xC3, 0x18, 0x00, 0x60, 0xC3, 0x80, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x03, 0xFC,
  0x04, 0x03, 0x00, 0xC1, 0x03, 0x00, 0x0C, 0x41, 0x00, 0x00, 0x90, 0x80,
  0x00, 0x14, 0x60, 0x00, 0x07, 0x10, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x18,
  0x00, 0x01, 0xC2, 0x00, 0x00, 0x50, 0x40, 0x00, 0x24, 0x0C, 0x00, 0x31,
  0x01, 0xC0, 0x38, 0x40, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x04,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x18, 0x00, 0x07,
  0x01, 0xB0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x02, 0x00, 0x80, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x40, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0xFF, 0x00, 0xC3, 0x80, 0xE0, 0xC4, 0x00, 0x30, 0xD8, 0x00, 0x08, 0xD0,
  0x00, 0x0C, 0xE0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x9F, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0B, 0x00, 0x00, 0xC3, 0x18, 0x00, 0x0C,
  0x60, 0xC0, 0x00, 0xCC, 0x04, 0x00, 0x0D, 0x80, 0x60, 0x00, 0xF0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x30, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xC2, 0x30,
  0x60, 0xC1, 0x89, 0x00, 0xC4, 0x01, 0x28, 0x01, 0x20, 0x06, 0xC0, 0x02,
  0x80, 0x0B, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xC3, 0x80,
  0xE0, 0xC4, 0x00, 0x30, 0xD8, 0x00, 0x08, 0xD0, 0x00, 0x0C, 0xE0, 0x00,
  0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x30, 0xE0, 0x38, 0x0C, 0x60, 0x01, 0x83, 0x60, 0x00, 0x30, 0xD0,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x38, 0x00, 0x00, 0x4E,
  0x00, 0x00, 0x23, 0x40, 0x00, 0x18, 0xD8, 0x00, 0x0C, 0x31, 0x80, 0x06,
  0x0C, 0x38, 0x0E, 0x03, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x30, 0x0C, 0x10, 0x30, 0x00, 0xC4, 0x10, 0x00, 0x09, 0x08,
  0x00, 0x01, 0x46, 0x00, 0x00, 0x71, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x58, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x1C, 0x20, 0x00, 0x05, 0x04, 0x00, 0x02, 0x40, 0xC0, 0x03,
  0x10, 0x1C, 0x03, 0x84, 0x00, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x08, 0x30, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xC8, 0x00, 0x02, 0x98, 0x00, 0x0D, 0x18, 0x00, 0x72, 0x0E,
  0x03, 0x84, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x60, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x10, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x08,
  0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x08, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x32, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x18, 0x00, 0x16, 0x00,
  0x0E, 0x00, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8,
  0x00, 0x24, 0x00, 0x23, 0x00, 0x09, 0x00, 0x08, 0x40, 0x06, 0x40, 0x02,
  0x10, 0x01, 0x98, 0x01, 0x84, 0x00, 0x46, 0x00, 0x41, 0x80, 0x10, 0x80,
  0x10, 0x20, 0x04, 0x20, 0x04, 0x08, 0x03, 0x08, 0x03, 0x02, 0x00, 0xC3,
  0x00, 0x80, 0xC0, 0x20, 0xC0, 0x20, 0x10, 0x08, 0x10, 0x08, 0x04, 0x02,
  0x04, 0x06, 0x01, 0x00, 0x81, 0x01, 0x00, 0x60, 0x60, 0x40, 0x40, 0x08,
  0x10, 0x18, 0x30, 0x02, 0x04, 0x02, 0x08, 0x00, 0x81, 0x00, 0x82, 0x00,
  0x30, 0x40, 0x20, 0x80, 0x04, 0x30, 0x08, 0x60, 0x01, 0x08, 0x03, 0x10,
  0x00, 0x42, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x11, 0x00, 0x02, 0x20, 0x04,
  0xC0, 0x00, 0x98, 0x01, 0x20, 0x00, 0x36, 0x00, 0x68, 0x00, 0x05, 0x00,
  0x1A, 0x00, 0x01, 0x40, 0x03, 0x80, 0x00, 0x50, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x18, 0x01, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x10, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x00, 0x30, 0x01,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x04, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x0C, 0x30, 0x00, 0x03, 0x18, 0x0C, 0x00, 0x02, 0x30, 0x06, 0x00, 0x02,
  0x20, 0x03, 0x00, 0x06, 0x60, 0x01, 0x80, 0x04, 0x40, 0x00, 0xC0, 0x04,
  0x40, 0x00, 0x60, 0x08, 0xC0, 0x00, 0x30, 0x18, 0x80, 0x00, 0x18, 0x30,
  0x80, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Thin66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 4, 46, 40, 18, -46 },
  { 24, 10, 17, 40, 15, -49 },
  { 46, 37, 46, 40, 1, -46 },
  { 259, 31, 62, 40, 4, -54 },
  { 500, 36, 48, 40, 2, -47 },
  { 716, 33, 48, 40, 3, -47 },
  { 914, 2, 17, 40, 19, -49 },
  { 919, 15, 59, 40, 16, -50 },
  { 1030, 15, 59, 40, 9, -50 },
  { 1141, 34, 33, 40, 3, -36 },
  { 1282, 32, 31, 40, 4, -36 },
  { 1406, 7, 16, 40, 15, -5 },
  { 1420, 18, 1, 40, 11, -21 },
  { 1423, 4, 4, 40, 18, -4 },
  { 1425, 26, 59, 40, 7, -50 },
  { 1617, 30, 48, 40, 5, -47 },
  { 1797, 30, 46, 40, 6, -46 },
  { 1970, 28, 47, 40, 6, -47 },
  { 2135, 27, 48, 40, 5, -47 },
  { 2297, 33, 46, 40, 3, -46 },
  { 2487, 27, 47, 40, 6, -46 },
  { 2646, 28, 47, 40, 6, -46 },
  { 2811, 29, 46, 40, 5, -46 },
  { 2978, 30, 48, 40, 5, -47 },
  { 3158, 28, 47, 40, 6, -47 },
  { 3323, 4, 35, 40, 18, -35 },
  { 3341, 7, 46, 40, 15, -35 },
  { 3382, 28, 35, 40, 6, -38 },
  { 3505, 32, 13, 40, 4, -27 },
  { 3557, 28, 35, 40, 6, -38 },
  { 3680, 26, 47, 40, 7, -47 },
  { 3833, 26, 54, 40, 6, -47 },
  { 4009, 33, 46, 40, 3, -46 },
  { 4199, 28, 46, 40, 6, -46 },
  { 4360, 29, 48, 40, 5, -47 },
  { 4534, 28, 46, 40, 7, -46 },
  { 4695, 27, 46, 40, 7, -46 },
  { 4851, 27, 46, 40, 7, -46 },
  { 5007, 29, 48, 40, 5, -47 },
  { 5181, 27, 46, 40, 6, -46 },
  { 5337, 28, 46, 40, 6, -46 },
  { 5498, 24, 47, 40, 6, -46 },
  { 5639, 29, 46, 40, 7, -46 },
  { 5806, 25, 46, 40, 10, -46 },
  { 5950, 28, 46, 40, 6, -46 },
  { 6111, 27, 46, 40, 6, -46 },
  { 6267, 30, 48, 40, 5, -47 },
  { 6447, 28, 46, 40, 7, -46 },
  { 6608, 30, 56, 40, 5, -47 },
  { 6818, 28, 46, 40, 7, -46 },
  { 6979, 31, 48, 40, 4, -47 },
  { 7165, 34, 46, 40, 3, -46 },
  { 7361, 27, 47, 40, 6, -46 },
  { 7520, 32, 46, 40, 4, -46 },
  { 7704, 32, 46, 40, 4, -46 },
  { 7888, 33, 46, 40, 3, -46 },
  { 8078, 36, 46, 40, 2, -46 },
  { 8285, 33, 46, 40, 3, -46 },
  { 8475, 16, 59, 40, 17, -50 },
  { 8593, 26, 59, 40, 7, -50 },
  { 8785, 16, 59, 40, 6, -50 },
  { 8903, 31, 25, 40, 4, -46 },
  { 9000, 32, 1, 40, 4, 8 },
  { 9004, 9, 11, 40, 13, -50 },
  { 9017, 30, 36, 40, 5, -35 },
  { 9152, 26, 50, 40, 8, -49 },
  { 9315, 26, 36, 40, 7, -35 },
  { 9432, 26, 50, 40, 5, -49 },
  { 9595, 28, 36, 40, 6, -35 },
  { 9721, 29, 49, 40, 6, -49 },
  { 9899, 31, 51, 40, 6, -37 },
  { 10097, 24, 49, 40, 8, -49 },
  { 10244, 27, 50, 40, 8, -50 },
  { 10413, 23, 63, 40, 6, -50 },
  { 10595, 28, 49, 40, 9, -49 },
  { 10767, 28, 49, 40, 6, -49 },
  { 10939, 30, 35, 40, 5, -35 },
  { 11071, 24, 35, 40, 8, -35 },
  { 11176, 28, 36, 40, 6, -35 },
  { 11302, 26, 48, 40, 8, -35 },
  { 11458, 26, 48, 40, 5, -35 },
  { 11614, 32, 34, 40, 5, -34 },
  { 11750, 28, 36, 40, 6, -35 },
  { 11876, 32, 46, 40, 2, -46 },
  { 12060, 23, 35, 40, 8, -34 },
  { 12161, 27, 34, 40, 6, -34 },
  { 12276, 34, 34, 40, 3, -34 },
  { 12421, 28, 34, 40, 6, -34 },
  { 12540, 29, 47, 40, 5, -34 },
  { 12711, 26, 34, 40, 7, -34 },
  { 12822, 24, 59, 40, 8, -50 },
  { 12999, 1, 59, 40, 19, -50 },
  { 13007, 24, 59, 40, 8, -50 },
  { 13184, 32, 11, 40, 4, -26 },
};

const GFXfont IBMPlexMono_Thin66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_THIN66PT7B_H_
