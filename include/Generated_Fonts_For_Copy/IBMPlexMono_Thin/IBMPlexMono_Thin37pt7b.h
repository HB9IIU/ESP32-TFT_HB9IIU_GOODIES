#ifndef _IBMPLEXMONO_THIN37PT7B_H_
#define _IBMPLEXMONO_THIN37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x56, 0xAA, 0xAA, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01,
  0x02, 0x07, 0xF0, 0x3F, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00,
  0x20, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0xFE, 0x0F, 0xE0, 0x40, 0x80,
  0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10,
  0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x07, 0x11, 0x83, 0x04, 0x10,
  0x81, 0x02, 0x40, 0x40, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40,
  0x40, 0x08, 0x10, 0x03, 0x04, 0x00, 0x31, 0x00, 0x03, 0xE0, 0x00, 0x17,
  0x00, 0x04, 0x30, 0x01, 0x06, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08,
  0x01, 0x01, 0x00, 0x40, 0xA0, 0x10, 0x24, 0x04, 0x08, 0xC1, 0x04, 0x0C,
  0x46, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x1F, 0x00, 0x12, 0x08, 0x02, 0x40, 0x40, 0x28, 0x04, 0x04, 0x80,
  0x40, 0x88, 0x04, 0x08, 0x80, 0x61, 0x08, 0x04, 0x10, 0x80, 0x42, 0x04,
  0x04, 0x20, 0x20, 0x84, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x21, 0x84, 0x04, 0x20, 0x20, 0x42, 0x01, 0x08, 0x20,
  0x10, 0x82, 0x01, 0x10, 0x20, 0x11, 0x02, 0x01, 0x20, 0x20, 0x14, 0x02,
  0x02, 0x40, 0x18, 0x48, 0x00, 0x78, 0x07, 0xC0, 0x02, 0x0C, 0x01, 0x01,
  0x80, 0x80, 0x20, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x1E, 0x03, 0xC8,
  0x80, 0x84, 0x10, 0x22, 0x02, 0x08, 0x80, 0x42, 0x20, 0x08, 0x88, 0x01,
  0x22, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00, 0xA1, 0x00, 0x44,
  0x30, 0x60, 0x87, 0xE0, 0x10, 0xFF, 0x80, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xC0, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0xC0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x03, 0x81, 0x07, 0x1C, 0x4E, 0x00, 0xFC, 0x00,
  0x0C, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x84, 0x00, 0x40, 0x80, 0x20,
  0x10, 0x08, 0x02, 0x04, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x3F, 0xFF, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x6D, 0x2D, 0x24, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x0C, 0x0C, 0x0C, 0x01,
  0x04, 0x00, 0x44, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x00, 0x03, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x12, 0x00, 0x10, 0x80, 0x08, 0x60, 0x08, 0x18, 0x18, 0x03,
  0xF0, 0x00, 0x00, 0xC0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x88, 0x01, 0x84,
  0x01, 0x02, 0x01, 0x01, 0x01, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xC0, 0x07, 0xE0,
  0x18, 0x18, 0x20, 0x0C, 0x40, 0x04, 0x40, 0x02, 0x80, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x22, 0x00, 0x28, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x01, 0x20, 0x06, 0x30,
  0x38, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x40, 0x10, 0x10, 0x08, 0x04, 0x04, 0x01, 0x01, 0x00,
  0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00, 0x43, 0xFF, 0xFF,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x3F, 0xFE, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47, 0xE0,
  0x58, 0x18, 0x60, 0x04, 0x40, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x80, 0x02, 0x40, 0x02,
  0x60, 0x04, 0x18, 0x18, 0x07, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x47, 0xE0, 0x58, 0x18, 0xA0, 0x04, 0xC0, 0x02, 0xC0, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xFF,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x07, 0xE0, 0x0C, 0x0C, 0x08, 0x01, 0x08, 0x00, 0x44, 0x00,
  0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x40, 0x02, 0x20, 0x01, 0x08,
  0x01, 0x03, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0xC1, 0x80, 0x18, 0x80, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00,
  0x09, 0x00, 0x04, 0xC0, 0x04, 0x38, 0x1C, 0x07, 0xF8, 0x00, 0x07, 0xE0,
  0x18, 0x18, 0x30, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x03,
  0x30, 0x05, 0x18, 0x1A, 0x07, 0xE2, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x6D, 0x2D, 0x24, 0x80, 0x00, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xC0, 0xC6, 0x00, 0x90, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x07, 0x80, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x18, 0x30, 0x40, 0x31, 0x00, 0x22, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0xFB, 0x02, 0x0E, 0x08, 0x0C,
  0x10, 0x18, 0x40, 0x30, 0x80, 0x61, 0x00, 0xC2, 0x01, 0x84, 0x03, 0x08,
  0x06, 0x10, 0x0C, 0x20, 0x18, 0x20, 0x28, 0x20, 0xD0, 0x3E, 0xA0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x02, 0x00, 0x40,
  0x80, 0x10, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x08,
  0x10, 0x02, 0x07, 0xFF, 0x82, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFF,
  0xE1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x01, 0x8F, 0xFE, 0x10,
  0x03, 0x20, 0x01, 0x40, 0x02, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x19, 0xFF, 0xE0,
  0x03, 0xF0, 0x0C, 0x08, 0x10, 0x04, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x40, 0x01, 0x20, 0x02, 0x10, 0x04,
  0x0C, 0x08, 0x03, 0xF0, 0xFF, 0xC0, 0x80, 0x30, 0x80, 0x18, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xD0, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x07, 0xE0,
  0x0C, 0x18, 0x30, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x7F, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x03, 0x30, 0x05, 0x0C, 0x19,
  0x07, 0xE1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x3F, 0xF8, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x48, 0x06, 0x20, 0x60,
  0xFC, 0x00, 0x80, 0x01, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10,
  0x80, 0x20, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x81, 0x00, 0x82, 0x00,
  0x86, 0x00, 0x8A, 0x00, 0x91, 0x00, 0xA0, 0x80, 0xC0, 0x80, 0x80, 0x40,
  0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x05, 0xA0, 0x05, 0xA0, 0x05, 0x90, 0x09, 0x90, 0x09, 0x88, 0x11, 0x88,
  0x11, 0x84, 0x21, 0x84, 0x21, 0x82, 0x41, 0x82, 0x41, 0x82, 0x41, 0x81,
  0x81, 0x80, 0x81, 0x81, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x1A, 0x00, 0x32, 0x00, 0x64, 0x00,
  0xC4, 0x01, 0x88, 0x03, 0x08, 0x06, 0x10, 0x0C, 0x10, 0x18, 0x20, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0x41, 0x80, 0x83, 0x00, 0x86, 0x01, 0x0C, 0x01,
  0x18, 0x02, 0x30, 0x02, 0x60, 0x04, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x0C,
  0x07, 0xE0, 0x0C, 0x0C, 0x0C, 0x01, 0x04, 0x00, 0x44, 0x00, 0x24, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x12, 0x00, 0x10, 0x80,
  0x08, 0x60, 0x08, 0x18, 0x18, 0x03, 0xF0, 0x00, 0xFF, 0xF1, 0x00, 0x12,
  0x00, 0x14, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x9F, 0xFE, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x0C,
  0x0C, 0x0C, 0x01, 0x04, 0x00, 0x44, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x12, 0x00, 0x10, 0x80, 0x08, 0x60, 0x08,
  0x18, 0x18, 0x03, 0xF0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xF8, 0xFF, 0xF1, 0x00, 0x12, 0x00, 0x14, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x28, 0x00, 0x9F, 0xFE, 0x20, 0x40, 0x40, 0x40, 0x80, 0x81, 0x00,
  0x82, 0x01, 0x84, 0x01, 0x08, 0x01, 0x10, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x04, 0x07, 0xF8, 0x07, 0x01, 0x83, 0x00, 0x10, 0x80,
  0x02, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x08, 0xC0, 0x04, 0x0C, 0x06,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0x90, 0x01,
  0x20, 0x04, 0x30, 0x30, 0x1F, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00,
  0x09, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x08, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x40,
  0xC0, 0x90, 0x30, 0x24, 0x0C, 0x09, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48,
  0x24, 0x21, 0x09, 0x08, 0x42, 0x22, 0x11, 0x08, 0x84, 0x42, 0x40, 0x90,
  0x90, 0x24, 0x24, 0x09, 0x0A, 0x01, 0x42, 0x80, 0x50, 0xA0, 0x14, 0x28,
  0x03, 0x04, 0x00, 0xC0, 0x80, 0x00, 0x50, 0x00, 0x22, 0x00, 0x10, 0x80,
  0x04, 0x10, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x20, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x12, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x02, 0x10, 0x01, 0x02, 0x00, 0x40, 0x80, 0x20,
  0x10, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00,
  0xA0, 0x00, 0x10, 0x80, 0x00, 0x14, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x04, 0x10, 0x00, 0x80, 0x80, 0x08, 0x08, 0x01, 0x00, 0x40, 0x20, 0x06,
  0x02, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x00, 0x90, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0xFF, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0xFF, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x40, 0x80, 0x20, 0x40, 0x20, 0x10, 0x20, 0x04, 0x10,
  0x02, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x14, 0x00, 0x04, 0xFF, 0xFF,
  0xC0, 0xC2, 0x08, 0x21, 0x04, 0x0F, 0xC0, 0x18, 0x18, 0x10, 0x06, 0x10,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x0F, 0xFE, 0x18, 0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x38, 0x80, 0x14, 0x30, 0x32, 0x07, 0xE1, 0xE0, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x8F, 0xC2, 0xC1, 0x8C, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xA0, 0x02, 0xC0, 0x12, 0xC1, 0x88, 0xF8, 0x00, 0x07, 0xE0,
  0x30, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0xA0, 0x02, 0x20, 0x08, 0x30, 0x20, 0x1F, 0x80, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x07, 0xC2, 0x30, 0x64, 0x80, 0x2A, 0x00, 0x34, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x20, 0x0A, 0x30, 0x64, 0x1F,
  0x88, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x03, 0x20, 0x02, 0x18,
  0x0C, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0x02, 0x00, 0x7E, 0x80, 0x20, 0x60, 0x10, 0x04,
  0x08, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x02,
  0x00, 0x40, 0x40, 0x10, 0x0C, 0x18, 0x01, 0xF8, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x40, 0x0C, 0x60, 0x00,
  0x90, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0xC0, 0x00, 0x90, 0x00, 0x43,
  0x00, 0x60, 0x3F, 0xE0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x8F, 0x85, 0x83, 0x30, 0x05, 0x00, 0x28,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x17,
  0xFF, 0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x06, 0x80, 0x08, 0x80, 0x10,
  0x80, 0x20, 0x80, 0xC0, 0x81, 0x00, 0x82, 0x00, 0x84, 0x00, 0x8A, 0x00,
  0x91, 0x00, 0xA0, 0x80, 0xC0, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10,
  0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0xFF, 0xFF, 0xBC, 0x1E, 0x61, 0x11, 0xA0, 0x70, 0x50, 0x30, 0x28, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x8F, 0x85, 0x83, 0x30, 0x05,
  0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x04, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x02, 0x30, 0x04,
  0x18, 0x18, 0x07, 0xE0, 0x8F, 0xC2, 0xC1, 0x8C, 0x01, 0x20, 0x02, 0x80,
  0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0xC0, 0x12, 0xC1, 0x88,
  0xF8, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x07, 0xC2, 0x30, 0x64, 0x80, 0x2A, 0x00, 0x34, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x20, 0x0A, 0x30, 0x64,
  0x1F, 0x88, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0xFE, 0x1F, 0xC0, 0x98, 0x00, 0x28, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xE0,
  0x18, 0x1C, 0x20, 0x02, 0x40, 0x02, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0xC0, 0x01, 0x60, 0x02, 0x18, 0x0C, 0x07, 0xF0,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xF0, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x50, 0x03, 0x60, 0x14, 0xC0, 0xD0, 0xFC, 0x40, 0x80, 0x01, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x40, 0x60, 0x24, 0x09, 0x02, 0x40, 0x90, 0x24,
  0x09, 0x02, 0x40, 0x90, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x04, 0x42, 0x20, 0x44, 0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x02,
  0x81, 0x40, 0x28, 0x14, 0x02, 0x80, 0xC0, 0x28, 0x08, 0x01, 0x00, 0xC0,
  0x03, 0x40, 0x02, 0x20, 0x04, 0x10, 0x08, 0x08, 0x10, 0x04, 0x10, 0x04,
  0x20, 0x02, 0x40, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x02, 0x40, 0x04,
  0x20, 0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x20, 0x04, 0x40, 0x02, 0xC0,
  0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20,
  0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04,
  0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFE, 0x00, 0x1C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFC,
  0x0E, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0xFF, 0x00, 0x1E, 0x00, 0x48, 0xC0, 0x14, 0x08, 0x05, 0x03,
  0x02, 0x80, 0x60, 0xA0, 0x0C, 0x48, 0x00, 0xE0,
};

const GFXglyph IBMPlexMono_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 2, 26, 22, 10, -26 },
  { 8, 6, 9, 22, 8, -27 },
  { 15, 20, 26, 22, 1, -26 },
  { 80, 18, 34, 22, 2, -30 },
  { 157, 20, 26, 22, 1, -26 },
  { 222, 18, 26, 22, 2, -26 },
  { 281, 1, 9, 22, 11, -27 },
  { 283, 8, 33, 22, 9, -28 },
  { 316, 8, 33, 22, 5, -28 },
  { 349, 18, 18, 22, 2, -20 },
  { 390, 18, 19, 22, 2, -21 },
  { 433, 3, 9, 22, 9, -3 },
  { 437, 10, 1, 22, 6, -12 },
  { 439, 2, 2, 22, 10, -2 },
  { 440, 14, 33, 22, 4, -28 },
  { 498, 17, 26, 22, 3, -26 },
  { 554, 17, 26, 22, 3, -26 },
  { 610, 16, 26, 22, 3, -26 },
  { 662, 15, 26, 22, 3, -26 },
  { 711, 18, 26, 22, 2, -26 },
  { 770, 16, 26, 22, 3, -26 },
  { 822, 16, 26, 22, 3, -26 },
  { 874, 16, 26, 22, 3, -26 },
  { 926, 17, 26, 22, 3, -26 },
  { 982, 16, 26, 22, 3, -26 },
  { 1034, 2, 19, 22, 10, -19 },
  { 1039, 3, 25, 22, 9, -19 },
  { 1049, 16, 20, 22, 3, -21 },
  { 1089, 18, 7, 22, 2, -15 },
  { 1105, 16, 20, 22, 3, -21 },
  { 1145, 14, 26, 22, 4, -26 },
  { 1191, 15, 30, 22, 3, -26 },
  { 1248, 18, 26, 22, 2, -26 },
  { 1307, 15, 26, 22, 4, -26 },
  { 1356, 16, 26, 22, 3, -26 },
  { 1408, 16, 26, 22, 4, -26 },
  { 1460, 15, 26, 22, 4, -26 },
  { 1509, 15, 26, 22, 4, -26 },
  { 1558, 16, 26, 22, 3, -26 },
  { 1610, 15, 26, 22, 4, -26 },
  { 1659, 16, 26, 22, 3, -26 },
  { 1711, 13, 26, 22, 4, -26 },
  { 1754, 16, 26, 22, 4, -26 },
  { 1806, 15, 26, 22, 5, -26 },
  { 1855, 16, 26, 22, 3, -26 },
  { 1907, 15, 26, 22, 4, -26 },
  { 1956, 17, 26, 22, 3, -26 },
  { 2012, 15, 26, 22, 4, -26 },
  { 2061, 17, 31, 22, 3, -26 },
  { 2127, 15, 26, 22, 4, -26 },
  { 2176, 18, 26, 22, 2, -26 },
  { 2235, 19, 26, 22, 2, -26 },
  { 2297, 15, 26, 22, 4, -26 },
  { 2346, 18, 26, 22, 2, -26 },
  { 2405, 18, 26, 22, 2, -26 },
  { 2464, 18, 26, 22, 2, -26 },
  { 2523, 20, 26, 22, 1, -26 },
  { 2588, 18, 26, 22, 2, -26 },
  { 2647, 9, 33, 22, 10, -28 },
  { 2685, 14, 33, 22, 4, -28 },
  { 2743, 8, 33, 22, 4, -28 },
  { 2776, 17, 14, 22, 3, -26 },
  { 2806, 18, 1, 22, 2, 4 },
  { 2809, 5, 6, 22, 7, -28 },
  { 2813, 17, 19, 22, 3, -19 },
  { 2854, 14, 27, 22, 5, -27 },
  { 2902, 15, 19, 22, 4, -19 },
  { 2938, 15, 27, 22, 3, -27 },
  { 2989, 16, 19, 22, 3, -19 },
  { 3027, 17, 27, 22, 3, -27 },
  { 3085, 18, 28, 22, 3, -21 },
  { 3148, 13, 27, 22, 5, -27 },
  { 3192, 16, 27, 22, 4, -27 },
  { 3246, 13, 34, 22, 4, -27 },
  { 3302, 16, 27, 22, 5, -27 },
  { 3356, 16, 27, 22, 3, -27 },
  { 3410, 17, 19, 22, 3, -19 },
  { 3451, 13, 19, 22, 5, -19 },
  { 3482, 16, 19, 22, 3, -19 },
  { 3520, 14, 26, 22, 5, -19 },
  { 3566, 15, 26, 22, 3, -19 },
  { 3615, 18, 19, 22, 3, -19 },
  { 3658, 16, 19, 22, 3, -19 },
  { 3696, 18, 26, 22, 1, -26 },
  { 3755, 14, 19, 22, 4, -19 },
  { 3789, 16, 19, 22, 3, -19 },
  { 3827, 20, 19, 22, 1, -19 },
  { 3875, 16, 19, 22, 3, -19 },
  { 3913, 16, 26, 22, 3, -19 },
  { 3965, 14, 19, 22, 4, -19 },
  { 3999, 14, 33, 22, 4, -28 },
  { 4057, 1, 33, 22, 11, -28 },
  { 4062, 14, 33, 22, 4, -28 },
  { 4120, 18, 7, 22, 2, -15 },
};

const GFXfont IBMPlexMono_Thin37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_THIN37PT7B_H_
