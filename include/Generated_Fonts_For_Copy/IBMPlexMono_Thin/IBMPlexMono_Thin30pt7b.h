#ifndef _IBMPLEXMONO_THIN30PT7B_H_
#define _IBMPLEXMONO_THIN30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA8, 0x03, 0xC0, 0x99, 0x99, 0x99, 0x99, 0x03,
  0x08, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x7C, 0x1F, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08,
  0x20, 0xF8, 0x3E, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x80, 0x10, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x03, 0xF0,
  0x32, 0x31, 0x08, 0x28, 0x20, 0xA0, 0x80, 0x82, 0x02, 0x08, 0x04, 0x20,
  0x18, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x23, 0x00, 0x82, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x82, 0x09, 0x08, 0x23, 0x23, 0x03, 0xF0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x3C, 0x01, 0x42, 0x02, 0x81, 0x02, 0x81,
  0x04, 0x81, 0x08, 0x81, 0x08, 0x81, 0x10, 0x81, 0x10, 0x42, 0x20, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x04, 0x42, 0x08, 0x81, 0x11, 0x01, 0x11,
  0x01, 0x21, 0x01, 0x21, 0x01, 0x40, 0x81, 0x80, 0x42, 0x80, 0x3C, 0x07,
  0x80, 0x30, 0x80, 0x40, 0x81, 0x01, 0x82, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x50, 0x39, 0x10, 0x44, 0x10, 0x90,
  0x11, 0x20, 0x12, 0x40, 0x18, 0x80, 0x11, 0x00, 0x21, 0x00, 0xA1, 0x02,
  0x21, 0xF0, 0x20, 0xFF, 0x06, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x18, 0x80, 0x80, 0x80, 0x80, 0x81, 0x01, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x08, 0x20, 0x82, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x81, 0x02, 0x71, 0x0D, 0x0F, 0xF0, 0x01, 0x80, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x18, 0x10, 0x08, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x69, 0x29, 0x20, 0xFF, 0xF0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x0F,
  0xC0, 0x41, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xA0, 0x0C, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xFF,
  0xFC, 0x1F, 0x81, 0x06, 0x10, 0x09, 0x00, 0x48, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0x81, 0x83, 0x10, 0x04, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x7C, 0x00, 0x38, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x90, 0x04, 0x60, 0xC0, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x04, 0x10, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x10, 0x40, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0x8A, 0x04, 0xC0, 0x20, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x26, 0x0C, 0x1F,
  0x80, 0x01, 0x80, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x9F, 0x8A, 0x04, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x22, 0x04, 0x1F, 0x80, 0xFF, 0xFC, 0x00,
  0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xC0, 0xC2,
  0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x20, 0x10,
  0x40, 0x80, 0xFC, 0x0E, 0x1C, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x14, 0x00, 0x8C, 0x0C, 0x0F, 0xC0, 0x1F, 0x83, 0x04,
  0x40, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x33, 0x07, 0x1F, 0x90, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x60, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x6C, 0x00, 0x00,
  0x00, 0x00, 0x1A, 0x4A, 0x48, 0x00, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0x80, 0x20, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x00, 0x0F, 0x83, 0x06, 0x40, 0x28, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x07, 0x80, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x1F, 0x83, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0x83, 0xD8, 0x43,
  0x88, 0x18, 0x81, 0x90, 0x19, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x81,
  0x84, 0x38, 0x7D, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0xFE,
  0x03, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x84,
  0x02, 0x10, 0x10, 0x40, 0x40, 0x81, 0x02, 0x08, 0x08, 0x20, 0x10, 0xFF,
  0xC4, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80,
  0x04, 0xFF, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0xFF, 0x88, 0x06, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xFF, 0xC0, 0x07, 0xC0, 0x60,
  0xC2, 0x01, 0x08, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x04, 0x80, 0x22, 0x01, 0x06, 0x0C, 0x07, 0xC0, 0xFF, 0x84,
  0x06, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x09, 0x01, 0x8F, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFD, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0x80, 0x14, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xF8,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x06, 0x30,
  0x50, 0x7C, 0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x3F, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x0A, 0x01, 0x30, 0x41, 0xF0,
  0x80, 0x0C, 0x00, 0xA0, 0x09, 0x00, 0x88, 0x08, 0x40, 0x82, 0x04, 0x10,
  0x40, 0x84, 0x04, 0x60, 0x25, 0x01, 0x44, 0x0C, 0x10, 0x40, 0x82, 0x02,
  0x10, 0x08, 0x80, 0x44, 0x01, 0x20, 0x05, 0x00, 0x28, 0x00, 0x80, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0x80, 0x18, 0x01, 0xC0, 0x3C,
  0x03, 0xA0, 0x5A, 0x05, 0xA0, 0x99, 0x09, 0x91, 0x18, 0x91, 0x8A, 0x18,
  0x61, 0x86, 0x18, 0x41, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x80, 0x1C, 0x01, 0xC0, 0x1A, 0x01, 0xA0, 0x19, 0x01,
  0x90, 0x18, 0x81, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11,
  0x81, 0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x38, 0x03, 0x80, 0x10, 0x0F,
  0xC0, 0x41, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0,
  0xFF, 0xC4, 0x01, 0x20, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x14, 0x00, 0xA0, 0x09, 0xFF, 0x88, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xC0, 0x41, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0xF0, 0xFF, 0xC4, 0x01, 0x20, 0x05,
  0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0,
  0x09, 0xFF, 0x88, 0x20, 0x41, 0x02, 0x04, 0x10, 0x10, 0x80, 0x44, 0x02,
  0x20, 0x09, 0x00, 0x28, 0x01, 0x80, 0x0F, 0xC0, 0xC0, 0xC4, 0x00, 0xA0,
  0x02, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x24, 0x00, 0x8C, 0x0C, 0x0F, 0xC0, 0xFF, 0xFF, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x26, 0x06, 0x1F, 0x80, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x50, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x08, 0x04, 0x20,
  0x10, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x21, 0x00, 0x84, 0x02,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0A, 0x14, 0x28, 0x48, 0xA1, 0x22, 0x48, 0x89, 0x21, 0x24, 0x84,
  0x92, 0x12, 0x50, 0x49, 0x40, 0xA5, 0x03, 0x18, 0x0C, 0x20, 0x10, 0x40,
  0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x20,
  0x04, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20,
  0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02,
  0x40, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x7F,
  0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x03, 0xF8, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0xFE, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF8, 0x03, 0x00,
  0x14, 0x00, 0x48, 0x02, 0x20, 0x08, 0x40, 0x40, 0x82, 0x02, 0x08, 0x04,
  0x40, 0x11, 0x00, 0x28, 0x00, 0x40, 0xFF, 0xFC, 0x84, 0x42, 0x10, 0x1F,
  0x80, 0x81, 0x04, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x07,
  0xF8, 0x60, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x61, 0x83, 0x81,
  0xF1, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x09, 0xF0, 0xE0, 0xC8, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0xE0, 0xC9, 0xF0, 0x0F,
  0x83, 0x04, 0x60, 0x24, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x01, 0x60, 0x23, 0x04, 0x0F, 0x80, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xF9, 0x30, 0x72,
  0x03, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x12, 0x03, 0x30, 0x70, 0xF9, 0x1F, 0x82, 0x04, 0x40, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x12, 0x02, 0x1F, 0xC0, 0x03, 0xF8, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x1F, 0xFF, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x7F, 0xF8, 0x00, 0x3C, 0x01, 0x00, 0xFC, 0x0C,
  0x10, 0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x83,
  0x04, 0x07, 0xE0, 0x20, 0x01, 0x00, 0x04, 0x00, 0x0F, 0xF8, 0x40, 0x1A,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x09, 0x00, 0xC3, 0xFC, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x7C, 0xE0, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF,
  0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFF, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x06,
  0x80, 0x44, 0x04, 0x20, 0x41, 0x04, 0x08, 0xC0, 0x4A, 0x02, 0x90, 0x18,
  0x40, 0x81, 0x04, 0x04, 0x20, 0x11, 0x00, 0x48, 0x01, 0x40, 0x0C, 0xFC,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0xBC, 0x7B, 0x0A, 0x28,
  0x30, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06,
  0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x40, 0x9F,
  0x38, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x1F, 0x82, 0x04, 0x40, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x22, 0x04, 0x1F, 0x80, 0x9F, 0x0E, 0x0C, 0x80, 0x48, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x4E, 0x0C, 0x9F, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x0F, 0x93, 0x07, 0x20, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x20, 0x33, 0x07, 0x0F, 0x90,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xFC, 0x7E, 0x09,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x3F,
  0xFE, 0x00, 0x1F, 0x83, 0x03, 0x20, 0x05, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x28, 0x01, 0x30,
  0x10, 0x7F, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x3F, 0xFF, 0x81, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xD0,
  0x73, 0xE4, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20,
  0x42, 0x08, 0x10, 0x81, 0x08, 0x09, 0x00, 0x90, 0x0A, 0x00, 0x60, 0x06,
  0x00, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x42, 0x42, 0x42,
  0x42, 0x44, 0x42, 0x44, 0x24, 0x44, 0x24, 0x24, 0x24, 0x28, 0x24, 0x28,
  0x14, 0x28, 0x18, 0x30, 0x18, 0x10, 0x08, 0x80, 0x14, 0x02, 0x60, 0x42,
  0x08, 0x10, 0x80, 0x90, 0x06, 0x00, 0x60, 0x0A, 0x00, 0x90, 0x10, 0x82,
  0x04, 0x40, 0x44, 0x02, 0x80, 0x10, 0x80, 0x0D, 0x00, 0x24, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x08, 0x40, 0x22, 0x00,
  0x48, 0x01, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x0F, 0xC0, 0x06, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F,
  0x06, 0x00, 0x80, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFE, 0x00, 0x38, 0x05, 0x10, 0x18,
  0x20, 0x60, 0x42, 0x80, 0x8A, 0x01, 0xC0,
};

const GFXglyph IBMPlexMono_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 2, 21, 18, 8, -21 },
  { 7, 4, 8, 18, 7, -22 },
  { 11, 16, 21, 18, 1, -21 },
  { 53, 14, 27, 18, 2, -24 },
  { 101, 16, 21, 18, 1, -21 },
  { 143, 15, 21, 18, 1, -21 },
  { 183, 1, 8, 18, 9, -22 },
  { 184, 7, 27, 18, 7, -23 },
  { 208, 7, 27, 18, 4, -23 },
  { 232, 16, 15, 18, 1, -16 },
  { 262, 14, 15, 18, 2, -17 },
  { 289, 3, 7, 18, 7, -2 },
  { 292, 8, 1, 18, 5, -10 },
  { 293, 2, 2, 18, 8, -2 },
  { 294, 12, 27, 18, 3, -23 },
  { 335, 14, 21, 18, 2, -21 },
  { 372, 14, 21, 18, 3, -21 },
  { 409, 13, 21, 18, 3, -21 },
  { 444, 13, 21, 18, 2, -21 },
  { 479, 16, 21, 18, 1, -21 },
  { 521, 12, 21, 18, 3, -21 },
  { 553, 12, 21, 18, 3, -21 },
  { 585, 13, 21, 18, 2, -21 },
  { 620, 14, 21, 18, 2, -21 },
  { 657, 12, 21, 18, 3, -21 },
  { 689, 2, 16, 18, 8, -16 },
  { 693, 3, 21, 18, 7, -16 },
  { 701, 12, 16, 18, 3, -17 },
  { 725, 14, 6, 18, 2, -12 },
  { 736, 12, 16, 18, 3, -17 },
  { 760, 12, 21, 18, 3, -21 },
  { 792, 12, 24, 18, 3, -21 },
  { 828, 14, 21, 18, 2, -21 },
  { 865, 12, 21, 18, 3, -21 },
  { 897, 14, 21, 18, 2, -21 },
  { 934, 13, 21, 18, 3, -21 },
  { 969, 12, 21, 18, 3, -21 },
  { 1001, 13, 21, 18, 3, -21 },
  { 1036, 13, 21, 18, 2, -21 },
  { 1071, 12, 21, 18, 3, -21 },
  { 1103, 12, 21, 18, 3, -21 },
  { 1135, 11, 21, 18, 3, -21 },
  { 1164, 13, 21, 18, 3, -21 },
  { 1199, 12, 21, 18, 4, -21 },
  { 1231, 12, 21, 18, 3, -21 },
  { 1263, 12, 21, 18, 3, -21 },
  { 1295, 14, 21, 18, 2, -21 },
  { 1332, 13, 21, 18, 3, -21 },
  { 1367, 14, 25, 18, 2, -21 },
  { 1411, 13, 21, 18, 3, -21 },
  { 1446, 14, 21, 18, 2, -21 },
  { 1483, 16, 21, 18, 1, -21 },
  { 1525, 12, 21, 18, 3, -21 },
  { 1557, 14, 21, 18, 2, -21 },
  { 1594, 14, 21, 18, 2, -21 },
  { 1631, 16, 21, 18, 1, -21 },
  { 1673, 16, 21, 18, 1, -21 },
  { 1715, 16, 21, 18, 1, -21 },
  { 1757, 7, 27, 18, 8, -23 },
  { 1781, 12, 27, 18, 3, -23 },
  { 1822, 7, 27, 18, 3, -23 },
  { 1846, 14, 11, 18, 2, -21 },
  { 1866, 14, 1, 18, 2, 3 },
  { 1868, 4, 5, 18, 6, -23 },
  { 1871, 14, 15, 18, 2, -15 },
  { 1898, 12, 22, 18, 4, -22 },
  { 1931, 12, 15, 18, 3, -15 },
  { 1954, 12, 22, 18, 2, -22 },
  { 1987, 12, 15, 18, 3, -15 },
  { 2010, 13, 22, 18, 3, -22 },
  { 2046, 14, 23, 18, 3, -17 },
  { 2087, 10, 22, 18, 4, -22 },
  { 2115, 12, 22, 18, 4, -22 },
  { 2148, 10, 28, 18, 3, -22 },
  { 2183, 13, 22, 18, 4, -22 },
  { 2219, 12, 22, 18, 3, -22 },
  { 2252, 14, 15, 18, 2, -15 },
  { 2279, 10, 15, 18, 4, -15 },
  { 2298, 12, 15, 18, 3, -15 },
  { 2321, 12, 21, 18, 4, -15 },
  { 2353, 12, 21, 18, 2, -15 },
  { 2385, 15, 15, 18, 2, -15 },
  { 2414, 13, 15, 18, 3, -15 },
  { 2439, 15, 21, 18, 1, -21 },
  { 2479, 10, 15, 18, 4, -15 },
  { 2498, 12, 15, 18, 3, -15 },
  { 2521, 16, 15, 18, 1, -15 },
  { 2551, 12, 15, 18, 3, -15 },
  { 2574, 14, 21, 18, 2, -15 },
  { 2611, 12, 15, 18, 3, -15 },
  { 2634, 12, 27, 18, 3, -23 },
  { 2675, 1, 27, 18, 9, -23 },
  { 2679, 12, 27, 18, 3, -23 },
  { 2720, 14, 6, 18, 2, -12 },
};

const GFXfont IBMPlexMono_Thin30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_THIN30PT7B_H_
