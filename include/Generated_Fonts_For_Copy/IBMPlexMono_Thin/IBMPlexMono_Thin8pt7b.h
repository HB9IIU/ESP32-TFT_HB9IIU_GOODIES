#ifndef _IBMPLEXMONO_THIN8PT7B_H_
#define _IBMPLEXMONO_THIN8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x53, 0x3E, 0xCF, 0x50, 0xDF, 0x37, 0xD0, 0xCE, 0xB8,
  0x2E, 0xD8, 0x68, 0x8D, 0xBF, 0xC0, 0xEA, 0xAC, 0xA5, 0x68, 0x4F, 0x69,
  0x4F, 0x44, 0xC0, 0xC0, 0x80, 0x29, 0x49, 0x20, 0xD6, 0xFB, 0xC0, 0x59,
  0x25, 0xC0, 0xD4, 0xA9, 0xC0, 0xC4, 0xF3, 0xC0, 0x22, 0x6A, 0xA7, 0xF2,
  0x33, 0xC0, 0x52, 0x7B, 0xC0, 0xF5, 0x29, 0x00, 0xD6, 0xFB, 0xC0, 0xD6,
  0xF2, 0x80, 0x90, 0x98, 0x2A, 0x46, 0xF0, 0x91, 0xA8, 0xD4, 0xE8, 0x80,
  0xD7, 0xDB, 0xB8, 0x26, 0x69, 0xF9, 0xD6, 0xFB, 0xC0, 0xD6, 0x49, 0xC0,
  0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0xD6, 0x7B, 0xC0,
  0xB6, 0xFB, 0x40, 0xF2, 0x49, 0xC0, 0xE4, 0x93, 0x80, 0xBA, 0x6D, 0x40,
  0x92, 0x49, 0xC0, 0xB7, 0xFB, 0x40, 0xB6, 0xFF, 0x40, 0xD6, 0xDB, 0xC0,
  0xD6, 0xE9, 0x00, 0xD6, 0xDB, 0x78, 0xD6, 0xED, 0x40, 0xD6, 0x33, 0xC0,
  0xF4, 0x44, 0x44, 0xB6, 0xDB, 0xC0, 0x99, 0x96, 0x66, 0x99, 0xBF, 0xF9,
  0x99, 0x66, 0x69, 0x8C, 0x98, 0x44, 0x20, 0x71, 0x24, 0x4F, 0xEA, 0xAC,
  0x92, 0x44, 0x88, 0xD5, 0x5C, 0x5A, 0x80, 0xF0, 0x80, 0xC7, 0xF0, 0x93,
  0xDB, 0xC0, 0xF2, 0x70, 0x27, 0xDB, 0xC0, 0xF7, 0x70, 0xF3, 0xC9, 0xC0,
  0xF5, 0x4F, 0xC0, 0x93, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x23, 0x24, 0x96,
  0x92, 0xED, 0x40, 0x92, 0x49, 0xC0, 0xF6, 0xD0, 0xF6, 0xD0, 0xF6, 0xF0,
  0xF6, 0xDD, 0x00, 0xF6, 0xD6, 0x40, 0xF2, 0x70, 0xF1, 0xF0, 0x44, 0xF4,
  0x47, 0xB6, 0xF0, 0xBB, 0x60, 0xFF, 0xBD, 0x60, 0xBB, 0x50, 0xBB, 0x29,
  0x00, 0xEA, 0x70, 0xF1, 0x45, 0x38, 0xFE, 0xCA, 0x3C, 0xB0, 0xF0,
};

const GFXglyph IBMPlexMono_Thin8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 7, 5, 1, -6 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 5, 0, -6 },
  { 17, 1, 2, 5, 2, -6 },
  { 18, 2, 7, 5, 2, -6 },
  { 20, 2, 7, 5, 1, -6 },
  { 22, 4, 4, 5, 0, -4 },
  { 24, 4, 4, 5, 0, -4 },
  { 26, 1, 2, 5, 2, -1 },
  { 27, 2, 1, 5, 1, -3 },
  { 28, 1, 1, 5, 2, -1 },
  { 29, 3, 7, 5, 1, -6 },
  { 32, 3, 6, 5, 1, -6 },
  { 35, 3, 6, 5, 1, -6 },
  { 38, 3, 6, 5, 1, -6 },
  { 41, 3, 6, 5, 1, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 3, 6, 5, 1, -6 },
  { 62, 1, 4, 5, 2, -4 },
  { 63, 1, 5, 5, 2, -4 },
  { 64, 3, 5, 5, 1, -5 },
  { 66, 4, 1, 5, 0, -3 },
  { 67, 3, 5, 5, 1, -5 },
  { 69, 3, 6, 5, 1, -6 },
  { 72, 3, 7, 5, 1, -6 },
  { 75, 4, 6, 5, 0, -6 },
  { 78, 3, 6, 5, 1, -6 },
  { 81, 3, 6, 5, 1, -6 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 3, 7, 5, 1, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 4, 6, 5, 0, -6 },
  { 135, 3, 6, 5, 1, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 4, 6, 5, 0, -6 },
  { 144, 4, 6, 5, 0, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 2, 7, 5, 2, -6 },
  { 156, 3, 7, 5, 1, -6 },
  { 159, 2, 7, 5, 1, -6 },
  { 161, 3, 3, 5, 1, -6 },
  { 163, 4, 1, 5, 0, 1 },
  { 164, 1, 1, 5, 2, -6 },
  { 165, 3, 4, 5, 1, -4 },
  { 167, 3, 6, 5, 1, -6 },
  { 170, 3, 4, 5, 1, -4 },
  { 172, 3, 6, 5, 1, -6 },
  { 175, 3, 4, 5, 1, -4 },
  { 177, 3, 6, 5, 1, -6 },
  { 180, 3, 6, 5, 1, -4 },
  { 183, 3, 6, 5, 1, -6 },
  { 186, 3, 6, 5, 1, -6 },
  { 189, 3, 8, 5, 1, -6 },
  { 192, 3, 6, 5, 1, -6 },
  { 195, 3, 6, 5, 1, -6 },
  { 198, 3, 4, 5, 1, -4 },
  { 200, 3, 4, 5, 1, -4 },
  { 202, 3, 4, 5, 1, -4 },
  { 204, 3, 6, 5, 1, -4 },
  { 207, 3, 6, 5, 1, -4 },
  { 210, 3, 4, 5, 1, -4 },
  { 212, 3, 4, 5, 1, -4 },
  { 214, 4, 6, 5, 0, -6 },
  { 217, 3, 4, 5, 1, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 5, 4, 5, 0, -4 },
  { 224, 3, 4, 5, 1, -4 },
  { 226, 3, 6, 5, 1, -4 },
  { 229, 3, 4, 5, 1, -4 },
  { 231, 3, 7, 5, 1, -6 },
  { 234, 1, 7, 5, 2, -6 },
  { 235, 3, 7, 5, 1, -6 },
  { 238, 4, 1, 5, 0, -3 },
};

const GFXfont IBMPlexMono_Thin8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_THIN8PT7B_H_
