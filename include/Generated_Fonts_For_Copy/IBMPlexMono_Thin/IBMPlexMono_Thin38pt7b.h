#ifndef _IBMPLEXMONO_THIN38PT7B_H_
#define _IBMPLEXMONO_THIN38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x00, 0x1F, 0x80,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x00, 0x41, 0x00, 0x02,
  0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80,
  0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x02, 0x03, 0xF8, 0x1F, 0xC0, 0x40,
  0x80, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x08, 0x10, 0x00,
  0x40, 0x80, 0x02, 0x04, 0x07, 0xF0, 0x3F, 0x80, 0x82, 0x00, 0x08, 0x10,
  0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x20, 0x00, 0x82, 0x00, 0x04,
  0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x7F, 0x00, 0xC4, 0x61, 0x82, 0x08, 0x81, 0x02,
  0x80, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x02, 0x04,
  0x01, 0x02, 0x00, 0x61, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x23, 0x00,
  0x10, 0x60, 0x08, 0x10, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x60, 0x20, 0x38, 0x10, 0x26, 0x08, 0x20, 0xC4, 0x60, 0x1F,
  0xC0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0x00,
  0x19, 0x04, 0x00, 0x90, 0x10, 0x08, 0x80, 0x80, 0x48, 0x02, 0x04, 0x40,
  0x10, 0x42, 0x00, 0x82, 0x10, 0x04, 0x20, 0x80, 0x21, 0x02, 0x02, 0x10,
  0x10, 0x11, 0x00, 0x41, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0x0C, 0x03, 0x10, 0x10, 0x11, 0x00, 0x81, 0x08, 0x04,
  0x10, 0x40, 0x20, 0x82, 0x01, 0x08, 0x10, 0x08, 0x40, 0x80, 0x44, 0x04,
  0x02, 0x40, 0x10, 0x12, 0x00, 0x43, 0x20, 0x01, 0xE0, 0x07, 0xE0, 0x01,
  0x86, 0x00, 0x40, 0x20, 0x08, 0x02, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x24, 0x03, 0xC8, 0x40, 0x42, 0x04, 0x10, 0x80,
  0x42, 0x10, 0x0C, 0x42, 0x00, 0xC8, 0x40, 0x0D, 0x08, 0x00, 0xA1, 0x00,
  0x08, 0x20, 0x01, 0x84, 0x00, 0x48, 0x40, 0x18, 0x86, 0x06, 0x10, 0x3F,
  0x01, 0x80, 0xFF, 0xC0, 0x01, 0x81, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0xC0, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x07, 0x02, 0x07, 0x1C, 0x47, 0x00, 0x7F, 0x00, 0x01, 0x00,
  0x00, 0x50, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x20, 0x20,
  0x08, 0x02, 0x02, 0x00, 0x40, 0x40, 0x04, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x2D, 0xA4, 0xA4, 0x90, 0xFF, 0xC0, 0xFC, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x07, 0xE0, 0x0E, 0x0C, 0x0C, 0x01, 0x04, 0x00, 0x44, 0x00,
  0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x04, 0x40, 0x04, 0x30, 0x04, 0x0E, 0x0C, 0x01, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x50, 0x00, 0x24, 0x00, 0x31, 0x00, 0x18, 0x40, 0x0C,
  0x10, 0x06, 0x04, 0x03, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x07, 0xFF,
  0xFC, 0x07, 0xE0, 0x0C, 0x0C, 0x08, 0x01, 0x0C, 0x00, 0x44, 0x00, 0x24,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xE0, 0x18, 0x18, 0x20, 0x0C, 0x40, 0x04, 0x80, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x10, 0x0F,
  0xE0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40,
  0x04, 0x30, 0x18, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x20, 0x80, 0x08, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x20, 0x04, 0x08, 0x00, 0x81,
  0x00, 0x10, 0x40, 0x02, 0x0F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xFE,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47, 0xF0, 0x58, 0x0C,
  0x60, 0x06, 0x40, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x40, 0x02, 0x20, 0x04,
  0x18, 0x18, 0x07, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x47, 0xF0, 0x58, 0x1C, 0x70, 0x06, 0xC0, 0x02, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x20, 0x02, 0x30, 0x04, 0x18, 0x18, 0x07, 0xF0, 0xFF, 0xFF,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x0C, 0x06, 0x08, 0x01, 0x88, 0x00,
  0x64, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20,
  0x01, 0x08, 0x00, 0x83, 0x01, 0x80, 0x7F, 0x00, 0xE0, 0xE0, 0x80, 0x08,
  0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x80, 0x02, 0x20, 0x02, 0x0C, 0x06, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0E, 0x0E, 0x0C, 0x01, 0x84, 0x00, 0x44, 0x00,
  0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50,
  0x00, 0x68, 0x00, 0x22, 0x00, 0x31, 0x80, 0x38, 0x70, 0x24, 0x0F, 0xE2,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x77, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x66, 0x44, 0x48, 0x88, 0x80, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x30, 0x80, 0x32, 0x00, 0x28,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x3C, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80,
  0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x81, 0xF3,
  0x06, 0x16, 0x10, 0x1C, 0x20, 0x18, 0x40, 0x31, 0x00, 0x62, 0x00, 0xC4,
  0x01, 0x88, 0x03, 0x10, 0x06, 0x20, 0x0C, 0x20, 0x18, 0x40, 0x70, 0x41,
  0x60, 0x7C, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x40,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x10, 0x02, 0x03, 0xFF,
  0xE0, 0x40, 0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00,
  0x22, 0x00, 0x02, 0x40, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x00, 0x80, 0xFF,
  0xE0, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x10, 0xFF, 0xE0, 0x80, 0x18, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x0C, 0xFF, 0xF0, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84,
  0x00, 0x22, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02, 0x10, 0x02, 0x06, 0x06,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x80, 0x30, 0x80, 0x08, 0x80, 0x04, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x06,
  0x04, 0x04, 0x01, 0x04, 0x00, 0x44, 0x00, 0x12, 0x00, 0x09, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x06, 0x40, 0x05,
  0x10, 0x06, 0x86, 0x06, 0x40, 0xFC, 0x20, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0xFF, 0xFF, 0x3F, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x40, 0x10,
  0xC1, 0x80, 0xF8, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x20, 0x01, 0x90, 0x00,
  0x88, 0x00, 0x84, 0x00, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40,
  0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x60, 0x04, 0x48, 0x02, 0x42, 0x01,
  0x41, 0x00, 0xC0, 0x40, 0x40, 0x10, 0x20, 0x08, 0x10, 0x02, 0x08, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x40, 0x00, 0xA0,
  0x00, 0x20, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F,
  0xFF, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xE8, 0x00, 0xB4, 0x00, 0x5A, 0x00,
  0x6C, 0x80, 0x26, 0x40, 0x13, 0x10, 0x11, 0x88, 0x08, 0xC2, 0x08, 0x61,
  0x04, 0x30, 0x84, 0x18, 0x22, 0x0C, 0x12, 0x06, 0x05, 0x03, 0x02, 0x81,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x1A, 0x00, 0x32, 0x00, 0x64,
  0x00, 0xC4, 0x01, 0x88, 0x03, 0x08, 0x06, 0x10, 0x0C, 0x10, 0x18, 0x20,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x41, 0x80, 0x83, 0x00, 0x86, 0x01, 0x0C,
  0x01, 0x18, 0x02, 0x30, 0x02, 0x60, 0x04, 0xC0, 0x05, 0x80, 0x0B, 0x00,
  0x0E, 0x00, 0x08, 0x07, 0xE0, 0x0E, 0x0C, 0x0C, 0x01, 0x04, 0x00, 0x44,
  0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x40, 0x04, 0x30, 0x04, 0x0E, 0x0C, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x0C, 0xFF, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x0E, 0x0C, 0x0C,
  0x01, 0x04, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x40, 0x04, 0x30, 0x04,
  0x0E, 0x0C, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C, 0xFF, 0xF0, 0x81, 0x00, 0x80,
  0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x10, 0x80,
  0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x03, 0x07, 0xF0, 0x0C,
  0x06, 0x18, 0x00, 0x88, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x80, 0x02,
  0x60, 0x02, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x60,
  0x30, 0x3F, 0x80, 0x80, 0x00, 0x30, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x40, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08,
  0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20,
  0x01, 0x08, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x48, 0x00, 0x05, 0x00,
  0x00, 0xA0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x40, 0x48, 0x18, 0x09, 0x02, 0x81, 0x20, 0x50,
  0x24, 0x12, 0x08, 0x82, 0x21, 0x10, 0x44, 0x22, 0x08, 0x84, 0x22, 0x10,
  0x84, 0x41, 0x10, 0x88, 0x22, 0x12, 0x04, 0x42, 0x40, 0x48, 0x48, 0x09,
  0x09, 0x01, 0x41, 0x40, 0x28, 0x28, 0x03, 0x05, 0x00, 0x60, 0x40, 0x0C,
  0x00, 0xC0, 0x00, 0x68, 0x00, 0x08, 0x80, 0x02, 0x18, 0x00, 0x81, 0x00,
  0x10, 0x10, 0x04, 0x02, 0x01, 0x00, 0x20, 0x20, 0x02, 0x08, 0x00, 0x42,
  0x00, 0x04, 0x40, 0x00, 0x50, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x28,
  0x00, 0x09, 0x00, 0x01, 0x10, 0x00, 0x41, 0x00, 0x10, 0x20, 0x02, 0x02,
  0x00, 0x80, 0x20, 0x20, 0x04, 0x04, 0x00, 0x41, 0x00, 0x04, 0x40, 0x00,
  0x88, 0x00, 0x0A, 0x00, 0x00, 0x80, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x88,
  0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x04, 0x08, 0x00, 0x40, 0x20, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x10, 0x10, 0x00, 0x41, 0x00, 0x02,
  0x08, 0x00, 0x08, 0x80, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F,
  0xC0, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xA0,
  0x00, 0x90, 0x00, 0x44, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x04, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x28, 0x00, 0x14,
  0x00, 0x04, 0xFF, 0xFF, 0xE0, 0x82, 0x10, 0x41, 0x04, 0x0F, 0xC0, 0x18,
  0x18, 0x10, 0x02, 0x10, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x07, 0xFE, 0x0C, 0x01, 0x08, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x20, 0x0A, 0x08,
  0x09, 0x03, 0xF0, 0xF0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x8F, 0xC1, 0x60, 0x63, 0x00,
  0x64, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x09, 0x80, 0x32, 0xC0, 0xC4, 0x7E, 0x00, 0x07, 0xE0, 0x30,
  0x30, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x28, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x01, 0x20, 0x02, 0x60, 0x08, 0x60, 0x60, 0x3F, 0x00, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x07, 0xE2, 0x30, 0x34, 0x80, 0x2A, 0x00, 0x34, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x40, 0x06, 0x40, 0x0C,
  0x60, 0x68, 0x3F, 0x10, 0x07, 0xE0, 0x0C, 0x18, 0x10, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x01,
  0x20, 0x02, 0x10, 0x02, 0x0C, 0x0C, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x01,
  0x00, 0x3E, 0x40, 0x30, 0x70, 0x10, 0x04, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x40, 0x18, 0x10,
  0x04, 0x03, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFE, 0x0C, 0x00, 0x64, 0x00, 0x09,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x09, 0x00, 0x06, 0x30,
  0x07, 0x03, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x8F, 0xC5, 0x83, 0x30, 0x05, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x2F, 0xFF,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x02, 0x80, 0x0C, 0x80, 0x10, 0x80,
  0x20, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82, 0x00, 0x86, 0x00, 0x99,
  0x00, 0xA0, 0x80, 0xC0, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0xFF, 0x9E, 0x1E, 0x50, 0x90, 0xB0, 0x50, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10,
  0x8F, 0xC5, 0x83, 0x30, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x07, 0xE0, 0x0C,
  0x18, 0x30, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x30, 0x04, 0x0C, 0x18, 0x07,
  0xE0, 0x8F, 0xC1, 0x60, 0x63, 0x00, 0x64, 0x00, 0x48, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x80, 0x32, 0xC0,
  0xC4, 0x7E, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE2, 0x30, 0x34, 0x80, 0x2A,
  0x00, 0x34, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01,
  0x40, 0x06, 0x40, 0x0C, 0x60, 0x68, 0x3F, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0xFF,
  0x1F, 0xC0, 0x48, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x0C, 0x06,
  0x08, 0x00, 0x88, 0x00, 0x64, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x01, 0x10, 0x01, 0x86, 0x01,
  0x80, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01,
  0x40, 0x0C, 0x80, 0x53, 0x02, 0x43, 0xF1, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x10,
  0x20, 0x20, 0x40, 0x80, 0x41, 0x00, 0x82, 0x01, 0x08, 0x01, 0x10, 0x02,
  0x20, 0x04, 0x80, 0x05, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x90, 0x14, 0x09, 0x02,
  0x40, 0x88, 0x22, 0x08, 0x82, 0x21, 0x08, 0x22, 0x10, 0x82, 0x21, 0x04,
  0x42, 0x10, 0x44, 0x12, 0x04, 0x41, 0x20, 0x24, 0x12, 0x02, 0x41, 0x20,
  0x24, 0x14, 0x02, 0x81, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0xC0,
  0x01, 0x20, 0x02, 0x20, 0x04, 0x10, 0x04, 0x08, 0x08, 0x04, 0x10, 0x04,
  0x30, 0x02, 0x20, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80, 0x01, 0x40, 0x02,
  0x20, 0x04, 0x30, 0x04, 0x10, 0x08, 0x08, 0x10, 0x04, 0x20, 0x02, 0x40,
  0x02, 0xC0, 0x01, 0x80, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x42,
  0x00, 0x21, 0x00, 0x20, 0x40, 0x10, 0x20, 0x08, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04,
  0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x60, 0xFE, 0x00, 0x0E,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xFC, 0x0E, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x83, 0xFE, 0x00, 0x1E, 0x00,
  0x24, 0x20, 0x09, 0x02, 0x01, 0x20, 0x20, 0x2C, 0x02, 0x09, 0x00, 0x23,
  0x20, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 27, 23, 10, -27 },
  { 12, 6, 10, 23, 8, -28 },
  { 20, 21, 27, 23, 1, -27 },
  { 91, 17, 35, 23, 3, -31 },
  { 166, 21, 27, 23, 1, -27 },
  { 237, 19, 27, 23, 2, -27 },
  { 302, 1, 10, 23, 11, -28 },
  { 304, 9, 34, 23, 9, -29 },
  { 343, 9, 34, 23, 5, -29 },
  { 382, 19, 19, 23, 2, -21 },
  { 428, 18, 19, 23, 2, -21 },
  { 471, 3, 10, 23, 9, -3 },
  { 475, 10, 1, 23, 6, -12 },
  { 477, 3, 2, 23, 10, -2 },
  { 478, 15, 34, 23, 4, -29 },
  { 542, 17, 27, 23, 3, -27 },
  { 600, 18, 27, 23, 3, -27 },
  { 661, 17, 27, 23, 3, -27 },
  { 719, 16, 27, 23, 3, -27 },
  { 773, 19, 27, 23, 2, -27 },
  { 838, 16, 27, 23, 3, -27 },
  { 892, 16, 27, 23, 3, -27 },
  { 946, 16, 27, 23, 3, -27 },
  { 1000, 17, 27, 23, 3, -27 },
  { 1058, 17, 27, 23, 3, -27 },
  { 1116, 3, 20, 23, 10, -20 },
  { 1124, 4, 27, 23, 9, -20 },
  { 1138, 17, 20, 23, 3, -22 },
  { 1181, 18, 7, 23, 2, -15 },
  { 1197, 17, 20, 23, 3, -22 },
  { 1240, 15, 27, 23, 4, -27 },
  { 1291, 15, 31, 23, 4, -27 },
  { 1350, 19, 27, 23, 2, -27 },
  { 1415, 16, 27, 23, 4, -27 },
  { 1469, 17, 27, 23, 3, -27 },
  { 1527, 16, 27, 23, 4, -27 },
  { 1581, 16, 27, 23, 4, -27 },
  { 1635, 16, 27, 23, 4, -27 },
  { 1689, 17, 27, 23, 3, -27 },
  { 1747, 15, 27, 23, 4, -27 },
  { 1798, 16, 27, 23, 3, -27 },
  { 1852, 14, 27, 23, 4, -27 },
  { 1900, 17, 27, 23, 4, -27 },
  { 1958, 14, 27, 23, 6, -27 },
  { 2006, 17, 27, 23, 3, -27 },
  { 2064, 15, 27, 23, 4, -27 },
  { 2115, 17, 27, 23, 3, -27 },
  { 2173, 16, 27, 23, 4, -27 },
  { 2227, 17, 32, 23, 3, -27 },
  { 2295, 16, 27, 23, 4, -27 },
  { 2349, 17, 27, 23, 3, -27 },
  { 2407, 19, 27, 23, 2, -27 },
  { 2472, 15, 27, 23, 4, -27 },
  { 2523, 19, 27, 23, 2, -27 },
  { 2588, 19, 27, 23, 2, -27 },
  { 2653, 19, 27, 23, 2, -27 },
  { 2718, 21, 27, 23, 1, -27 },
  { 2789, 19, 27, 23, 2, -27 },
  { 2854, 9, 34, 23, 10, -29 },
  { 2893, 15, 34, 23, 4, -29 },
  { 2957, 9, 34, 23, 4, -29 },
  { 2996, 17, 14, 23, 3, -27 },
  { 3026, 19, 1, 23, 2, 4 },
  { 3029, 5, 6, 23, 8, -29 },
  { 3033, 17, 20, 23, 3, -20 },
  { 3076, 15, 28, 23, 5, -28 },
  { 3129, 15, 20, 23, 4, -20 },
  { 3167, 15, 28, 23, 3, -28 },
  { 3220, 16, 20, 23, 3, -20 },
  { 3260, 17, 28, 23, 3, -28 },
  { 3320, 18, 30, 23, 3, -22 },
  { 3388, 13, 28, 23, 5, -28 },
  { 3434, 16, 29, 23, 4, -29 },
  { 3492, 13, 37, 23, 4, -29 },
  { 3553, 16, 28, 23, 5, -28 },
  { 3609, 16, 28, 23, 3, -28 },
  { 3665, 17, 20, 23, 3, -20 },
  { 3708, 13, 20, 23, 5, -20 },
  { 3741, 16, 20, 23, 3, -20 },
  { 3781, 15, 28, 23, 5, -20 },
  { 3834, 15, 28, 23, 3, -20 },
  { 3887, 18, 20, 23, 3, -20 },
  { 3932, 17, 20, 23, 3, -20 },
  { 3975, 19, 27, 23, 1, -27 },
  { 4040, 14, 20, 23, 4, -20 },
  { 4075, 15, 20, 23, 4, -20 },
  { 4113, 20, 20, 23, 1, -20 },
  { 4163, 16, 20, 23, 3, -20 },
  { 4203, 17, 28, 23, 3, -20 },
  { 4263, 15, 20, 23, 4, -20 },
  { 4301, 14, 34, 23, 4, -29 },
  { 4361, 1, 34, 23, 11, -29 },
  { 4366, 14, 34, 23, 4, -29 },
  { 4426, 19, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_Thin38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_THIN38PT7B_H_
