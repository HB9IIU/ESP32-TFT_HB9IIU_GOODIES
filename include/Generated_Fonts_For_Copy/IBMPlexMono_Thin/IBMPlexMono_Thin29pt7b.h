#ifndef _IBMPLEXMONO_THIN29PT7B_H_
#define _IBMPLEXMONO_THIN29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA8, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x20, 0x04, 0x20, 0x7C,
  0x1F, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0xF8, 0x7E, 0x08, 0x40, 0x08, 0x40, 0x10, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x10, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0x83, 0x22, 0x21,
  0x0A, 0x08, 0x30, 0x40, 0x82, 0x04, 0x10, 0x10, 0x80, 0x44, 0x01, 0xF0,
  0x01, 0x70, 0x08, 0x40, 0x41, 0x02, 0x08, 0x10, 0x40, 0x83, 0x04, 0x14,
  0x20, 0x99, 0x18, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x3C, 0x03,
  0x42, 0x02, 0x81, 0x04, 0x81, 0x04, 0x81, 0x08, 0x81, 0x10, 0x81, 0x10,
  0x42, 0x20, 0x3C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x78, 0x08, 0x86,
  0x11, 0x02, 0x11, 0x02, 0x21, 0x02, 0x21, 0x02, 0x41, 0x02, 0x80, 0x86,
  0x80, 0x78, 0x0F, 0x80, 0x30, 0x80, 0x80, 0x81, 0x01, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x38, 0x1C, 0x98, 0x42, 0x18,
  0x88, 0x19, 0x10, 0x12, 0x20, 0x14, 0x40, 0x18, 0x80, 0x10, 0x80, 0x50,
  0x83, 0x10, 0xF8, 0x30, 0xFE, 0x04, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x80, 0x80, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x41, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x18, 0x20, 0x4E,
  0x4F, 0x03, 0xE0, 0x02, 0x80, 0x05, 0x00, 0x11, 0x00, 0x41, 0x00, 0x81,
  0x02, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x56, 0xA8, 0xFF, 0xF0, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x00, 0x0F, 0x80,
  0x83, 0x08, 0x04, 0x80, 0x2C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x10, 0x60, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x40, 0x11, 0x00, 0x84, 0x18, 0x1F, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x90,
  0x04, 0x40, 0x21, 0x03, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x1F, 0xFF, 0x1F, 0x02, 0x0C, 0x40, 0x48, 0x02,
  0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF,
  0x0F, 0x83, 0x06, 0x40, 0x28, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x41, 0xF8, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x14, 0x02, 0x20, 0x61, 0xF8, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40,
  0x04, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x41, 0x00, 0x84, 0x01, 0x10, 0x02, 0x3F, 0xFF, 0x80, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x3F, 0xF1, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x4F, 0x83, 0x83,
  0x10, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x80, 0x12,
  0x00, 0x8C, 0x18, 0x1F, 0x00, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x9F, 0x0E, 0x0C, 0x80, 0x28, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x60, 0xC1, 0xF0, 0xFF,
  0xFC, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x00, 0x0F, 0xC1, 0x83, 0x10,
  0x04, 0x80, 0x24, 0x00, 0xC0, 0x05, 0x00, 0x48, 0x02, 0x30, 0x20, 0x7E,
  0x0E, 0x18, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A,
  0x00, 0x8C, 0x0C, 0x1F, 0x80, 0x1F, 0x82, 0x0C, 0x40, 0x28, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x60, 0xD1, 0xFA, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0xF0,
  0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x92, 0x92, 0x40, 0x00,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x00,
  0x1F, 0x84, 0x19, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x1C, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x20, 0x18, 0x03, 0x00,
  0x61, 0xEC, 0x63, 0x88, 0x32, 0x06, 0x40, 0xC8, 0x19, 0x03, 0x20, 0x62,
  0x0C, 0x43, 0x87, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x60, 0x07, 0xF8,
  0x02, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x08, 0x80, 0x22, 0x00, 0x88,
  0x04, 0x10, 0x10, 0x40, 0x41, 0x02, 0x02, 0x08, 0x08, 0x20, 0x20, 0xFF,
  0xC4, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x01, 0xFF,
  0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x4F, 0xF8, 0x80, 0x68, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x6F, 0xF8, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0x80, 0x14,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x01, 0x40, 0x09, 0x00, 0x86, 0x08,
  0x1F, 0x80, 0xFF, 0x08, 0x0C, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0xCF, 0xF0, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x80, 0x83, 0x08,
  0x04, 0x80, 0x24, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x03, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x40, 0x09,
  0x00, 0xC4, 0x0A, 0x1F, 0x90, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x0F, 0xFF, 0x3F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x80, 0x60, 0x16, 0x18, 0x78, 0x80, 0x1C, 0x01, 0x20, 0x09, 0x00,
  0x88, 0x08, 0x40, 0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0xA0, 0x28, 0x81,
  0x84, 0x08, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08, 0x80, 0x24, 0x01, 0x20,
  0x05, 0x00, 0x10, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xC0, 0x0E, 0x00, 0xE8, 0x07,
  0x40, 0x5A, 0x02, 0xC8, 0x26, 0x41, 0x31, 0x11, 0x88, 0x8C, 0x28, 0x61,
  0x43, 0x06, 0x18, 0x20, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x80, 0x1C, 0x01, 0xC0, 0x1A, 0x01, 0xA0, 0x19,
  0x01, 0x90, 0x18, 0x81, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18,
  0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x38, 0x03, 0x0F, 0x80,
  0x83, 0x08, 0x04, 0x80, 0x2C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x40, 0x11, 0x00, 0x84, 0x18, 0x1F, 0x00, 0xFF, 0xC8, 0x06, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x06, 0xFF, 0xC8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x0F, 0x80, 0x83, 0x08, 0x04, 0x80, 0x2C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x40, 0x11, 0x00, 0x8C, 0x18, 0x1F, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x7E, 0xFF, 0xC8, 0x06, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x06, 0xFF, 0xC8, 0x40, 0x82, 0x08,
  0x10, 0x81, 0x08, 0x08, 0x80, 0x48, 0x04, 0x80, 0x28, 0x01, 0x0F, 0xC1,
  0x81, 0x10, 0x05, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x0A, 0x00, 0x4C, 0x0C, 0x1F, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x24, 0x02,
  0x60, 0x41, 0xF8, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x40, 0x11,
  0x00, 0x44, 0x01, 0x08, 0x08, 0x20, 0x20, 0x80, 0x81, 0x04, 0x04, 0x10,
  0x10, 0x40, 0x22, 0x00, 0x88, 0x02, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50,
  0x00, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x20, 0xA1, 0x42, 0x85, 0x0A, 0x14, 0x28, 0x50, 0xA2, 0x22, 0x48,
  0x89, 0x22, 0x45, 0x05, 0x14, 0x14, 0x50, 0x51, 0x40, 0xC6, 0x03, 0x08,
  0x0C, 0x40, 0x06, 0x80, 0x08, 0x80, 0x20, 0x80, 0x81, 0x01, 0x01, 0x04,
  0x01, 0x10, 0x03, 0x20, 0x02, 0x80, 0x02, 0x00, 0x06, 0x00, 0x14, 0x00,
  0x44, 0x00, 0x84, 0x02, 0x08, 0x08, 0x08, 0x10, 0x08, 0x40, 0x11, 0x00,
  0x16, 0x00, 0x10, 0x80, 0x03, 0x40, 0x02, 0x40, 0x04, 0x20, 0x08, 0x20,
  0x08, 0x10, 0x10, 0x08, 0x20, 0x08, 0x20, 0x04, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFC, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0xFE, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xFC, 0x02, 0x00, 0x28, 0x01, 0x20,
  0x11, 0x01, 0x04, 0x08, 0x20, 0x80, 0x84, 0x02, 0x40, 0x14, 0x00, 0x60,
  0x02, 0xFF, 0xFC, 0x88, 0x42, 0x30, 0x1F, 0x81, 0x06, 0x10, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x83, 0xFC, 0x60, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x30, 0x70, 0xFC, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x27, 0xC7, 0x0C, 0x80, 0x50, 0x0A, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x70, 0x49, 0xF0,
  0x0F, 0x83, 0x04, 0x40, 0x24, 0x02, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x03, 0x40, 0x23, 0x04, 0x0F, 0x80, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0x93, 0x05, 0x40,
  0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x14, 0x01, 0x40, 0x33, 0x05, 0x0F, 0x90, 0x1F, 0x02, 0x0C, 0x40, 0x28,
  0x02, 0x80, 0x28, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x32, 0x06, 0x1F, 0x80, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x02, 0x07, 0xD0, 0x41, 0x84,
  0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02, 0x08, 0x30, 0x3E,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x07, 0xFC, 0x40, 0x14, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x60, 0x18, 0xFF, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x09, 0xE3, 0x86, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0xFC, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0B, 0xFE, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x04, 0x80, 0x88, 0x30,
  0x84, 0x08, 0x80, 0x98, 0x0A, 0x40, 0xC2, 0x08, 0x10, 0x80, 0x88, 0x08,
  0x80, 0x48, 0x02, 0x80, 0x10, 0xFC, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF,
  0xF0, 0xBC, 0xF6, 0x28, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x20, 0x9E, 0x38, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x1F, 0x02, 0x0C,
  0x40, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x40, 0x22, 0x0C, 0x1F, 0x00, 0x9F, 0x1C, 0x32, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x28, 0x05, 0xC1, 0x27, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x0F, 0x93, 0x05, 0x40, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x33, 0x05, 0x0F, 0x90,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xFC, 0x7C, 0x16,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xFF, 0x80,
  0x1F, 0x86, 0x04, 0x80, 0x28, 0x00, 0x80, 0x04, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x16, 0x06, 0x1F, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x03, 0xFF, 0xF0, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x14, 0x06, 0x41, 0x47, 0xC8, 0x80, 0x18, 0x02, 0x80, 0x24,
  0x04, 0x40, 0x44, 0x04, 0x20, 0x82, 0x08, 0x10, 0x81, 0x10, 0x11, 0x00,
  0xA0, 0x0A, 0x00, 0xA0, 0x04, 0x00, 0x81, 0x03, 0x05, 0x06, 0x0A, 0x0C,
  0x14, 0x14, 0x28, 0x48, 0x88, 0x91, 0x11, 0x22, 0x22, 0x44, 0x44, 0x50,
  0x48, 0xA0, 0xA1, 0x41, 0x42, 0x81, 0x86, 0x03, 0x04, 0x06, 0x00, 0x80,
  0x34, 0x02, 0x40, 0x42, 0x08, 0x11, 0x00, 0x90, 0x0A, 0x00, 0x40, 0x0A,
  0x00, 0x90, 0x11, 0x02, 0x08, 0x40, 0x48, 0x02, 0x80, 0x30, 0x80, 0x0A,
  0x00, 0x90, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10, 0x41, 0x02, 0x08, 0x08,
  0x40, 0x44, 0x02, 0x20, 0x0A, 0x00, 0x50, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x3F, 0xF8, 0x07, 0xE1, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x01, 0x0F, 0xC0,
  0x1C, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x3E, 0x1C, 0x02, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x1F, 0xC0, 0x38, 0x05,
  0x10, 0x28, 0x20, 0xA0, 0x66, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 2, 20, 17, 8, -20 },
  { 6, 5, 7, 17, 6, -21 },
  { 11, 16, 20, 17, 1, -20 },
  { 51, 13, 26, 17, 2, -23 },
  { 94, 16, 20, 17, 1, -20 },
  { 134, 15, 20, 17, 1, -20 },
  { 172, 1, 7, 17, 8, -21 },
  { 173, 6, 26, 17, 7, -22 },
  { 193, 7, 26, 17, 4, -22 },
  { 216, 15, 14, 17, 1, -16 },
  { 243, 14, 15, 17, 2, -16 },
  { 270, 2, 7, 17, 7, -2 },
  { 272, 8, 1, 17, 5, -9 },
  { 273, 2, 2, 17, 8, -2 },
  { 274, 11, 26, 17, 3, -22 },
  { 310, 13, 20, 17, 2, -20 },
  { 343, 14, 20, 17, 2, -20 },
  { 378, 12, 20, 17, 3, -20 },
  { 408, 12, 20, 17, 2, -20 },
  { 438, 15, 20, 17, 1, -20 },
  { 476, 13, 20, 17, 2, -20 },
  { 509, 12, 20, 17, 3, -20 },
  { 539, 13, 20, 17, 2, -20 },
  { 572, 13, 20, 17, 2, -20 },
  { 605, 12, 20, 17, 3, -20 },
  { 635, 2, 15, 17, 8, -15 },
  { 639, 3, 20, 17, 7, -15 },
  { 647, 13, 15, 17, 2, -16 },
  { 672, 14, 6, 17, 2, -12 },
  { 683, 13, 15, 17, 2, -16 },
  { 708, 11, 20, 17, 3, -20 },
  { 736, 11, 23, 17, 3, -20 },
  { 768, 14, 20, 17, 2, -20 },
  { 803, 12, 20, 17, 3, -20 },
  { 833, 13, 20, 17, 2, -20 },
  { 866, 12, 20, 17, 3, -20 },
  { 896, 12, 20, 17, 3, -20 },
  { 926, 12, 20, 17, 3, -20 },
  { 956, 13, 20, 17, 2, -20 },
  { 989, 12, 20, 17, 3, -20 },
  { 1019, 12, 20, 17, 3, -20 },
  { 1049, 10, 20, 17, 3, -20 },
  { 1074, 13, 20, 17, 3, -20 },
  { 1107, 11, 20, 17, 4, -20 },
  { 1135, 13, 20, 17, 2, -20 },
  { 1168, 12, 20, 17, 3, -20 },
  { 1198, 13, 20, 17, 2, -20 },
  { 1231, 12, 20, 17, 3, -20 },
  { 1261, 13, 24, 17, 2, -20 },
  { 1300, 12, 20, 17, 3, -20 },
  { 1330, 13, 20, 17, 2, -20 },
  { 1363, 15, 20, 17, 1, -20 },
  { 1401, 12, 20, 17, 3, -20 },
  { 1431, 14, 20, 17, 2, -20 },
  { 1466, 14, 20, 17, 2, -20 },
  { 1501, 15, 20, 17, 1, -20 },
  { 1539, 16, 20, 17, 1, -20 },
  { 1579, 15, 20, 17, 1, -20 },
  { 1617, 7, 26, 17, 8, -22 },
  { 1640, 11, 26, 17, 3, -22 },
  { 1676, 7, 26, 17, 3, -22 },
  { 1699, 13, 11, 17, 2, -20 },
  { 1717, 14, 1, 17, 2, 3 },
  { 1719, 4, 5, 17, 6, -22 },
  { 1722, 13, 15, 17, 2, -15 },
  { 1747, 11, 21, 17, 4, -21 },
  { 1776, 12, 15, 17, 3, -15 },
  { 1799, 12, 21, 17, 2, -21 },
  { 1831, 12, 15, 17, 3, -15 },
  { 1854, 13, 21, 17, 2, -21 },
  { 1889, 13, 23, 17, 3, -17 },
  { 1927, 10, 21, 17, 4, -21 },
  { 1954, 13, 22, 17, 3, -22 },
  { 1990, 10, 28, 17, 3, -22 },
  { 2025, 12, 21, 17, 4, -21 },
  { 2057, 12, 21, 17, 3, -21 },
  { 2089, 13, 15, 17, 2, -15 },
  { 2114, 10, 15, 17, 4, -15 },
  { 2133, 12, 15, 17, 3, -15 },
  { 2156, 11, 21, 17, 4, -15 },
  { 2185, 12, 21, 17, 2, -15 },
  { 2217, 14, 15, 17, 2, -15 },
  { 2244, 12, 15, 17, 3, -15 },
  { 2267, 14, 20, 17, 1, -20 },
  { 2302, 11, 15, 17, 3, -15 },
  { 2323, 12, 15, 17, 3, -15 },
  { 2346, 15, 15, 17, 1, -15 },
  { 2375, 12, 15, 17, 3, -15 },
  { 2398, 13, 21, 17, 2, -15 },
  { 2433, 11, 15, 17, 3, -15 },
  { 2454, 11, 26, 17, 3, -22 },
  { 2490, 1, 26, 17, 8, -22 },
  { 2494, 11, 26, 17, 3, -22 },
  { 2530, 14, 5, 17, 2, -12 },
};

const GFXfont IBMPlexMono_Thin29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_THIN29PT7B_H_
