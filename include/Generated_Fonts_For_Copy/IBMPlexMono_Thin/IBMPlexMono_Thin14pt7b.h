#ifndef _IBMPLEXMONO_THIN14PT7B_H_
#define _IBMPLEXMONO_THIN14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xFF, 0x14, 0x14, 0x14, 0x63, 0x24, 0x28, 0xE7, 0x28,
  0x28, 0x48, 0x21, 0xEA, 0x68, 0xA1, 0xC2, 0xC9, 0xA6, 0x97, 0x88, 0x71,
  0x92, 0x92, 0x94, 0x70, 0x06, 0x29, 0x51, 0x49, 0x86, 0x71, 0x12, 0x04,
  0x04, 0x75, 0x26, 0x44, 0x8C, 0xEC, 0xF0, 0x34, 0x48, 0x88, 0x88, 0x88,
  0x44, 0x30, 0x89, 0x12, 0x49, 0x25, 0x28, 0x20, 0x42, 0x8B, 0xE3, 0x09,
  0x23, 0x00, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x00, 0xE8, 0xF0, 0x80,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x80, 0x7A, 0x18,
  0x61, 0x86, 0x58, 0x61, 0x85, 0xE0, 0x10, 0x61, 0x44, 0x81, 0x02, 0x04,
  0x08, 0x11, 0xFC, 0x3B, 0x18, 0x41, 0x08, 0x21, 0x08, 0xC3, 0xF0, 0x3B,
  0x10, 0x42, 0x30, 0x20, 0x41, 0x85, 0xE0, 0x08, 0x30, 0xA2, 0x44, 0x91,
  0x22, 0x7F, 0x08, 0x10, 0x7E, 0x08, 0x1E, 0x84, 0x10, 0x41, 0x85, 0xE0,
  0x10, 0x84, 0x20, 0xBB, 0x18, 0x61, 0x85, 0xE0, 0xFE, 0x18, 0x82, 0x10,
  0x42, 0x08, 0x21, 0x00, 0x7A, 0x18, 0x61, 0x7B, 0x38, 0x61, 0x85, 0xE0,
  0x7A, 0x18, 0x61, 0x85, 0xF0, 0x42, 0x10, 0x80, 0x81, 0x40, 0x03, 0xA0,
  0x04, 0x66, 0x20, 0x40, 0xC0, 0xC0, 0xFE, 0x03, 0xF8, 0x81, 0x81, 0x81,
  0x08, 0xCC, 0x00, 0x39, 0x18, 0x41, 0x08, 0xC2, 0x00, 0x00, 0x80, 0x39,
  0x18, 0x67, 0xA7, 0x1C, 0x69, 0x9D, 0x03, 0xC0, 0x10, 0x61, 0x42, 0x44,
  0x91, 0x1F, 0x42, 0x85, 0x04, 0xFA, 0x18, 0x62, 0xFA, 0x18, 0x61, 0x87,
  0xE0, 0x39, 0x18, 0x60, 0x82, 0x08, 0x21, 0x44, 0xE0, 0xF4, 0x63, 0x18,
  0xC6, 0x31, 0x8F, 0x80, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x87, 0xC0, 0xFC,
  0x21, 0x0F, 0xC2, 0x10, 0x84, 0x00, 0x39, 0x28, 0x60, 0x82, 0x78, 0x61,
  0x44, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xFC, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x78, 0x42, 0x10, 0x84, 0x31, 0x8B,
  0x80, 0x8E, 0x4A, 0x28, 0xC2, 0x8A, 0x24, 0x8A, 0x30, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x87, 0xC0, 0x86, 0x1C, 0xF3, 0xD6, 0xDA, 0x61, 0x86, 0x10,
  0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x8E, 0x10, 0x7A, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xE0, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x84, 0x00, 0x7A,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE2, 0x07, 0xF4, 0x63, 0x18, 0xFA,
  0x94, 0x94, 0x40, 0x7A, 0x18, 0x20, 0x70, 0x30, 0x61, 0x85, 0xE0, 0xFE,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xE0, 0x87, 0x0A, 0x14, 0x44, 0x89, 0x12, 0x18, 0x30,
  0x20, 0x83, 0x0A, 0x14, 0xAB, 0x56, 0xB5, 0x66, 0x4D, 0x08, 0x87, 0x09,
  0x22, 0x83, 0x02, 0x1C, 0x24, 0x85, 0x0C, 0x81, 0x42, 0x44, 0x24, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40,
  0x81, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x20, 0x82, 0x04, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0,
  0x11, 0xC4, 0xA2, 0x84, 0xFE, 0xB0, 0x7A, 0x20, 0x9E, 0x8A, 0x27, 0x40,
  0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8F, 0x80, 0x74, 0x61, 0x08, 0x4D, 0x80,
  0x04, 0x10, 0x5D, 0x8E, 0x18, 0x61, 0x85, 0xF0, 0x7A, 0x18, 0x7F, 0x82,
  0x07, 0xC0, 0x1C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x06, 0x10,
  0xE2, 0x28, 0x49, 0x0E, 0x60, 0x7D, 0x86, 0x0B, 0xE0, 0x84, 0x21, 0xE8,
  0xC6, 0x31, 0x8C, 0x40, 0x20, 0x01, 0xC2, 0x10, 0x84, 0x27, 0xC0, 0x08,
  0x01, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x17, 0x80, 0x82, 0x08, 0x22, 0x93,
  0x8A, 0x24, 0x8A, 0x30, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0xF0,
  0xEE, 0x5A, 0x69, 0xA6, 0x9A, 0x40, 0xF4, 0x63, 0x18, 0xC6, 0x20, 0x7A,
  0x18, 0x61, 0x86, 0x17, 0x80, 0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x00,
  0x76, 0x38, 0x61, 0x86, 0x17, 0xC1, 0x04, 0x10, 0xEE, 0x60, 0x81, 0x02,
  0x04, 0x3F, 0x00, 0x7A, 0x18, 0x1F, 0x06, 0x17, 0x80, 0x10, 0x20, 0x47,
  0xF1, 0x02, 0x04, 0x08, 0x10, 0x3C, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x86,
  0x14, 0x92, 0x50, 0xC1, 0x00, 0x93, 0x66, 0xD6, 0xAC, 0xD9, 0xA1, 0x00,
  0x85, 0x23, 0x08, 0x51, 0x28, 0x40, 0x86, 0x14, 0x92, 0x50, 0xC1, 0x08,
  0x23, 0x00, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0xC0, 0x3A, 0x10, 0x82, 0x13,
  0x04, 0x22, 0x10, 0x83, 0x80, 0xFF, 0xF8, 0xE1, 0x08, 0x84, 0x20, 0xEC,
  0x42, 0x08, 0x4E, 0x00, 0x63, 0x2A, 0x30,
};

const GFXglyph IBMPlexMono_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 10, 8, 4, -10 },
  { 3, 2, 4, 8, 3, -10 },
  { 4, 8, 10, 8, 0, -10 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 10, 8, 0, -10 },
  { 33, 7, 10, 8, 1, -10 },
  { 42, 1, 4, 8, 4, -10 },
  { 43, 4, 13, 8, 3, -11 },
  { 50, 3, 13, 8, 2, -11 },
  { 55, 7, 7, 8, 1, -8 },
  { 62, 7, 7, 8, 1, -8 },
  { 69, 2, 3, 8, 3, -1 },
  { 70, 4, 1, 8, 2, -5 },
  { 71, 1, 1, 8, 4, -1 },
  { 72, 6, 13, 8, 1, -11 },
  { 82, 6, 10, 8, 1, -10 },
  { 90, 7, 10, 8, 1, -10 },
  { 99, 6, 10, 8, 1, -10 },
  { 107, 6, 10, 8, 1, -10 },
  { 115, 7, 10, 8, 1, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 6, 10, 8, 1, -10 },
  { 164, 1, 8, 8, 4, -8 },
  { 165, 2, 10, 8, 3, -8 },
  { 168, 6, 7, 8, 1, -8 },
  { 174, 7, 3, 8, 1, -6 },
  { 177, 6, 7, 8, 1, -8 },
  { 183, 6, 10, 8, 1, -10 },
  { 191, 6, 11, 8, 1, -10 },
  { 200, 7, 10, 8, 1, -10 },
  { 209, 6, 10, 8, 1, -10 },
  { 217, 6, 10, 8, 1, -10 },
  { 225, 5, 10, 8, 2, -10 },
  { 232, 5, 10, 8, 2, -10 },
  { 239, 5, 10, 8, 2, -10 },
  { 246, 6, 10, 8, 1, -10 },
  { 254, 6, 10, 8, 1, -10 },
  { 262, 6, 10, 8, 1, -10 },
  { 270, 5, 10, 8, 1, -10 },
  { 277, 6, 10, 8, 2, -10 },
  { 285, 5, 10, 8, 2, -10 },
  { 292, 6, 10, 8, 1, -10 },
  { 300, 6, 10, 8, 1, -10 },
  { 308, 6, 10, 8, 1, -10 },
  { 316, 5, 10, 8, 2, -10 },
  { 323, 6, 12, 8, 1, -10 },
  { 332, 5, 10, 8, 2, -10 },
  { 339, 6, 10, 8, 1, -10 },
  { 347, 7, 10, 8, 1, -10 },
  { 356, 6, 10, 8, 1, -10 },
  { 364, 7, 10, 8, 1, -10 },
  { 373, 7, 10, 8, 1, -10 },
  { 382, 7, 10, 8, 1, -10 },
  { 391, 8, 10, 8, 0, -10 },
  { 401, 7, 10, 8, 1, -10 },
  { 410, 3, 13, 8, 4, -11 },
  { 415, 6, 13, 8, 1, -11 },
  { 425, 4, 13, 8, 1, -11 },
  { 432, 6, 5, 8, 1, -10 },
  { 436, 7, 1, 8, 1, 1 },
  { 437, 2, 2, 8, 3, -11 },
  { 438, 6, 7, 8, 1, -7 },
  { 444, 5, 10, 8, 2, -10 },
  { 451, 5, 7, 8, 2, -7 },
  { 456, 6, 10, 8, 1, -10 },
  { 464, 6, 7, 8, 1, -7 },
  { 470, 6, 10, 8, 1, -10 },
  { 478, 7, 12, 8, 1, -9 },
  { 489, 5, 10, 8, 2, -10 },
  { 496, 5, 10, 8, 2, -10 },
  { 503, 5, 13, 8, 1, -10 },
  { 512, 6, 10, 8, 2, -10 },
  { 520, 6, 10, 8, 1, -10 },
  { 528, 6, 7, 8, 1, -7 },
  { 534, 5, 7, 8, 2, -7 },
  { 539, 6, 7, 8, 1, -7 },
  { 545, 5, 10, 8, 2, -7 },
  { 552, 6, 10, 8, 1, -7 },
  { 560, 7, 7, 8, 1, -7 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 7, 10, 8, 0, -10 },
  { 582, 5, 7, 8, 2, -7 },
  { 587, 6, 7, 8, 1, -7 },
  { 593, 7, 7, 8, 1, -7 },
  { 600, 6, 7, 8, 1, -7 },
  { 606, 6, 10, 8, 1, -7 },
  { 614, 6, 7, 8, 1, -7 },
  { 620, 5, 13, 8, 2, -11 },
  { 629, 1, 13, 8, 4, -11 },
  { 631, 5, 13, 8, 2, -11 },
  { 640, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_Thin14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_THIN14PT7B_H_
