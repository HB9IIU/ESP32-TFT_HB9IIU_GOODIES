#ifndef _IBMPLEXMONO_THIN62PT7B_H_
#define _IBMPLEXMONO_THIN62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0xFB, 0xDC, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x00, 0x40, 0x18, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0x00, 0x40, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x10, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x63, 0xC0,
  0x06, 0x03, 0x03, 0x80, 0x60, 0x18, 0x06, 0x04, 0x00, 0xC0, 0x18, 0x60,
  0x06, 0x00, 0x62, 0x00, 0x30, 0x02, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00, 0x10,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0x20, 0x00, 0x30, 0x01, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x05, 0x00, 0x06, 0x00, 0x2C, 0x00,
  0x30, 0x03, 0x30, 0x01, 0x80, 0x10, 0xC0, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0x18, 0x0E, 0x03, 0x03, 0x00, 0x1E, 0x18, 0x70, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x44, 0x01, 0x80, 0x00, 0x64, 0x00,
  0x60, 0x00, 0x26, 0x00, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x00, 0x31, 0x00,
  0x02, 0x00, 0x11, 0x80, 0x01, 0x00, 0x18, 0xC0, 0x00, 0x80, 0x08, 0x60,
  0x00, 0x40, 0x08, 0x30, 0x00, 0x20, 0x0C, 0x18, 0x00, 0x10, 0x04, 0x0C,
  0x00, 0x08, 0x06, 0x06, 0x00, 0x04, 0x02, 0x01, 0x00, 0x02, 0x02, 0x00,
  0x80, 0x03, 0x03, 0x00, 0x60, 0x01, 0x01, 0x00, 0x10, 0x01, 0x81, 0x80,
  0x04, 0x01, 0x80, 0x80, 0x01, 0x83, 0x80, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x08, 0x06, 0x0C, 0x00, 0x08, 0x0C,
  0x01, 0x80, 0x04, 0x04, 0x00, 0x40, 0x04, 0x04, 0x00, 0x10, 0x06, 0x02,
  0x00, 0x08, 0x02, 0x03, 0x00, 0x06, 0x03, 0x01, 0x00, 0x01, 0x01, 0x00,
  0x80, 0x00, 0x81, 0x00, 0x40, 0x00, 0x41, 0x80, 0x20, 0x00, 0x20, 0x80,
  0x10, 0x00, 0x10, 0xC0, 0x08, 0x00, 0x08, 0x40, 0x04, 0x00, 0x04, 0x40,
  0x03, 0x00, 0x06, 0x60, 0x00, 0x80, 0x02, 0x20, 0x00, 0x40, 0x01, 0x30,
  0x00, 0x10, 0x01, 0x10, 0x00, 0x0C, 0x01, 0x90, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x04, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x40, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x3F, 0x8C, 0x0C, 0x00,
  0x60, 0x10, 0x0C, 0x00, 0xC0, 0x40, 0x08, 0x01, 0x01, 0x80, 0x08, 0x02,
  0x02, 0x00, 0x08, 0x04, 0x0C, 0x00, 0x18, 0x08, 0x10, 0x00, 0x18, 0x10,
  0x20, 0x00, 0x18, 0x20, 0x40, 0x00, 0x10, 0x40, 0x80, 0x00, 0x11, 0x81,
  0x00, 0x00, 0x12, 0x02, 0x00, 0x00, 0x14, 0x04, 0x00, 0x00, 0x38, 0x08,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x10, 0x00, 0x01, 0xB0, 0x20,
  0x00, 0x06, 0x30, 0x20, 0x00, 0x08, 0x30, 0x60, 0x00, 0x60, 0x20, 0x60,
  0x01, 0x80, 0x20, 0x38, 0x0E, 0x00, 0x20, 0x1F, 0xE0, 0x00, 0x20, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x37, 0x80, 0x10, 0x03, 0xC1, 0xE0, 0x20, 0x3C, 0x00,
  0x7C, 0x43, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x18, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C,
  0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0x86, 0x18, 0x41, 0x04, 0x20, 0xFF,
  0xFF, 0x80, 0x77, 0xDE, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0xE2, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x1C, 0x01, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x04,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x98, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0B, 0x80, 0x00, 0x06, 0x30, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x0E, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x40, 0x02, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x40, 0x01, 0x00, 0x00, 0x80, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x04, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0x82,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x07, 0xFC, 0x00, 0xC6, 0x00,
  0xE0, 0x26, 0x00, 0x0C, 0x0A, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x00, 0x38, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x87, 0x01, 0xC0, 0x11,
  0x00, 0x06, 0x06, 0xC0, 0x00, 0x60, 0x90, 0x00, 0x06, 0x14, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xE0, 0x3C, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0x30, 0x10,
  0x00, 0x02, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x11, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC8, 0x00, 0x00, 0xA3, 0x00, 0x00,
  0x28, 0x60, 0x00, 0x12, 0x0E, 0x00, 0x19, 0x80, 0xE0, 0x18, 0x40, 0x07,
  0xF8, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x77, 0xDE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3B, 0xEF, 0x70, 0x1C, 0x7C, 0x78, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x86, 0x0C, 0x18, 0x70,
  0xC1, 0x83, 0x04, 0x18, 0x30, 0x40, 0x81, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x06, 0x03, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x61, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x02, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0,
  0x70, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x80, 0x00, 0x40, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12,
  0x00, 0x3F, 0x0B, 0x00, 0x70, 0x65, 0x80, 0x60, 0x0B, 0x80, 0x20, 0x03,
  0xC0, 0x30, 0x00, 0xE0, 0x10, 0x00, 0x70, 0x18, 0x00, 0x38, 0x08, 0x00,
  0x1C, 0x04, 0x00, 0x0E, 0x02, 0x00, 0x07, 0x01, 0x00, 0x03, 0x80, 0x80,
  0x01, 0xC0, 0x40, 0x00, 0xE0, 0x20, 0x00, 0x70, 0x10, 0x00, 0x38, 0x08,
  0x00, 0x1C, 0x04, 0x00, 0x0E, 0x02, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80,
  0x40, 0x01, 0xC0, 0x20, 0x00, 0xE0, 0x18, 0x00, 0xF8, 0x06, 0x00, 0xBC,
  0x01, 0x80, 0xDE, 0x00, 0x7F, 0x8D, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x80, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x04, 0x01, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x08, 0x00, 0x20, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x01, 0x00, 0x08, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x1C, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x70, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x06, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x70, 0x08, 0x00, 0x07, 0x02,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x70, 0x20, 0x00, 0x70, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFA, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF2, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01,
  0xC4, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0x60, 0xC0,
  0x00, 0x4C, 0x0C, 0x00, 0x31, 0x80, 0x70, 0x1C, 0x30, 0x03, 0xFC, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x28, 0x00, 0x00, 0x58, 0x00, 0x01,
  0x90, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x06, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x06, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60,
  0x10, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x80, 0x08, 0x00,
  0x30, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x80, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x03, 0x80, 0x00, 0x40, 0xD0,
  0x00, 0x08, 0x13, 0x00, 0x01, 0x04, 0x30, 0x00, 0x21, 0x02, 0x00, 0x04,
  0x40, 0x60, 0x00, 0x90, 0x06, 0x00, 0x16, 0x00, 0x40, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x08, 0x01, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x10, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x02, 0xF8, 0x00, 0x00, 0xDD, 0x00, 0x00, 0x13, 0xB0, 0x00,
  0x06, 0x72, 0x00, 0x00, 0x8E, 0x60, 0x00, 0x11, 0xC4, 0x00, 0x06, 0x38,
  0xC0, 0x00, 0x87, 0x08, 0x00, 0x30, 0xE1, 0x00, 0x04, 0x1C, 0x10, 0x01,
  0x83, 0x82, 0x00, 0x20, 0x70, 0x60, 0x0C, 0x0E, 0x04, 0x01, 0x01, 0xC0,
  0xC0, 0x20, 0x38, 0x08, 0x08, 0x07, 0x01, 0x81, 0x00, 0xE0, 0x10, 0x60,
  0x1C, 0x02, 0x08, 0x03, 0x80, 0x23, 0x00, 0x70, 0x04, 0x40, 0x0E, 0x00,
  0xD8, 0x01, 0xC0, 0x0A, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x10, 0x00,
  0xE0, 0x02, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x20, 0x00, 0x03, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x04, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x08, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00,
  0x08, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x20, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x04,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x0E,
  0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x0E, 0x0F, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x04, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x20, 0x00, 0x0E, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x0E, 0x0F, 0xFF,
  0xFE, 0x02, 0x00, 0x60, 0x00, 0x80, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x02, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00, 0x60,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x20, 0x00,
  0x08, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x00, 0x0E,
  0x00, 0xF0, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x1F, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x80, 0x06, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x80, 0x00, 0x60, 0x01, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x11, 0x00, 0x0C, 0x00, 0x44, 0x00, 0x70, 0x01, 0x10, 0x01, 0x40, 0x04,
  0x60, 0x05, 0x80, 0x11, 0x80, 0x32, 0x00, 0x46, 0x00, 0x88, 0x01, 0x08,
  0x02, 0x20, 0x0C, 0x20, 0x08, 0xC0, 0x30, 0x80, 0x61, 0x00, 0xC2, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x18, 0x08, 0x20, 0x30, 0x20, 0x20, 0x80, 0x80,
  0x80, 0x82, 0x02, 0x03, 0x02, 0x0C, 0x18, 0x0C, 0x08, 0x30, 0x40, 0x10,
  0x20, 0xC1, 0x00, 0x41, 0x81, 0x04, 0x01, 0x86, 0x04, 0x30, 0x02, 0x18,
  0x10, 0x80, 0x08, 0x40, 0x42, 0x00, 0x31, 0x01, 0x18, 0x00, 0x44, 0x04,
  0x40, 0x01, 0x10, 0x11, 0x00, 0x06, 0x40, 0x6C, 0x00, 0x19, 0x01, 0xB0,
  0x00, 0x24, 0x06, 0x80, 0x00, 0xB0, 0x0A, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x40, 0x01, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x08, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x80, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x00, 0xFF,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0E, 0x04, 0x00, 0x01, 0x60, 0x60, 0x00, 0x26, 0x03, 0x00,
  0x04, 0x60, 0x0E, 0x03, 0x83, 0xF0, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0xFE, 0x00, 0x87, 0x01, 0xC0, 0x88, 0x00, 0x60, 0x90, 0x00, 0x10,
  0xA0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xA0, 0x00, 0x08, 0x90, 0x00, 0x10, 0x88, 0x00, 0x60,
  0x87, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x80, 0xE0,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x30, 0x00, 0x02,
  0x20, 0x00, 0x03, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x01, 0x30, 0x00, 0x02, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x01, 0x80, 0x70, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x7F, 0x81, 0x01, 0x80, 0xE1, 0x06, 0x00, 0x19,
  0x0C, 0x00, 0x0D, 0x18, 0x00, 0x05, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03,
  0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x20, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x05, 0x0C, 0x00, 0x0D,
  0x06, 0x00, 0x19, 0x01, 0x80, 0xE1, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x60, 0x01, 0x00, 0x20, 0x00, 0x30, 0x10, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x80, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x70, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0x88, 0x00, 0x18, 0x0E, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x80, 0x08, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x1C, 0x00, 0x1F, 0xFE, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x07, 0xF8, 0x08, 0x60, 0x38, 0x22, 0x00,
  0x18, 0x90, 0x00, 0x32, 0x80, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x02,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x11, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x02,
  0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x02, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x20, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x02, 0x07, 0x00, 0x00, 0x82, 0x20, 0x00, 0x23, 0x0C, 0x00, 0x09,
  0x81, 0x80, 0x02, 0xC0, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x08, 0x00, 0x10, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x18, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0,
  0x3F, 0x09, 0x83, 0x0C, 0x1C, 0xA0, 0x19, 0x80, 0x4C, 0x00, 0xD0, 0x02,
  0xC0, 0x0E, 0x00, 0x28, 0x00, 0x60, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00,
  0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00,
  0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80,
  0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40,
  0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38,
  0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04,
  0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03,
  0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00,
  0x40, 0x03, 0x80, 0x04, 0x00, 0x30, 0x01, 0xFE, 0x02, 0x18, 0x0E, 0x08,
  0x80, 0x06, 0x24, 0x00, 0x0C, 0xA0, 0x00, 0x13, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x01, 0x00, 0x20,
  0x00, 0x30, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x04,
  0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x03, 0x80, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x87, 0x01, 0xC0, 0x88, 0x00,
  0x60, 0x90, 0x00, 0x10, 0xA0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xA0, 0x00, 0x08, 0x90, 0x00,
  0x10, 0x88, 0x00, 0x60, 0x87, 0x01, 0xC0, 0x81, 0xFE, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x80,
  0xE1, 0x06, 0x00, 0x19, 0x0C, 0x00, 0x0D, 0x18, 0x00, 0x05, 0x30, 0x00,
  0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x05, 0x0C, 0x00, 0x0D, 0x06, 0x00, 0x19, 0x01, 0x80, 0xE1, 0x00, 0x7F,
  0x81, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x83, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x01, 0xC0, 0x40, 0x00, 0x18, 0x20, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x05,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x58, 0x00, 0x03, 0x20, 0x00, 0x1C, 0x40,
  0x00, 0xD0, 0x80, 0x06, 0x41, 0xC0, 0x71, 0x01, 0xFE, 0x00, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x68, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10,
  0x00, 0x04, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00,
  0xC0, 0x01, 0x80, 0x20, 0x00, 0x80, 0x18, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x40, 0x10, 0x00, 0x20, 0x08,
  0x00, 0x18, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x03, 0x02, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x80, 0x00, 0x04,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0x50, 0x00, 0x48, 0x00, 0x28, 0x00, 0x24, 0x00, 0x32, 0x00, 0x13, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x08, 0x80, 0x0C, 0x40, 0x04, 0x60, 0x04, 0x20,
  0x06, 0x10, 0x02, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x83, 0x00, 0xC1, 0x00, 0xC0, 0x80, 0x60, 0x80, 0x40, 0x40, 0x20,
  0x40, 0x20, 0x20, 0x10, 0x30, 0x10, 0x18, 0x08, 0x18, 0x18, 0x04, 0x04,
  0x04, 0x08, 0x02, 0x06, 0x02, 0x04, 0x01, 0x02, 0x01, 0x02, 0x00, 0xC1,
  0x00, 0x83, 0x00, 0x20, 0x80, 0x61, 0x00, 0x10, 0x40, 0x10, 0x80, 0x08,
  0x60, 0x08, 0x40, 0x02, 0x20, 0x04, 0x40, 0x01, 0x10, 0x02, 0x20, 0x00,
  0x88, 0x01, 0x90, 0x00, 0x44, 0x00, 0x58, 0x00, 0x16, 0x00, 0x28, 0x00,
  0x0B, 0x00, 0x14, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x04, 0x02, 0x00, 0x02, 0x00, 0x40, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x60, 0x10, 0x00, 0x08,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x02, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20,
  0x30, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x08, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x10, 0x00, 0x18, 0x02,
  0x00, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x10, 0x00, 0x30, 0x06, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x0C, 0x21, 0x80, 0x00, 0x21, 0x01, 0x80, 0x00, 0x88,
  0x03, 0x00, 0x02, 0x60, 0x04, 0x00, 0x19, 0x00, 0x08, 0x00, 0x44, 0x00,
  0x10, 0x01, 0x30, 0x00, 0x20, 0x08, 0x80, 0x00, 0x40, 0x62, 0x00, 0x00,
  0xC3, 0x08, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 5, 43, 37, 16, -43 },
  { 28, 9, 16, 37, 14, -46 },
  { 46, 35, 43, 37, 1, -43 },
  { 235, 29, 57, 37, 4, -50 },
  { 442, 33, 45, 37, 2, -44 },
  { 628, 31, 45, 37, 3, -44 },
  { 803, 1, 16, 37, 18, -46 },
  { 805, 14, 56, 37, 15, -47 },
  { 903, 14, 56, 37, 8, -47 },
  { 1001, 31, 31, 37, 3, -34 },
  { 1122, 29, 31, 37, 4, -34 },
  { 1235, 6, 16, 37, 14, -5 },
  { 1247, 17, 1, 37, 10, -19 },
  { 1250, 5, 4, 37, 16, -4 },
  { 1253, 24, 56, 37, 7, -47 },
  { 1421, 29, 45, 37, 4, -44 },
  { 1585, 29, 43, 37, 5, -43 },
  { 1741, 27, 44, 37, 5, -44 },
  { 1890, 26, 45, 37, 4, -44 },
  { 2037, 31, 43, 37, 3, -43 },
  { 2204, 26, 44, 37, 5, -43 },
  { 2347, 27, 44, 37, 5, -43 },
  { 2496, 27, 43, 37, 5, -43 },
  { 2642, 29, 45, 37, 4, -44 },
  { 2806, 26, 44, 37, 6, -44 },
  { 2949, 5, 33, 37, 16, -33 },
  { 2970, 7, 44, 37, 14, -33 },
  { 3009, 27, 33, 37, 5, -35 },
  { 3121, 29, 12, 37, 4, -25 },
  { 3165, 27, 33, 37, 5, -35 },
  { 3277, 25, 44, 37, 6, -44 },
  { 3415, 25, 51, 37, 6, -44 },
  { 3575, 31, 43, 37, 3, -43 },
  { 3742, 26, 43, 37, 6, -43 },
  { 3882, 27, 45, 37, 5, -44 },
  { 4034, 26, 43, 37, 7, -43 },
  { 4174, 25, 43, 37, 7, -43 },
  { 4309, 25, 43, 37, 7, -43 },
  { 4444, 27, 45, 37, 5, -44 },
  { 4596, 25, 43, 37, 6, -43 },
  { 4731, 26, 43, 37, 6, -43 },
  { 4871, 23, 44, 37, 6, -43 },
  { 4998, 27, 43, 37, 7, -43 },
  { 5144, 24, 43, 37, 9, -43 },
  { 5273, 27, 43, 37, 5, -43 },
  { 5419, 25, 43, 37, 6, -43 },
  { 5554, 29, 45, 37, 4, -44 },
  { 5718, 26, 43, 37, 7, -43 },
  { 5858, 29, 52, 37, 4, -44 },
  { 6047, 26, 43, 37, 7, -43 },
  { 6187, 29, 45, 37, 4, -44 },
  { 6351, 32, 43, 37, 3, -43 },
  { 6523, 25, 44, 37, 6, -43 },
  { 6661, 31, 43, 37, 3, -43 },
  { 6828, 30, 43, 37, 4, -43 },
  { 6990, 31, 43, 37, 3, -43 },
  { 7157, 33, 43, 37, 2, -43 },
  { 7335, 31, 43, 37, 3, -43 },
  { 7502, 15, 56, 37, 16, -47 },
  { 7607, 24, 56, 37, 7, -47 },
  { 7775, 15, 56, 37, 6, -47 },
  { 7880, 29, 23, 37, 4, -43 },
  { 7964, 29, 1, 37, 4, 8 },
  { 7968, 8, 10, 37, 13, -47 },
  { 7978, 28, 34, 37, 5, -33 },
  { 8097, 24, 47, 37, 8, -46 },
  { 8238, 24, 34, 37, 7, -33 },
  { 8340, 24, 47, 37, 5, -46 },
  { 8481, 26, 34, 37, 6, -33 },
  { 8592, 28, 46, 37, 5, -46 },
  { 8753, 28, 48, 37, 6, -35 },
  { 8921, 22, 46, 37, 8, -46 },
  { 9048, 26, 46, 37, 7, -46 },
  { 9198, 22, 58, 37, 6, -46 },
  { 9358, 26, 46, 37, 9, -46 },
  { 9508, 26, 46, 37, 6, -46 },
  { 9658, 28, 33, 37, 5, -33 },
  { 9774, 22, 33, 37, 8, -33 },
  { 9865, 26, 34, 37, 6, -33 },
  { 9976, 24, 45, 37, 8, -33 },
  { 10111, 24, 45, 37, 5, -33 },
  { 10246, 29, 32, 37, 5, -32 },
  { 10362, 26, 34, 37, 6, -33 },
  { 10473, 30, 43, 37, 2, -43 },
  { 10635, 22, 33, 37, 7, -32 },
  { 10726, 25, 32, 37, 6, -32 },
  { 10826, 33, 32, 37, 2, -32 },
  { 10958, 26, 32, 37, 6, -32 },
  { 11062, 27, 44, 37, 5, -32 },
  { 11211, 25, 32, 37, 6, -32 },
  { 11311, 23, 56, 37, 7, -47 },
  { 11472, 1, 56, 37, 18, -47 },
  { 11479, 23, 56, 37, 7, -47 },
  { 11640, 30, 11, 37, 4, -24 },
};

const GFXfont IBMPlexMono_Thin62pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin62pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin62pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _IBMPLEXMONO_THIN62PT7B_H_
