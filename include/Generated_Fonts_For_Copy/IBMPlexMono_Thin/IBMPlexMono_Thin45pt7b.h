#ifndef _IBMPLEXMONO_THIN45PT7B_H_
#define _IBMPLEXMONO_THIN45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x0F,
  0xF8, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x08, 0x00, 0x04, 0x04, 0x00,
  0x02, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x20, 0x20, 0x0F, 0xF0, 0x1F, 0xE0, 0x08, 0x08,
  0x00, 0x04, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20,
  0x20, 0x0F, 0xF0, 0x1F, 0xE0, 0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02,
  0x06, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x40, 0x40, 0x00, 0x20, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0x00, 0x38, 0x8E, 0x02, 0x04, 0x08, 0x20, 0x20, 0x23,
  0x01, 0x00, 0x90, 0x08, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00, 0x20, 0x10,
  0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0x40, 0x20, 0x01, 0x01, 0x00, 0x04,
  0x08, 0x00, 0x18, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x86,
  0x00, 0x04, 0x0C, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x08, 0x04, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x02,
  0x80, 0x20, 0x12, 0x01, 0x00, 0x98, 0x08, 0x08, 0x20, 0x40, 0x80, 0xE2,
  0x18, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x00, 0x08, 0x30, 0x00, 0xC8,
  0x04, 0x00, 0x48, 0x02, 0x00, 0x44, 0x00, 0x80, 0x22, 0x00, 0x40, 0x21,
  0x00, 0x20, 0x20, 0x80, 0x10, 0x10, 0x40, 0x08, 0x10, 0x20, 0x04, 0x08,
  0x10, 0x02, 0x08, 0x08, 0x02, 0x08, 0x02, 0x01, 0x04, 0x00, 0x83, 0x04,
  0x00, 0x3E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x3E, 0x00, 0x10, 0x61, 0x80, 0x10, 0x40, 0x20, 0x10,
  0x20, 0x08, 0x08, 0x20, 0x04, 0x08, 0x10, 0x02, 0x04, 0x08, 0x01, 0x04,
  0x04, 0x00, 0x82, 0x02, 0x00, 0x42, 0x01, 0x00, 0x22, 0x00, 0x80, 0x11,
  0x00, 0x20, 0x09, 0x00, 0x10, 0x08, 0x80, 0x06, 0x18, 0x80, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x40,
  0x10, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x80, 0x3C,
  0xC3, 0x00, 0x82, 0x06, 0x02, 0x10, 0x08, 0x08, 0x40, 0x10, 0x42, 0x00,
  0x21, 0x08, 0x00, 0x44, 0x20, 0x00, 0x90, 0x80, 0x01, 0x42, 0x00, 0x05,
  0x08, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x40, 0x01, 0x21, 0x00, 0x0C, 0x42,
  0x00, 0x60, 0x86, 0x07, 0x01, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xC0,
  0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x02,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x10, 0x06, 0x70, 0x20, 0x70, 0x1E, 0x47, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x05, 0x00, 0x00, 0x11, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x82, 0x00, 0x02, 0x02, 0x00, 0x08, 0x02, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x04, 0x01, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF,
  0xFF, 0xF0, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x19, 0x8C, 0x62, 0x11, 0x88,
  0x42, 0x11, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x80, 0x00, 0x88, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00,
  0x05, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40,
  0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x08, 0x40, 0x00, 0x43, 0x00, 0x04,
  0x08, 0x00, 0x20, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x01, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x48, 0x00, 0x0C, 0x40, 0x00, 0xC2, 0x00,
  0x0C, 0x10, 0x00, 0xC0, 0x80, 0x08, 0x04, 0x00, 0x80, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x01,
  0x81, 0xC0, 0x40, 0x0C, 0x10, 0x00, 0xC4, 0x00, 0x09, 0x80, 0x01, 0x20,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0xFF, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x60, 0x04, 0x10, 0x00, 0x42, 0x00,
  0x04, 0x80, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x2C, 0x00, 0x04, 0x80, 0x01,
  0x0C, 0x00, 0x60, 0x60, 0x30, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x14, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x20, 0x00, 0x08, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41,
  0x00, 0x01, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x80, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x40, 0x02, 0x00, 0x80, 0x04, 0x02, 0x00, 0x08, 0x08, 0x00, 0x10, 0x20,
  0x00, 0x20, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xFF, 0xC4, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x87, 0xF0, 0x13,
  0x01, 0x82, 0x80, 0x08, 0x60, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x40, 0x00, 0x64, 0x00, 0x08, 0x40,
  0x02, 0x07, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x87, 0xF0, 0x13, 0x01, 0x82, 0x80, 0x08, 0xA0, 0x00, 0x98, 0x00,
  0x0B, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00,
  0x22, 0x00, 0x08, 0x20, 0x02, 0x03, 0x01, 0x80, 0x1F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x18, 0x06, 0x00, 0x30,
  0x20, 0x00, 0x82, 0x00, 0x02, 0x10, 0x00, 0x11, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x41,
  0x00, 0x04, 0x0C, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x3F, 0x80, 0x0E, 0x03,
  0x80, 0xC0, 0x06, 0x08, 0x00, 0x08, 0x80, 0x00, 0x64, 0x00, 0x01, 0x20,
  0x00, 0x0A, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x03, 0x10, 0x00, 0x10, 0x60,
  0x03, 0x01, 0xC0, 0x70, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0x80, 0xC0,
  0x40, 0x04, 0x10, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x19, 0x00, 0x05, 0x10, 0x01, 0x21,
  0xC0, 0xC8, 0x0F, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x38, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x98, 0xC6, 0x21,
  0x18, 0x84, 0x21, 0x10, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x07, 0xF0,
  0x0C, 0x06, 0x08, 0x00, 0x88, 0x00, 0x24, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x01, 0xF0, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x01, 0x83, 0x80, 0x80,
  0x30, 0x40, 0x04, 0x20, 0x00, 0x88, 0x00, 0x24, 0x00, 0x05, 0x00, 0x01,
  0x40, 0x00, 0x50, 0x00, 0x14, 0x03, 0xE6, 0x03, 0x05, 0x81, 0x80, 0xE0,
  0x40, 0x18, 0x30, 0x06, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20,
  0x06, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01,
  0x81, 0x00, 0x60, 0x40, 0x34, 0x08, 0x15, 0x01, 0xF9, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x50, 0x00,
  0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x04,
  0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x40, 0x10, 0x00, 0x80,
  0x20, 0x01, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x40, 0x01, 0x00, 0xFF, 0xFE, 0x01, 0x00, 0x04, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x48, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x80,
  0xFF, 0xFC, 0x10, 0x00, 0xC2, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x02, 0x20, 0x01, 0x87,
  0xFF, 0xE0, 0x80, 0x03, 0x10, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x09, 0x00, 0x06, 0x3F,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0xC0, 0x60, 0x20, 0x06, 0x08, 0x00, 0x22,
  0x00, 0x04, 0xC0, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0xB0, 0x00, 0x12, 0x00, 0x04, 0x20,
  0x00, 0x82, 0x00, 0x60, 0x30, 0x18, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x10,
  0x03, 0x82, 0x00, 0x18, 0x40, 0x00, 0x88, 0x00, 0x19, 0x00, 0x01, 0x20,
  0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x05, 0x00,
  0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x06, 0x40, 0x00, 0x88, 0x00, 0x61, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x30,
  0x0C, 0x00, 0x81, 0x80, 0x04, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x34, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01,
  0x20, 0x00, 0x12, 0x00, 0x03, 0x10, 0x00, 0x31, 0x80, 0x05, 0x0C, 0x00,
  0x90, 0x70, 0x31, 0x00, 0xFC, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x48, 0x00, 0x26, 0x00, 0x21,
  0x80, 0x30, 0x60, 0x70, 0x0F, 0xE0, 0x80, 0x00, 0x38, 0x00, 0x04, 0x80,
  0x00, 0x88, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x0C, 0x08,
  0x01, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x08, 0x08, 0x00,
  0x81, 0x00, 0x08, 0x30, 0x00, 0x85, 0x80, 0x08, 0x88, 0x00, 0x90, 0x40,
  0x0A, 0x06, 0x00, 0xE0, 0x20, 0x0C, 0x01, 0x00, 0x80, 0x18, 0x08, 0x00,
  0x80, 0x80, 0x04, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x02, 0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x20, 0x02, 0x64, 0x00, 0x4C, 0x40,
  0x11, 0x88, 0x02, 0x30, 0x80, 0x86, 0x10, 0x10, 0xC1, 0x04, 0x18, 0x20,
  0x83, 0x06, 0x20, 0x60, 0x44, 0x0C, 0x08, 0x81, 0x80, 0xA0, 0x30, 0x14,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x34, 0x00,
  0x06, 0x80, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x03, 0x10, 0x00, 0x62, 0x00,
  0x0C, 0x20, 0x01, 0x84, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0xC0, 0x80,
  0x18, 0x10, 0x03, 0x01, 0x00, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x30, 0x04, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x00, 0x83, 0x00, 0x10,
  0x60, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x02, 0x30, 0x00, 0x46, 0x00, 0x04,
  0xC0, 0x00, 0x98, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x18, 0x01, 0xFC,
  0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10,
  0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x90, 0x00, 0x05, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x08, 0x40, 0x00, 0x43,
  0x00, 0x04, 0x08, 0x00, 0x20, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x01, 0xFC,
  0x00, 0xFF, 0xFC, 0x10, 0x00, 0x62, 0x00, 0x06, 0x40, 0x00, 0x68, 0x00,
  0x05, 0x00, 0x00, 0xA0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00,
  0x64, 0x00, 0x18, 0xFF, 0xFC, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x20,
  0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x02,
  0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x05, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x88,
  0x00, 0x08, 0x40, 0x00, 0x43, 0x00, 0x04, 0x08, 0x00, 0x20, 0x30, 0x06,
  0x00, 0xC0, 0x60, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFC,
  0x10, 0x00, 0x62, 0x00, 0x06, 0x40, 0x00, 0x68, 0x00, 0x05, 0x00, 0x00,
  0xA0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x18,
  0xFF, 0xFC, 0x10, 0x10, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x10,
  0x01, 0xFE, 0x00, 0x70, 0x1C, 0x04, 0x00, 0x10, 0x40, 0x00, 0x44, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x05, 0x00,
  0x00, 0x24, 0x00, 0x01, 0x30, 0x00, 0x10, 0x40, 0x01, 0x01, 0xC0, 0x30,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x50, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00,
  0x01, 0x30, 0x00, 0x62, 0x00, 0x08, 0x20, 0x02, 0x07, 0x01, 0x80, 0x3F,
  0xE0, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x10, 0x00, 0x10, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x40, 0x02,
  0x00, 0x80, 0x04, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80,
  0x00, 0x05, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x90, 0x14, 0x04,
  0x80, 0xA0, 0x24, 0x05, 0x01, 0x20, 0x28, 0x09, 0x02, 0x20, 0x48, 0x11,
  0x02, 0x40, 0x88, 0x12, 0x08, 0x20, 0x90, 0x41, 0x04, 0x82, 0x08, 0x42,
  0x20, 0x22, 0x11, 0x01, 0x10, 0x88, 0x08, 0x84, 0x40, 0x44, 0x24, 0x01,
  0x21, 0x20, 0x09, 0x09, 0x00, 0x48, 0x50, 0x01, 0x42, 0x80, 0x0A, 0x14,
  0x00, 0x60, 0x60, 0x03, 0x00, 0x40, 0x00, 0x04, 0x40, 0x00, 0x10, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x80, 0x80, 0x02, 0x01, 0x80, 0x04, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x02, 0x02, 0x00, 0x02, 0x08,
  0x00, 0x06, 0x30, 0x00, 0x04, 0x40, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x28, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x10, 0x00, 0x40, 0x40, 0x00, 0x40, 0x80,
  0x00, 0x82, 0x00, 0x00, 0x88, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x88, 0x00, 0x00, 0x82, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x40, 0x30, 0x00, 0x60, 0x08, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x10, 0x10,
  0x00, 0x0C, 0x08, 0x00, 0x02, 0x08, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0x00, 0x20, 0x00,
  0x02, 0x80, 0x00, 0x36, 0x00, 0x01, 0x10, 0x00, 0x10, 0x40, 0x00, 0x82,
  0x00, 0x08, 0x08, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x00, 0x40, 0x04, 0x02,
  0x00, 0x20, 0x20, 0x00, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x80, 0x00, 0x08, 0xFF, 0xFF, 0xF8, 0xC1, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x07, 0xF0, 0x01, 0x81, 0x80, 0x30, 0x06, 0x04, 0x00,
  0x20, 0x40, 0x03, 0x08, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x0F, 0xFF, 0x03,
  0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x50, 0x40, 0x09,
  0x03, 0x01, 0x1F, 0x0F, 0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x43, 0xF0, 0x26, 0x06, 0x14, 0x00, 0x8C, 0x00, 0x24, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0B, 0x00, 0x09,
  0x40, 0x08, 0x98, 0x18, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0x03, 0x81,
  0x00, 0x30, 0x80, 0x04, 0x20, 0x00, 0x90, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x61, 0x00, 0x30, 0x30,
  0x30, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x81,
  0xF8, 0x43, 0x03, 0x22, 0x00, 0x52, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x06, 0x20, 0x05,
  0x0C, 0x0C, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x40, 0x04,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0xA0, 0x00, 0x22, 0x00, 0x04, 0x60, 0x01, 0x06, 0x00, 0x40,
  0x70, 0x30, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC8, 0x01, 0x81, 0xC0,
  0x10, 0x06, 0x01, 0x00, 0x10, 0x08, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00,
  0x10, 0x20, 0x00, 0x81, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x01, 0x01,
  0x00, 0x08, 0x08, 0x00, 0x80, 0x20, 0x0C, 0x00, 0xC0, 0xC0, 0x07, 0xF8,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xF0, 0x38, 0x00, 0x63, 0x00, 0x01,
  0x90, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00,
  0x00, 0x48, 0x00, 0x06, 0x60, 0x00, 0x60, 0xC0, 0x0C, 0x01, 0xFF, 0x80,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xE0, 0x98, 0x18, 0xA0, 0x04,
  0xC0, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x7F,
  0xFE, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x03, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00, 0x08, 0x20, 0x06,
  0x04, 0x01, 0x80, 0x80, 0x40, 0x10, 0x10, 0x02, 0x04, 0x00, 0x41, 0x80,
  0x08, 0xC8, 0x01, 0x31, 0x80, 0x28, 0x10, 0x06, 0x01, 0x00, 0x80, 0x10,
  0x10, 0x01, 0x02, 0x00, 0x10, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x02,
  0x20, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x20, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0x83, 0xC4, 0x86, 0x61, 0xA8, 0x14, 0x05, 0x80,
  0x60, 0x3C, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x07, 0xE0, 0x98, 0x18, 0xA0, 0x04,
  0xC0, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x60,
  0x0C, 0x10, 0x00, 0xC2, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x06, 0x00,
  0xC0, 0x60, 0x30, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x4C, 0x0C, 0x28, 0x01,
  0x18, 0x00, 0x48, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x28, 0x00, 0x16, 0x00, 0x12, 0x80, 0x11, 0x30, 0x30, 0x87, 0xE0, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x44, 0x00, 0xA4,
  0x00, 0x34, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x28, 0x00, 0x14,
  0x00, 0x09, 0x00, 0x0C, 0x40, 0x0A, 0x18, 0x19, 0x03, 0xF0, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0xFF, 0x87, 0xF8, 0x04, 0xC0, 0x00, 0x28, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0x80, 0xE0, 0xC0, 0x06,
  0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02, 0xC0, 0x00, 0x8C, 0x00, 0x30,
  0x60, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0xFF, 0xE0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x03, 0x20, 0x05, 0x18,
  0x19, 0x07, 0xE0, 0x80, 0x00, 0x28, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x22, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x10, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x50, 0x06, 0x00, 0xA0, 0x0C, 0x01, 0x40, 0x18, 0x02, 0x80,
  0x48, 0x08, 0x80, 0x90, 0x11, 0x01, 0x20, 0x22, 0x02, 0x40, 0x84, 0x04,
  0x81, 0x04, 0x08, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x10, 0x10, 0x84,
  0x20, 0x21, 0x08, 0x40, 0x42, 0x08, 0x80, 0x88, 0x12, 0x00, 0x90, 0x24,
  0x01, 0x20, 0x48, 0x02, 0x40, 0x90, 0x04, 0x80, 0xC0, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x08, 0x80, 0x02,
  0x08, 0x00, 0x80, 0x80, 0x20, 0x18, 0x0C, 0x01, 0x01, 0x00, 0x10, 0x40,
  0x01, 0x10, 0x00, 0x36, 0x00, 0x02, 0x80, 0x00, 0x20, 0x00, 0x0A, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x40, 0x04, 0x04, 0x01, 0x00, 0x40,
  0x60, 0x0C, 0x08, 0x00, 0x82, 0x00, 0x08, 0x80, 0x00, 0xB0, 0x00, 0x18,
  0x80, 0x00, 0x30, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x00, 0x82, 0x00,
  0x10, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x30, 0x1F, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x01, 0xFF, 0x80,
  0x1E, 0x00, 0x09, 0x8C, 0x00, 0x50, 0x30, 0x02, 0x80, 0xC0, 0x18, 0x03,
  0x01, 0x40, 0x0C, 0x0A, 0x00, 0x31, 0x90, 0x00, 0x78,
};

const GFXglyph IBMPlexMono_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 3, 31, 27, 12, -31 },
  { 13, 7, 11, 27, 10, -33 },
  { 23, 25, 31, 27, 1, -31 },
  { 120, 21, 43, 27, 3, -37 },
  { 233, 25, 33, 27, 1, -32 },
  { 337, 22, 33, 27, 2, -32 },
  { 428, 1, 11, 27, 13, -33 },
  { 430, 10, 40, 27, 11, -34 },
  { 480, 10, 40, 27, 6, -34 },
  { 530, 23, 22, 27, 2, -25 },
  { 594, 21, 23, 27, 3, -25 },
  { 655, 5, 12, 27, 10, -4 },
  { 663, 11, 1, 27, 8, -14 },
  { 665, 3, 3, 27, 12, -3 },
  { 667, 17, 40, 27, 5, -34 },
  { 752, 21, 33, 27, 3, -32 },
  { 839, 21, 31, 27, 4, -31 },
  { 921, 19, 32, 27, 4, -32 },
  { 997, 19, 33, 27, 3, -32 },
  { 1076, 23, 31, 27, 2, -31 },
  { 1166, 19, 32, 27, 4, -31 },
  { 1242, 19, 32, 27, 4, -31 },
  { 1318, 20, 31, 27, 3, -31 },
  { 1396, 21, 33, 27, 3, -32 },
  { 1483, 19, 32, 27, 4, -32 },
  { 1559, 3, 24, 27, 12, -24 },
  { 1568, 5, 32, 27, 10, -24 },
  { 1588, 19, 24, 27, 4, -26 },
  { 1645, 21, 9, 27, 3, -18 },
  { 1669, 19, 24, 27, 4, -26 },
  { 1726, 17, 32, 27, 5, -32 },
  { 1794, 18, 37, 27, 4, -32 },
  { 1878, 23, 31, 27, 2, -31 },
  { 1968, 19, 31, 27, 4, -31 },
  { 2042, 19, 33, 27, 4, -32 },
  { 2121, 19, 31, 27, 5, -31 },
  { 2195, 18, 31, 27, 5, -31 },
  { 2265, 18, 31, 27, 5, -31 },
  { 2335, 20, 33, 27, 3, -32 },
  { 2418, 19, 31, 27, 4, -31 },
  { 2492, 19, 31, 27, 4, -31 },
  { 2566, 17, 32, 27, 4, -31 },
  { 2634, 20, 31, 27, 5, -31 },
  { 2712, 17, 31, 27, 7, -31 },
  { 2778, 19, 31, 27, 4, -31 },
  { 2852, 19, 31, 27, 4, -31 },
  { 2926, 21, 33, 27, 3, -32 },
  { 3013, 19, 31, 27, 5, -31 },
  { 3087, 21, 39, 27, 3, -32 },
  { 3190, 19, 31, 27, 5, -31 },
  { 3264, 21, 33, 27, 3, -32 },
  { 3351, 23, 31, 27, 2, -31 },
  { 3441, 19, 32, 27, 4, -31 },
  { 3517, 23, 31, 27, 2, -31 },
  { 3607, 21, 31, 27, 3, -31 },
  { 3689, 23, 31, 27, 2, -31 },
  { 3779, 25, 31, 27, 1, -31 },
  { 3876, 23, 31, 27, 2, -31 },
  { 3966, 11, 40, 27, 12, -34 },
  { 4021, 17, 40, 27, 5, -34 },
  { 4106, 11, 40, 27, 4, -34 },
  { 4161, 21, 17, 27, 3, -31 },
  { 4206, 21, 1, 27, 3, 5 },
  { 4209, 6, 7, 27, 9, -34 },
  { 4215, 20, 25, 27, 4, -24 },
  { 4278, 17, 34, 27, 6, -33 },
  { 4351, 18, 25, 27, 5, -24 },
  { 4408, 17, 34, 27, 4, -33 },
  { 4481, 19, 25, 27, 4, -24 },
  { 4541, 20, 33, 27, 4, -33 },
  { 4624, 21, 35, 27, 4, -25 },
  { 4716, 16, 33, 27, 6, -33 },
  { 4782, 19, 33, 27, 5, -33 },
  { 4861, 16, 42, 27, 4, -33 },
  { 4945, 19, 33, 27, 6, -33 },
  { 5024, 19, 33, 27, 4, -33 },
  { 5103, 21, 24, 27, 3, -24 },
  { 5166, 16, 24, 27, 6, -24 },
  { 5214, 19, 25, 27, 4, -24 },
  { 5274, 17, 33, 27, 6, -24 },
  { 5345, 17, 33, 27, 4, -24 },
  { 5416, 21, 23, 27, 4, -23 },
  { 5477, 19, 25, 27, 4, -24 },
  { 5537, 21, 31, 27, 2, -31 },
  { 5619, 16, 24, 27, 5, -23 },
  { 5667, 19, 23, 27, 4, -23 },
  { 5722, 23, 23, 27, 2, -23 },
  { 5789, 19, 23, 27, 4, -23 },
  { 5844, 19, 32, 27, 4, -23 },
  { 5920, 17, 23, 27, 5, -23 },
  { 5969, 17, 40, 27, 5, -34 },
  { 6054, 1, 40, 27, 13, -34 },
  { 6059, 17, 40, 27, 5, -34 },
  { 6144, 21, 8, 27, 3, -18 },
};

const GFXfont IBMPlexMono_Thin45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_THIN45PT7B_H_
