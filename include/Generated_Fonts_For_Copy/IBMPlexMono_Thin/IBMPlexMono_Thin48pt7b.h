#ifndef _IBMPLEXMONO_THIN48PT7B_H_
#define _IBMPLEXMONO_THIN48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x07, 0xFC, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x10, 0x00, 0x08, 0x08, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x10, 0x10, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x80, 0x40,
  0x00, 0x10, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08,
  0x08, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x08, 0x08, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x06, 0x02, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x08,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC,
  0x00, 0x61, 0x1C, 0x06, 0x04, 0x0C, 0x30, 0x10, 0x18, 0x80, 0x40, 0x34,
  0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x01,
  0x00, 0x10, 0x04, 0x00, 0x40, 0x10, 0x00, 0x80, 0x40, 0x03, 0x01, 0x00,
  0x06, 0x04, 0x00, 0x0E, 0x10, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x04, 0x30, 0x00, 0x10, 0x30, 0x00, 0x40, 0x60, 0x01, 0x00, 0x80, 0x04,
  0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x01,
  0x00, 0x10, 0x04, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x50, 0x04, 0x02, 0x20,
  0x10, 0x18, 0x60, 0x40, 0xC0, 0x61, 0x0C, 0x00, 0x7F, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xC0, 0x00, 0x46, 0x0C, 0x00, 0x12, 0x01, 0x00, 0x08, 0x80, 0x20,
  0x04, 0x40, 0x08, 0x01, 0x10, 0x01, 0x00, 0x84, 0x00, 0x40, 0x21, 0x00,
  0x10, 0x10, 0x40, 0x04, 0x08, 0x10, 0x01, 0x02, 0x04, 0x00, 0x41, 0x01,
  0x00, 0x20, 0x40, 0x20, 0x08, 0x20, 0x08, 0x04, 0x10, 0x01, 0x83, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xC1, 0x83, 0x00, 0x20, 0xC0, 0x60,
  0x10, 0x20, 0x08, 0x04, 0x10, 0x01, 0x02, 0x04, 0x00, 0x41, 0x01, 0x00,
  0x10, 0x40, 0x40, 0x04, 0x20, 0x10, 0x01, 0x08, 0x04, 0x00, 0x44, 0x01,
  0x00, 0x12, 0x00, 0x40, 0x04, 0x80, 0x08, 0x02, 0x40, 0x03, 0x01, 0x90,
  0x00, 0x60, 0xC8, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x07, 0x00,
  0x04, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x08, 0xC0, 0x1F,
  0x10, 0x40, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10, 0x10, 0x40, 0x08, 0x10,
  0xC0, 0x04, 0x10, 0x80, 0x06, 0x10, 0x80, 0x03, 0x10, 0x80, 0x01, 0x20,
  0x80, 0x00, 0xA0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x40, 0x00, 0x50,
  0x40, 0x00, 0x98, 0x20, 0x01, 0x8C, 0x30, 0x03, 0x06, 0x0C, 0x0C, 0x03,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x80, 0x08, 0x01, 0x38, 0x04, 0x03,
  0xC3, 0x82, 0x0E, 0x00, 0x39, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x41, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x20, 0x20, 0x00, 0x20, 0x08, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x10, 0x00, 0x40, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x39, 0x8C, 0x62, 0x31, 0x88, 0x42, 0x21, 0x00, 0xFF,
  0xF8, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0C, 0x06, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08, 0x10, 0x00, 0x10,
  0xC0, 0x00, 0x42, 0x00, 0x00, 0x88, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x41, 0x00, 0x01, 0x02,
  0x00, 0x08, 0x04, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x09, 0x00, 0x00, 0xC4, 0x00, 0x06, 0x10,
  0x00, 0x30, 0x40, 0x01, 0x81, 0x00, 0x0C, 0x04, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x70, 0x38, 0x06, 0x00, 0x60, 0x40, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00,
  0x13, 0x00, 0x00, 0x90, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x30, 0x18, 0x02, 0x00, 0x30, 0x20,
  0x00, 0x82, 0x00, 0x02, 0x10, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x03, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x84, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0x70, 0x18, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x20, 0x00,
  0x03, 0x20, 0x00, 0x02, 0x20, 0x00, 0x04, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x10, 0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x20, 0x00, 0x80, 0x20, 0x01, 0x80, 0x20, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x20, 0x04, 0x00, 0x20, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x20, 0x10, 0x00, 0x20, 0x20, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x21, 0xFC, 0x02, 0x60, 0x30, 0x38, 0x00, 0x82,
  0x00, 0x04, 0x40, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x02, 0xC0, 0x00, 0x26, 0x00,
  0x04, 0x30, 0x00, 0x80, 0xC0, 0x30, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x07, 0xF0,
  0x08, 0xC0, 0x60, 0x58, 0x00, 0xC3, 0x80, 0x02, 0x18, 0x00, 0x09, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00,
  0x01, 0x20, 0x00, 0x10, 0x80, 0x00, 0x86, 0x00, 0x08, 0x18, 0x00, 0x80,
  0x30, 0x18, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xA0, 0x00,
  0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1C, 0x06, 0x00, 0xC0, 0x06, 0x04, 0x00, 0x0C, 0x30, 0x00,
  0x10, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x30, 0x00, 0x10, 0x40,
  0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0, 0x60, 0x00, 0xFE, 0x00, 0x1C, 0x07,
  0x01, 0x80, 0x06, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x09, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x8C, 0x00, 0x04, 0x18, 0x00, 0x20, 0x1C, 0x07, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x30, 0x18, 0x02, 0x00, 0x30, 0x20, 0x00, 0xC2, 0x00,
  0x02, 0x30, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0x6C, 0x00, 0x02, 0x20, 0x00, 0x30, 0x80, 0x02, 0x86,
  0x00, 0x34, 0x0C, 0x06, 0x20, 0x1F, 0xC2, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xC6, 0x31, 0x18, 0xC4, 0x21, 0x10,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0x80, 0xC0, 0x40, 0x06, 0x10, 0x00, 0x44, 0x00, 0x05, 0x80, 0x00, 0xA0,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x30, 0x0C,
  0x01, 0x81, 0x80, 0x0C, 0x10, 0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x01, 0x40, 0x1F, 0x14, 0x06, 0x09,
  0x40, 0xC0, 0x54, 0x08, 0x03, 0x41, 0x00, 0x34, 0x10, 0x01, 0x41, 0x00,
  0x18, 0x10, 0x01, 0xC1, 0x00, 0x1C, 0x10, 0x01, 0xC1, 0x00, 0x1C, 0x10,
  0x01, 0xC1, 0x00, 0x14, 0x10, 0x01, 0x41, 0x00, 0x34, 0x18, 0x03, 0x40,
  0x80, 0x54, 0x04, 0x05, 0x40, 0x3F, 0x94, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x14, 0x00, 0x00, 0x14, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x22, 0x00, 0x00, 0x43, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x81, 0x80, 0x00, 0x80, 0x80, 0x00, 0x80, 0x80, 0x01,
  0x00, 0xC0, 0x01, 0x00, 0x40, 0x01, 0x00, 0x40, 0x02, 0x00, 0x60, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x30, 0x04, 0x00, 0x10, 0x04,
  0x00, 0x10, 0x0F, 0xFF, 0xF8, 0x08, 0x00, 0x08, 0x08, 0x00, 0x08, 0x18,
  0x00, 0x0C, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x08, 0x00, 0x60, 0x80, 0x01, 0x08, 0x00, 0x08,
  0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00,
  0x08, 0x80, 0x01, 0x08, 0x00, 0x60, 0xFF, 0xFC, 0x08, 0x00, 0x38, 0x80,
  0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x03,
  0x8F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x10, 0x30,
  0x00, 0x41, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x28, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x90, 0x00, 0x08, 0x40, 0x00,
  0x43, 0x00, 0x04, 0x0C, 0x00, 0x40, 0x18, 0x0C, 0x00, 0x3F, 0x80, 0xFF,
  0xF8, 0x08, 0x00, 0xE0, 0x80, 0x03, 0x08, 0x00, 0x08, 0x80, 0x00, 0xC8,
  0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48,
  0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x30, 0x80, 0x0E, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x18, 0x03, 0x00, 0x20, 0x20, 0x00,
  0x83, 0x00, 0x02, 0x10, 0x00, 0x19, 0x00, 0x00, 0x48, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x50, 0x00,
  0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0x90, 0x00, 0x14, 0xC0, 0x00, 0xA2,
  0x00, 0x09, 0x0C, 0x00, 0xC8, 0x38, 0x18, 0x40, 0x7F, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xF0, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A,
  0x00, 0x04, 0x80, 0x04, 0x20, 0x06, 0x0C, 0x0E, 0x01, 0xF8, 0x00, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x88, 0x00, 0x08,
  0x40, 0x00, 0x82, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x0C, 0x04, 0x00,
  0xC0, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x04, 0x00, 0x40, 0x40, 0x02,
  0x06, 0x00, 0x10, 0x50, 0x00, 0x86, 0x40, 0x04, 0x62, 0x00, 0x26, 0x08,
  0x01, 0x20, 0x60, 0x0A, 0x01, 0x00, 0x60, 0x04, 0x02, 0x00, 0x30, 0x10,
  0x00, 0x80, 0x80, 0x02, 0x04, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x01,
  0x08, 0x00, 0x0C, 0x40, 0x00, 0x22, 0x00, 0x00, 0x90, 0x00, 0x06, 0x80,
  0x00, 0x14, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE8, 0x00, 0x0B, 0x40, 0x00, 0x59, 0x00, 0x04, 0xC8,
  0x00, 0x26, 0x40, 0x03, 0x31, 0x00, 0x11, 0x88, 0x01, 0x8C, 0x20, 0x08,
  0x61, 0x00, 0x43, 0x04, 0x04, 0x18, 0x20, 0x20, 0xC0, 0x82, 0x06, 0x04,
  0x10, 0x30, 0x21, 0x01, 0x80, 0x88, 0x0C, 0x04, 0x40, 0x60, 0x14, 0x03,
  0x00, 0xA0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xD0,
  0x00, 0x1B, 0x00, 0x03, 0x20, 0x00, 0x66, 0x00, 0x0C, 0x40, 0x01, 0x8C,
  0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x10, 0x03, 0x02,
  0x00, 0x60, 0x20, 0x0C, 0x04, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x00,
  0x80, 0xC0, 0x10, 0x18, 0x01, 0x03, 0x00, 0x20, 0x60, 0x02, 0x0C, 0x00,
  0x41, 0x80, 0x04, 0x30, 0x00, 0x86, 0x00, 0x08, 0xC0, 0x01, 0x18, 0x00,
  0x13, 0x00, 0x02, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0xFE, 0x00, 0x0C, 0x06, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08,
  0x10, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x00, 0x88, 0x00, 0x02, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x41,
  0x00, 0x01, 0x02, 0x00, 0x08, 0x04, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFE, 0x08, 0x00, 0x18, 0x80, 0x00, 0x48, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x01, 0x8F, 0xFF, 0xE0, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x06, 0x00, 0x40, 0x04, 0x02,
  0x00, 0x08, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x00, 0x88, 0x00,
  0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x40, 0x00, 0x05, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0xC0,
  0x00, 0x41, 0x00, 0x01, 0x02, 0x00, 0x08, 0x04, 0x00, 0x40, 0x0C, 0x06,
  0x00, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFE, 0x08, 0x00,
  0x18, 0x80, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x04,
  0x80, 0x01, 0x8F, 0xFF, 0xE0, 0x80, 0x40, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x08, 0x01, 0x00, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80,
  0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x03, 0x01, 0xFF, 0x00,
  0x18, 0x07, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x06, 0x20, 0x00, 0x0D, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00, 0x8C, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x13, 0x00,
  0x04, 0x30, 0x01, 0x83, 0x80, 0xE0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0x4C,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x30, 0x00, 0x10, 0x20,
  0x00, 0x20, 0x40, 0x00, 0x40, 0xC0, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00,
  0x04, 0x02, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x08, 0x02, 0x00, 0x10, 0x04, 0x00, 0x20, 0x18, 0x00, 0x20, 0x20,
  0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x09, 0x00, 0x40, 0x12, 0x01, 0x40, 0x24, 0x02, 0x80,
  0x48, 0x05, 0x00, 0x90, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40, 0x44, 0x08,
  0x80, 0x88, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84,
  0x20, 0x41, 0x08, 0x40, 0x42, 0x10, 0x80, 0x84, 0x21, 0x01, 0x08, 0x44,
  0x03, 0x10, 0x88, 0x02, 0x41, 0x10, 0x04, 0x81, 0x40, 0x09, 0x02, 0x80,
  0x0A, 0x05, 0x00, 0x14, 0x0A, 0x00, 0x28, 0x18, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x40, 0x00, 0x03, 0x20, 0x00, 0x02, 0x30, 0x00, 0x04, 0x10, 0x00,
  0x0C, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0x80, 0x80, 0x00, 0xC1,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x22, 0x00, 0x00, 0x34, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x41, 0x00, 0x00, 0x80, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0x00, 0x40, 0x02, 0x00, 0x20, 0x06, 0x00, 0x30, 0x04, 0x00,
  0x10, 0x08, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x08, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x10, 0x02, 0x00, 0x08,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x01, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80,
  0x20, 0x00, 0x10, 0x10, 0x00, 0x06, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x07, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0,
  0x00, 0x02, 0x20, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x40, 0x40,
  0x01, 0x00, 0x80, 0x02, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x40, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x02, 0x08, 0x00, 0x02, 0x30,
  0x00, 0x04, 0x40, 0x00, 0x05, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFE, 0x83,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x03, 0xF8, 0x00, 0x60, 0x70, 0x0C, 0x00,
  0xC0, 0xC0, 0x02, 0x04, 0x00, 0x08, 0x40, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x7F, 0xF8, 0x1C, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x10, 0x80,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x43, 0x00, 0x0E, 0x0C, 0x00, 0x50, 0x38, 0x1C, 0x78, 0x7F,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x41, 0xF8, 0x08, 0xC0, 0xC1, 0x60, 0x06, 0x28,
  0x00, 0x66, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0xC0, 0x00, 0x94, 0x00, 0x32, 0xC0,
  0x0C, 0x46, 0x06, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0xE0, 0x20,
  0x06, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x50, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x02, 0x40, 0x00, 0xC4, 0x00,
  0x10, 0x40, 0x0C, 0x06, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0xFC,
  0x10, 0xE0, 0x62, 0x30, 0x02, 0x4C, 0x00, 0x29, 0x00, 0x03, 0x40, 0x00,
  0x68, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03,
  0x20, 0x00, 0x66, 0x00, 0x14, 0x60, 0x04, 0x87, 0x03, 0x10, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x30, 0x18, 0x02, 0x00, 0x20, 0x20, 0x00, 0x82, 0x00,
  0x02, 0x10, 0x00, 0x11, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x90, 0x00, 0x05, 0x80, 0x00, 0x2F, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x10, 0x40, 0x01,
  0x01, 0x00, 0x10, 0x06, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0x00, 0x07, 0xF2, 0x00, 0x30, 0x1C, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x10, 0x30,
  0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x80, 0x01, 0x01, 0x00,
  0x02, 0x02, 0x00, 0x08, 0x06, 0x00, 0x10, 0x06, 0x00, 0x40, 0x06, 0x03,
  0x00, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x10, 0x00, 0x60, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x64, 0x00, 0x00, 0x58,
  0x00, 0x00, 0xA0, 0x00, 0x01, 0x60, 0x00, 0x02, 0x40, 0x00, 0x0C, 0x80,
  0x00, 0x10, 0x80, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0x7F, 0xF0, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x7E,
  0x08, 0xC0, 0xC4, 0x80, 0x13, 0x80, 0x05, 0x80, 0x02, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x06,
  0x80, 0x00, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0x80, 0x80, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x08, 0x08, 0x00, 0x83, 0x00, 0x08, 0x70,
  0x00, 0x8C, 0x80, 0x09, 0x0C, 0x00, 0xA0, 0x60, 0x0C, 0x02, 0x00, 0x80,
  0x10, 0x08, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xCF, 0x81, 0xF3, 0x41, 0x98, 0x6E,
  0x02, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01,
  0x00, 0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01, 0x00,
  0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x70,
  0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x70, 0x04,
  0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x70, 0x04, 0x01,
  0xC0, 0x10, 0x04, 0x83, 0xF0, 0x46, 0x06, 0x24, 0x00, 0x9C, 0x00, 0x2C,
  0x00, 0x14, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x01, 0xFC, 0x00,
  0x60, 0x30, 0x08, 0x00, 0x81, 0x00, 0x04, 0x20, 0x00, 0x62, 0x00, 0x02,
  0x40, 0x00, 0x34, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x20,
  0x00, 0x22, 0x00, 0x06, 0x10, 0x00, 0x40, 0x80, 0x08, 0x06, 0x03, 0x00,
  0x1F, 0xC0, 0x83, 0xF0, 0x11, 0x81, 0x82, 0xC0, 0x0C, 0x50, 0x00, 0xCC,
  0x00, 0x09, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40,
  0x00, 0x28, 0x00, 0x05, 0x80, 0x01, 0x28, 0x00, 0x65, 0x80, 0x18, 0x8C,
  0x0C, 0x10, 0x7E, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x21, 0xC0, 0xC4, 0x60, 0x04, 0x98, 0x00, 0x52,
  0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x28, 0xC0, 0x09, 0x0E,
  0x06, 0x20, 0x7F, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0x18, 0x00, 0x02, 0x40, 0x00, 0x05,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x70, 0x1C, 0x04, 0x00, 0x30, 0x40, 0x00,
  0x42, 0x00, 0x03, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xA0, 0x00, 0x08,
  0x80, 0x00, 0x43, 0x00, 0x0C, 0x0E, 0x01, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xFC, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0D,
  0x00, 0x0A, 0x40, 0x0D, 0x18, 0x1C, 0x83, 0xF0, 0x00, 0xC0, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x04,
  0x10, 0x00, 0x41, 0x00, 0x04, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x20, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x09, 0x00, 0x00, 0x50, 0x00, 0x05, 0x00, 0x00, 0x20, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0A, 0x00, 0x60, 0x05, 0x00, 0x30, 0x02, 0x80,
  0x24, 0x02, 0x40, 0x12, 0x01, 0x10, 0x09, 0x00, 0x88, 0x04, 0x80, 0x44,
  0x02, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81, 0x08, 0x10, 0x40, 0x84, 0x08,
  0x20, 0x42, 0x08, 0x10, 0x21, 0x04, 0x04, 0x20, 0x42, 0x02, 0x10, 0x21,
  0x01, 0x08, 0x11, 0x00, 0x84, 0x08, 0x80, 0x22, 0x04, 0x40, 0x11, 0x02,
  0x20, 0x09, 0x00, 0xA0, 0x06, 0x80, 0x50, 0x01, 0x40, 0x28, 0x00, 0xA0,
  0x14, 0x00, 0x50, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x11, 0x00, 0x01,
  0x0C, 0x00, 0x18, 0x20, 0x00, 0x80, 0x80, 0x08, 0x02, 0x00, 0x80, 0x18,
  0x0C, 0x00, 0x40, 0x40, 0x01, 0x04, 0x00, 0x04, 0x40, 0x00, 0x36, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x00, 0x00, 0x28, 0x00, 0x02, 0x60, 0x00, 0x31,
  0x00, 0x01, 0x04, 0x00, 0x10, 0x10, 0x01, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x80, 0x08, 0x08, 0x00, 0x20, 0x80, 0x01, 0x8C, 0x00, 0x04, 0xC0, 0x00,
  0x18, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x42,
  0x00, 0x02, 0x10, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08, 0x18, 0x00,
  0x80, 0x40, 0x04, 0x02, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x03,
  0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x1C, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x06, 0x80,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x02, 0x61, 0x80,
  0x04, 0x81, 0x80, 0x12, 0x01, 0x80, 0x24, 0x01, 0x80, 0x50, 0x01, 0x81,
  0x20, 0x01, 0x84, 0x40, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 3, 34, 29, 13, -34 },
  { 14, 7, 12, 29, 11, -36 },
  { 25, 27, 34, 29, 1, -34 },
  { 140, 22, 45, 29, 3, -39 },
  { 264, 26, 35, 29, 1, -34 },
  { 378, 24, 35, 29, 2, -34 },
  { 483, 1, 12, 29, 14, -36 },
  { 485, 11, 43, 29, 11, -36 },
  { 545, 11, 43, 29, 6, -36 },
  { 605, 25, 24, 29, 2, -26 },
  { 680, 23, 23, 29, 3, -26 },
  { 747, 5, 12, 29, 11, -4 },
  { 755, 13, 1, 29, 8, -15 },
  { 757, 3, 3, 29, 13, -3 },
  { 759, 19, 43, 29, 5, -36 },
  { 862, 22, 35, 29, 3, -34 },
  { 959, 22, 34, 29, 4, -34 },
  { 1053, 21, 34, 29, 4, -34 },
  { 1143, 21, 35, 29, 3, -34 },
  { 1235, 24, 34, 29, 2, -34 },
  { 1337, 20, 35, 29, 4, -34 },
  { 1425, 21, 35, 29, 4, -34 },
  { 1517, 21, 34, 29, 4, -34 },
  { 1607, 22, 35, 29, 3, -34 },
  { 1704, 21, 34, 29, 4, -34 },
  { 1794, 3, 25, 29, 13, -25 },
  { 1804, 5, 33, 29, 11, -25 },
  { 1825, 21, 26, 29, 4, -28 },
  { 1894, 23, 9, 29, 3, -19 },
  { 1920, 21, 26, 29, 4, -28 },
  { 1989, 19, 34, 29, 5, -34 },
  { 2070, 20, 39, 29, 4, -34 },
  { 2168, 24, 34, 29, 2, -34 },
  { 2270, 20, 34, 29, 5, -34 },
  { 2355, 21, 35, 29, 4, -34 },
  { 2447, 20, 34, 29, 5, -34 },
  { 2532, 20, 34, 29, 5, -34 },
  { 2617, 20, 34, 29, 5, -34 },
  { 2702, 21, 35, 29, 4, -34 },
  { 2794, 19, 34, 29, 5, -34 },
  { 2875, 20, 34, 29, 4, -34 },
  { 2960, 17, 35, 29, 5, -34 },
  { 3035, 21, 34, 29, 5, -34 },
  { 3125, 18, 34, 29, 7, -34 },
  { 3202, 21, 34, 29, 4, -34 },
  { 3292, 19, 34, 29, 5, -34 },
  { 3373, 22, 35, 29, 3, -34 },
  { 3470, 20, 34, 29, 5, -34 },
  { 3555, 22, 41, 29, 3, -34 },
  { 3668, 20, 34, 29, 5, -34 },
  { 3753, 22, 35, 29, 3, -34 },
  { 3850, 25, 34, 29, 2, -34 },
  { 3957, 19, 35, 29, 5, -34 },
  { 4041, 23, 34, 29, 3, -34 },
  { 4139, 23, 34, 29, 3, -34 },
  { 4237, 24, 34, 29, 2, -34 },
  { 4339, 26, 34, 29, 1, -34 },
  { 4450, 25, 34, 29, 2, -34 },
  { 4557, 11, 43, 29, 13, -36 },
  { 4617, 19, 43, 29, 5, -36 },
  { 4720, 11, 43, 29, 5, -36 },
  { 4780, 23, 18, 29, 3, -34 },
  { 4832, 23, 1, 29, 3, 6 },
  { 4835, 6, 8, 29, 10, -37 },
  { 4841, 21, 26, 29, 4, -25 },
  { 4910, 19, 37, 29, 6, -36 },
  { 4998, 19, 26, 29, 5, -25 },
  { 5060, 19, 37, 29, 4, -36 },
  { 5148, 21, 26, 29, 4, -25 },
  { 5217, 22, 36, 29, 4, -36 },
  { 5316, 23, 37, 29, 4, -27 },
  { 5423, 17, 36, 29, 6, -36 },
  { 5500, 20, 36, 29, 6, -36 },
  { 5590, 16, 46, 29, 5, -36 },
  { 5682, 20, 36, 29, 7, -36 },
  { 5772, 20, 36, 29, 4, -36 },
  { 5862, 22, 25, 29, 3, -25 },
  { 5931, 17, 25, 29, 6, -25 },
  { 5985, 20, 26, 29, 4, -25 },
  { 6050, 19, 35, 29, 6, -25 },
  { 6134, 19, 35, 29, 4, -25 },
  { 6218, 23, 25, 29, 4, -25 },
  { 6290, 21, 26, 29, 4, -25 },
  { 6359, 23, 34, 29, 2, -34 },
  { 6457, 17, 26, 29, 6, -25 },
  { 6513, 20, 25, 29, 4, -25 },
  { 6576, 25, 25, 29, 2, -25 },
  { 6655, 21, 25, 29, 4, -25 },
  { 6721, 21, 35, 29, 4, -25 },
  { 6813, 19, 25, 29, 5, -25 },
  { 6873, 17, 43, 29, 6, -36 },
  { 6965, 1, 43, 29, 14, -36 },
  { 6971, 17, 43, 29, 6, -36 },
  { 7063, 23, 8, 29, 3, -19 },
};

const GFXfont IBMPlexMono_Thin48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_THIN48PT7B_H_
