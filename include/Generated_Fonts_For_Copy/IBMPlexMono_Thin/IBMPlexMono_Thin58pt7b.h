#ifndef _IBMPLEXMONO_THIN58PT7B_H_
#define _IBMPLEXMONO_THIN58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x40, 0x10, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x10, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x20, 0x08, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x18, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1C,
  0x21, 0xC0, 0x0C, 0x04, 0x06, 0x03, 0x00, 0x80, 0x60, 0xC0, 0x10, 0x06,
  0x10, 0x02, 0x00, 0x66, 0x00, 0x40, 0x00, 0x80, 0x08, 0x00, 0x10, 0x01,
  0x00, 0x02, 0x00, 0x20, 0x00, 0x40, 0x04, 0x00, 0x08, 0x00, 0x80, 0x01,
  0x00, 0x10, 0x00, 0x30, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x60, 0x08,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x02, 0x78, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x10, 0x01, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x40, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x10, 0x00,
  0x20, 0x02, 0x00, 0x04, 0x00, 0x50, 0x00, 0x80, 0x19, 0x00, 0x10, 0x02,
  0x30, 0x02, 0x00, 0xC3, 0x80, 0x40, 0x30, 0x18, 0x08, 0x0C, 0x00, 0xE1,
  0x0E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x04, 0xC0, 0x30,
  0x00, 0x13, 0x00, 0x30, 0x00, 0x64, 0x00, 0x20, 0x00, 0x88, 0x00, 0x40,
  0x03, 0x20, 0x00, 0x40, 0x04, 0x40, 0x00, 0x80, 0x10, 0x80, 0x01, 0x00,
  0x61, 0x00, 0x02, 0x00, 0x82, 0x00, 0x04, 0x03, 0x04, 0x00, 0x08, 0x04,
  0x08, 0x00, 0x10, 0x10, 0x08, 0x00, 0x60, 0x60, 0x10, 0x00, 0x80, 0x80,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x10, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x30, 0x70, 0x00, 0x80, 0x80, 0x30, 0x02, 0x03, 0x00, 0x20, 0x04,
  0x04, 0x00, 0x20, 0x10, 0x18, 0x00, 0x40, 0x60, 0x20, 0x00, 0x80, 0x80,
  0x40, 0x01, 0x83, 0x00, 0x80, 0x03, 0x04, 0x01, 0x00, 0x06, 0x10, 0x02,
  0x00, 0x0C, 0x60, 0x04, 0x00, 0x18, 0x80, 0x08, 0x00, 0x23, 0x00, 0x18,
  0x00, 0x44, 0x00, 0x10, 0x00, 0x90, 0x00, 0x20, 0x02, 0x20, 0x00, 0x20,
  0x0C, 0x80, 0x00, 0x30, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x30, 0x40, 0x03, 0xF1, 0x80, 0x80, 0x08, 0x04,
  0x01, 0x00, 0x60, 0x20, 0x06, 0x01, 0x80, 0x80, 0x0C, 0x06, 0x04, 0x00,
  0x18, 0x10, 0x10, 0x00, 0x20, 0x40, 0x40, 0x00, 0x41, 0x01, 0x00, 0x00,
  0x84, 0x0C, 0x00, 0x01, 0x10, 0x30, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x0E,
  0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x70, 0x10, 0x00, 0x01, 0x60,
  0x20, 0x00, 0x0C, 0x80, 0xC0, 0x00, 0x61, 0x01, 0x00, 0x03, 0x02, 0x03,
  0x00, 0x18, 0x04, 0x07, 0x01, 0x80, 0x18, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0xE0, 0x04, 0x00, 0xF1, 0xE0,
  0x20, 0x3C, 0x01, 0xE1, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x10, 0x01, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x80, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x21, 0x86, 0x10,
  0x41, 0x08, 0x00, 0xFF, 0xFE, 0x7F, 0xF7, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x60, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x08, 0x30,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x20, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x07,
  0x00, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x40, 0x04, 0x00, 0x06, 0x00, 0x20, 0x00, 0x20,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x10, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFE, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0xFF, 0x80,
  0x23, 0x00, 0xE0, 0x2C, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0xFF, 0x00, 0x31, 0xC0, 0x70, 0x13, 0x00, 0x0C, 0x0B, 0x00, 0x01, 0x05,
  0x00, 0x00, 0x47, 0x00, 0x00, 0x33, 0x80, 0x00, 0x09, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x07,
  0x01, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x38, 0x07, 0x80, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x08, 0x60, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x80, 0x70, 0x00, 0x60, 0x03, 0x80, 0x78, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x0E, 0x01,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xE4, 0x00, 0x00, 0x61, 0x00, 0x00, 0x50, 0xC0, 0x00, 0x68, 0x18,
  0x00, 0x44, 0x07, 0x01, 0xC4, 0x00, 0x7F, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x70, 0x1C, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC6,
  0x18, 0x63, 0x8C, 0x30, 0xC2, 0x18, 0x61, 0x04, 0x10, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x80,
  0x00, 0xC2, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x90, 0x00, 0x01, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x03, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x07, 0xE2, 0x40, 0x18, 0x13, 0x40, 0x30, 0x0B, 0x40, 0x20, 0x07,
  0x40, 0x40, 0x03, 0x40, 0x40, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x80, 0x03,
  0xC0, 0x80, 0x03, 0xC0, 0x80, 0x03, 0xC0, 0x80, 0x03, 0xC0, 0x80, 0x03,
  0xC0, 0x80, 0x03, 0xC0, 0x80, 0x03, 0xC0, 0x80, 0x03, 0xC0, 0x80, 0x03,
  0xC0, 0x80, 0x03, 0x40, 0xC0, 0x03, 0x40, 0x40, 0x03, 0x40, 0x40, 0x03,
  0x40, 0x60, 0x07, 0x40, 0x20, 0x07, 0x40, 0x10, 0x0B, 0x40, 0x0F, 0xF3,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x10, 0x03, 0x00, 0x00, 0x80, 0x08, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x03, 0x00, 0x08, 0x00, 0x08, 0x00, 0x40, 0x00, 0x40,
  0x04, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x70, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x80, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x40, 0x00, 0x10, 0x30, 0x00, 0x10,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x02, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x07, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x00,
  0x80, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x02, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x20,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x07,
  0x08, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xB0, 0x60, 0x00, 0x6C, 0x0C, 0x00,
  0x33, 0x00, 0xE0, 0x30, 0xC0, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x80,
  0x00, 0x64, 0x00, 0x02, 0x30, 0x00, 0x20, 0xC0, 0x02, 0x01, 0x80, 0x60,
  0x03, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x10, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x02, 0x00,
  0x0C, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x38,
  0x00, 0x0C, 0x1A, 0x00, 0x03, 0x0C, 0xC0, 0x00, 0xC6, 0x18, 0x00, 0x33,
  0x02, 0x00, 0x0C, 0x80, 0x40, 0x03, 0x40, 0x18, 0x00, 0xE0, 0x02, 0x00,
  0x30, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x40, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0x68, 0x00, 0x00, 0xB4, 0x00, 0x00, 0x99, 0x00, 0x00, 0x4C,
  0x80, 0x00, 0x46, 0x20, 0x00, 0x23, 0x10, 0x00, 0x11, 0x8C, 0x00, 0x10,
  0xC2, 0x00, 0x08, 0x61, 0x80, 0x08, 0x30, 0x40, 0x04, 0x18, 0x30, 0x04,
  0x0C, 0x08, 0x02, 0x06, 0x06, 0x02, 0x03, 0x01, 0x01, 0x01, 0x80, 0xC1,
  0x00, 0xC0, 0x20, 0x80, 0x60, 0x10, 0xC0, 0x30, 0x04, 0x40, 0x18, 0x02,
  0x60, 0x0C, 0x00, 0xA0, 0x06, 0x00, 0x50, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x84, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x10, 0x00, 0x30, 0x30, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0x40, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x04,
  0x03, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x10, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x63,
  0x00, 0x00, 0x46, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x98, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x30, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x06, 0x0F, 0xFF, 0xFC, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x06, 0x0F,
  0xFF, 0xFC, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x20,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x08, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x06, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x03, 0x80, 0x38, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x86, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x07, 0x00,
  0x60, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x40, 0x02, 0x00, 0x02, 0x00, 0x10, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x20,
  0x06, 0x00, 0x22, 0x00, 0x70, 0x02, 0x20, 0x05, 0x00, 0x22, 0x00, 0x50,
  0x02, 0x20, 0x0D, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x63,
  0x01, 0x88, 0x06, 0x30, 0x10, 0x40, 0x43, 0x01, 0x04, 0x04, 0x10, 0x30,
  0x40, 0x41, 0x02, 0x06, 0x04, 0x10, 0x20, 0x20, 0x41, 0x02, 0x02, 0x04,
  0x10, 0x60, 0x30, 0x41, 0x04, 0x01, 0x04, 0x10, 0x40, 0x10, 0xC1, 0x0C,
  0x01, 0x0C, 0x18, 0x80, 0x18, 0x81, 0x88, 0x00, 0x88, 0x09, 0x80, 0x08,
  0x80, 0x90, 0x00, 0xC8, 0x09, 0x00, 0x04, 0x80, 0x90, 0x00, 0x48, 0x0B,
  0x00, 0x06, 0x80, 0xA0, 0x00, 0x28, 0x0A, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0x40, 0x04, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x18, 0x00, 0x80, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x20,
  0x06, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x60, 0x00, 0xC0,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x10, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x81,
  0x81, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x01, 0xFE, 0x00, 0x01,
  0xC0, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x30,
  0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xE0,
  0x1C, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x02, 0x83,
  0x00, 0x00, 0xA0, 0x40, 0x00, 0x48, 0x08, 0x00, 0x22, 0x01, 0xC0, 0x70,
  0xFC, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x1F, 0xE0, 0x10, 0xE0, 0x30, 0x22, 0x00, 0x18, 0x48,
  0x00, 0x18, 0xA0, 0x00, 0x11, 0x80, 0x00, 0x13, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x58, 0x00, 0x01, 0x30, 0x00, 0x02, 0x50, 0x00, 0x08, 0x90,
  0x00, 0x31, 0x10, 0x00, 0xC2, 0x1C, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x41, 0x80,
  0x00, 0xC2, 0x00, 0x00, 0x88, 0x00, 0x01, 0x90, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x80, 0xC0,
  0x06, 0x00, 0x60, 0x38, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x60, 0x60, 0x38, 0xC3,
  0x00, 0x19, 0x8C, 0x00, 0x0B, 0x30, 0x00, 0x0E, 0x40, 0x00, 0x1D, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x98,
  0x00, 0x07, 0x18, 0x00, 0x16, 0x18, 0x00, 0xCC, 0x0C, 0x07, 0x18, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x0C, 0x01,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x80, 0x30, 0x01, 0x80,
  0x0E, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE2, 0x00, 0x06, 0x03, 0x40,
  0x01, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x10, 0x06, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x0C, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x08, 0x00, 0x08, 0x00,
  0x80, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x1F, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x06, 0x20, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x1F, 0xE0, 0x63, 0x01, 0xC3, 0x20, 0x03, 0x1A, 0x00,
  0x0C, 0xE0, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x40, 0x00, 0x60, 0x20,
  0x00, 0x60, 0x10, 0x00, 0x40, 0x08, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x02,
  0x00, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x40, 0xE0, 0x00,
  0x20, 0x98, 0x00, 0x10, 0x86, 0x00, 0x09, 0x81, 0x80, 0x05, 0x80, 0x40,
  0x03, 0x80, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x40, 0x00,
  0xC0, 0x20, 0x00, 0x30, 0x10, 0x00, 0x08, 0x08, 0x00, 0x02, 0x04, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x60, 0xFF, 0xF8, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3E,
  0x11, 0x06, 0x18, 0x32, 0x40, 0x64, 0x02, 0x50, 0x05, 0x00, 0x2C, 0x00,
  0xE0, 0x05, 0x80, 0x08, 0x00, 0xB0, 0x01, 0x00, 0x1C, 0x00, 0x20, 0x03,
  0x80, 0x04, 0x00, 0x70, 0x00, 0x80, 0x0E, 0x00, 0x10, 0x01, 0xC0, 0x02,
  0x00, 0x38, 0x00, 0x40, 0x07, 0x00, 0x08, 0x00, 0xE0, 0x01, 0x00, 0x1C,
  0x00, 0x20, 0x03, 0x80, 0x04, 0x00, 0x70, 0x00, 0x80, 0x0E, 0x00, 0x10,
  0x01, 0xC0, 0x02, 0x00, 0x38, 0x00, 0x40, 0x07, 0x00, 0x08, 0x00, 0xE0,
  0x01, 0x00, 0x1C, 0x00, 0x20, 0x03, 0x80, 0x04, 0x00, 0x70, 0x00, 0x80,
  0x0E, 0x00, 0x10, 0x01, 0xC0, 0x02, 0x00, 0x38, 0x00, 0x40, 0x07, 0x00,
  0x08, 0x00, 0xE0, 0x01, 0x00, 0x18, 0x01, 0xFE, 0x06, 0x30, 0x1C, 0x32,
  0x00, 0x31, 0xA0, 0x00, 0xCE, 0x00, 0x03, 0x60, 0x00, 0x0B, 0x00, 0x00,
  0x58, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x70, 0x01, 0x80,
  0x0C, 0x01, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x06, 0x60, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x0E, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0x0E,
  0x03, 0x02, 0x20, 0x01, 0x84, 0x80, 0x01, 0x8A, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x13, 0x00,
  0x00, 0x25, 0x00, 0x00, 0x89, 0x00, 0x03, 0x11, 0x00, 0x0C, 0x21, 0xC0,
  0x60, 0x40, 0xFF, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x06, 0x03, 0x8C, 0x30, 0x01, 0x98, 0xC0, 0x00, 0xB3,
  0x00, 0x00, 0xE4, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0x80, 0x00, 0x39, 0x80, 0x00, 0x71, 0x80, 0x01, 0x61,
  0x80, 0x0C, 0xC0, 0xC0, 0x71, 0x80, 0x7F, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0xFF, 0xE0, 0x7F, 0xE0, 0x04, 0x30, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0x80, 0x70, 0x03, 0x00, 0x06, 0x02, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x20, 0x60, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x14, 0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x05, 0x10, 0x00, 0x90, 0xE0,
  0x71, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x08, 0x0C, 0x00,
  0x10, 0x04, 0x00, 0x10, 0x04, 0x00, 0x10, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01, 0x00, 0x40, 0x01, 0x80,
  0x80, 0x00, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x22, 0x00, 0x00, 0x22, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x14, 0x00, 0x00, 0x18, 0x00, 0x80, 0x03,
  0x00, 0x07, 0x80, 0x05, 0x00, 0x09, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x14,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x48, 0x00, 0x88, 0x01, 0x98, 0x01, 0x10,
  0x02, 0x10, 0x02, 0x20, 0x04, 0x20, 0x08, 0x60, 0x08, 0x40, 0x10, 0x40,
  0x10, 0x80, 0x20, 0x80, 0x21, 0x80, 0x41, 0x00, 0x81, 0x01, 0x03, 0x01,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x18, 0x08, 0x08,
  0x10, 0x20, 0x08, 0x30, 0x30, 0x40, 0x10, 0x40, 0x20, 0x80, 0x20, 0x80,
  0x43, 0x00, 0x41, 0x00, 0x84, 0x00, 0x42, 0x01, 0x08, 0x00, 0x8C, 0x03,
  0x10, 0x01, 0x10, 0x02, 0x60, 0x02, 0x20, 0x04, 0x80, 0x02, 0x40, 0x09,
  0x00, 0x04, 0x80, 0x12, 0x00, 0x09, 0x00, 0x38, 0x00, 0x14, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x60,
  0x00, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x00,
  0x40, 0x40, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x18, 0x08,
  0x00, 0x08, 0x02, 0x00, 0x08, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00,
  0x10, 0x04, 0x00, 0x04, 0x04, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x10, 0x20, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x04,
  0x02, 0x00, 0x06, 0x00, 0x80, 0x02, 0x00, 0x40, 0x01, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0x80,
  0x20, 0x00, 0x60, 0x20, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x02,
  0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x10, 0xC3, 0x00, 0x01, 0x10, 0x18, 0x00, 0x13,
  0x00, 0xC0, 0x01, 0x20, 0x06, 0x00, 0x26, 0x00, 0x30, 0x02, 0x40, 0x01,
  0x80, 0x44, 0x00, 0x0C, 0x0C, 0x40, 0x00, 0x61, 0x8C, 0x00, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 4, 40, 35, 15, -40 },
  { 21, 9, 15, 35, 13, -43 },
  { 38, 33, 40, 35, 1, -40 },
  { 203, 27, 54, 35, 4, -47 },
  { 386, 31, 42, 35, 2, -41 },
  { 549, 30, 42, 35, 2, -41 },
  { 707, 1, 15, 35, 17, -43 },
  { 709, 13, 52, 35, 14, -44 },
  { 794, 13, 52, 35, 8, -44 },
  { 879, 29, 29, 35, 3, -32 },
  { 985, 27, 29, 35, 4, -32 },
  { 1083, 6, 15, 35, 13, -5 },
  { 1095, 15, 1, 35, 10, -18 },
  { 1097, 4, 4, 35, 15, -4 },
  { 1099, 23, 52, 35, 6, -44 },
  { 1249, 27, 42, 35, 4, -41 },
  { 1391, 27, 40, 35, 5, -40 },
  { 1526, 25, 41, 35, 5, -41 },
  { 1655, 24, 42, 35, 4, -41 },
  { 1781, 29, 40, 35, 3, -40 },
  { 1926, 24, 41, 35, 5, -40 },
  { 2049, 25, 41, 35, 5, -40 },
  { 2178, 26, 40, 35, 4, -40 },
  { 2308, 27, 42, 35, 4, -41 },
  { 2450, 25, 41, 35, 5, -41 },
  { 2579, 4, 31, 35, 15, -31 },
  { 2595, 6, 41, 35, 13, -31 },
  { 2626, 25, 31, 35, 5, -33 },
  { 2723, 27, 11, 35, 4, -23 },
  { 2761, 25, 31, 35, 5, -33 },
  { 2858, 23, 41, 35, 6, -41 },
  { 2976, 24, 47, 35, 5, -41 },
  { 3117, 29, 40, 35, 3, -40 },
  { 3262, 24, 40, 35, 6, -40 },
  { 3382, 25, 42, 35, 5, -41 },
  { 3514, 25, 40, 35, 6, -40 },
  { 3639, 24, 40, 35, 6, -40 },
  { 3759, 24, 40, 35, 6, -40 },
  { 3879, 26, 42, 35, 4, -41 },
  { 4016, 23, 40, 35, 6, -40 },
  { 4131, 24, 40, 35, 5, -40 },
  { 4251, 21, 41, 35, 6, -40 },
  { 4359, 26, 40, 35, 6, -40 },
  { 4489, 23, 40, 35, 8, -40 },
  { 4604, 25, 40, 35, 5, -40 },
  { 4729, 23, 40, 35, 6, -40 },
  { 4844, 27, 42, 35, 4, -41 },
  { 4986, 25, 40, 35, 6, -40 },
  { 5111, 27, 49, 35, 4, -41 },
  { 5277, 25, 40, 35, 6, -40 },
  { 5402, 27, 42, 35, 4, -41 },
  { 5544, 30, 40, 35, 2, -40 },
  { 5694, 23, 41, 35, 6, -40 },
  { 5812, 29, 40, 35, 3, -40 },
  { 5957, 28, 40, 35, 3, -40 },
  { 6097, 29, 40, 35, 3, -40 },
  { 6242, 31, 40, 35, 2, -40 },
  { 6397, 29, 40, 35, 3, -40 },
  { 6542, 14, 52, 35, 15, -44 },
  { 6633, 23, 52, 35, 6, -44 },
  { 6783, 13, 52, 35, 6, -44 },
  { 6868, 27, 22, 35, 4, -40 },
  { 6943, 28, 1, 35, 3, 7 },
  { 6947, 7, 10, 35, 12, -45 },
  { 6956, 26, 32, 35, 5, -31 },
  { 7060, 23, 44, 35, 7, -43 },
  { 7187, 23, 32, 35, 6, -31 },
  { 7279, 23, 44, 35, 5, -43 },
  { 7406, 25, 32, 35, 5, -31 },
  { 7506, 26, 43, 35, 5, -43 },
  { 7646, 27, 44, 35, 5, -32 },
  { 7795, 21, 43, 35, 7, -43 },
  { 7908, 24, 43, 35, 7, -43 },
  { 8037, 20, 55, 35, 6, -43 },
  { 8175, 25, 43, 35, 8, -43 },
  { 8310, 25, 43, 35, 5, -43 },
  { 8445, 27, 31, 35, 4, -31 },
  { 8550, 21, 31, 35, 7, -31 },
  { 8632, 25, 32, 35, 5, -31 },
  { 8732, 23, 43, 35, 7, -31 },
  { 8856, 23, 43, 35, 5, -31 },
  { 8980, 27, 30, 35, 5, -30 },
  { 9082, 25, 32, 35, 5, -31 },
  { 9182, 28, 40, 35, 2, -40 },
  { 9322, 20, 31, 35, 7, -30 },
  { 9400, 24, 30, 35, 5, -30 },
  { 9490, 31, 30, 35, 2, -30 },
  { 9607, 25, 30, 35, 5, -30 },
  { 9701, 25, 42, 35, 5, -30 },
  { 9833, 23, 30, 35, 6, -30 },
  { 9920, 21, 52, 35, 7, -44 },
  { 10057, 1, 52, 35, 17, -44 },
  { 10064, 21, 52, 35, 7, -44 },
  { 10201, 28, 10, 35, 3, -23 },
};

const GFXfont IBMPlexMono_Thin58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Thin58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Thin58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_THIN58PT7B_H_
