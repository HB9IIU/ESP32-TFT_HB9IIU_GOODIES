#ifndef _NOTOSANS_EXTRABOLDITALIC20PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x70, 0x00, 0x03, 0x8F,
  0x1E, 0x00, 0xF7, 0xEE, 0xEE, 0xCE, 0xCC, 0x07, 0x70, 0x33, 0x01, 0x98,
  0x1C, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x03, 0xB8, 0xFF, 0xF7, 0xFF, 0x8E,
  0x60, 0x67, 0x03, 0x30, 0x39, 0x80, 0x03, 0x03, 0xE3, 0xFD, 0xFF, 0x76,
  0x5D, 0x07, 0xC0, 0xFC, 0x1F, 0x82, 0xE0, 0xBB, 0x2E, 0xFF, 0xBF, 0x81,
  0x00, 0x40, 0x3E, 0x0E, 0x7E, 0x18, 0x66, 0x38, 0xE6, 0x70, 0xEE, 0x60,
  0xEE, 0xCE, 0xFD, 0xFF, 0x7F, 0xBF, 0x03, 0x73, 0x06, 0x73, 0x0E, 0x77,
  0x1C, 0x77, 0x18, 0x7E, 0x38, 0x3C, 0x01, 0x00, 0x3F, 0x00, 0xFE, 0x07,
  0x38, 0x1C, 0xE0, 0x77, 0x80, 0xFC, 0x07, 0xC7, 0x3F, 0x3D, 0xFE, 0xEF,
  0x3F, 0xBC, 0x7C, 0x7F, 0xE1, 0xFF, 0xC3, 0xF7, 0x80, 0xFE, 0xEC, 0xC0,
  0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0x70, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC1, 0x87, 0x0E, 0x1C,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xC0, 0x0E, 0x06, 0x33, 0x1F, 0xF7,
  0xF9, 0xFD, 0xF1, 0xDC, 0x26, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3B, 0x9D, 0xCE, 0x00, 0x7D,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x00,
  0x02, 0x07, 0xE3, 0xFD, 0xEF, 0x71, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8,
  0xFE, 0x3B, 0x9E, 0xFF, 0x3F, 0xC7, 0xC0, 0x0F, 0x1F, 0x7F, 0xFE, 0xEE,
  0x4E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x0F, 0xE1, 0xFE,
  0x1C, 0xF0, 0x8F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0xFE, 0x7F, 0xCF, 0xFC, 0x1F, 0xC7, 0xFC, 0x67, 0x80, 0x70,
  0x1E, 0x1F, 0x87, 0xC0, 0xFC, 0x03, 0xC0, 0x38, 0x0F, 0x7F, 0xEF, 0xF9,
  0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xFC, 0x3B, 0x8E, 0xF3,
  0x9C, 0x63, 0x9F, 0xFF, 0xFF, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8E, 0x03, 0x80, 0x7F, 0x0F, 0xF1, 0xBE, 0x01, 0xC0, 0x38,
  0x0F, 0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0x00, 0xA1, 0xF8, 0x7F, 0x1E, 0x07,
  0x80, 0xE0, 0x3B, 0xE7, 0xFC, 0xF3, 0x9C, 0x7B, 0x8E, 0x71, 0xCF, 0x78,
  0xFE, 0x0F, 0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0x01, 0xE0, 0x78, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x02,
  0x07, 0xE3, 0xFD, 0xE7, 0x71, 0xDE, 0xF3, 0xF8, 0x78, 0x7F, 0x3D, 0xEE,
  0x3B, 0x8E, 0xE7, 0xBF, 0xC7, 0xE0, 0x04, 0x0F, 0xC7, 0xF9, 0xCF, 0xF1,
  0xFC, 0x7F, 0x3F, 0xFF, 0x7F, 0xDE, 0xE0, 0x38, 0x1C, 0xFF, 0x3F, 0x8F,
  0x80, 0x3C, 0xF3, 0x80, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x00, 0x1E, 0x3C,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xC3, 0x8E, 0x18, 0x00, 0x00,
  0x40, 0x30, 0x3C, 0x3E, 0x3C, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF0,
  0x0C, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x30, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x7C, 0xFC, 0x3C, 0x08, 0x00, 0x7F,
  0x3F, 0xD8, 0xE0, 0x70, 0x78, 0x78, 0x78, 0x70, 0x38, 0x20, 0x00, 0x0E,
  0x0F, 0x03, 0x80, 0x07, 0xF8, 0x1F, 0xFC, 0x3C, 0x0E, 0x70, 0xC7, 0x63,
  0xF3, 0xE7, 0x73, 0xEE, 0x73, 0xCC, 0x63, 0xCC, 0x67, 0xCC, 0xE6, 0xCF,
  0xFC, 0xE7, 0x38, 0x60, 0x00, 0x78, 0x60, 0x3F, 0xE0, 0x0F, 0x80, 0x01,
  0xE0, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC3, 0x8E,
  0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0xF0, 0xF7, 0x07, 0xF8, 0x3C, 0x1F, 0xE1,
  0xFF, 0x1C, 0xF1, 0xC7, 0x3C, 0x73, 0xFE, 0x3F, 0x83, 0xFE, 0x38, 0xE7,
  0x8E, 0x78, 0xE7, 0xFE, 0x7F, 0xCF, 0xF8, 0x01, 0x00, 0xFF, 0x1F, 0xF3,
  0xE6, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x38,
  0xF3, 0xC7, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F, 0x38, 0x7B, 0xC7, 0x9E, 0x7C,
  0xFF, 0xC7, 0xFC, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xC0, 0x3C,
  0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x38, 0x07, 0x80, 0x78, 0x07, 0xF8, 0x7F,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xC0, 0x3C, 0x03, 0xC0, 0x3F,
  0xC3, 0xFC, 0x3F, 0x87, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x80, 0x7F, 0xC7, 0xFC, 0x7C, 0x67, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x7E,
  0xF3, 0xF7, 0x9F, 0x3C, 0x39, 0xE1, 0xC7, 0xFE, 0x3F, 0xF0, 0x7F, 0x00,
  0x1E, 0x1C, 0x70, 0xF1, 0xC3, 0xC7, 0x0E, 0x3C, 0x38, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x38, 0x71, 0xE1, 0xC7, 0x87, 0x1C, 0x3C, 0x70, 0xF3, 0xC3,
  0x80, 0x1F, 0xC7, 0xF0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x7F, 0x3F, 0x80, 0x01, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x81, 0xE2, 0xF8, 0xFC, 0x3E, 0x00, 0x1E, 0x3C, 0x71, 0xE1, 0xCF, 0x07,
  0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xEF, 0x07,
  0x9C, 0x1C, 0x78, 0x71, 0xE3, 0xC3, 0xC0, 0x1E, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0xF7, 0xFF, 0xFC, 0x1F,
  0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0x6C, 0x3E, 0x3B, 0x1F, 0x8E, 0xC6,
  0xE3, 0xB3, 0xF8, 0xEC, 0xDC, 0x3B, 0x77, 0x1C, 0xD9, 0xC7, 0x3E, 0x71,
  0xCF, 0x38, 0x73, 0xCE, 0x3C, 0xE3, 0x80, 0x1F, 0x0F, 0x1F, 0x0E, 0x1F,
  0x0E, 0x1F, 0x8E, 0x3B, 0x9E, 0x3B, 0x9C, 0x3B, 0x9C, 0x39, 0xDC, 0x39,
  0xDC, 0x71, 0xD8, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0xF0, 0xF8, 0x01,
  0x00, 0x7F, 0x07, 0xFC, 0x79, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1, 0xE7, 0xFE, 0x3F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0xCF, 0x3F, 0xF3, 0xFE,
  0x3F, 0x87, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x01, 0x00, 0x7F,
  0x07, 0xFC, 0x7D, 0xF7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1D, 0xE1, 0xE7, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x1F, 0xC1, 0xFE, 0x1C, 0xF1, 0xC7, 0x3C, 0x73, 0xCF,
  0x3F, 0xE3, 0xFC, 0x3F, 0x87, 0xBC, 0x79, 0xC7, 0x1E, 0x71, 0xEF, 0x0F,
  0x0F, 0xE3, 0xFC, 0xF3, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x72, 0x0E, 0x7F, 0xCF, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0x3C, 0x00, 0x3C, 0x39, 0xC3, 0xCE, 0x1C, 0x70, 0xE7, 0x87, 0x3C, 0x79,
  0xC3, 0xCE, 0x1C, 0xF0, 0xE7, 0x87, 0x3C, 0x78, 0xFF, 0x87, 0xF8, 0x1F,
  0x80, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x78, 0xE7, 0x0E,
  0x70, 0xEE, 0x0E, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xE1, 0xC3,
  0xF8, 0x70, 0xEE, 0x3C, 0x3B, 0x8F, 0x1C, 0xE7, 0xC7, 0x39, 0xB3, 0xCE,
  0xEC, 0xE3, 0xBB, 0x38, 0xEC, 0xDC, 0x3F, 0x37, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF0, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x1C, 0x78, 0x3D, 0xE0,
  0x7B, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F,
  0xC0, 0xF3, 0x81, 0xC7, 0x87, 0x8F, 0x1E, 0x0F, 0x00, 0xE1, 0xFE, 0x3B,
  0xCE, 0x3B, 0xC7, 0x70, 0xFC, 0x1F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xFF,
  0xC7, 0xFC, 0x7F, 0xE0, 0x1F, 0x1F, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xF8, 0xF8, 0xE7, 0x18, 0xE7,
  0x39, 0xCE, 0x31, 0x8E, 0x73, 0x9C, 0x1F, 0x1F, 0x07, 0x06, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0xF8, 0xF8, 0x03,
  0x00, 0xE0, 0x3E, 0x06, 0xC1, 0xD8, 0x73, 0x8C, 0x73, 0x86, 0xE0, 0xE0,
  0xFF, 0x80, 0xF7, 0x30, 0x1E, 0xE7, 0xF9, 0xFF, 0x38, 0xEF, 0x1D, 0xC7,
  0xB8, 0xE7, 0x1C, 0xFF, 0x9F, 0xF1, 0xEE, 0x00, 0x1E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xFC, 0x7F, 0xCF, 0xF9, 0xC7, 0x38, 0xEF, 0x1D, 0xC7, 0xB8,
  0xE7, 0xBC, 0xFF, 0x3B, 0xC0, 0x1F, 0x9F, 0xDF, 0xDE, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xFE, 0x3F, 0x1F, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x1F, 0xE3, 0xFC, 0x7F, 0xC7, 0x1C, 0xF1, 0xCE, 0x3C, 0xE3, 0x8E, 0x38,
  0xFF, 0x8F, 0xF8, 0x7B, 0x00, 0x1F, 0x8F, 0xF7, 0x9D, 0xC7, 0xF7, 0xBF,
  0xEF, 0xC3, 0x80, 0xF1, 0x1F, 0xC3, 0xF0, 0x01, 0xF0, 0x3E, 0x03, 0x90,
  0x78, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x0F, 0x71, 0xFE, 0x3F, 0xE3, 0x8E, 0x78, 0xE7, 0x1E, 0x71, 0xC7,
  0x1C, 0x7F, 0xC7, 0xFC, 0x3F, 0x80, 0x38, 0x83, 0x8F, 0xF8, 0xFF, 0x07,
  0xC0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFC, 0x7F, 0xCF, 0xF9, 0xE7,
  0x38, 0xEF, 0x1D, 0xE7, 0xB8, 0xF7, 0x1C, 0xE3, 0xBC, 0xF0, 0x1E, 0x3C,
  0x30, 0x01, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x18, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x3F, 0x0F, 0x83,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC7, 0x9E, 0x70, 0xE7,
  0x07, 0x70, 0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xF7, 0x07, 0x3C, 0x39, 0xE3,
  0xC7, 0x80, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3,
  0x87, 0x0E, 0x3C, 0x00, 0x1B, 0xCF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0x9E,
  0x73, 0x8E, 0x3B, 0xC7, 0x1D, 0xE7, 0x9E, 0xE3, 0x8F, 0x71, 0xC7, 0x38,
  0xE3, 0xBC, 0xF3, 0xC0, 0x1B, 0xC7, 0xFC, 0xFF, 0x9E, 0x73, 0x8E, 0xF1,
  0xDE, 0x7B, 0x8F, 0x71, 0xCE, 0x3B, 0xCF, 0x00, 0x1F, 0x0F, 0xE7, 0xBF,
  0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8E, 0xF7, 0x9F, 0xC3, 0xE0, 0x0D, 0xE1,
  0xFF, 0x1F, 0xF1, 0xC7, 0x1C, 0x73, 0xC7, 0x38, 0xF3, 0x8E, 0x3D, 0xE3,
  0xFC, 0x7F, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0xE7,
  0xF9, 0xFF, 0x38, 0xEF, 0x1D, 0xC7, 0xB8, 0xE7, 0x1C, 0xFF, 0x9F, 0xF1,
  0xFC, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x1B, 0x9F, 0xCF, 0xE7,
  0x83, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x00, 0x1F, 0x9F, 0xDE,
  0x6F, 0x03, 0xE1, 0xF8, 0x3C, 0x0E, 0xC7, 0x7F, 0xBF, 0x80, 0x1C, 0x38,
  0x7F, 0xFF, 0xFE, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x78,
  0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1D, 0xE7, 0xB8, 0xF7, 0x1C, 0xFF, 0x9F,
  0xF1, 0xEE, 0x00, 0xE1, 0xFC, 0x7B, 0x8E, 0x73, 0xCE, 0x70, 0xFE, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0xE3, 0xC7, 0xE3, 0xCE, 0xE7,
  0xCE, 0xE7, 0xDC, 0xEF, 0xDC, 0xED, 0xFC, 0xED, 0xF8, 0x7D, 0xF8, 0x79,
  0xF0, 0x79, 0xF0, 0x71, 0xE0, 0x3C, 0x78, 0xF7, 0x87, 0xB8, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0xC3, 0xCE, 0x3C, 0x78, 0x38,
  0x79, 0xC7, 0x8E, 0x38, 0x7B, 0xC1, 0xDC, 0x0E, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x1C,
  0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xFF,
  0x3F, 0xCF, 0xF0, 0x07, 0x0F, 0x0E, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xE0,
  0xF0, 0x38, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x0F,
  0x07, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0x70, 0x7F, 0xFF,
  0xFE, 0x0C,
};

const GFXglyph NotoSans_ExtraBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 14, 6, 0, -14 },
  { 14, 8, 5, 9, 2, -14 },
  { 19, 13, 14, 13, 0, -14 },
  { 42, 10, 16, 11, 1, -15 },
  { 62, 16, 14, 18, 1, -14 },
  { 90, 14, 15, 14, 0, -15 },
  { 117, 4, 5, 5, 2, -14 },
  { 120, 7, 17, 7, 1, -14 },
  { 135, 7, 18, 7, -1, -15 },
  { 151, 9, 9, 11, 2, -15 },
  { 162, 10, 10, 12, 1, -12 },
  { 175, 5, 5, 6, -1, -2 },
  { 179, 6, 3, 7, 0, -7 },
  { 182, 4, 3, 6, 0, -3 },
  { 184, 11, 14, 9, -1, -14 },
  { 204, 10, 15, 11, 1, -15 },
  { 223, 8, 14, 11, 2, -14 },
  { 237, 12, 14, 11, -1, -14 },
  { 258, 11, 14, 11, 0, -14 },
  { 278, 11, 14, 11, 0, -14 },
  { 298, 11, 14, 11, 0, -14 },
  { 318, 11, 15, 11, 1, -15 },
  { 339, 11, 14, 11, 1, -14 },
  { 359, 10, 15, 11, 1, -15 },
  { 378, 10, 15, 11, 1, -15 },
  { 397, 6, 11, 6, 0, -11 },
  { 406, 7, 14, 6, -1, -11 },
  { 419, 10, 11, 12, 1, -13 },
  { 433, 10, 6, 12, 1, -10 },
  { 441, 10, 11, 12, 1, -13 },
  { 455, 9, 14, 9, 1, -14 },
  { 471, 16, 16, 18, 1, -14 },
  { 503, 13, 14, 13, -1, -14 },
  { 526, 12, 14, 13, 0, -14 },
  { 547, 12, 15, 12, 1, -15 },
  { 570, 13, 14, 14, 0, -14 },
  { 593, 12, 14, 11, 0, -14 },
  { 614, 12, 14, 11, 0, -14 },
  { 635, 13, 15, 14, 1, -15 },
  { 660, 14, 14, 14, 0, -14 },
  { 685, 10, 14, 8, -1, -14 },
  { 703, 10, 18, 7, -3, -14 },
  { 726, 14, 14, 13, 0, -14 },
  { 751, 9, 14, 10, 0, -14 },
  { 767, 18, 14, 18, 0, -14 },
  { 799, 16, 14, 15, 0, -14 },
  { 827, 13, 15, 15, 1, -15 },
  { 852, 12, 14, 12, 0, -14 },
  { 873, 13, 18, 15, 1, -15 },
  { 903, 12, 14, 13, 0, -14 },
  { 924, 11, 14, 11, 0, -14 },
  { 944, 10, 14, 11, 2, -14 },
  { 962, 13, 14, 14, 1, -14 },
  { 985, 12, 14, 12, 2, -14 },
  { 1006, 18, 14, 18, 2, -14 },
  { 1038, 15, 14, 13, -1, -14 },
  { 1065, 11, 14, 12, 2, -14 },
  { 1085, 13, 14, 11, -1, -14 },
  { 1108, 8, 17, 7, 0, -14 },
  { 1125, 5, 14, 9, 2, -14 },
  { 1134, 8, 17, 7, -1, -14 },
  { 1151, 11, 9, 11, 0, -14 },
  { 1164, 9, 1, 8, -2, 2 },
  { 1166, 4, 3, 7, 3, -15 },
  { 1168, 11, 11, 12, 1, -11 },
  { 1184, 11, 15, 12, 0, -15 },
  { 1205, 9, 11, 10, 1, -11 },
  { 1218, 12, 15, 12, 1, -15 },
  { 1241, 10, 11, 11, 1, -11 },
  { 1255, 12, 20, 8, -2, -15 },
  { 1285, 12, 16, 12, 0, -11 },
  { 1309, 11, 15, 12, 0, -15 },
  { 1330, 7, 15, 6, 0, -15 },
  { 1344, 10, 20, 6, -3, -15 },
  { 1369, 13, 15, 12, 0, -15 },
  { 1394, 7, 15, 6, 0, -15 },
  { 1408, 17, 11, 18, 0, -11 },
  { 1432, 11, 11, 12, 0, -11 },
  { 1448, 10, 11, 12, 1, -11 },
  { 1462, 12, 16, 12, -1, -11 },
  { 1486, 11, 16, 12, 1, -11 },
  { 1508, 9, 11, 9, 0, -11 },
  { 1521, 9, 11, 10, 0, -11 },
  { 1534, 8, 13, 9, 1, -13 },
  { 1547, 11, 11, 12, 1, -11 },
  { 1563, 11, 11, 11, 1, -11 },
  { 1579, 16, 11, 16, 1, -11 },
  { 1601, 13, 11, 11, -1, -11 },
  { 1619, 13, 16, 11, -1, -11 },
  { 1645, 10, 11, 10, 0, -11 },
  { 1659, 8, 17, 7, 0, -14 },
  { 1676, 3, 20, 11, 4, -15 },
  { 1684, 8, 17, 7, -1, -14 },
  { 1701, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_ExtraBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRABOLDITALIC20PT7B_H_
