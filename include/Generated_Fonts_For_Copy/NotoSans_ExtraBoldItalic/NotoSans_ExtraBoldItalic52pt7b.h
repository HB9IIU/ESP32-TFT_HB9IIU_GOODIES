#ifndef _NOTOSANS_EXTRABOLDITALIC52PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x3F, 0xCF,
  0xF7, 0xF8, 0xFF, 0x7F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC3, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x9E, 0x3C, 0x0F, 0xF9,
  0xE0, 0x40, 0xFF, 0x1C, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0xFF, 0xBC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0x7F, 0xC0, 0x00, 0xE3, 0xFC, 0x00, 0x1E, 0x3F, 0xCC, 0x01, 0xE3,
  0xFC, 0xF8, 0x1E, 0x7F, 0x8F, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC3,
  0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0xFC, 0x00,
  0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x87, 0xE0, 0xFE,
  0x3F, 0x8F, 0xC7, 0xFE, 0x3F, 0x9F, 0xE7, 0xF3, 0xFF, 0xCF, 0xFF, 0xF3,
  0xF9, 0xFF, 0xF9, 0xFF, 0xF9, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7E, 0x7F,
  0xFF, 0x8F, 0xFF, 0x3F, 0x9F, 0xC7, 0xF1, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC,
  0x0E, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x07, 0xF1, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x7F,
  0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0x01,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0xF8, 0x7F, 0xC3, 0xFE, 0xFF, 0x8F,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0x80, 0xFC, 0x00, 0xE0,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7F, 0x9F, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x87, 0xFF, 0xE0,
  0x07, 0xFB, 0xF0, 0x0F, 0xF9, 0xFC, 0x03, 0xFC, 0x7E, 0x00, 0x7C, 0x3F,
  0x80, 0x1C, 0x1F, 0xC0, 0x06, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x00, 0x04, 0x0F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03,
  0xFE, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xF8,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x07, 0xFE,
  0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0x0F,
  0xE7, 0xFC, 0x3F, 0x1F, 0xF0, 0x70, 0x7F, 0x80, 0x81, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xC0,
  0x18, 0x03, 0xFE, 0x00, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0x00, 0xE0, 0x1F,
  0xF0, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC8, 0x00,
  0x0F, 0xFC, 0xF0, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0x9F,
  0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x06,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x80, 0x01, 0xFF, 0x8E, 0x00, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x2F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFD, 0xFF, 0xE0, 0x7F, 0xBF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFB, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8,
  0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFB, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE3, 0xFE, 0x3F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFC, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF8, 0x7F, 0xF7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xF7, 0xF8, 0x3F, 0xF9, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE3,
  0xFF, 0x3C, 0x07, 0xFC, 0x40, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x01, 0xFF, 0xC1,
  0xFC, 0x7F, 0x01, 0xFF, 0xFC, 0x3F, 0x1F, 0x80, 0xFF, 0xFF, 0x0F, 0xCF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xF3, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0xFC, 0x1F,
  0xE1, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xDF, 0x83, 0xF8, 0x1F,
  0x83, 0xF7, 0xE1, 0xFC, 0x0F, 0xC0, 0xFD, 0xF8, 0x7F, 0x03, 0xF0, 0x3F,
  0xFE, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xFF, 0xC3,
  0xF8, 0x1F, 0xC1, 0xFB, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x3F, 0x0F, 0xE1, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFF, 0xDF,
  0xE3, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0x83, 0xFF, 0x9F, 0xFC, 0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0x01, 0xFC, 0x07,
  0xC0, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFF, 0x07, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xF8, 0x1F, 0xF8, 0x00,
  0x60, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x1F, 0xFC, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0xFF,
  0x00, 0x04, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0x3F,
  0xF0, 0x3F, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xC7,
  0xFC, 0x0F, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x81, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x00,
  0x7E, 0xFE, 0x01, 0xFE, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFB, 0xF0, 0x0F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0x01, 0xF9,
  0xFE, 0x01, 0xFC, 0xFC, 0x0F, 0xEF, 0xF0, 0x0F, 0xF3, 0xF0, 0x3F, 0x3F,
  0xC0, 0x3F, 0xCF, 0xC1, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x07, 0xE3, 0xFC,
  0x03, 0xFC, 0xFC, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x80,
  0x7F, 0x8F, 0xC7, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x1F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFC, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xF3, 0xF8, 0xFF, 0x00, 0x7F,
  0x0F, 0xDF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x0F,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x0F,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0xFF,
  0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0xFF, 0x00, 0xFF, 0x0F,
  0xF9, 0xFE, 0x03, 0xFC, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0x1F, 0xE7, 0xF8,
  0x0F, 0xF0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0x80,
  0x7F, 0xBF, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFF,
  0x80, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xC7, 0xF8,
  0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFC, 0x03, 0x80, 0xFF, 0x80, 0x08, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x80, 0x03, 0xFE, 0x0C, 0x00, 0x3F, 0xE0, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x7F,
  0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F,
  0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F,
  0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFB, 0xF0, 0x3F, 0xC0, 0x7F,
  0x83, 0xFB, 0xF0, 0x7F, 0xC0, 0x7F, 0x87, 0xF7, 0xF0, 0x7F, 0x80, 0x7F,
  0x87, 0xF7, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xF7, 0xF0, 0xFF, 0x00, 0x7F,
  0x8F, 0xE7, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xE7, 0xF1, 0xFF, 0x00, 0x7F,
  0x9F, 0xC7, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFE, 0x00, 0x7F,
  0x3F, 0xC7, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x83, 0xF3, 0xFC, 0x00, 0x7F,
  0x3F, 0x83, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x03, 0xF7, 0xF8, 0x00, 0x7F,
  0x7F, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x03, 0xF7, 0xF0, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0xFF, 0x83, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x7F, 0xC0,
  0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC7, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x0F, 0xFC, 0x7F, 0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFE, 0x01, 0xFF, 0xCF,
  0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC7, 0xE0, 0x03, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFB, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF1,
  0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x3F, 0xC0,
  0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xC0, 0xFE, 0x3F, 0xF8,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8, 0x1C, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x10, 0xFF,
  0xC0, 0x70, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x7F,
  0x80, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0xFF, 0xFB, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0x3F, 0x80, 0x07, 0xFC, 0x7F,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC7, 0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0xF0, 0x3F, 0xCF, 0xF8,
  0x0F, 0xF3, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x03, 0x07, 0xFE, 0x03, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFF, 0x8F,
  0xE0, 0x0F, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8,
  0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xF0, 0x03, 0xFF,
  0x7F, 0xC0, 0x07, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x03, 0x00, 0x1F, 0xF0,
  0x0F, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x03, 0xFC, 0xFF,
  0xC0, 0x7F, 0xDF, 0xFE, 0x07, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC,
  0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xF3,
  0xFF, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xF1, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0x3F, 0xFE, 0x7F, 0xFE, 0x07, 0xF7, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x87, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xFC, 0x07, 0xF3, 0xFF, 0xE0, 0x7F, 0x3F,
  0xFE, 0x07, 0xF7, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFE, 0x3F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFD, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF,
  0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F,
  0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x83, 0xFE, 0x1F, 0xF9, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0xE0, 0x03, 0xF9, 0xFF, 0xE0, 0x07,
  0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFE, 0x00, 0xFF, 0x3F, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xFC, 0x7F, 0x01, 0xFF, 0xE7,
  0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFE, 0x03,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80,
  0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFE,
  0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x18, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x3E, 0x07, 0xF1, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F,
  0xDF, 0xF0, 0x7F, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0x84, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFC, 0x1E, 0x0F, 0xF0,
  0x0C, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x90, 0x01, 0xFF, 0x3C, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x70,
  0x00, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x03, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xEF, 0xE0, 0x7F, 0xFC, 0xFE, 0x03,
  0xFF, 0x9F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFE,
  0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x87, 0xF8,
  0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xCF, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFD, 0xFE,
  0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFE, 0x03,
  0xFC, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0x8F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xF7, 0xE1, 0xFE, 0x0F, 0xF0, 0xFD, 0xF8,
  0x7F, 0x83, 0xFC, 0x7F, 0x7E, 0x3F, 0xC0, 0x7F, 0x1F, 0x9F, 0x8F, 0xF0,
  0x1F, 0xC7, 0xE7, 0xE7, 0xF8, 0x07, 0xF3, 0xF1, 0xF9, 0xFE, 0x01, 0xFC,
  0xFC, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x1F, 0xBF, 0xC0, 0x1F, 0xDF, 0x87,
  0xEF, 0xF0, 0x07, 0xF7, 0xE1, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x1F, 0x7F, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x80, 0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 38, 15, 0, -37 },
  { 82, 20, 13, 24, 5, -37 },
  { 115, 33, 37, 34, 1, -37 },
  { 268, 28, 43, 29, 1, -40 },
  { 419, 42, 38, 46, 3, -38 },
  { 619, 36, 39, 37, 1, -38 },
  { 795, 10, 13, 13, 5, -37 },
  { 812, 20, 46, 18, 2, -38 },
  { 927, 21, 46, 19, -4, -38 },
  { 1048, 25, 26, 28, 4, -40 },
  { 1130, 25, 25, 30, 3, -31 },
  { 1209, 14, 13, 15, -3, -6 },
  { 1232, 15, 7, 17, 1, -17 },
  { 1246, 10, 10, 15, 0, -9 },
  { 1259, 29, 38, 23, -2, -38 },
  { 1397, 27, 39, 29, 2, -38 },
  { 1529, 22, 37, 29, 4, -37 },
  { 1631, 29, 38, 29, -1, -38 },
  { 1769, 28, 39, 29, 0, -38 },
  { 1906, 29, 37, 29, 0, -37 },
  { 2041, 28, 38, 29, 1, -37 },
  { 2174, 28, 39, 29, 2, -38 },
  { 2311, 31, 37, 29, 1, -37 },
  { 2455, 28, 39, 29, 1, -38 },
  { 2592, 26, 39, 29, 2, -38 },
  { 2719, 15, 30, 15, 0, -29 },
  { 2776, 18, 36, 15, -3, -29 },
  { 2857, 25, 28, 30, 3, -33 },
  { 2945, 25, 17, 30, 3, -27 },
  { 2999, 25, 28, 30, 3, -33 },
  { 3087, 22, 39, 25, 4, -38 },
  { 3195, 42, 42, 46, 2, -37 },
  { 3416, 34, 37, 34, -3, -37 },
  { 3574, 31, 37, 33, 1, -37 },
  { 3718, 31, 39, 32, 3, -38 },
  { 3870, 33, 37, 35, 1, -37 },
  { 4023, 29, 37, 29, 1, -37 },
  { 4158, 29, 37, 29, 1, -37 },
  { 4293, 33, 39, 36, 3, -38 },
  { 4454, 36, 37, 37, 1, -37 },
  { 4621, 26, 37, 21, -2, -37 },
  { 4742, 27, 48, 18, -8, -37 },
  { 4904, 37, 37, 33, 1, -37 },
  { 5076, 23, 37, 27, 1, -37 },
  { 5183, 46, 37, 46, 1, -37 },
  { 5396, 39, 37, 40, 1, -37 },
  { 5577, 34, 39, 38, 3, -38 },
  { 5743, 31, 37, 32, 1, -37 },
  { 5887, 34, 47, 38, 3, -38 },
  { 6087, 30, 37, 33, 1, -37 },
  { 6226, 28, 39, 28, 1, -38 },
  { 6363, 28, 37, 28, 4, -37 },
  { 6493, 34, 38, 36, 3, -37 },
  { 6655, 32, 37, 31, 4, -37 },
  { 6803, 48, 37, 47, 4, -37 },
  { 7025, 40, 37, 33, -3, -37 },
  { 7210, 31, 37, 30, 4, -37 },
  { 7354, 33, 37, 28, -2, -37 },
  { 7507, 22, 46, 18, -1, -38 },
  { 7634, 13, 38, 23, 6, -38 },
  { 7696, 22, 46, 18, -3, -38 },
  { 7823, 27, 24, 28, 0, -37 },
  { 7904, 24, 5, 22, -5, 4 },
  { 7919, 12, 8, 18, 7, -40 },
  { 7931, 28, 30, 31, 2, -29 },
  { 8036, 28, 41, 31, 1, -40 },
  { 8180, 24, 30, 26, 2, -29 },
  { 8270, 31, 41, 31, 2, -40 },
  { 8429, 26, 30, 29, 2, -29 },
  { 8527, 31, 52, 20, -5, -40 },
  { 8729, 30, 41, 31, 1, -29 },
  { 8883, 28, 40, 32, 1, -40 },
  { 9023, 16, 40, 16, 1, -40 },
  { 9103, 25, 52, 16, -7, -40 },
  { 9266, 32, 40, 31, 1, -40 },
  { 9426, 17, 40, 16, 1, -40 },
  { 9511, 44, 29, 48, 1, -29 },
  { 9671, 28, 29, 32, 1, -29 },
  { 9773, 27, 30, 31, 2, -29 },
  { 9875, 31, 41, 31, -2, -29 },
  { 10034, 28, 41, 31, 2, -29 },
  { 10178, 23, 29, 22, 1, -29 },
  { 10262, 23, 30, 25, 1, -29 },
  { 10349, 21, 35, 22, 2, -34 },
  { 10441, 28, 30, 32, 3, -29 },
  { 10546, 28, 29, 27, 2, -29 },
  { 10648, 42, 29, 42, 3, -29 },
  { 10801, 34, 29, 29, -3, -29 },
  { 10925, 33, 41, 28, -3, -29 },
  { 11095, 27, 29, 25, -1, -29 },
  { 11193, 22, 45, 19, 0, -37 },
  { 11317, 7, 51, 29, 11, -39 },
  { 11362, 22, 45, 19, -3, -37 },
  { 11486, 25, 9, 30, 3, -23 },
};

const GFXfont NotoSans_ExtraBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRABOLDITALIC52PT7B_H_
