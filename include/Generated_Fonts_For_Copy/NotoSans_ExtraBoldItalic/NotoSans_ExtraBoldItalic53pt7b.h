#ifndef _NOTOSANS_EXTRABOLDITALIC53PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x30, 0x00,
  0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7E, 0x0F, 0xC3,
  0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xF9, 0xF8, 0x1F,
  0xF3, 0xC1, 0x80, 0xFF, 0x9E, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x3F, 0xE7,
  0x00, 0x01, 0xFF, 0x78, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7B, 0xFE, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x1E, 0x7F,
  0x88, 0x00, 0xE3, 0xFC, 0x70, 0x0F, 0x1F, 0xE3, 0xF0, 0x79, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xBF,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87,
  0xF1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0x8F,
  0xE7, 0xFF, 0x1F, 0xEF, 0xF3, 0xF9, 0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0xBF, 0x9F, 0xFF, 0xE7, 0xFF, 0xE7, 0xF3, 0xFF, 0xFC,
  0x7F, 0xF9, 0xFC, 0xFF, 0x1F, 0x83, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0x00,
  0x0F, 0xC3, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFE, 0x07, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFF, 0xDF, 0xF0, 0xFF, 0x0F, 0xFC, 0x7F, 0xCF, 0xF8, 0x7F,
  0xC3, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xF8, 0x01,
  0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3,
  0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0,
  0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x08, 0x03, 0xF0, 0x03, 0x81, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0x7F, 0x9F, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xC1, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xC7, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x0C, 0x0F, 0xE0, 0x01, 0x03, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x0F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x86, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0xC0,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xDF,
  0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF,
  0xDF, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8,
  0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFE, 0x7F, 0x83, 0xF8,
  0xFF, 0x03, 0xC3, 0xFE, 0x07, 0x07, 0xFC, 0x04, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0x00, 0xF8, 0x0F, 0xFC,
  0x01, 0xC0, 0x1F, 0xF0, 0x06, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xFF, 0x00, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x60, 0x00,
  0x7F, 0xE3, 0xC0, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F,
  0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0xC0, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE1, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x40, 0x00, 0xFF, 0xC3, 0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x3F, 0x00, 0x3F, 0xCF, 0xFC, 0x03, 0xFD, 0xFF, 0xF0, 0x7F,
  0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF0, 0xFF, 0xCF, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xCF,
  0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80,
  0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFE, 0x3F, 0xF0, 0x3F, 0xC7, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF,
  0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x1F,
  0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xEF, 0xFC, 0x3F, 0xF9, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xDF, 0xF0, 0x3F, 0xF3, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x20, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFE, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0x18, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x07,
  0xF0, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0x07, 0xFF, 0xF8, 0x7E, 0x3F, 0x03,
  0xFF, 0xFE, 0x0F, 0xCF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF9, 0xF8, 0x1F, 0xE1,
  0xF8, 0x3F, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xEF, 0xE1, 0xFC, 0x0F, 0xE0,
  0xFD, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xBF, 0x0F, 0xE0, 0x3F, 0x03, 0xF7,
  0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0xFF, 0x87,
  0xE0, 0x3F, 0x03, 0xF7, 0xF0, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0x81,
  0xFC, 0x1F, 0xDF, 0xC3, 0xF0, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x0F, 0xF1,
  0xFE, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0xC3, 0xFF, 0x9F, 0xFE, 0x03, 0xF8,
  0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0x80, 0xE0, 0x0F, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x81, 0xFC, 0x0F, 0xFE, 0x00, 0x38, 0x1F, 0xFC, 0x00, 0x08, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x7F, 0xF8, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x9F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFC, 0x0F, 0xFF, 0x00, 0x0C, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0x9F,
  0xF0, 0x1F, 0xFF, 0xCF, 0xF8, 0x1F, 0xFF, 0xE7, 0xFC, 0x0F, 0xFF, 0xE3,
  0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x10, 0x3F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xC0,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0x8F,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xBF,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0x00, 0xFE,
  0xFF, 0x00, 0xFF, 0x7E, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFC, 0x07, 0xF3,
  0xFC, 0x03, 0xFD, 0xF8, 0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xF0, 0x3F, 0x9F,
  0xE0, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0xFC, 0x7F,
  0x80, 0x7F, 0x9F, 0xC3, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0x87, 0xE3, 0xFC,
  0x01, 0xFE, 0x7F, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFE, 0x3F, 0x0F, 0xF0,
  0x0F, 0xF1, 0xFC, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xF9, 0xFC, 0x7F, 0x80,
  0x3F, 0xC7, 0xF7, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xEF, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0x0F, 0xF8, 0x07,
  0xF8, 0x7F, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xC0, 0xFF, 0x00, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFC,
  0x03, 0xFB, 0xFC, 0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x07, 0xFC, 0x07, 0xFB,
  0xFE, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x07,
  0xF8, 0x07, 0xF9, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xDF, 0xE0, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xE0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x0F,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF,
  0x9F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7C, 0x07, 0xFC, 0x00,
  0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x80, 0x01, 0xFF, 0x0E, 0x00,
  0x3F, 0xF0, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07,
  0xFE, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xFC, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xCF,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE3,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xF8, 0x07, 0xFC,
  0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF,
  0x80, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFB, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC3, 0xF9, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF1, 0xFE, 0x7F, 0x1F, 0xF0, 0x07, 0xF8, 0xFE, 0x3F, 0x8F,
  0xF0, 0x03, 0xFC, 0xFF, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF8, 0x00, 0xFF, 0x3F, 0x87, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0x83, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xC1, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x7F,
  0xE7, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x80,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x01,
  0xFE, 0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x40, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x7F, 0xF9, 0xFE,
  0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x81,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0xFF,
  0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x01,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFC, 0x01, 0xFF, 0xCF, 0xE0, 0x07, 0xFC,
  0x7F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x86, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFE, 0x03,
  0xF8, 0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xF8, 0x04, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x41, 0xFF, 0x81, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x38, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x1F,
  0xFC, 0xFF, 0x80, 0x7F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0x3F, 0x80, 0x07, 0xFC, 0x7F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xFE, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x1F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0x03, 0xFF, 0x01, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x0F, 0xFF, 0x3F, 0xC0,
  0x7F, 0xFE, 0xFF, 0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xC0, 0x0F, 0xFC, 0xFF,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x0C, 0x00, 0x7F, 0xE0, 0x3E,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x3F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xC3,
  0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFC,
  0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0x87, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x1F, 0xC3, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x7F,
  0xF8, 0x7F, 0xF8, 0x0F, 0xF7, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF,
  0x7F, 0xFF, 0x03, 0xFB, 0xFF, 0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0xFE, 0x7F, 0xF8, 0x0F, 0xF7,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF7, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80,
  0xFF, 0xBF, 0xF0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF,
  0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xF8, 0x00, 0xFF, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF,
  0x80, 0x1F, 0xF7, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0x60,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x7F, 0xF9, 0xFE,
  0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0xFF,
  0x80, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFC, 0x01, 0xFF, 0x9F, 0xE0, 0x07, 0xF9,
  0xFF, 0x00, 0x02, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0xF8, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xFB,
  0xFE, 0x07, 0xFB, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x08, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0xC0, 0x0F, 0xF8, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x20, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x3F, 0x80, 0x7F, 0xF1, 0xFC,
  0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFB,
  0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0xC7, 0xF8,
  0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFB, 0xFC, 0x07,
  0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0xF0,
  0x7F, 0xCF, 0xF0, 0x3F, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xFE, 0x0F, 0xF8,
  0xFF, 0x07, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0xE1, 0xFF, 0x07, 0xF0,
  0xFD, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x7E, 0x1F, 0xE0, 0x7F, 0x1F, 0xDF,
  0x8F, 0xF0, 0x1F, 0xC7, 0xE7, 0xE3, 0xFC, 0x07, 0xF3, 0xF9, 0xF9, 0xFF,
  0x01, 0xFC, 0xFC, 0x7E, 0x7F, 0x80, 0x7F, 0x3F, 0x1F, 0x9F, 0xE0, 0x1F,
  0xDF, 0xC7, 0xEF, 0xF0, 0x07, 0xF7, 0xE1, 0xFB, 0xFC, 0x01, 0xFD, 0xF8,
  0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x5F, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFA, 0x00, 0x3F, 0xFC, 0x80,
  0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 39, 16, 0, -38 },
  { 84, 21, 14, 24, 5, -38 },
  { 121, 34, 38, 34, 1, -38 },
  { 283, 29, 43, 30, 1, -40 },
  { 439, 43, 38, 47, 3, -38 },
  { 644, 37, 39, 38, 1, -38 },
  { 825, 10, 14, 13, 5, -38 },
  { 843, 20, 46, 19, 2, -38 },
  { 958, 21, 47, 19, -4, -39 },
  { 1082, 26, 26, 29, 4, -41 },
  { 1167, 26, 26, 31, 3, -32 },
  { 1252, 14, 13, 16, -3, -6 },
  { 1275, 15, 7, 17, 1, -18 },
  { 1289, 10, 10, 16, 0, -9 },
  { 1302, 29, 38, 24, -2, -38 },
  { 1440, 27, 39, 30, 2, -38 },
  { 1572, 23, 38, 30, 4, -38 },
  { 1682, 30, 38, 30, -1, -38 },
  { 1825, 29, 39, 30, 0, -38 },
  { 1967, 29, 38, 30, 0, -38 },
  { 2105, 29, 39, 30, 1, -38 },
  { 2247, 28, 39, 30, 2, -38 },
  { 2384, 31, 38, 30, 1, -38 },
  { 2532, 29, 39, 30, 1, -38 },
  { 2674, 27, 39, 30, 2, -38 },
  { 2806, 15, 31, 16, 0, -30 },
  { 2865, 18, 37, 16, -3, -30 },
  { 2949, 26, 28, 31, 3, -33 },
  { 3040, 26, 17, 31, 3, -27 },
  { 3096, 26, 28, 31, 3, -33 },
  { 3187, 23, 39, 25, 4, -38 },
  { 3300, 43, 43, 46, 2, -38 },
  { 3532, 34, 38, 34, -3, -38 },
  { 3694, 32, 38, 33, 1, -38 },
  { 3846, 32, 39, 33, 3, -38 },
  { 4002, 33, 38, 36, 1, -38 },
  { 4159, 30, 38, 29, 1, -38 },
  { 4302, 30, 38, 29, 1, -38 },
  { 4445, 33, 39, 37, 3, -38 },
  { 4606, 37, 38, 37, 1, -38 },
  { 4782, 26, 38, 21, -2, -38 },
  { 4906, 27, 50, 19, -8, -38 },
  { 5075, 37, 38, 34, 1, -38 },
  { 5251, 23, 38, 28, 1, -38 },
  { 5361, 47, 38, 47, 1, -38 },
  { 5585, 40, 38, 41, 1, -38 },
  { 5775, 34, 39, 39, 3, -38 },
  { 5941, 31, 38, 33, 1, -38 },
  { 6089, 34, 47, 39, 3, -38 },
  { 6289, 31, 38, 34, 1, -38 },
  { 6437, 28, 39, 29, 1, -38 },
  { 6574, 28, 38, 29, 4, -38 },
  { 6707, 34, 39, 37, 3, -38 },
  { 6873, 32, 38, 32, 4, -38 },
  { 7025, 49, 38, 48, 4, -38 },
  { 7258, 41, 38, 34, -3, -38 },
  { 7453, 31, 38, 31, 5, -38 },
  { 7601, 33, 38, 28, -2, -38 },
  { 7758, 23, 47, 18, -1, -38 },
  { 7894, 13, 38, 24, 6, -38 },
  { 7956, 23, 47, 18, -4, -38 },
  { 8092, 28, 25, 29, 0, -38 },
  { 8180, 24, 5, 22, -5, 4 },
  { 8195, 12, 9, 18, 8, -41 },
  { 8209, 29, 31, 32, 2, -30 },
  { 8322, 29, 41, 32, 1, -40 },
  { 8471, 25, 31, 26, 2, -30 },
  { 8568, 31, 41, 32, 2, -40 },
  { 8727, 27, 31, 30, 2, -30 },
  { 8832, 32, 54, 21, -6, -41 },
  { 9048, 30, 43, 32, 1, -30 },
  { 9210, 29, 40, 32, 1, -40 },
  { 9355, 17, 41, 16, 1, -41 },
  { 9443, 25, 54, 16, -7, -41 },
  { 9612, 33, 40, 31, 1, -40 },
  { 9777, 17, 40, 16, 1, -40 },
  { 9862, 45, 30, 49, 1, -30 },
  { 10031, 29, 30, 32, 1, -30 },
  { 10140, 27, 31, 32, 2, -30 },
  { 10245, 32, 43, 32, -2, -30 },
  { 10417, 29, 43, 32, 2, -30 },
  { 10573, 24, 30, 23, 1, -30 },
  { 10663, 24, 31, 26, 1, -30 },
  { 10756, 22, 36, 23, 2, -35 },
  { 10855, 29, 30, 32, 3, -29 },
  { 10964, 29, 29, 28, 2, -29 },
  { 11070, 42, 29, 43, 3, -29 },
  { 11223, 35, 29, 29, -3, -29 },
  { 11350, 35, 42, 28, -4, -29 },
  { 11534, 27, 29, 25, -1, -29 },
  { 11632, 22, 46, 19, 0, -38 },
  { 11759, 6, 52, 30, 12, -40 },
  { 11798, 22, 46, 19, -3, -38 },
  { 11925, 26, 9, 31, 3, -23 },
};

const GFXfont NotoSans_ExtraBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRABOLDITALIC53PT7B_H_
