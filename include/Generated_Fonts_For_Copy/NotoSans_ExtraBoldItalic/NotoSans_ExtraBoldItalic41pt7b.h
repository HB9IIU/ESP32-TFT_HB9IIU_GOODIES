#ifndef _NOTOSANS_EXTRABOLDITALIC41PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7E, 0x00, 0x7E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E,
  0x7C, 0x7E, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xCE, 0x70,
  0x7F, 0x70, 0x41, 0xF9, 0xC0, 0x07, 0xF7, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x73, 0xF0, 0x01, 0xCF, 0xC8,
  0x07, 0x3F, 0x3C, 0x39, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x7E, 0x03, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x80, 0x3E, 0x03, 0xFF,
  0xE0, 0x3E, 0x01, 0xF3, 0xF0, 0x3F, 0x01, 0xF8, 0xF8, 0x1F, 0x00, 0xF8,
  0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x8F, 0x80, 0x0F, 0xCF, 0xCF, 0x8F, 0xC7,
  0xE7, 0xEF, 0xCF, 0xF9, 0xFF, 0xE7, 0xCF, 0xFC, 0xFF, 0xE7, 0xCF, 0xFF,
  0x7F, 0xF7, 0xEF, 0xFF, 0x9F, 0xF7, 0xE7, 0xE7, 0xC1, 0xC3, 0xE7, 0xE3,
  0xE0, 0x03, 0xE3, 0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x7E, 0x01, 0xF0, 0x3E, 0x3F, 0x01, 0xF8, 0x1F,
  0x1F, 0x00, 0xF8, 0x0F, 0x9F, 0x80, 0xF8, 0x07, 0xFF, 0x80, 0xF8, 0x03,
  0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0x0F, 0xE7, 0xFF, 0xF8,
  0xFE, 0x7F, 0x3F, 0xDF, 0xCF, 0xF1, 0xFD, 0xFC, 0xFE, 0x1F, 0xFF, 0x8F,
  0xE0, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFC, 0x7E, 0xFD, 0xFB, 0xE7, 0xDF,
  0xBE, 0x7C, 0xF9, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x02,
  0x07, 0xC0, 0x30, 0x7C, 0x07, 0xC7, 0x80, 0x7F, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xBE, 0x07, 0xF3, 0xE0, 0x1E, 0x3F, 0x00, 0xC1,
  0xF0, 0x04, 0x1E, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0x1C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0x7E,
  0x1F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F,
  0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x1F, 0x87, 0xF8, 0x7F, 0x3F, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xFE, 0xFC, 0x7F, 0x7F, 0x0F, 0x9F, 0xC3,
  0x87, 0xE0, 0x43, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFC, 0x7F, 0x80, 0xE0, 0x7F, 0x01, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x38, 0x1F, 0xC0, 0x40, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xB0, 0x01, 0xFC, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F, 0x00, 0xFC,
  0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x30, 0x03, 0xFC, 0x7C, 0x1F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x7E, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x8F, 0xE3, 0xFC, 0x3F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE,
  0x3F, 0x87, 0xF8, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xCF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0x83, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0xF8, 0xFE, 0x1F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xBF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x7E, 0x1F, 0xE7, 0xE0, 0xFC, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x81, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0xC1, 0xFC, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0xF0, 0x3E, 0x3F, 0x03, 0xFF, 0x8F, 0x9F,
  0x07, 0xFF, 0xC7, 0xDF, 0x07, 0xFF, 0xE3, 0xEF, 0x87, 0xF3, 0xE1, 0xF7,
  0xC7, 0xE1, 0xF0, 0xFF, 0xC3, 0xE0, 0xF8, 0x7F, 0xE3, 0xF0, 0x7C, 0x3F,
  0xF1, 0xF0, 0x7C, 0x1F, 0xF8, 0xF8, 0x3E, 0x0F, 0x7C, 0x7C, 0x1F, 0x0F,
  0xBE, 0x3E, 0x1F, 0x87, 0xDF, 0x1F, 0x0F, 0x87, 0xCF, 0x8F, 0x8F, 0xE7,
  0xE7, 0xC7, 0xFF, 0xFF, 0xE3, 0xE1, 0xFF, 0x7F, 0xE1, 0xF8, 0xFF, 0x3F,
  0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0xDF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x07,
  0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x78, 0x3F, 0xE0, 0x0C, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x40, 0x7F, 0xF7, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xE0, 0x7F,
  0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F,
  0xC0, 0x7F, 0x87, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0,
  0xF0, 0x7F, 0xC0, 0x04, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFF, 0xE7,
  0xF0, 0x7F, 0xF3, 0xFC, 0x3F, 0xFC, 0xFE, 0x0F, 0xFF, 0x3F, 0x83, 0xFF,
  0xCF, 0xE0, 0xFF, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xF0, 0x7F, 0xE3, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF8,
  0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xEF, 0xC0, 0xFD, 0xF0, 0x3E, 0xFC, 0x0F, 0xDF, 0x07,
  0xFF, 0xC0, 0xFD, 0xF0, 0x7D, 0xF8, 0x1F, 0x9F, 0x0F, 0xDF, 0x81, 0xF9,
  0xF0, 0xF9, 0xF8, 0x1F, 0x9F, 0x1F, 0xBF, 0x81, 0xF9, 0xF1, 0xF3, 0xF0,
  0x3F, 0x9F, 0x3F, 0x3F, 0x03, 0xF1, 0xF3, 0xE3, 0xF0, 0x3F, 0x1F, 0x7E,
  0x3F, 0x03, 0xF1, 0xF7, 0xC7, 0xF0, 0x3F, 0x1F, 0xFC, 0x7E, 0x07, 0xF1,
  0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0x0F, 0xE0,
  0x7E, 0x1F, 0xF0, 0xFE, 0x07, 0xE1, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xE0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xF8, 0x03, 0xF0, 0x3F,
  0xF0, 0x07, 0xE0, 0x7F, 0xF0, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0xC0, 0x7E, 0x07, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x1F, 0xBF,
  0x03, 0xF0, 0x3F, 0x7E, 0x0F, 0xE0, 0x7E, 0xFE, 0x1F, 0x81, 0xF8, 0xFC,
  0x3F, 0x03, 0xF1, 0xF8, 0x7E, 0x07, 0xE3, 0xF9, 0xFC, 0x0F, 0xC3, 0xF3,
  0xF8, 0x3F, 0x87, 0xE7, 0xE0, 0x7F, 0x0F, 0xEF, 0xC0, 0xFC, 0x1F, 0xDF,
  0x81, 0xF8, 0x1F, 0xBF, 0x03, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8,
  0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xC0,
  0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xE0, 0x07, 0xFC, 0x0F,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xF3, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0xFF, 0x1F, 0xC1,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F,
  0xF0, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE,
  0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC7, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFE, 0x0F, 0x07, 0xF0, 0x08, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x08, 0x01, 0xFC,
  0x30, 0x07, 0xF0, 0xF8, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC,
  0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F,
  0x9F, 0x80, 0x7F, 0x00, 0xFC, 0x7E, 0x03, 0xFC, 0x07, 0xF1, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0xC0, 0xFE, 0x1F, 0x81, 0xFF, 0x03, 0xF8,
  0x7E, 0x0F, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0xF0, 0x7F, 0x07, 0xE1, 0xFF,
  0xC1, 0xF8, 0x1F, 0x87, 0xDF, 0x0F, 0xE0, 0x7E, 0x1F, 0x7C, 0x3F, 0x81,
  0xF8, 0xFD, 0xF0, 0xFC, 0x07, 0xE3, 0xE7, 0xC7, 0xF0, 0x1F, 0x9F, 0x9F,
  0x1F, 0x80, 0x7E, 0x7C, 0x7C, 0xFE, 0x01, 0xFB, 0xF1, 0xF3, 0xF0, 0x07,
  0xEF, 0xC7, 0xCF, 0xC0, 0x1F, 0xBE, 0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x7D,
  0xF8, 0x01, 0xFF, 0xC1, 0xF7, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF3, 0xF0, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x3F, 0x80, 0x7F,
  0x7F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF0,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x78, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x3E, 0x00,
  0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C,
  0x00, 0xF0, 0x7C, 0x0F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x03,
  0xF1, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xBF,
  0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE7, 0xC0, 0x3F, 0xBF, 0x80, 0xFD, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7F,
  0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x03, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0x07,
  0xF1, 0xFE, 0x7F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xF7, 0xFE, 0x0F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xF0, 0x23, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x02, 0x1F, 0xE1,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xF1, 0xFC, 0x03, 0xFD, 0xFC, 0x0F, 0xFD, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xC0, 0x1F, 0xCF, 0x80, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC,
  0x7F, 0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0x7F, 0x07, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x18, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x3E, 0x07, 0xFC, 0xFC, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x81,
  0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFD, 0xFC, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x82, 0x00, 0xFE, 0x07, 0xEF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x3F,
  0xBF, 0xC0, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x00,
  0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F,
  0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xBF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F,
  0x8F, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x3E, 0x01, 0xF9, 0xFE, 0x1F, 0xF0, 0x3F, 0x7F, 0xE7, 0xFF, 0x07, 0xDF,
  0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87,
  0xF8, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0x0F,
  0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0x81, 0xFC, 0x7E, 0x07, 0xF0, 0x3F, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0xC0, 0xFC, 0x7F, 0x03, 0xF8, 0x3F,
  0x8F, 0xE0, 0x7E, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8,
  0x1F, 0xC0, 0x0F, 0xC3, 0xE0, 0x3F, 0x3F, 0xC0, 0xFD, 0xFF, 0x83, 0xEF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F,
  0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x3F,
  0x83, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF7, 0xF8, 0xFE, 0x1F,
  0xCF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE,
  0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x03, 0xF7,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xE3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x3F,
  0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x7C, 0x0F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x03, 0xF1, 0xFC,
  0x0F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F,
  0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7F, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC3, 0xC3, 0xF3, 0xF0, 0xFD, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE0, 0xE3, 0xF8,
  0x10, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x80, 0x7F, 0x30,
  0x1F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x10, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xBF, 0x07, 0xFF, 0x7C, 0x0F, 0xFC, 0xF8, 0x0F, 0xF3,
  0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81,
  0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0,
  0x7E, 0x1F, 0xC1, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x9F, 0xC0, 0x7E,
  0x7E, 0x00, 0xFB, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x07,
  0xF8, 0x1F, 0xFF, 0x83, 0xFC, 0x1F, 0xDF, 0xC1, 0xFE, 0x0F, 0xEF, 0xE1,
  0xFF, 0x07, 0xE3, 0xF0, 0xFF, 0x87, 0xF1, 0xF8, 0xFF, 0xC3, 0xF0, 0xFC,
  0x7F, 0xE3, 0xF8, 0x7E, 0x3D, 0xF1, 0xF8, 0x3F, 0x3E, 0xF9, 0xFC, 0x1F,
  0x9F, 0x7C, 0xFC, 0x0F, 0xDF, 0x3E, 0x7E, 0x07, 0xEF, 0x9F, 0x7E, 0x03,
  0xF7, 0xCF, 0xBF, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF7, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x1F,
  0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x17, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 29, 12, 0, -29 },
  { 52, 16, 10, 19, 4, -29 },
  { 72, 26, 29, 26, 1, -29 },
  { 167, 22, 33, 23, 1, -31 },
  { 258, 33, 30, 36, 2, -30 },
  { 382, 28, 30, 30, 1, -30 },
  { 487, 7, 10, 10, 4, -29 },
  { 496, 16, 36, 15, 1, -30 },
  { 568, 16, 36, 15, -3, -30 },
  { 640, 20, 20, 22, 3, -31 },
  { 690, 20, 19, 24, 2, -24 },
  { 738, 10, 10, 12, -2, -5 },
  { 751, 12, 6, 13, 1, -14 },
  { 760, 8, 7, 12, 0, -7 },
  { 767, 23, 30, 18, -2, -30 },
  { 854, 22, 30, 23, 1, -30 },
  { 937, 18, 29, 23, 3, -29 },
  { 1003, 23, 30, 23, -1, -30 },
  { 1090, 22, 30, 23, 0, -30 },
  { 1173, 23, 29, 23, 0, -29 },
  { 1257, 23, 29, 23, 0, -29 },
  { 1341, 22, 30, 23, 2, -30 },
  { 1424, 24, 29, 23, 1, -29 },
  { 1511, 22, 30, 23, 1, -30 },
  { 1594, 20, 30, 23, 2, -30 },
  { 1669, 12, 23, 12, 0, -23 },
  { 1704, 14, 28, 12, -2, -23 },
  { 1753, 20, 22, 24, 2, -26 },
  { 1808, 20, 13, 24, 2, -21 },
  { 1841, 20, 22, 24, 2, -26 },
  { 1896, 18, 31, 19, 3, -30 },
  { 1966, 33, 33, 36, 2, -29 },
  { 2103, 26, 29, 27, -2, -29 },
  { 2198, 24, 29, 26, 1, -29 },
  { 2285, 25, 30, 25, 2, -30 },
  { 2379, 26, 29, 28, 1, -29 },
  { 2474, 23, 29, 23, 1, -29 },
  { 2558, 23, 29, 23, 1, -29 },
  { 2642, 26, 30, 28, 2, -30 },
  { 2740, 28, 29, 29, 1, -29 },
  { 2842, 20, 29, 17, -1, -29 },
  { 2915, 22, 38, 14, -7, -29 },
  { 3020, 29, 29, 26, 1, -29 },
  { 3126, 18, 29, 21, 1, -29 },
  { 3192, 36, 29, 37, 1, -29 },
  { 3323, 31, 29, 32, 1, -29 },
  { 3436, 27, 30, 30, 2, -30 },
  { 3538, 24, 29, 25, 1, -29 },
  { 3625, 27, 37, 30, 2, -30 },
  { 3750, 24, 29, 26, 1, -29 },
  { 3837, 22, 30, 22, 1, -30 },
  { 3920, 22, 29, 22, 3, -29 },
  { 4000, 26, 29, 29, 3, -29 },
  { 4095, 25, 29, 25, 3, -29 },
  { 4186, 38, 29, 37, 3, -29 },
  { 4324, 31, 29, 26, -2, -29 },
  { 4437, 23, 29, 24, 4, -29 },
  { 4521, 26, 29, 22, -2, -29 },
  { 4616, 18, 37, 14, -1, -30 },
  { 4700, 11, 30, 18, 4, -30 },
  { 4742, 18, 37, 14, -3, -30 },
  { 4826, 22, 19, 22, 0, -29 },
  { 4879, 19, 4, 17, -4, 3 },
  { 4889, 9, 6, 14, 6, -31 },
  { 4896, 22, 23, 25, 2, -23 },
  { 4960, 22, 31, 25, 1, -31 },
  { 5046, 19, 23, 20, 2, -23 },
  { 5101, 24, 31, 25, 2, -31 },
  { 5194, 20, 23, 23, 2, -23 },
  { 5252, 24, 41, 16, -4, -31 },
  { 5375, 23, 33, 25, 1, -23 },
  { 5470, 22, 31, 25, 1, -31 },
  { 5556, 13, 31, 13, 1, -31 },
  { 5607, 19, 41, 13, -5, -31 },
  { 5705, 25, 31, 24, 1, -31 },
  { 5802, 13, 31, 13, 1, -31 },
  { 5853, 35, 23, 38, 1, -23 },
  { 5954, 22, 23, 25, 1, -23 },
  { 6018, 21, 23, 24, 2, -23 },
  { 6079, 24, 33, 25, -1, -23 },
  { 6178, 22, 33, 25, 2, -23 },
  { 6269, 18, 23, 18, 1, -23 },
  { 6321, 18, 23, 20, 1, -23 },
  { 6373, 16, 27, 18, 2, -27 },
  { 6427, 23, 23, 25, 2, -23 },
  { 6494, 22, 23, 22, 2, -23 },
  { 6558, 33, 23, 33, 2, -23 },
  { 6653, 27, 23, 23, -2, -23 },
  { 6731, 27, 33, 22, -3, -23 },
  { 6843, 21, 23, 20, -1, -23 },
  { 6904, 17, 35, 15, 0, -29 },
  { 6979, 5, 40, 23, 9, -31 },
  { 7004, 17, 35, 15, -2, -29 },
  { 7079, 20, 7, 24, 2, -18 },
};

const GFXfont NotoSans_ExtraBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRABOLDITALIC41PT7B_H_
