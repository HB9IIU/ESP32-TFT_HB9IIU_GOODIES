#ifndef _NOTOSANS_EXTRABOLDITALIC17PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x01, 0x8E, 0x38, 0xEF, 0x7D,
  0xB6, 0x0E, 0xC1, 0x98, 0x36, 0x3F, 0xF7, 0xFE, 0x33, 0x06, 0xC7, 0xFE,
  0xFF, 0xC6, 0xC0, 0xD8, 0x33, 0x00, 0x02, 0x03, 0xC3, 0xFC, 0xFE, 0x34,
  0x0F, 0x03, 0xE0, 0x3C, 0x0B, 0xA2, 0xEF, 0xF3, 0xF8, 0x18, 0x04, 0x00,
  0x78, 0x31, 0xF1, 0x8E, 0xCC, 0x33, 0x70, 0xDD, 0x83, 0xED, 0xE7, 0xEF,
  0xC1, 0xB7, 0x0C, 0xDC, 0x63, 0x63, 0x0F, 0x9C, 0x3C, 0x0F, 0x81, 0xFC,
  0x19, 0xC1, 0x98, 0x1F, 0x81, 0xE7, 0x7E, 0x77, 0x7E, 0xE7, 0xCF, 0x3C,
  0x7F, 0xC3, 0xEE, 0xFB, 0x60, 0x1C, 0xE3, 0x1C, 0x63, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x86, 0x00, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C,
  0x71, 0x8E, 0x31, 0x8C, 0x00, 0x0C, 0x06, 0x1B, 0x1F, 0xF1, 0xF9, 0xE1,
  0xF0, 0x4C, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x37, 0x6E,
  0x7F, 0xFE, 0x7F, 0x80, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x80, 0x3E, 0x7F, 0x77, 0xE3, 0xE3,
  0xE7, 0xE7, 0xC7, 0xC7, 0xEE, 0xFC, 0x78, 0x0F, 0x1E, 0xFE, 0x7E, 0x4E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x1F, 0x3F, 0xCC, 0xE0, 0x70,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xDF, 0xE0, 0x3F, 0x1F, 0xC4,
  0xE0, 0x70, 0x78, 0xF0, 0x7C, 0x06, 0x03, 0xC3, 0xBF, 0xDF, 0xC0, 0x03,
  0x83, 0xC3, 0xE1, 0xF1, 0xB1, 0xB9, 0xDD, 0xFF, 0xFF, 0xFF, 0xC3, 0x81,
  0xC0, 0x1F, 0xC7, 0xE3, 0x80, 0xE0, 0x3E, 0x1F, 0xC2, 0x70, 0x0E, 0x03,
  0xA1, 0xCF, 0xF3, 0xF8, 0x1F, 0x9F, 0x9C, 0x0C, 0x0E, 0xE7, 0xFB, 0x9D,
  0xCE, 0xC7, 0x77, 0xBF, 0x8F, 0x80, 0x3F, 0xCF, 0xF0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0x1F, 0x9F, 0xCE,
  0x67, 0x33, 0xF8, 0xF0, 0xFC, 0xE7, 0xE3, 0xF1, 0xDF, 0xC7, 0xC0, 0x3E,
  0x7F, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x0E, 0x1E, 0xFC, 0xF8, 0x39,
  0xC8, 0x00, 0x01, 0x9C, 0xE0, 0x1C, 0x71, 0x00, 0x00, 0x00, 0x1C, 0x71,
  0x8E, 0x00, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x3C,
  0xF0, 0xC0, 0xFE, 0x7E, 0x47, 0x06, 0x1E, 0x3C, 0x70, 0x70, 0x00, 0x60,
  0xE0, 0xE0, 0x0F, 0xE0, 0x7F, 0xC3, 0x01, 0x99, 0xF6, 0xCF, 0xCF, 0x33,
  0x3D, 0x99, 0xB6, 0x66, 0xDB, 0xBB, 0x3B, 0xCE, 0x00, 0x1C, 0x20, 0x3F,
  0x80, 0x10, 0x00, 0x03, 0xC0, 0xF8, 0x1B, 0x07, 0x60, 0xEC, 0x39, 0x87,
  0x31, 0xFF, 0x3F, 0xEE, 0x1D, 0xC3, 0xF0, 0x70, 0x1F, 0x87, 0xF3, 0x9C,
  0xE7, 0x39, 0xCF, 0xC3, 0xF9, 0xC7, 0x71, 0xDC, 0xE7, 0xFB, 0xF8, 0x1F,
  0xCF, 0xF7, 0x89, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x47,
  0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0xE7, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x3B,
  0x87, 0x71, 0xCE, 0xF9, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF3, 0x80, 0xE0,
  0x38, 0x8F, 0xC3, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0xF3, 0xF8, 0x1F, 0xC7,
  0xF3, 0x80, 0xE0, 0x38, 0x0F, 0xE3, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0x0F, 0xE7, 0xF9, 0xE1, 0x38, 0x0E, 0x01, 0xCF, 0xB9, 0xF7, 0x0E,
  0xE3, 0x9E, 0x71, 0xFE, 0x1F, 0xC0, 0x1C, 0x71, 0x87, 0x38, 0x73, 0x8E,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0x0C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x1C,
  0x1F, 0x8F, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1F,
  0x9F, 0x80, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xC7, 0xE3, 0xE1, 0xE0, 0x1C, 0xF1, 0x8E, 0x39,
  0xC3, 0xB8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0x70, 0x77, 0x87, 0x38, 0x73,
  0x8E, 0x3C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x7F, 0xFE, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0xF9, 0xF1, 0xE3, 0x66, 0xC6,
  0xCF, 0x8D, 0xB7, 0x3B, 0x6E, 0x77, 0x98, 0xCF, 0x31, 0x9C, 0xE7, 0x39,
  0xC0, 0x1C, 0x38, 0xF1, 0xCF, 0x8E, 0x7C, 0x63, 0x73, 0x1B, 0xB8, 0xCD,
  0xCE, 0x7E, 0x73, 0xE3, 0x0F, 0x18, 0x79, 0xC3, 0xC0, 0x1F, 0x87, 0xF9,
  0xE7, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDE, 0x79, 0xFE,
  0x1F, 0x00, 0x1F, 0x87, 0xF3, 0x9C, 0xE3, 0x39, 0xCF, 0xF3, 0xF9, 0xF8,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDE, 0x71, 0xFE, 0x1F, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1F, 0x87, 0xF3, 0x9C, 0xE7, 0x39, 0xCF, 0xF3, 0xF1, 0xDC,
  0x77, 0x1C, 0xE7, 0x3B, 0x87, 0x1F, 0x9F, 0xCE, 0x27, 0x03, 0x81, 0xF0,
  0x78, 0x0E, 0x07, 0x63, 0xBF, 0x9F, 0x80, 0x7F, 0xFF, 0xC7, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x00, 0x38, 0xE6, 0x1D,
  0xC3, 0x38, 0xE7, 0x1C, 0xE3, 0xB8, 0x77, 0x1C, 0xE3, 0x9C, 0xF1, 0xFC,
  0x1F, 0x00, 0xE1, 0xEC, 0x39, 0x8E, 0x31, 0xC6, 0x30, 0xCE, 0x19, 0x83,
  0xF0, 0x6C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xE1, 0x87, 0xE3, 0x86, 0xE3,
  0xCE, 0x67, 0xCC, 0x67, 0xDC, 0x6F, 0xDC, 0x6D, 0xF8, 0x6D, 0xF8, 0x7D,
  0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x71, 0xE0, 0x1C, 0x78, 0xE3, 0x83, 0xB8,
  0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x1D, 0xC1, 0xCE, 0x1C,
  0x71, 0xE3, 0xC0, 0xF1, 0xDC, 0xE7, 0x39, 0xDC, 0x3E, 0x0F, 0x83, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xFE, 0x7F, 0xC0, 0x1E,
  0x7C, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x1E, 0x3C,
  0x00, 0xCC, 0xEE, 0x66, 0x66, 0x77, 0x33, 0x1E, 0x3C, 0x38, 0x60, 0xC1,
  0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x1E, 0x3C, 0x00, 0x06, 0x07, 0x03,
  0x83, 0x63, 0x31, 0x99, 0x87, 0xC3, 0x7F, 0xFF, 0xF7, 0x30, 0x10, 0x1F,
  0xDF, 0xFC, 0xEE, 0x77, 0x3B, 0x9D, 0xDE, 0xFE, 0x3B, 0x00, 0x1C, 0x0E,
  0x0E, 0x07, 0x43, 0xF9, 0xFC, 0xE6, 0xE3, 0x73, 0xB9, 0xDD, 0xEF, 0xEF,
  0xE0, 0x08, 0x3F, 0x7E, 0xE0, 0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C, 0x01,
  0xC0, 0x60, 0x38, 0x4E, 0x3F, 0x9F, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0xE3, 0xF8, 0x76, 0x00, 0x08, 0x3F, 0x7F, 0xE7, 0xEF, 0xFE, 0xE0, 0xE2,
  0xFE, 0x7E, 0x03, 0xC1, 0xF0, 0x70, 0x1C, 0x1F, 0x87, 0xE0, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xE0, 0xF0, 0x00,
  0x08, 0x07, 0xF3, 0xFD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xDE, 0x7F, 0x0F,
  0xC0, 0x72, 0x3C, 0xFE, 0x3F, 0x00, 0x1C, 0x07, 0x03, 0x80, 0xE4, 0x3F,
  0x8F, 0xF3, 0x9D, 0xC6, 0x73, 0x9C, 0xE7, 0x39, 0x8E, 0xE7, 0x00, 0x1C,
  0x71, 0x80, 0x38, 0xE3, 0x1C, 0x71, 0xC7, 0x18, 0xE0, 0x07, 0x07, 0x06,
  0x00, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38,
  0xF0, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x13, 0x9C, 0x77, 0x0D, 0xC3,
  0xF0, 0x7E, 0x0F, 0xE1, 0xDC, 0x33, 0x8E, 0x38, 0x1C, 0x73, 0x8E, 0x38,
  0xE3, 0x1C, 0x71, 0xC7, 0x18, 0xE0, 0x01, 0x08, 0x6F, 0x78, 0xFF, 0xF9,
  0xCE, 0x77, 0x18, 0xEE, 0x71, 0x9C, 0xE7, 0x39, 0xCE, 0x63, 0x9D, 0xCE,
  0x38, 0x01, 0x0D, 0xE3, 0xFC, 0xE7, 0x71, 0x9C, 0xE7, 0x39, 0xCE, 0x63,
  0xB9, 0xC0, 0x08, 0x3E, 0x7F, 0xE7, 0xE3, 0xE7, 0xE7, 0xE7, 0xFE, 0x7C,
  0x01, 0x06, 0xF1, 0xFC, 0x73, 0x38, 0xCE, 0x73, 0x9C, 0xEF, 0x3F, 0x9D,
  0xC7, 0x01, 0xC0, 0x70, 0x38, 0x00, 0x10, 0x1F, 0xDF, 0xFC, 0xEE, 0x77,
  0x3B, 0x9D, 0xDE, 0xFE, 0x3F, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x09, 0x37,
  0x3F, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x08, 0x3F, 0x7E, 0x70,
  0x7C, 0x3E, 0x0E, 0x8E, 0xFE, 0xFC, 0x38, 0x67, 0xF7, 0xE7, 0x0C, 0x38,
  0x70, 0xE1, 0xF3, 0xE0, 0x73, 0xB9, 0xD8, 0xFC, 0x6E, 0x77, 0x3B, 0xBD,
  0xFE, 0x76, 0x00, 0xE3, 0xF3, 0xB9, 0x9D, 0xCE, 0xC3, 0xE1, 0xE0, 0xF0,
  0x70, 0x00, 0xE7, 0x3F, 0xBC, 0xEE, 0xF3, 0x3B, 0xDC, 0xFB, 0x63, 0xEF,
  0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0x80, 0x3D, 0xE3, 0xB8, 0x7E, 0x07, 0x80,
  0xE0, 0x3E, 0x0E, 0xC3, 0x9C, 0xF3, 0x80, 0x38, 0xE7, 0x38, 0xE6, 0x1D,
  0xC3, 0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x7C, 0x0E,
  0x00, 0x3F, 0x7F, 0x0E, 0x1C, 0x38, 0x78, 0x70, 0xFE, 0xFE, 0x0E, 0x3C,
  0x60, 0xC1, 0x87, 0x3C, 0x70, 0x70, 0xE1, 0xC3, 0x07, 0x0E, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x78, 0x30, 0xE1, 0xC3, 0x87, 0x87,
  0x3C, 0x70, 0xC1, 0x87, 0x1C, 0x30, 0x00, 0x41, 0xFF, 0xFF, 0x84,
};

const GFXglyph NotoSans_ExtraBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 12, 5, 0, -12 },
  { 10, 6, 4, 8, 2, -12 },
  { 13, 11, 12, 11, 0, -12 },
  { 30, 10, 14, 10, 0, -13 },
  { 48, 14, 12, 15, 1, -12 },
  { 69, 12, 12, 12, 0, -12 },
  { 87, 3, 4, 4, 2, -12 },
  { 89, 6, 15, 6, 1, -12 },
  { 101, 6, 15, 6, -1, -12 },
  { 113, 9, 8, 9, 1, -13 },
  { 122, 8, 8, 10, 1, -10 },
  { 130, 4, 4, 5, -1, -2 },
  { 132, 5, 3, 6, 0, -6 },
  { 134, 3, 3, 5, 0, -3 },
  { 136, 10, 12, 8, -1, -12 },
  { 151, 8, 12, 10, 1, -12 },
  { 163, 8, 12, 10, 1, -12 },
  { 175, 9, 12, 10, 0, -12 },
  { 189, 9, 12, 10, 0, -12 },
  { 203, 9, 12, 10, 0, -12 },
  { 217, 10, 12, 10, 0, -12 },
  { 232, 9, 12, 10, 1, -12 },
  { 246, 10, 12, 10, 0, -12 },
  { 261, 9, 12, 10, 0, -12 },
  { 275, 8, 12, 10, 1, -12 },
  { 287, 5, 9, 5, 0, -9 },
  { 293, 6, 11, 5, -1, -9 },
  { 302, 8, 9, 10, 1, -11 },
  { 311, 8, 6, 10, 1, -9 },
  { 317, 8, 9, 10, 1, -11 },
  { 326, 8, 12, 8, 1, -12 },
  { 338, 14, 14, 15, 1, -12 },
  { 363, 11, 12, 11, -1, -12 },
  { 380, 10, 12, 11, 0, -12 },
  { 395, 10, 12, 11, 1, -12 },
  { 410, 11, 12, 12, 0, -12 },
  { 427, 10, 12, 9, 0, -12 },
  { 442, 10, 12, 9, 0, -12 },
  { 457, 11, 12, 12, 1, -12 },
  { 474, 12, 12, 12, 0, -12 },
  { 492, 9, 12, 7, -1, -12 },
  { 506, 9, 16, 6, -3, -12 },
  { 524, 12, 12, 11, 0, -12 },
  { 542, 8, 12, 9, 0, -12 },
  { 554, 15, 12, 15, 0, -12 },
  { 577, 13, 12, 13, 0, -12 },
  { 597, 11, 12, 12, 1, -12 },
  { 614, 10, 12, 10, 0, -12 },
  { 629, 11, 15, 12, 1, -12 },
  { 650, 10, 12, 11, 0, -12 },
  { 665, 9, 12, 9, 0, -12 },
  { 679, 9, 12, 9, 1, -12 },
  { 693, 11, 12, 12, 1, -12 },
  { 710, 11, 12, 10, 1, -12 },
  { 727, 16, 12, 16, 1, -12 },
  { 751, 13, 12, 11, -1, -12 },
  { 771, 10, 12, 10, 1, -12 },
  { 786, 11, 12, 9, -1, -12 },
  { 803, 7, 15, 6, 0, -12 },
  { 817, 4, 12, 8, 2, -12 },
  { 823, 7, 15, 6, -1, -12 },
  { 837, 9, 8, 9, 0, -12 },
  { 846, 8, 2, 7, -2, 1 },
  { 848, 4, 3, 6, 2, -13 },
  { 850, 9, 10, 10, 1, -10 },
  { 862, 9, 13, 10, 0, -13 },
  { 877, 8, 10, 8, 1, -10 },
  { 887, 10, 13, 10, 1, -13 },
  { 904, 8, 10, 10, 1, -10 },
  { 914, 10, 17, 7, -2, -13 },
  { 936, 10, 14, 10, 0, -10 },
  { 954, 10, 13, 10, 0, -13 },
  { 971, 6, 13, 5, 0, -13 },
  { 981, 8, 17, 5, -2, -13 },
  { 998, 11, 13, 10, 0, -13 },
  { 1016, 6, 13, 5, 0, -13 },
  { 1026, 15, 10, 16, 0, -10 },
  { 1045, 10, 10, 10, 0, -10 },
  { 1058, 8, 10, 10, 1, -10 },
  { 1068, 10, 14, 10, -1, -10 },
  { 1086, 9, 14, 10, 1, -10 },
  { 1102, 8, 10, 7, 0, -10 },
  { 1112, 8, 10, 8, 0, -10 },
  { 1122, 7, 11, 7, 1, -11 },
  { 1132, 9, 9, 10, 1, -9 },
  { 1143, 9, 9, 9, 1, -9 },
  { 1154, 14, 9, 14, 1, -9 },
  { 1170, 11, 9, 9, -1, -9 },
  { 1183, 11, 13, 9, -1, -9 },
  { 1201, 8, 9, 8, 0, -9 },
  { 1210, 7, 15, 6, 0, -12 },
  { 1224, 2, 17, 9, 4, -13 },
  { 1229, 7, 15, 6, -1, -12 },
  { 1243, 8, 4, 10, 1, -8 },
};

const GFXfont NotoSans_ExtraBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRABOLDITALIC17PT7B_H_
