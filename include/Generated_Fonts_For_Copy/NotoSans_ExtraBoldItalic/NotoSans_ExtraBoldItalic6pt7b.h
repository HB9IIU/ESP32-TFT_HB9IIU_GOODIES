#ifndef _NOTOSANS_EXTRABOLDITALIC6PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0xC0, 0x5F, 0xFA, 0x2D, 0x3E, 0xFE, 0xCE, 0xB0, 0x66, 0xBF,
  0x80, 0x72, 0x48, 0x55, 0x80, 0x3D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x29, 0x40, 0x76, 0xF0, 0xE5, 0x20, 0x65, 0x70, 0x6C, 0xF0, 0x2F, 0xB0,
  0x7C, 0xF0, 0x7E, 0xF0, 0x72, 0x4C, 0x6E, 0xF0, 0x75, 0xE0, 0x48, 0x4A,
  0x39, 0x80, 0xFC, 0x8F, 0x00, 0xED, 0x60, 0x7D, 0xF7, 0x47, 0x00, 0x66,
  0xEB, 0x76, 0xAE, 0x78, 0x86, 0x75, 0x9E, 0x76, 0x8E, 0x6E, 0x40, 0x7E,
  0x96, 0x57, 0x9A, 0x69, 0x60, 0x24, 0xAC, 0x56, 0xAA, 0x4A, 0x70, 0x4A,
  0xEB, 0x50, 0x4B, 0xAD, 0x60, 0x7D, 0x96, 0x77, 0xC8, 0x7D, 0x96, 0x30,
  0x76, 0xAA, 0x68, 0xF0, 0xF4, 0x44, 0x55, 0x96, 0xD6, 0x64, 0xB6, 0xE5,
  0x94, 0x56, 0x6A, 0xFA, 0x40, 0x76, 0x4E, 0x5A, 0x80, 0xF0, 0x56, 0x80,
  0x6E, 0x80, 0xE0, 0x80, 0x7A, 0xE0, 0x49, 0xDE, 0x73, 0x80, 0x11, 0x6A,
  0xE0, 0x7F, 0x80, 0x13, 0x62, 0x4C, 0x7A, 0xEE, 0x49, 0xDA, 0x46, 0x80,
  0x20, 0xA5, 0x80, 0x45, 0x6E, 0xA0, 0x56, 0x80, 0x7D, 0x6A, 0x76, 0x80,
  0x77, 0x80, 0x77, 0xC0, 0x7A, 0xE6, 0x72, 0x00, 0xEF, 0x00, 0x5E, 0x60,
  0x7A, 0xE0, 0xBA, 0x40, 0xAE, 0xBC, 0xF4, 0xA0, 0xBA, 0x48, 0xEB, 0x00,
  0x6A, 0x4C, 0xFC, 0xD6, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 3, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 4, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 2, 3, 2, 0, -3 },
  { 47, 2, 4, 2, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 5, 5, 5, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 4, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 3, 4, 2, 0, -4 },
  { 77, 3, 5, 2, -1, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 5, 4, 5, 0, -4 },
  { 86, 5, 4, 5, 0, -4 },
  { 89, 4, 4, 4, 0, -4 },
  { 91, 4, 4, 4, 0, -4 },
  { 93, 4, 5, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 4, 4, 3, 0, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 6, 4, 5, 0, -4 },
  { 109, 4, 4, 4, 0, -4 },
  { 111, 3, 4, 3, 1, -4 },
  { 113, 4, 4, 3, 0, -4 },
  { 115, 2, 5, 2, 0, -4 },
  { 117, 1, 4, 3, 1, -4 },
  { 118, 2, 5, 2, 0, -4 },
  { 120, 3, 3, 3, 0, -4 },
  { 122, 3, 1, 3, -1, 0 },
  { 123, 1, 1, 2, 1, -5 },
  { 124, 4, 3, 4, 0, -3 },
  { 126, 3, 5, 4, 0, -5 },
  { 128, 3, 3, 3, 0, -3 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 4, 6, 2, -1, -5 },
  { 138, 4, 4, 4, 0, -3 },
  { 140, 3, 5, 4, 0, -5 },
  { 142, 2, 5, 2, 0, -5 },
  { 144, 3, 6, 2, -1, -5 },
  { 147, 4, 5, 4, 0, -5 },
  { 150, 2, 5, 2, 0, -5 },
  { 152, 5, 3, 5, 0, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 3, 4, 4, 0, -3 },
  { 160, 4, 4, 4, 0, -3 },
  { 162, 3, 3, 3, 0, -3 },
  { 164, 3, 3, 3, 0, -3 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 4, 3, 4, 0, -3 },
  { 170, 4, 3, 3, 0, -3 },
  { 172, 5, 3, 5, 0, -3 },
  { 174, 4, 3, 3, 0, -3 },
  { 176, 4, 4, 3, 0, -3 },
  { 178, 3, 3, 3, 0, -3 },
  { 180, 3, 5, 2, 0, -4 },
  { 182, 1, 6, 3, 1, -5 },
  { 183, 2, 5, 2, 0, -4 },
  { 185, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRABOLDITALIC6PT7B_H_
