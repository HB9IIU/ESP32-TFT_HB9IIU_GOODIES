#ifndef _NOTOSANS_EXTRABOLDITALIC46PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0x10, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xF3, 0xF1, 0xFD,
  0xFC, 0x7E, 0x7F, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x07,
  0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0xFC, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0x07,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xDF, 0x03, 0xF9, 0xC1, 0x83, 0xFC, 0xE0, 0x01, 0xFE, 0x70,
  0x00, 0x7F, 0x78, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xF7, 0xF8, 0x00, 0x7B, 0xFC, 0x00,
  0x38, 0xFE, 0x40, 0x1C, 0xFE, 0x3C, 0x0E, 0x7F, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0x80, 0x7F, 0xFC, 0x00,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x9F, 0x80, 0xFC, 0x01, 0xF8,
  0xFC, 0x07, 0xC0, 0x1F, 0xC7, 0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0x07, 0xE0,
  0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC,
  0x3F, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x3F, 0x1F, 0xC3,
  0xF3, 0xF9, 0xF9, 0xFF, 0x9F, 0xFF, 0x9F, 0x9F, 0xFC, 0xFF, 0xF9, 0xF9,
  0xFF, 0xF3, 0xFF, 0xDF, 0x9F, 0xFF, 0x9F, 0xFC, 0xFC, 0xFC, 0xFC, 0x3F,
  0x8F, 0xCF, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x7E,
  0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xF1, 0xFC,
  0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0xFF, 0xFE, 0x03, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0x80, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF7, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0xF0,
  0x07, 0xFF, 0x0F, 0xF8, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7E, 0x01, 0xE1,
  0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xF3, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xBF, 0x01, 0xFC, 0x7C, 0x01, 0xF1,
  0xF8, 0x03, 0x87, 0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF8, 0x04, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF,
  0x7F, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xF7, 0xF1, 0xFC, 0xFE, 0x1E, 0x3F, 0xC3, 0x87,
  0xF8, 0x40, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xCF, 0xFC,
  0x07, 0x80, 0xFF, 0x00, 0xC0, 0x3F, 0xC0, 0x20, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0x83, 0xFE, 0x03,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x40, 0x01, 0xFF, 0x3C, 0x01,
  0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xE1, 0xFE, 0x07, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x40,
  0x03, 0xFE, 0x38, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x87,
  0x00, 0x7F, 0x9F, 0xE0, 0x7F, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xE7, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0x87, 0xF8,
  0x3F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xFC, 0xFF,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF8, 0xFF, 0x87,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF,
  0x1F, 0xE0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFC, 0x07, 0xFB,
  0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x7F, 0xDF, 0xE0, 0xFF, 0xBF,
  0xE7, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xEF, 0xE0, 0xFF, 0xBF, 0xC0, 0x7C, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC2, 0x01, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x07,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0x04, 0x00, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3E, 0x0F, 0xF1, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0xC7, 0xE0,
  0x7F, 0xFC, 0x7E, 0x7E, 0x0F, 0xFF, 0xE1, 0xF3, 0xE0, 0xFF, 0xFF, 0x0F,
  0xBF, 0x0F, 0xF1, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0x83, 0xEF, 0x87, 0xE0,
  0x7C, 0x1F, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xE3, 0xF0, 0x3F, 0x07, 0xFF,
  0x1F, 0x81, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0x87, 0xE0, 0xFC,
  0x1F, 0x7C, 0x3F, 0x07, 0xE1, 0xFB, 0xE1, 0xF8, 0x7E, 0x1F, 0x9F, 0x8F,
  0xC7, 0xF9, 0xFC, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xE1, 0xFF, 0xFF, 0xFC,
  0x1F, 0x0F, 0xFC, 0xFF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x03,
  0xFC, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xF1,
  0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xE0,
  0xFF, 0xC0, 0x1C, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0x03, 0xFF, 0x81, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC1, 0xFC,
  0x0F, 0xFC, 0x1F, 0xE7, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0x80, 0x0C, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xEF, 0xF0, 0x3F, 0xFE,
  0xFF, 0x07, 0xFF, 0xCF, 0xF0, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0xCF, 0xF0,
  0x7F, 0xFC, 0xFE, 0x08, 0x3F, 0xCF, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0xF0, 0x7F,
  0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07,
  0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFD, 0xFC, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x0F, 0xEF, 0xC1, 0xFB,
  0xF8, 0x0F, 0xEF, 0xC3, 0xF3, 0xF8, 0x1F, 0xCF, 0xC3, 0xF3, 0xF8, 0x1F,
  0xCF, 0xC7, 0xE3, 0xF8, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0, 0x1F, 0xCF, 0xCF,
  0xC7, 0xF0, 0x1F, 0xCF, 0xCF, 0xC7, 0xF0, 0x3F, 0x8F, 0xDF, 0x87, 0xF0,
  0x3F, 0x8F, 0xDF, 0x87, 0xF0, 0x3F, 0x8F, 0xFF, 0x0F, 0xE0, 0x3F, 0x8F,
  0xFF, 0x0F, 0xE0, 0x3F, 0x8F, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xFC, 0x1F, 0xC0, 0x7F,
  0x0F, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0,
  0x0F, 0xE0, 0x3F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0xFD,
  0xFC, 0x07, 0xF0, 0x1F, 0xBF, 0x80, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x80,
  0xFE, 0x7F, 0x07, 0xF0, 0x1F, 0xCF, 0xE0, 0xFE, 0x03, 0xF9, 0xFC, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x1F, 0xC0, 0x7F, 0x0F, 0xF3, 0xF8, 0x0F, 0xE0, 0xFE, 0x7F, 0x01, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFC, 0x07, 0xF0, 0x07,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x3F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE,
  0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFF,
  0x00, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x04, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x80, 0x07, 0xF8,
  0xC0, 0x0F, 0xF0, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8,
  0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xF0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x81,
  0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0x7C,
  0x0F, 0xE0, 0xFE, 0x0F, 0xDF, 0x07, 0xF8, 0x3F, 0x83, 0xF7, 0xE1, 0xFC,
  0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x7E, 0x3F, 0x80, 0xFE,
  0x3F, 0x9F, 0x8F, 0xE0, 0x3F, 0x8F, 0xC7, 0xE7, 0xF8, 0x0F, 0xE7, 0xF1,
  0xF9, 0xFC, 0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x1F, 0xBF,
  0x80, 0x1F, 0xBF, 0x87, 0xEF, 0xE0, 0x07, 0xEF, 0xC1, 0xFF, 0xF0, 0x01,
  0xFB, 0xF0, 0x7D, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0x7E, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F,
  0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x3F,
  0xC7, 0xF0, 0xFE, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0x0F, 0xC0, 0xFF, 0xCF, 0xE0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7,
  0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xE0, 0x3F, 0xF3,
  0xF0, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x70,
  0x01, 0xFC, 0xFF, 0x00, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x1F,
  0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7E, 0x7F, 0xF0, 0x3F, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xEF, 0x87, 0xFC, 0x04, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x11, 0xFF, 0x03, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0x0F, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07,
  0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F,
  0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xF0, 0x07, 0xFE, 0x7E, 0x00, 0x7F,
  0x8F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F,
  0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01,
  0x07, 0xFC, 0x3E, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x08, 0x7F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x1F, 0xF9, 0xFC, 0x0F, 0xFF, 0x7E,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1,
  0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xEF, 0xE0, 0x1F, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x20, 0x03, 0xFC,
  0x0E, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x38, 0x01, 0xFC, 0xFF, 0x00, 0xFE,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFD, 0xFF, 0x0F, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x07,
  0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80,
  0xFF, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x23, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x41,
  0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01,
  0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0xC7, 0xF8, 0x1F, 0xE0, 0x1F, 0x9F,
  0xF8, 0x7F, 0xE0, 0x7F, 0x7F, 0xF9, 0xFF, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xFE, 0xFF, 0x87, 0xFC,
  0x3F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0xFF,
  0x03, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0x3F, 0x80, 0xFE, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xF1,
  0xFE, 0x01, 0xF9, 0xFF, 0x81, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFB, 0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF1,
  0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xE3, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03,
  0xFC, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFC,
  0xFF, 0x9F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03,
  0xFB, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7,
  0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xE1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xE0, 0x1F, 0xCF, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x0F,
  0xC0, 0xFF, 0xCF, 0xE0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7, 0xF8,
  0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x7F,
  0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xF0,
  0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x1F, 0xDF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xC0, 0xE3, 0xFC, 0x04, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC8, 0x03,
  0xFC, 0xF8, 0x7F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x43, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x84, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0,
  0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0xCF, 0xE0,
  0x1F, 0xE3, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xC0,
  0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F,
  0xC3, 0xF8, 0x07, 0xE3, 0xFC, 0x03, 0xF1, 0xFC, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFE, 0x07, 0xFC, 0x0F,
  0xEF, 0xE0, 0xFF, 0xC1, 0xFE, 0xFE, 0x0F, 0xFC, 0x1F, 0xCF, 0xE1, 0xFF,
  0xC3, 0xFC, 0xFE, 0x1F, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xC7, 0xF8, 0xFE,
  0x3F, 0xFC, 0x7F, 0x0F, 0xE3, 0xEF, 0xC7, 0xF0, 0xFE, 0x7E, 0xFC, 0xFE,
  0x0F, 0xE7, 0xCF, 0xCF, 0xE0, 0xFE, 0xFC, 0xFD, 0xFC, 0x0F, 0xEF, 0xCF,
  0xDF, 0xC0, 0xFE, 0xF8, 0xFD, 0xF8, 0x0F, 0xFF, 0x8F, 0xBF, 0x80, 0xFF,
  0xF8, 0xFB, 0xF8, 0x0F, 0xFF, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xF9, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0xFF,
  0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x02, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x40, 0x01,
  0xF8,
};

const GFXglyph NotoSans_ExtraBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 34, 14, 0, -33 },
  { 65, 18, 12, 21, 4, -33 },
  { 92, 29, 33, 30, 1, -33 },
  { 212, 25, 38, 26, 1, -35 },
  { 331, 37, 33, 41, 3, -33 },
  { 484, 32, 33, 33, 1, -33 },
  { 616, 9, 12, 11, 4, -33 },
  { 630, 18, 40, 16, 2, -33 },
  { 720, 18, 41, 16, -3, -34 },
  { 813, 22, 22, 25, 4, -35 },
  { 874, 23, 22, 27, 2, -27 },
  { 938, 11, 11, 14, -2, -5 },
  { 954, 13, 6, 15, 1, -15 },
  { 964, 9, 9, 14, 0, -8 },
  { 975, 26, 33, 20, -2, -33 },
  { 1083, 24, 33, 26, 1, -33 },
  { 1182, 19, 33, 26, 4, -33 },
  { 1261, 26, 33, 26, -1, -33 },
  { 1369, 25, 33, 26, 0, -33 },
  { 1473, 25, 33, 26, 0, -33 },
  { 1577, 25, 33, 26, 1, -33 },
  { 1681, 24, 33, 26, 2, -33 },
  { 1780, 27, 33, 26, 1, -33 },
  { 1892, 25, 33, 26, 1, -33 },
  { 1996, 23, 33, 26, 2, -33 },
  { 2091, 13, 27, 14, 0, -26 },
  { 2135, 16, 32, 14, -3, -26 },
  { 2199, 23, 25, 27, 2, -29 },
  { 2271, 23, 15, 27, 2, -24 },
  { 2315, 23, 25, 27, 2, -29 },
  { 2387, 20, 34, 22, 3, -33 },
  { 2472, 37, 37, 40, 2, -33 },
  { 2644, 30, 33, 30, -3, -33 },
  { 2768, 27, 33, 29, 1, -33 },
  { 2880, 27, 33, 29, 3, -33 },
  { 2992, 29, 33, 31, 1, -33 },
  { 3112, 26, 33, 25, 1, -33 },
  { 3220, 26, 33, 25, 1, -33 },
  { 3328, 28, 33, 32, 3, -33 },
  { 3444, 32, 33, 33, 1, -33 },
  { 3576, 22, 33, 19, -1, -33 },
  { 3667, 23, 43, 16, -7, -33 },
  { 3791, 32, 33, 29, 1, -33 },
  { 3923, 20, 33, 24, 1, -33 },
  { 4006, 40, 33, 41, 1, -33 },
  { 4171, 35, 33, 36, 1, -33 },
  { 4316, 29, 33, 34, 3, -33 },
  { 4436, 27, 33, 28, 1, -33 },
  { 4548, 29, 41, 34, 3, -33 },
  { 4697, 27, 33, 29, 1, -33 },
  { 4809, 24, 33, 25, 1, -33 },
  { 4908, 24, 33, 25, 4, -33 },
  { 5007, 29, 33, 32, 3, -33 },
  { 5127, 28, 33, 28, 4, -33 },
  { 5243, 42, 33, 42, 4, -33 },
  { 5417, 36, 33, 29, -3, -33 },
  { 5566, 27, 33, 27, 4, -33 },
  { 5678, 29, 33, 25, -2, -33 },
  { 5798, 20, 41, 16, -1, -33 },
  { 5901, 12, 33, 20, 5, -33 },
  { 5951, 20, 41, 16, -3, -33 },
  { 6054, 24, 22, 25, 0, -33 },
  { 6120, 20, 4, 19, -4, 4 },
  { 6130, 10, 7, 16, 7, -35 },
  { 6139, 25, 26, 28, 2, -26 },
  { 6221, 25, 35, 28, 1, -35 },
  { 6331, 21, 26, 23, 2, -26 },
  { 6400, 27, 35, 28, 2, -35 },
  { 6519, 23, 26, 26, 2, -26 },
  { 6594, 28, 46, 18, -5, -35 },
  { 6755, 26, 37, 28, 1, -26 },
  { 6876, 25, 35, 28, 1, -35 },
  { 6986, 14, 35, 14, 1, -35 },
  { 7048, 22, 46, 14, -6, -35 },
  { 7175, 29, 35, 27, 1, -35 },
  { 7302, 15, 35, 14, 1, -35 },
  { 7368, 39, 26, 42, 1, -26 },
  { 7495, 25, 26, 28, 1, -26 },
  { 7577, 23, 26, 27, 2, -26 },
  { 7652, 28, 37, 28, -2, -26 },
  { 7782, 25, 37, 28, 2, -26 },
  { 7898, 21, 26, 20, 1, -26 },
  { 7967, 20, 26, 22, 1, -26 },
  { 8032, 19, 31, 20, 2, -31 },
  { 8106, 26, 25, 28, 2, -25 },
  { 8188, 25, 25, 24, 2, -25 },
  { 8267, 36, 25, 37, 3, -25 },
  { 8380, 30, 25, 25, -2, -25 },
  { 8474, 30, 36, 24, -3, -25 },
  { 8609, 24, 25, 22, -1, -25 },
  { 8684, 20, 40, 16, 0, -33 },
  { 8784, 6, 45, 26, 10, -35 },
  { 8818, 20, 40, 16, -3, -33 },
  { 8918, 23, 8, 27, 2, -20 },
};

const GFXfont NotoSans_ExtraBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRABOLDITALIC46PT7B_H_
