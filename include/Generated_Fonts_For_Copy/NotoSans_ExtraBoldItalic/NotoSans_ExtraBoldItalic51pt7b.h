#ifndef _NOTOSANS_EXTRABOLDITALIC51PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x7F, 0x8F, 0xF7, 0xF8,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E,
  0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF0, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x47, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0x9C, 0x18, 0x0F, 0xF3, 0xC0, 0x00, 0xFF, 0x3C, 0x00, 0x0F,
  0xF3, 0xC0, 0x00, 0xFF, 0xBC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xE7, 0xF8, 0x00, 0x1E, 0x7F, 0x80, 0x01, 0xE7, 0xF8,
  0xC0, 0x1E, 0x7F, 0x8F, 0x01, 0xC7, 0xF8, 0xFF, 0x9D, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x7E, 0x00, 0x7F,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x3F, 0x8F, 0xF0, 0xFE,
  0x7F, 0x1F, 0x8F, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF, 0xFF, 0xBF, 0xFF, 0x9F,
  0xCF, 0xFF, 0xCF, 0xFF, 0xDF, 0xCF, 0xFF, 0xE3, 0xFF, 0xCF, 0xC7, 0xF3,
  0xF8, 0xFF, 0x8F, 0xE7, 0xF1, 0xFC, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x00,
  0x07, 0xE3, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x0F, 0xC3, 0xF8, 0x03,
  0xF8, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0x1F,
  0xF9, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xF7, 0xF8, 0xFF, 0x83, 0xFF, 0xFF,
  0x1F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F,
  0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF9, 0xFF,
  0x00, 0x3F, 0xFC, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xBF,
  0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F,
  0x80, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0x80, 0xFC, 0x00,
  0xF0, 0x7E, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0xDF, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x0E, 0x0F, 0xFF, 0x80, 0x0F, 0xF7,
  0xE0, 0x0F, 0xF3, 0xF0, 0x0F, 0xF9, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x78,
  0x3F, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xFE, 0x00, 0x1F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFC, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF3, 0xFE, 0x03,
  0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x03, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F,
  0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x7F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xBF, 0xC7, 0xFD, 0xFF, 0x0F,
  0xC7, 0xF8, 0x1E, 0x1F, 0xE0, 0x60, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7,
  0xFE, 0x00, 0xF8, 0x1F, 0xF8, 0x07, 0x00, 0x7F, 0xC0, 0x10, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0x03, 0xFF, 0x00, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x80, 0x00, 0xFF, 0x8E, 0x00, 0x1F, 0xF8, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x80,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x78, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x08, 0x00, 0x1F, 0xF0, 0xE0, 0x07, 0xFF, 0x0F,
  0xE7, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x02, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x87, 0xE0, 0x0F, 0xF3, 0xFF, 0x03, 0xFD, 0xFF, 0xF0, 0x7F, 0xBF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFE, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F,
  0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xF9, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0xCF, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC3, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7, 0xF8,
  0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC1, 0xFF, 0x9F, 0xF8, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xDF,
  0xE0, 0xFF, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x00, 0x61, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0x81, 0xFF, 0x38, 0x07, 0xFC,
  0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFF, 0xFC, 0x7E, 0x1F,
  0x80, 0xFF, 0xFE, 0x1F, 0x8F, 0xE0, 0x7F, 0xFF, 0x87, 0xE3, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFC, 0xFC, 0x1F, 0xE1, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xDF, 0x83, 0xF0, 0x3F, 0x03, 0xF7, 0xE1, 0xFC, 0x0F, 0xC1, 0xF9,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xBF, 0x0F,
  0xE0, 0x7E, 0x07, 0xEF, 0xC3, 0xF0, 0x1F, 0x81, 0xFB, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFC, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F,
  0x8F, 0xC3, 0xF8, 0xFF, 0x9F, 0xE3, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7E,
  0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0x07, 0xF0, 0x7F,
  0x87, 0xFC, 0x01, 0xFC, 0x07, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x3F, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x0F,
  0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xFE, 0x00, 0x70, 0x3F, 0xF8, 0x00, 0x20,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x10, 0x0F, 0xFC, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x20, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0x00, 0x38, 0x1F,
  0xFC, 0x00, 0x08, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xFC, 0xFF,
  0x81, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xF8, 0xFF,
  0x83, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x02, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x2F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x01,
  0xFB, 0xFC, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xE0, 0x1F, 0xDF, 0xC0, 0xFC,
  0xFF, 0x01, 0xFE, 0xFE, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F,
  0x80, 0x7F, 0xBF, 0x87, 0xF3, 0xFC, 0x03, 0xF8, 0xFC, 0x3F, 0x9F, 0xE0,
  0x1F, 0xC7, 0xE3, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x1F, 0xC7, 0xF0, 0x0F,
  0xF1, 0xF9, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xCF, 0xE3, 0xFC, 0x03, 0xF8,
  0x7E, 0x7E, 0x1F, 0xE0, 0x3F, 0xC3, 0xF7, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xBF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xFF,
  0x83, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xC0,
  0xFE, 0x01, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0x7F, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x80, 0x7F,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0xFE, 0x01, 0xFE, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x0F, 0xF7, 0xF8, 0x07,
  0xF8, 0x1F, 0xEF, 0xF0, 0x0F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0x7F,
  0xBF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF,
  0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x83, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0xFC, 0x0F, 0xF8, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x0C,
  0x00, 0x3F, 0xE1, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x81,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0xF8, 0x0F, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xC1, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x7E,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFD, 0xFC, 0x3F, 0xE0, 0x3F, 0x83, 0xFB,
  0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE7, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xCF,
  0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0x9F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x3F,
  0x9F, 0xE0, 0x07, 0xF1, 0xFC, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x80, 0x1F, 0xCF, 0xE1, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x83, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE,
  0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE3, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF7, 0xF8, 0x00,
  0x7F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x01,
  0xFF, 0xC7, 0xF0, 0x3F, 0xFE, 0xFE, 0x07, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0,
  0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xEF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFD, 0xFE, 0x01, 0xFF, 0x9F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x40, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xDF, 0xF8, 0x0F, 0xF7, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF,
  0xCF, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xF3, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF3, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xC1, 0xFC, 0xFF, 0xE0, 0x3F, 0x87, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFC, 0x7C, 0x3F, 0xF0, 0x08, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x60, 0x7F, 0xF3,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xC0, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0xDF, 0xF0, 0x0F,
  0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0xFC, 0x00, 0x7F, 0xF7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xEF, 0xFC, 0x7F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F,
  0xF3, 0xFC, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC7, 0xFF, 0x9F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x02, 0x07, 0xFC, 0x03, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x04, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xF8, 0xFE, 0x03, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0x7F,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xFC, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x06, 0x00, 0x7F, 0xE0, 0x3F, 0x8F, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x08, 0x00, 0x3F, 0xCF, 0xF8, 0x07, 0xF9, 0xFF, 0xC0, 0x7F, 0xBF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7,
  0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x7E, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC7, 0xFF, 0x0F, 0xFE, 0x03, 0xF9,
  0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0x7F, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF9, 0xFF, 0xF3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x8F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x0F,
  0xF8, 0x07, 0xF1, 0xFF, 0xC0, 0x7F, 0x3F, 0xFC, 0x07, 0xF7, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xF3, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE3, 0xFF, 0x3F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF8,
  0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE7,
  0xFF, 0x00, 0x3F, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0x80, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0x81, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0xC7, 0xF0, 0x3F,
  0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xDF, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xBF, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x10, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x08, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xE0,
  0x7F, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFE, 0xFE, 0x0F, 0xF0, 0x1C, 0x3F,
  0xE0, 0x08, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x10, 0x01, 0xFE, 0x38, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xCE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xF8,
  0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xFE,
  0x0F, 0xF9, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFD, 0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xF9, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF7, 0xF8, 0x03, 0xFE,
  0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xF8,
  0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x3F, 0xE0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x7F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0xE0, 0x7F, 0xDF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xF0, 0x3F, 0xE7, 0xF8, 0x3F, 0xF8,
  0x1F, 0xE3, 0xFC, 0x1F, 0xFC, 0x1F, 0xF1, 0xFE, 0x1F, 0xBE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xDF, 0x07, 0xF8, 0x7F, 0x87, 0xFF, 0x87, 0xF8, 0x3F, 0xC7,
  0xEF, 0xC3, 0xFC, 0x1F, 0xE3, 0xF7, 0xE3, 0xFC, 0x0F, 0xF3, 0xFB, 0xF1,
  0xFE, 0x03, 0xF9, 0xF9, 0xF9, 0xFE, 0x01, 0xFC, 0xFC, 0xFC, 0xFF, 0x00,
  0xFE, 0xFC, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0x3F, 0x7F, 0x80, 0x3F, 0xBF,
  0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x87, 0xFF,
  0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x8F, 0xF8, 0x00, 0x5F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x03, 0xFE, 0x40, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 17, 37, 15, 0, -36 },
  { 80, 20, 13, 23, 5, -36 },
  { 113, 33, 36, 33, 1, -36 },
  { 262, 28, 42, 29, 1, -39 },
  { 409, 41, 37, 45, 3, -37 },
  { 599, 35, 38, 37, 1, -37 },
  { 766, 9, 13, 13, 5, -36 },
  { 781, 20, 45, 18, 2, -37 },
  { 894, 19, 45, 18, -3, -37 },
  { 1001, 25, 25, 28, 4, -39 },
  { 1080, 25, 24, 29, 2, -30 },
  { 1155, 13, 13, 15, -3, -6 },
  { 1177, 15, 7, 17, 1, -17 },
  { 1191, 10, 9, 15, 0, -8 },
  { 1203, 28, 37, 23, -2, -37 },
  { 1333, 26, 38, 29, 2, -37 },
  { 1457, 22, 36, 29, 4, -36 },
  { 1556, 29, 37, 29, -1, -37 },
  { 1691, 28, 38, 29, 0, -37 },
  { 1824, 28, 36, 29, 0, -36 },
  { 1950, 28, 37, 29, 1, -36 },
  { 2080, 27, 38, 29, 2, -37 },
  { 2209, 30, 36, 29, 1, -36 },
  { 2344, 27, 38, 29, 1, -37 },
  { 2473, 26, 38, 29, 2, -37 },
  { 2597, 15, 29, 15, 0, -28 },
  { 2652, 18, 35, 15, -3, -28 },
  { 2731, 25, 27, 29, 2, -32 },
  { 2816, 25, 16, 29, 2, -26 },
  { 2866, 25, 27, 29, 2, -32 },
  { 2951, 22, 38, 24, 4, -37 },
  { 3056, 42, 42, 45, 2, -37 },
  { 3277, 33, 36, 33, -3, -36 },
  { 3426, 30, 36, 32, 1, -36 },
  { 3561, 31, 38, 32, 3, -37 },
  { 3709, 32, 36, 35, 1, -36 },
  { 3853, 29, 36, 28, 1, -36 },
  { 3984, 29, 36, 28, 1, -36 },
  { 4115, 32, 38, 35, 3, -37 },
  { 4267, 35, 36, 36, 1, -36 },
  { 4425, 25, 36, 21, -2, -36 },
  { 4538, 26, 47, 18, -8, -36 },
  { 4691, 36, 36, 33, 1, -36 },
  { 4853, 23, 36, 27, 1, -36 },
  { 4957, 45, 36, 46, 1, -36 },
  { 5160, 39, 36, 39, 1, -36 },
  { 5336, 33, 38, 37, 3, -37 },
  { 5493, 30, 36, 31, 1, -36 },
  { 5628, 33, 46, 37, 3, -37 },
  { 5818, 30, 36, 32, 1, -36 },
  { 5953, 27, 38, 27, 1, -37 },
  { 6082, 27, 36, 28, 4, -36 },
  { 6204, 33, 37, 36, 3, -36 },
  { 6357, 31, 36, 31, 4, -36 },
  { 6497, 47, 36, 47, 4, -36 },
  { 6709, 39, 36, 32, -3, -36 },
  { 6885, 30, 36, 30, 4, -36 },
  { 7020, 32, 36, 27, -2, -36 },
  { 7164, 22, 45, 18, -1, -37 },
  { 7288, 12, 37, 23, 6, -37 },
  { 7344, 22, 45, 18, -3, -37 },
  { 7468, 27, 24, 28, 0, -37 },
  { 7549, 23, 5, 22, -5, 4 },
  { 7564, 12, 8, 17, 7, -39 },
  { 7576, 28, 30, 31, 2, -29 },
  { 7681, 27, 40, 31, 1, -39 },
  { 7816, 24, 30, 25, 2, -29 },
  { 7906, 30, 40, 31, 2, -39 },
  { 8056, 26, 30, 29, 2, -29 },
  { 8154, 30, 51, 20, -5, -39 },
  { 8346, 29, 41, 31, 1, -29 },
  { 8495, 28, 39, 31, 1, -39 },
  { 8632, 16, 39, 16, 1, -39 },
  { 8710, 24, 51, 16, -7, -39 },
  { 8863, 32, 39, 30, 1, -39 },
  { 9019, 17, 39, 16, 1, -39 },
  { 9102, 43, 29, 47, 1, -29 },
  { 9258, 28, 29, 31, 1, -29 },
  { 9360, 26, 30, 30, 2, -29 },
  { 9458, 30, 41, 31, -2, -29 },
  { 9612, 28, 41, 31, 2, -29 },
  { 9756, 23, 29, 22, 1, -29 },
  { 9840, 23, 30, 25, 1, -29 },
  { 9927, 21, 35, 22, 2, -34 },
  { 10019, 28, 29, 31, 3, -28 },
  { 10121, 28, 28, 27, 2, -28 },
  { 10219, 41, 28, 41, 3, -28 },
  { 10363, 34, 28, 28, -3, -28 },
  { 10482, 33, 40, 27, -3, -28 },
  { 10647, 26, 28, 24, -1, -28 },
  { 10738, 22, 44, 18, 0, -36 },
  { 10859, 6, 51, 28, 11, -39 },
  { 10898, 21, 44, 18, -3, -36 },
  { 11014, 25, 10, 29, 2, -23 },
};

const GFXfont NotoSans_ExtraBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRABOLDITALIC51PT7B_H_
