#ifndef _NOTOSANS_EXTRABOLDITALIC19PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x8C, 0x70, 0x00, 0x1C, 0xF3, 0x80,
  0xEF, 0xDF, 0xBE, 0x6C, 0xC0, 0x06, 0x60, 0x66, 0x06, 0x60, 0xEE, 0x7F,
  0xF7, 0xFF, 0x1D, 0xC1, 0x98, 0xFF, 0xEF, 0xFE, 0x3B, 0x83, 0x30, 0x33,
  0x07, 0x70, 0x03, 0x01, 0xFC, 0x7F, 0x1D, 0x63, 0xA0, 0x7C, 0x0F, 0xC0,
  0x7C, 0x07, 0xD0, 0xB9, 0x37, 0x3F, 0xC7, 0xF0, 0x10, 0x06, 0x00, 0x18,
  0x1C, 0xF8, 0x31, 0xB8, 0xC7, 0x73, 0x8E, 0xEE, 0x1D, 0xD8, 0x3F, 0x6F,
  0xFF, 0xFF, 0x37, 0x76, 0x0C, 0xCC, 0x31, 0x98, 0xE3, 0x71, 0x87, 0xCE,
  0x0F, 0x00, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x07, 0x38, 0x1D, 0xC0, 0x7F,
  0x00, 0xF8, 0x4F, 0xCE, 0x7F, 0x3B, 0xCF, 0xCF, 0x3E, 0x3E, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xEC, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x70,
  0xE1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0x60, 0x1C, 0x18, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC7, 0x0C, 0x38, 0xE0, 0x10,
  0x06, 0x23, 0x1F, 0x0F, 0xF9, 0xFD, 0xF1, 0xD8, 0x6E, 0x04, 0x00, 0x1C,
  0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x3B, 0x9D,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x0F, 0xE3, 0xF9, 0xCE, 0xF3, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3,
  0xB8, 0xEE, 0x73, 0xBC, 0xFE, 0x1F, 0x00, 0x07, 0x1E, 0x3E, 0xFE, 0xEE,
  0x5E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x03, 0x81, 0xFC,
  0x7F, 0x84, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3F, 0xE7, 0xFD, 0xFF, 0x80, 0x0F, 0x0F, 0xF3, 0xFC, 0x47, 0x01, 0xC0,
  0xF1, 0xF0, 0x7C, 0x03, 0x80, 0xF0, 0x3F, 0x1E, 0xFF, 0xBF, 0x80, 0x01,
  0xC0, 0x70, 0x3C, 0x1F, 0x0F, 0xC7, 0xE3, 0xB8, 0xCE, 0x63, 0xBF, 0xFF,
  0xFC, 0x1C, 0x07, 0x01, 0xC0, 0x1F, 0xE3, 0xF8, 0x7F, 0x0E, 0x03, 0x80,
  0x7C, 0x0F, 0xE3, 0xFC, 0x03, 0xC0, 0x78, 0x0E, 0x63, 0xCF, 0xF1, 0xFC,
  0x00, 0x07, 0xC7, 0xF3, 0xF9, 0xE0, 0x70, 0x3B, 0xCF, 0xFB, 0xFE, 0xE3,
  0xB8, 0xEE, 0x3B, 0xDC, 0x7F, 0x1F, 0x80, 0x7F, 0xEF, 0xF9, 0xFF, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x1C, 0x73, 0x9C, 0x7F, 0x87,
  0xE1, 0xFC, 0x7B, 0x8E, 0x3B, 0xC7, 0x39, 0xE7, 0xF8, 0x7E, 0x00, 0x1E,
  0x1F, 0x9F, 0xFE, 0x7E, 0x3F, 0x1F, 0xDF, 0xFF, 0x7B, 0x83, 0xC1, 0xD3,
  0xCF, 0xE7, 0xC0, 0x19, 0xCE, 0x70, 0x00, 0x00, 0x77, 0xB8, 0x0C, 0x71,
  0xC7, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x18, 0xE0, 0x00, 0x81, 0xC3, 0xE7,
  0xCF, 0x87, 0x81, 0xF0, 0x3F, 0x07, 0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8, 0x1C, 0x7C, 0xF8,
  0xF0, 0x60, 0x00, 0x1C, 0x3F, 0x9F, 0xC8, 0xF0, 0x70, 0x78, 0x78, 0x70,
  0x30, 0x20, 0x00, 0x0E, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0x1F, 0xF0, 0x78,
  0xF1, 0xC0, 0x77, 0x3F, 0x6C, 0xFC, 0xF3, 0x99, 0xE6, 0x33, 0xCC, 0xE7,
  0xB9, 0x9B, 0x3F, 0xF7, 0x7B, 0xCE, 0x00, 0x0F, 0x0C, 0x0F, 0xF8, 0x07,
  0xC0, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0x60, 0xE6, 0x0E, 0x61,
  0xC7, 0x1F, 0xF3, 0xFF, 0x3F, 0xF7, 0x07, 0x70, 0x7E, 0x07, 0x1F, 0x81,
  0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0xF3, 0x8E, 0x3F, 0xC3, 0xFC, 0x39, 0xE7,
  0x9E, 0x71, 0xE7, 0xFC, 0x7F, 0xCF, 0xF0, 0x07, 0xC1, 0xFF, 0x3F, 0xE7,
  0x82, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0xB8, 0x7F, 0x83, 0xF8, 0x1F, 0x01, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0x73,
  0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x8F, 0x71, 0xE7, 0xFC, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03, 0xC0, 0x70, 0x0F, 0xF1, 0xFC,
  0x38, 0x0F, 0x01, 0xC0, 0x3F, 0xC7, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8E, 0x03, 0xC0, 0x70, 0x0F, 0xF1, 0xFC, 0x3F, 0x8F, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC1, 0xFF, 0x3F, 0xE3, 0xC2, 0x78,
  0x07, 0x00, 0xF3, 0xEE, 0x3E, 0xE7, 0xEE, 0x1E, 0xF1, 0xC7, 0xFC, 0x7F,
  0xC3, 0xFC, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x78, 0xE1,
  0xC3, 0xFF, 0x0F, 0xFC, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x70,
  0xE3, 0xC7, 0x80, 0x1F, 0xC7, 0xE1, 0xF8, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x7E, 0x3F, 0x80, 0x01, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE3, 0xF0, 0xFC, 0x3E, 0x00, 0x1C, 0x3C, 0x71, 0xE1,
  0xCF, 0x07, 0x78, 0x3D, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xEE, 0x07, 0x3C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x80, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0F, 0xF7, 0xFF,
  0xF8, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE3, 0xF1, 0xF1,
  0xF9, 0xF8, 0xFC, 0xDC, 0x7E, 0xEE, 0x37, 0x6E, 0x3B, 0xF7, 0x1C, 0xF3,
  0x8E, 0x79, 0xC7, 0x38, 0xC7, 0x1C, 0xE0, 0x1E, 0x0E, 0x3C, 0x1C, 0x7C,
  0x70, 0xF8, 0xE3, 0xF1, 0xC7, 0x73, 0x8E, 0xE6, 0x1D, 0xDC, 0x31, 0xB8,
  0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0x87, 0x0F, 0x1C, 0x1E, 0x00, 0x07, 0x81,
  0xFE, 0x3F, 0xF7, 0x8F, 0x78, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xF0, 0xE7, 0xBE, 0x7F, 0xC3, 0xF0, 0x1F, 0x01, 0xFE, 0x1F, 0xE1,
  0xCF, 0x3C, 0xF3, 0x8F, 0x39, 0xE3, 0xFE, 0x3F, 0x87, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xF3, 0x8F, 0x78, 0x77,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xE7, 0xFC, 0x7F, 0xC3,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xE0, 0x1F, 0x03, 0xF8, 0x7F, 0x8E, 0x73,
  0xCE, 0x71, 0xCF, 0xF9, 0xFE, 0x3F, 0x8F, 0x71, 0xCF, 0x38, 0xE7, 0x1D,
  0xE3, 0xC0, 0x07, 0x87, 0xF3, 0xFC, 0xE1, 0x38, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xE8, 0x3B, 0xBE, 0xFF, 0x1F, 0x80, 0x7F, 0xEF, 0xF9, 0xFF,
  0x47, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x78, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xEF, 0x1C, 0xF1, 0xCF, 0xFC, 0x7F, 0x83,
  0xF0, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xCE, 0x39, 0xC7, 0x70,
  0xEE, 0x1D, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xE0, 0x00, 0xE1, 0xC3, 0xF1,
  0xE3, 0xF8, 0xF1, 0xDC, 0x78, 0xEE, 0x7C, 0xE7, 0x3E, 0x73, 0xBF, 0x71,
  0xDB, 0xB8, 0xFD, 0xDC, 0x7E, 0xFC, 0x36, 0x7E, 0x1F, 0x3E, 0x0F, 0x1F,
  0x07, 0x8F, 0x00, 0x1C, 0x1E, 0x3C, 0x78, 0x39, 0xE0, 0x73, 0x80, 0xFE,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xF7, 0x81,
  0xC7, 0x07, 0x8E, 0x1E, 0x1E, 0x00, 0xE1, 0xFC, 0x3B, 0x8E, 0x7B, 0xC7,
  0x70, 0xFC, 0x1F, 0x83, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0xFC, 0x7F, 0xCF, 0xFC, 0x1F,
  0x1F, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xE0, 0xF8, 0xF0, 0xE7, 0x38, 0xC6, 0x31, 0xCE, 0x73, 0x8C, 0x63,
  0x9C, 0x1F, 0x1F, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0xF8, 0xF0, 0x02, 0x01, 0xC0, 0x70, 0x3C, 0x1F,
  0x86, 0x63, 0x19, 0xC7, 0xE0, 0xC0, 0x7F, 0xFF, 0xC0, 0xEE, 0x70, 0x08,
  0x0F, 0xF7, 0xFD, 0xCF, 0xF3, 0xB8, 0xEE, 0x3B, 0x9E, 0xF7, 0x3F, 0xC7,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0xC3, 0xFC, 0x7F, 0x8E, 0x79, 0xCF,
  0x71, 0xEE, 0x39, 0xC7, 0x3D, 0xE7, 0xF9, 0xDE, 0x00, 0x0E, 0x1F, 0xDF,
  0xCE, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xF6, 0x7F, 0x1F, 0x80, 0x00, 0xE0,
  0x3C, 0x07, 0x04, 0xE3, 0xFC, 0xFF, 0x9C, 0xE7, 0x9C, 0xE3, 0x9C, 0x73,
  0x8E, 0x7B, 0x8F, 0xF0, 0xFE, 0x00, 0x0E, 0x1F, 0xDF, 0xEE, 0x7E, 0x3F,
  0xFB, 0xF9, 0xC0, 0xE1, 0x7F, 0x9F, 0x80, 0x00, 0x40, 0x7C, 0x0F, 0x83,
  0x80, 0x70, 0x3F, 0x87, 0xF0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0x30, 0x00, 0x04,
  0x03, 0xFC, 0xFF, 0x9C, 0xF7, 0x9C, 0xE3, 0x9C, 0x73, 0x9E, 0x7B, 0x8F,
  0xF0, 0xEE, 0x01, 0xC8, 0x79, 0xFE, 0x3F, 0x81, 0xC0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0xC3, 0xFC, 0x7F, 0xCF, 0x79, 0xCF, 0x79, 0xCE, 0x39, 0xC7,
  0x38, 0xE7, 0x3D, 0xE7, 0x00, 0x0C, 0x71, 0xC0, 0x00, 0xF3, 0x8E, 0x39,
  0xE7, 0x1C, 0x71, 0xCF, 0x00, 0x03, 0x07, 0x07, 0x00, 0x00, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0xF8, 0xF0,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC1, 0x38, 0xE3, 0x9C, 0x3B, 0x83,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0x38, 0x73, 0xCF, 0x3C, 0x1E, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x00, 0x01,
  0x86, 0x3B, 0xDF, 0x3F, 0xFF, 0x3D, 0xE7, 0x39, 0xE7, 0x79, 0xC7, 0x71,
  0xC7, 0x71, 0xC7, 0x71, 0xCF, 0x73, 0xCE, 0xF3, 0x8E, 0x01, 0x87, 0xF8,
  0xFF, 0x9E, 0xF3, 0x9E, 0xF3, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0x7B, 0xCE,
  0x00, 0x0E, 0x0F, 0xC7, 0xF9, 0xCE, 0xF3, 0xF8, 0xEE, 0x3B, 0x8E, 0xE7,
  0xBF, 0xC7, 0xE0, 0x00, 0x81, 0xFE, 0x1F, 0xE1, 0xCF, 0x1C, 0xF3, 0x8F,
  0x38, 0xE3, 0x8E, 0x3D, 0xE3, 0xFC, 0x77, 0x87, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x08, 0x0F, 0xF7, 0xFD, 0xCF, 0xF3, 0xB8, 0xEE, 0x3B,
  0x8E, 0xF7, 0x3F, 0xC7, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x01,
  0x9D, 0xCF, 0xC7, 0x93, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x00,
  0x0E, 0x1F, 0xDF, 0xCF, 0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x8F, 0x7F, 0x3F,
  0x00, 0x18, 0x18, 0x39, 0xFE, 0xFE, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xF4,
  0xFC, 0x7C, 0x79, 0xDC, 0x77, 0x1D, 0xCF, 0xE3, 0xB8, 0xEE, 0x7B, 0x9E,
  0xFF, 0x1E, 0xC0, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0x6E, 0x1B, 0x86, 0xC1,
  0xF0, 0x78, 0x1E, 0x00, 0xE3, 0x8F, 0xCF, 0x3B, 0x9E, 0x77, 0x7D, 0xCE,
  0xDB, 0x9D, 0xB6, 0x3E, 0x7C, 0x7C, 0xF8, 0x79, 0xE0, 0xE3, 0xC0, 0x3C,
  0xF8, 0xEF, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x07, 0x70,
  0x7B, 0xC7, 0x8E, 0x00, 0x38, 0xF3, 0x8E, 0x39, 0xE3, 0x9C, 0x1B, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F,
  0x00, 0xC0, 0x00, 0x3F, 0x9F, 0xC1, 0xC1, 0xC1, 0xC1, 0xE1, 0xE0, 0xE0,
  0xFF, 0x7F, 0x00, 0x03, 0x0F, 0x0F, 0x1C, 0x1C, 0x1C, 0x18, 0xF8, 0xF0,
  0xF0, 0x70, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0x1C, 0x1E, 0x0E, 0x0C, 0x0C, 0x1C, 0x0E, 0x0F, 0x1E, 0x38,
  0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0, 0xFC, 0xFF, 0xE1, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 6, 0, -14 },
  { 12, 7, 5, 9, 2, -14 },
  { 17, 12, 14, 12, 0, -14 },
  { 38, 11, 15, 11, 0, -14 },
  { 59, 15, 14, 17, 1, -14 },
  { 86, 14, 14, 14, 0, -14 },
  { 111, 3, 5, 5, 2, -14 },
  { 113, 7, 17, 7, 1, -14 },
  { 128, 7, 17, 7, -1, -14 },
  { 143, 9, 10, 10, 2, -15 },
  { 155, 9, 9, 11, 1, -11 },
  { 166, 5, 4, 6, -1, -2 },
  { 169, 6, 2, 6, 0, -6 },
  { 171, 4, 3, 6, 0, -3 },
  { 173, 11, 14, 8, -1, -14 },
  { 193, 10, 14, 11, 1, -14 },
  { 211, 8, 14, 11, 2, -14 },
  { 225, 11, 14, 11, -1, -14 },
  { 245, 10, 14, 11, 0, -14 },
  { 263, 10, 14, 11, 0, -14 },
  { 281, 11, 14, 11, 0, -14 },
  { 301, 10, 14, 11, 1, -14 },
  { 319, 11, 14, 11, 1, -14 },
  { 339, 11, 14, 11, 0, -14 },
  { 359, 9, 14, 11, 1, -14 },
  { 375, 5, 11, 6, 0, -11 },
  { 382, 6, 13, 6, -1, -11 },
  { 392, 9, 10, 11, 1, -12 },
  { 404, 9, 6, 11, 1, -10 },
  { 411, 9, 10, 11, 1, -12 },
  { 423, 9, 14, 9, 1, -14 },
  { 439, 15, 16, 17, 1, -14 },
  { 469, 12, 14, 12, -1, -14 },
  { 490, 12, 14, 12, 0, -14 },
  { 511, 12, 14, 12, 1, -14 },
  { 532, 12, 14, 13, 0, -14 },
  { 553, 11, 14, 10, 0, -14 },
  { 573, 11, 14, 10, 0, -14 },
  { 593, 12, 14, 13, 1, -14 },
  { 614, 14, 14, 13, 0, -14 },
  { 639, 10, 14, 8, -1, -14 },
  { 657, 10, 18, 7, -3, -14 },
  { 680, 14, 14, 12, 0, -14 },
  { 705, 9, 14, 10, 0, -14 },
  { 721, 17, 14, 17, 0, -14 },
  { 751, 15, 14, 15, 0, -14 },
  { 778, 12, 14, 14, 1, -14 },
  { 799, 12, 14, 12, 0, -14 },
  { 820, 12, 17, 14, 1, -14 },
  { 846, 11, 14, 12, 0, -14 },
  { 866, 10, 14, 10, 0, -14 },
  { 884, 11, 14, 10, 1, -14 },
  { 904, 12, 14, 13, 1, -14 },
  { 925, 11, 14, 11, 2, -14 },
  { 945, 17, 14, 17, 2, -14 },
  { 975, 15, 14, 12, -1, -14 },
  { 1002, 11, 14, 11, 2, -14 },
  { 1022, 12, 14, 10, -1, -14 },
  { 1043, 8, 17, 7, 0, -14 },
  { 1060, 5, 14, 8, 2, -14 },
  { 1069, 8, 17, 7, -1, -14 },
  { 1086, 10, 9, 10, 0, -14 },
  { 1098, 9, 2, 8, -2, 1 },
  { 1101, 4, 3, 6, 3, -15 },
  { 1103, 10, 11, 11, 1, -11 },
  { 1117, 11, 14, 11, 0, -14 },
  { 1137, 9, 11, 9, 1, -11 },
  { 1150, 11, 14, 11, 1, -14 },
  { 1170, 9, 11, 11, 1, -11 },
  { 1183, 11, 20, 7, -2, -15 },
  { 1211, 11, 16, 11, 0, -11 },
  { 1233, 11, 14, 12, 0, -14 },
  { 1253, 6, 15, 6, 0, -15 },
  { 1265, 8, 20, 6, -2, -15 },
  { 1285, 12, 14, 11, 0, -14 },
  { 1306, 7, 14, 6, 0, -14 },
  { 1319, 16, 11, 17, 0, -11 },
  { 1341, 11, 11, 12, 0, -11 },
  { 1357, 10, 11, 11, 1, -11 },
  { 1371, 12, 16, 11, -1, -11 },
  { 1395, 10, 16, 11, 1, -11 },
  { 1415, 9, 11, 8, 0, -11 },
  { 1428, 9, 11, 9, 0, -11 },
  { 1441, 8, 13, 8, 1, -13 },
  { 1454, 10, 10, 12, 1, -10 },
  { 1467, 10, 10, 10, 1, -10 },
  { 1480, 15, 10, 15, 1, -10 },
  { 1499, 13, 10, 10, -1, -10 },
  { 1516, 12, 15, 10, -1, -10 },
  { 1539, 9, 10, 9, 0, -10 },
  { 1551, 8, 17, 7, 0, -14 },
  { 1568, 2, 18, 11, 4, -14 },
  { 1573, 8, 17, 7, -1, -14 },
  { 1590, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_ExtraBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRABOLDITALIC19PT7B_H_
