#ifndef _NOTOSANS_EXTRABOLDITALIC14PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0xE6, 0x31, 0x80, 0xE7, 0x00, 0x6D, 0x6D, 0xB6, 0x09,
  0x0D, 0x86, 0xCF, 0xF1, 0x61, 0xB3, 0xFC, 0x48, 0x6C, 0x36, 0x00, 0x04,
  0x0E, 0x3F, 0x7A, 0x78, 0x3C, 0x1E, 0x16, 0xD6, 0xFC, 0x10, 0x30, 0x70,
  0xDB, 0x33, 0x6C, 0x6D, 0x0F, 0x7F, 0xFB, 0xC6, 0xD8, 0x9B, 0x33, 0x6C,
  0x38, 0x1E, 0x0F, 0xC3, 0x30, 0xF8, 0x1C, 0x1F, 0x7E, 0xFB, 0x9C, 0xFF,
  0x1F, 0xE0, 0x6B, 0x60, 0x1C, 0x63, 0x18, 0x61, 0x86, 0x30, 0x41, 0x86,
  0x18, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x99, 0xC0, 0x10, 0x33, 0xC3,
  0xF3, 0xBF, 0x13, 0x00, 0x30, 0x63, 0xFF, 0xF3, 0x06, 0x00, 0x36, 0x6C,
  0x7F, 0xFC, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xE0,
  0x1E, 0x3E, 0x77, 0x67, 0x67, 0x67, 0xE6, 0xEE, 0x7C, 0x78, 0x1C, 0xFF,
  0xD6, 0x18, 0x63, 0x8C, 0x30, 0xC0, 0x3E, 0x7E, 0x27, 0x06, 0x0E, 0x1C,
  0x38, 0x70, 0xFE, 0xFC, 0x7E, 0x3F, 0x07, 0x06, 0x3C, 0x3C, 0x06, 0x06,
  0xFE, 0xFC, 0x07, 0x0E, 0x1E, 0x1E, 0x36, 0x6E, 0xFF, 0xFE, 0x0C, 0x1C,
  0x3F, 0x3F, 0x30, 0x30, 0x7E, 0x2E, 0x06, 0x0E, 0xFE, 0xFC, 0x1E, 0xFD,
  0x86, 0xCF, 0xDD, 0xB3, 0x66, 0xFC, 0xF0, 0x3F, 0xBF, 0x81, 0xC1, 0xC0,
  0xC0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x00, 0x1E, 0x3F, 0x33, 0x36, 0x3C,
  0x7E, 0x66, 0xE6, 0x7E, 0x7C, 0x7D, 0xFB, 0x3E, 0x7C, 0xFF, 0x9B, 0x0E,
  0xF9, 0xE0, 0x37, 0x20, 0x00, 0xEE, 0x19, 0xC4, 0x00, 0x01, 0xCC, 0x66,
  0x00, 0x02, 0x1C, 0xE7, 0x0E, 0x07, 0x83, 0x81, 0xFE, 0x00, 0x07, 0xF0,
  0x81, 0x81, 0xC0, 0xE1, 0xEF, 0x30, 0x40, 0x7B, 0xF0, 0xC7, 0x39, 0x86,
  0x00, 0xE3, 0x80, 0x1F, 0x87, 0x39, 0x81, 0xE7, 0xBD, 0xB7, 0x66, 0xEC,
  0x9D, 0xFE, 0xC9, 0x1C, 0x20, 0xFC, 0x00, 0x07, 0x03, 0x83, 0x61, 0xB1,
  0x99, 0xCC, 0xFE, 0xFF, 0x61, 0xF0, 0xC0, 0x3F, 0x1F, 0xCC, 0xE6, 0x67,
  0xE3, 0xF9, 0x8C, 0xCE, 0x7E, 0x7E, 0x00, 0x1F, 0x7F, 0x61, 0xE0, 0xC0,
  0xC0, 0xC0, 0xE0, 0xFC, 0x7C, 0x3E, 0x1F, 0x8C, 0xE6, 0x37, 0x1B, 0x9D,
  0x8E, 0xCE, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x30, 0x30, 0x7E, 0x7E, 0x60,
  0x60, 0x7C, 0xFC, 0x3F, 0x3F, 0x30, 0x30, 0x7E, 0x7E, 0x60, 0x60, 0x60,
  0xE0, 0x1F, 0xBF, 0x9C, 0x1C, 0x0C, 0xF6, 0x7B, 0x1D, 0xCC, 0xFE, 0x3F,
  0x00, 0x39, 0xCC, 0x73, 0x18, 0xC6, 0x7F, 0x9F, 0xE6, 0x39, 0x8C, 0x63,
  0x39, 0xC0, 0x3D, 0xF3, 0x8C, 0x30, 0xC7, 0x1C, 0xFB, 0xC0, 0x06, 0x1C,
  0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE7, 0x8E, 0x00, 0x39, 0xCC,
  0xE3, 0x70, 0xD8, 0x7C, 0x1F, 0x06, 0xE1, 0x98, 0x67, 0x39, 0xC0, 0x38,
  0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x7F, 0xF0, 0x3C, 0x79, 0xE3, 0x8F, 0x3C,
  0x79, 0x67, 0xDF, 0x36, 0xF1, 0xBD, 0x8D, 0xEC, 0x6E, 0x67, 0x77, 0x00,
  0x38, 0x67, 0x9C, 0xF3, 0x1E, 0x67, 0xEC, 0xCD, 0x99, 0xF3, 0x3C, 0x63,
  0x9C, 0x70, 0x1E, 0x3F, 0x98, 0xFC, 0x7C, 0x3E, 0x1F, 0x0D, 0x8E, 0xFE,
  0x3E, 0x00, 0x3E, 0x1F, 0x8C, 0xE6, 0x77, 0x73, 0xF9, 0xE0, 0xC0, 0x60,
  0x70, 0x00, 0x1E, 0x3F, 0x98, 0xFC, 0x7C, 0x3E, 0x1F, 0x0D, 0x8E, 0xFE,
  0x3E, 0x03, 0x01, 0xE0, 0x3E, 0x3F, 0x33, 0x33, 0x7F, 0x7E, 0x6E, 0x66,
  0x67, 0xE7, 0x1F, 0x3E, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x8E, 0xFC, 0xF8,
  0xFF, 0xFE, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x73, 0xB1,
  0xD8, 0xCC, 0x6E, 0x37, 0x3B, 0x19, 0x8C, 0xFE, 0x3E, 0x00, 0xC3, 0xF3,
  0xB9, 0x9D, 0xC6, 0xC3, 0x61, 0xE0, 0xF0, 0x70, 0x38, 0x00, 0xC7, 0x3E,
  0x39, 0xB3, 0xCD, 0x9E, 0xEC, 0xB6, 0x6D, 0xF3, 0x6F, 0x1E, 0x78, 0xF3,
  0x87, 0x1C, 0x00, 0x38, 0xE3, 0x38, 0x76, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0xC1, 0xD8, 0x73, 0x9C, 0x70, 0xE7, 0x66, 0x6E, 0x6C, 0x78, 0x38, 0x30,
  0x30, 0x70, 0x60, 0x1F, 0x9F, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60,
  0x7F, 0x7F, 0x00, 0x3C, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x38,
  0xDB, 0x6D, 0x93, 0x6C, 0x1C, 0xB0, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0x3C, 0x0C, 0x38, 0x51, 0xA6, 0x6C, 0xF0, 0x80, 0xFC, 0xCC, 0x80, 0x36,
  0xFF, 0xBE, 0x7C, 0xD9, 0xBF, 0x76, 0x38, 0x38, 0x30, 0x36, 0x3F, 0x77,
  0x67, 0x67, 0x66, 0x7E, 0xDC, 0x3D, 0xFE, 0x30, 0xC3, 0x0F, 0x9E, 0x07,
  0x07, 0x06, 0x36, 0x7E, 0xEE, 0xCE, 0xCC, 0xCC, 0xFC, 0xEC, 0x3C, 0xFB,
  0xBE, 0xEF, 0x98, 0x3E, 0x3C, 0x07, 0x0F, 0x1C, 0x1E, 0x3E, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x30, 0x70, 0xF0, 0xE0, 0x1B, 0x3F, 0x77, 0x67, 0x66,
  0x66, 0x7E, 0x7E, 0x0C, 0xDC, 0xF8, 0x38, 0x38, 0x30, 0x36, 0x3F, 0x73,
  0x77, 0x67, 0x66, 0x66, 0xE6, 0x11, 0xC0, 0x63, 0x39, 0xCC, 0x63, 0x38,
  0x04, 0x1C, 0x00, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x8F, 0x1E,
  0x00, 0x38, 0x1C, 0x0C, 0x06, 0x73, 0x73, 0xF1, 0xF0, 0xF8, 0x6C, 0x37,
  0x39, 0xC0, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0x63, 0x38, 0x36, 0x63, 0xFF,
  0x77, 0x37, 0x73, 0x67, 0x76, 0x67, 0x66, 0x6E, 0xE6, 0x36, 0x3F, 0x73,
  0x77, 0x67, 0x66, 0x66, 0xE6, 0x38, 0xFB, 0xBE, 0x7C, 0xF9, 0xBF, 0x3C,
  0x1F, 0x0F, 0xCE, 0xE6, 0x73, 0x39, 0x98, 0xFC, 0xFC, 0x60, 0x30, 0x38,
  0x00, 0x36, 0xFF, 0xBE, 0x7C, 0xD9, 0xBF, 0x7E, 0x18, 0x30, 0x60, 0x36,
  0x79, 0xF3, 0x86, 0x0C, 0x18, 0x70, 0x3E, 0xF9, 0x83, 0xC3, 0xC3, 0xBF,
  0x7C, 0x33, 0xFE, 0xCE, 0x63, 0x1E, 0xF0, 0x67, 0xCF, 0x9E, 0x7C, 0xD9,
  0xBF, 0x76, 0xC7, 0x9F, 0x36, 0xCD, 0x9E, 0x3C, 0x30, 0xCE, 0x79, 0xDB,
  0x7B, 0x6A, 0xCF, 0x59, 0xEB, 0x39, 0xC7, 0x38, 0x39, 0x9D, 0xC7, 0xC3,
  0xC1, 0xC1, 0xF1, 0xD9, 0xCE, 0x31, 0x99, 0xCC, 0xC6, 0xC3, 0x61, 0xE0,
  0x70, 0x30, 0x38, 0x78, 0x38, 0x00, 0x3E, 0xFC, 0x70, 0xC3, 0x0C, 0x3F,
  0x7C, 0x1C, 0x73, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x87, 0x1C, 0xFF, 0xFF,
  0xFF, 0xF0, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xCC, 0x30, 0xCE, 0x38, 0xF3,
  0x7C,
};

const GFXglyph NotoSans_ExtraBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 10, 4, 0, -10 },
  { 8, 6, 4, 6, 1, -10 },
  { 11, 9, 10, 9, 0, -10 },
  { 23, 8, 12, 8, 0, -11 },
  { 35, 11, 10, 12, 1, -10 },
  { 49, 10, 10, 10, 0, -10 },
  { 62, 3, 4, 3, 1, -10 },
  { 64, 6, 12, 5, 0, -10 },
  { 73, 5, 12, 5, -1, -10 },
  { 81, 7, 7, 8, 1, -11 },
  { 88, 7, 6, 8, 1, -8 },
  { 94, 4, 4, 4, -1, -2 },
  { 96, 4, 2, 5, 0, -5 },
  { 97, 3, 2, 4, 0, -2 },
  { 98, 8, 10, 6, -1, -10 },
  { 108, 8, 10, 8, 0, -10 },
  { 118, 6, 10, 8, 1, -10 },
  { 126, 8, 10, 8, 0, -10 },
  { 136, 8, 10, 8, 0, -10 },
  { 146, 8, 10, 8, 0, -10 },
  { 156, 8, 10, 8, 0, -10 },
  { 166, 7, 10, 8, 1, -10 },
  { 175, 9, 10, 8, 0, -10 },
  { 187, 8, 10, 8, 0, -10 },
  { 197, 7, 10, 8, 1, -10 },
  { 206, 4, 8, 4, 0, -8 },
  { 210, 5, 10, 4, -1, -8 },
  { 217, 7, 8, 8, 1, -9 },
  { 224, 7, 4, 8, 1, -7 },
  { 228, 7, 8, 8, 1, -9 },
  { 235, 6, 10, 7, 1, -10 },
  { 243, 11, 11, 12, 1, -10 },
  { 259, 9, 10, 9, -1, -10 },
  { 271, 9, 10, 9, 0, -10 },
  { 283, 8, 10, 9, 1, -10 },
  { 293, 9, 10, 10, 0, -10 },
  { 305, 8, 10, 8, 0, -10 },
  { 315, 8, 10, 8, 0, -10 },
  { 325, 9, 10, 10, 1, -10 },
  { 337, 10, 10, 10, 0, -10 },
  { 350, 6, 10, 6, 0, -10 },
  { 358, 7, 13, 5, -2, -10 },
  { 370, 10, 10, 9, 0, -10 },
  { 383, 6, 10, 7, 0, -10 },
  { 391, 13, 10, 13, 0, -10 },
  { 408, 11, 10, 11, 0, -10 },
  { 422, 9, 10, 10, 1, -10 },
  { 434, 9, 10, 9, 0, -10 },
  { 446, 9, 12, 10, 1, -10 },
  { 460, 8, 10, 9, 0, -10 },
  { 470, 8, 10, 8, 0, -10 },
  { 480, 8, 10, 8, 1, -10 },
  { 490, 9, 10, 10, 1, -10 },
  { 502, 9, 10, 8, 1, -10 },
  { 514, 13, 10, 13, 1, -10 },
  { 531, 11, 10, 9, -1, -10 },
  { 545, 8, 10, 8, 1, -10 },
  { 555, 9, 10, 8, -1, -10 },
  { 567, 6, 12, 5, 0, -10 },
  { 576, 3, 10, 6, 2, -10 },
  { 580, 6, 12, 5, -1, -10 },
  { 589, 7, 7, 8, 0, -10 },
  { 596, 6, 1, 6, -1, 1 },
  { 597, 3, 3, 5, 2, -11 },
  { 599, 7, 8, 8, 1, -8 },
  { 606, 8, 11, 8, 0, -11 },
  { 617, 6, 8, 7, 1, -8 },
  { 623, 8, 11, 8, 1, -11 },
  { 634, 7, 8, 8, 1, -8 },
  { 641, 8, 14, 5, -1, -11 },
  { 655, 8, 11, 8, 0, -8 },
  { 666, 8, 11, 9, 0, -11 },
  { 677, 5, 11, 4, 0, -11 },
  { 684, 7, 14, 4, -2, -11 },
  { 697, 9, 11, 8, 0, -11 },
  { 710, 5, 11, 4, 0, -11 },
  { 717, 12, 8, 13, 0, -8 },
  { 729, 8, 8, 9, 0, -8 },
  { 737, 7, 8, 8, 1, -8 },
  { 744, 9, 11, 8, -1, -8 },
  { 757, 7, 11, 8, 1, -8 },
  { 767, 7, 8, 6, 0, -8 },
  { 774, 7, 8, 7, 0, -8 },
  { 781, 5, 9, 6, 1, -9 },
  { 787, 7, 8, 9, 1, -8 },
  { 794, 7, 8, 7, 1, -8 },
  { 801, 11, 8, 11, 1, -8 },
  { 812, 9, 8, 8, -1, -8 },
  { 821, 9, 11, 7, -1, -8 },
  { 834, 7, 8, 7, 0, -8 },
  { 841, 6, 12, 5, 0, -10 },
  { 850, 2, 14, 8, 3, -11 },
  { 854, 6, 12, 5, -1, -10 },
  { 863, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_ExtraBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRABOLDITALIC14PT7B_H_
