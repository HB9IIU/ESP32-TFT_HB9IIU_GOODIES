#ifndef _NOTOSANS_EXTRABOLDITALIC43PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x04, 0x00, 0x3F, 0x3F, 0xBF,
  0x9F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xFC, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xFC, 0x7C, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xDC, 0x70, 0x7F,
  0x38, 0x00, 0xFE, 0x70, 0x01, 0xFC, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0x7F, 0x00, 0x1E, 0xFE,
  0x00, 0x39, 0xFC, 0xC0, 0x73, 0xF9, 0xF0, 0xEF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x3F,
  0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0xF0, 0x1F, 0x80,
  0x7E, 0x7E, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0xF8, 0x03, 0xF1, 0xF8, 0x3E,
  0x00, 0x7C, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xE3, 0xF0, 0x03, 0xF0, 0xF8,
  0x7C, 0x00, 0x7E, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xE7, 0xE3, 0xE1, 0xF9,
  0xF9, 0xF9, 0xFF, 0x1F, 0xFF, 0x3E, 0x7F, 0xF3, 0xFF, 0xCF, 0xDF, 0xFE,
  0x7F, 0xFB, 0xF3, 0xFF, 0xE7, 0xFE, 0xFC, 0xFC, 0xFC, 0x3F, 0x1F, 0x1F,
  0x9F, 0x80, 0x07, 0xE7, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x7E, 0x00, 0x3E,
  0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xE1, 0xF8, 0x03, 0xF0, 0x7C, 0x3E, 0x00,
  0xFC, 0x0F, 0x8F, 0xC0, 0x1F, 0x01, 0xF1, 0xF8, 0x07, 0xC0, 0x3F, 0x7E,
  0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x0F,
  0xFC, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x3F, 0xC3, 0xFF, 0xC0, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0xFF, 0xFE,
  0x1F, 0xC7, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xFB, 0xF8, 0xFF, 0x0F, 0xFF,
  0xE3, 0xF8, 0x3F, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0x80, 0xFF, 0xE0,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0x00, 0x7F,
  0xE1, 0xFE, 0x00, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x02, 0x03, 0xE0, 0x1C, 0x3E, 0x01,
  0xF9, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x04, 0x7F, 0xF8, 0x07,
  0xF7, 0xC0, 0x7F, 0x9F, 0x00, 0xF8, 0xF8, 0x03, 0x87, 0xE0, 0x04, 0x3F,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x83, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0,
  0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC,
  0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03,
  0xF9, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F,
  0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xF7,
  0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F,
  0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xDF, 0xC7, 0xC7, 0xF0,
  0xE3, 0xF8, 0x20, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xF0, 0xFF, 0x01, 0xC0, 0x7F, 0x00, 0x80, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xF0, 0x7F, 0x80, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0xC0, 0x07, 0xF9, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFD, 0xF8,
  0x01, 0xFB, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x10, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0xC0, 0x1F, 0xF1, 0xF9, 0xFF, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x07, 0xF7, 0xFE, 0x0F, 0xDF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xDF, 0xF1, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F,
  0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x0F, 0xF1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFE, 0x0F,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x1F, 0xEF, 0xF0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF9, 0xFF, 0xDF, 0xCF, 0xFF, 0xFC, 0x1F, 0xCF, 0xE0, 0x10, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC7, 0x1F, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xE0, 0x10, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x07, 0xF9, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x78, 0x0F, 0xC3, 0xE0, 0x7F, 0xF8, 0xF8,
  0xFC, 0x1F, 0xFF, 0x1F, 0x9F, 0x07, 0xFF, 0xE1, 0xF7, 0xC1, 0xFF, 0xFC,
  0x3E, 0xF8, 0x7E, 0x1F, 0x07, 0xDF, 0x0F, 0x83, 0xE0, 0xFF, 0xC3, 0xF0,
  0x7C, 0x1F, 0xF8, 0x7C, 0x0F, 0x87, 0xFF, 0x1F, 0x83, 0xE0, 0xFB, 0xE3,
  0xF0, 0x7C, 0x1F, 0x7C, 0x7E, 0x0F, 0x87, 0xEF, 0x8F, 0xC3, 0xF0, 0xF9,
  0xF1, 0xF8, 0xFE, 0x3F, 0x3E, 0x3F, 0xFF, 0xFF, 0xC7, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFC, 0x7F, 0xEF, 0xFC, 0x0F, 0x87, 0xF8, 0xFF, 0x01, 0xF8, 0x1C,
  0x0F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC0, 0xF0, 0x7F, 0xC0, 0x0C, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x38, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0xF0, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0,
  0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x0F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0x7F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0xE0,
  0x7F, 0xC0, 0x04, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0x9F,
  0xC1, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC, 0xFF, 0x07, 0xFF, 0x9F, 0xE0, 0xFF,
  0xF3, 0xFC, 0x1F, 0xFE, 0x7F, 0x84, 0x3F, 0xCF, 0xF0, 0x07, 0xF1, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0xC0, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xC0,
  0x07, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0xC0, 0x03,
  0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFB, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFD, 0xF0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0,
  0xFD, 0xF8, 0x0F, 0xDF, 0x03, 0xE7, 0xE0, 0x3F, 0x7C, 0x1F, 0xBF, 0x81,
  0xFD, 0xF0, 0x7C, 0xFE, 0x07, 0xF7, 0xC3, 0xF3, 0xF0, 0x1F, 0x9F, 0x8F,
  0x8F, 0xC0, 0x7E, 0x7E, 0x7E, 0x7F, 0x01, 0xF9, 0xF9, 0xF9, 0xFC, 0x0F,
  0xE7, 0xEF, 0xC7, 0xF0, 0x3F, 0x9F, 0xBF, 0x1F, 0x80, 0xFC, 0x7F, 0xF8,
  0x7E, 0x03, 0xF1, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0xFF, 0x0F, 0xE0, 0x7F,
  0x1F, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xE0, 0xFC, 0x07, 0xE0, 0xFF, 0x87,
  0xF0, 0x1F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x00,
  0x7F, 0x07, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0x80,
  0x7E, 0x07, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x0F, 0xDF, 0xC0,
  0xFE, 0x0F, 0xDF, 0xC0, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0x0F, 0xCF, 0xE1,
  0xFC, 0x0F, 0xCF, 0xE1, 0xFC, 0x1F, 0xC7, 0xE1, 0xF8, 0x1F, 0xC7, 0xF1,
  0xF8, 0x1F, 0x87, 0xF3, 0xF8, 0x1F, 0x87, 0xF3, 0xF8, 0x1F, 0x83, 0xF3,
  0xF8, 0x3F, 0x83, 0xFB, 0xF0, 0x3F, 0x83, 0xFB, 0xF0, 0x3F, 0x01, 0xFB,
  0xF0, 0x3F, 0x01, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0xFF,
  0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF,
  0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC3, 0xFE,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07,
  0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xC3, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF3, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFC,
  0x1E, 0x0F, 0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x40,
  0x07, 0xF0, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xA0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF,
  0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x7F,
  0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xE0, 0x3F, 0x9F, 0x80, 0x7F, 0xC0, 0x7F, 0x3F, 0x01, 0xFF, 0x81,
  0xFC, 0x7E, 0x03, 0xFF, 0x03, 0xF8, 0xFC, 0x07, 0xFE, 0x07, 0xF1, 0xF8,
  0x1F, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0xF8, 0x3F, 0x87, 0xE0, 0xFF, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF7, 0xE1, 0xFC, 0x1F, 0x87, 0xEF, 0xC7, 0xF0, 0x3F,
  0x0F, 0xDF, 0x8F, 0xE0, 0x7E, 0x3F, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x7E,
  0x7F, 0x01, 0xF8, 0xFC, 0xFC, 0xFE, 0x03, 0xF3, 0xF1, 0xF9, 0xF8, 0x07,
  0xE7, 0xE3, 0xF7, 0xF0, 0x0F, 0xDF, 0x87, 0xEF, 0xC0, 0x1F, 0xBF, 0x0F,
  0xFF, 0x80, 0x3F, 0x7C, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7,
  0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xEF, 0xF0, 0x03, 0xF7, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF3, 0xC0, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xFC, 0x7E, 0x00, 0xF9, 0xF8, 0x01,
  0xF7, 0xE0, 0x03, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x83, 0xE0, 0x7C, 0x00,
  0xF8, 0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83,
  0xFC, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F,
  0x9F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFE, 0xFC, 0x0F, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE7,
  0xC0, 0x3F, 0xBF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF,
  0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFF, 0x07, 0xF1, 0xFE,
  0x1F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0x7F,
  0xF0, 0x7E, 0x7F, 0xC0, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xC0,
  0xC7, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x10, 0xFF, 0xDF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7C, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0x80, 0x7F, 0xEF, 0x80, 0x1F,
  0xC7, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF1, 0xFC, 0xFF, 0x07, 0xEF, 0xF0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x02, 0x3F, 0xC0, 0x70, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x3F,
  0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0xDF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x80, 0x1F, 0xC0, 0xF0, 0x7F, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF8,
  0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07,
  0xF3, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x7F, 0x81, 0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x3F,
  0xC1, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07,
  0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x7F, 0x83, 0xFC,
  0x0F, 0xDF, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xF1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x3F, 0xC0, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xE0, 0xFF, 0x3F, 0x81, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x0F, 0xE7, 0xF8,
  0x1F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xFC, 0xFF, 0x07, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x03, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x9F, 0xF0, 0x3F, 0x7F, 0xF0,
  0x7E, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0x8F,
  0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFE,
  0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0,
  0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF1, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x7F,
  0x80, 0x1F, 0xBF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x7E,
  0x07, 0xFC, 0xFC, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFE,
  0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0,
  0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xC3, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xEF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x87, 0x0F, 0xE0,
  0x21, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x90, 0x07, 0xF3, 0x81, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x30, 0xFF, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7,
  0xE0, 0x3F, 0xE7, 0xE0, 0x1F, 0xC7, 0xE0, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x8F, 0xC0, 0xFE,
  0x1F, 0x81, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xE0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x03,
  0xF9, 0xF8, 0x1F, 0xE0, 0x7F, 0x3F, 0x07, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF,
  0x83, 0xF8, 0xFC, 0x1F, 0xF0, 0xFE, 0x1F, 0x87, 0xFE, 0x1F, 0xC3, 0xF0,
  0xFF, 0xC3, 0xF8, 0x7E, 0x3E, 0xF8, 0xFE, 0x0F, 0xC7, 0xDF, 0x1F, 0xC1,
  0xF9, 0xFB, 0xE7, 0xF0, 0x3F, 0x3E, 0x7C, 0xFE, 0x07, 0xE7, 0xCF, 0x9F,
  0x80, 0xFD, 0xF9, 0xF7, 0xF0, 0x1F, 0xBE, 0x3E, 0xFC, 0x03, 0xF7, 0xC7,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xE3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F,
  0xBF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0xFF, 0xD0, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 32, 13, 0, -31 },
  { 57, 17, 11, 19, 4, -31 },
  { 81, 27, 31, 28, 1, -31 },
  { 186, 23, 36, 24, 1, -33 },
  { 290, 35, 31, 38, 2, -31 },
  { 426, 30, 31, 31, 1, -31 },
  { 543, 8, 11, 11, 4, -31 },
  { 554, 17, 38, 15, 1, -31 },
  { 635, 17, 38, 15, -3, -31 },
  { 716, 21, 21, 23, 3, -33 },
  { 772, 21, 21, 25, 2, -26 },
  { 828, 11, 11, 13, -2, -5 },
  { 844, 12, 5, 14, 1, -14 },
  { 852, 8, 8, 13, 0, -7 },
  { 860, 24, 31, 19, -2, -31 },
  { 953, 23, 31, 24, 1, -31 },
  { 1043, 18, 31, 24, 4, -31 },
  { 1113, 24, 31, 24, -1, -31 },
  { 1206, 23, 31, 24, 0, -31 },
  { 1296, 24, 31, 24, 0, -31 },
  { 1389, 23, 31, 24, 1, -31 },
  { 1479, 23, 31, 24, 2, -31 },
  { 1569, 25, 31, 24, 1, -31 },
  { 1666, 23, 31, 24, 1, -31 },
  { 1756, 21, 31, 24, 2, -31 },
  { 1838, 12, 25, 13, 0, -24 },
  { 1876, 14, 30, 13, -2, -24 },
  { 1929, 21, 23, 25, 2, -27 },
  { 1990, 21, 14, 25, 2, -22 },
  { 2027, 21, 23, 25, 2, -27 },
  { 2088, 19, 32, 20, 3, -31 },
  { 2164, 35, 35, 38, 2, -31 },
  { 2318, 28, 31, 28, -3, -31 },
  { 2427, 25, 31, 27, 1, -31 },
  { 2524, 26, 31, 27, 2, -31 },
  { 2625, 27, 31, 29, 1, -31 },
  { 2730, 24, 31, 24, 1, -31 },
  { 2823, 24, 31, 24, 1, -31 },
  { 2916, 27, 31, 30, 2, -31 },
  { 3021, 30, 31, 30, 1, -31 },
  { 3138, 21, 31, 17, -1, -31 },
  { 3220, 22, 40, 15, -7, -31 },
  { 3330, 30, 31, 27, 1, -31 },
  { 3447, 19, 31, 22, 1, -31 },
  { 3521, 38, 31, 38, 1, -31 },
  { 3669, 32, 31, 33, 1, -31 },
  { 3793, 28, 31, 32, 2, -31 },
  { 3902, 25, 31, 26, 1, -31 },
  { 3999, 28, 38, 32, 2, -31 },
  { 4132, 25, 31, 27, 1, -31 },
  { 4229, 23, 31, 23, 1, -31 },
  { 4319, 23, 31, 23, 3, -31 },
  { 4409, 27, 31, 30, 3, -31 },
  { 4514, 25, 31, 26, 4, -31 },
  { 4611, 39, 31, 39, 4, -31 },
  { 4763, 34, 31, 27, -3, -31 },
  { 4895, 25, 31, 25, 4, -31 },
  { 4992, 27, 31, 23, -2, -31 },
  { 5097, 19, 38, 15, -1, -31 },
  { 5188, 11, 31, 19, 5, -31 },
  { 5231, 19, 38, 15, -3, -31 },
  { 5322, 23, 20, 23, 0, -31 },
  { 5380, 19, 4, 18, -4, 3 },
  { 5390, 10, 7, 14, 6, -33 },
  { 5399, 23, 24, 26, 2, -24 },
  { 5468, 23, 33, 26, 1, -33 },
  { 5563, 20, 24, 21, 2, -24 },
  { 5623, 25, 33, 26, 2, -33 },
  { 5727, 21, 24, 24, 2, -24 },
  { 5790, 25, 43, 17, -4, -33 },
  { 5925, 24, 34, 26, 1, -24 },
  { 6027, 23, 33, 26, 1, -33 },
  { 6122, 13, 33, 13, 1, -33 },
  { 6176, 21, 43, 13, -6, -33 },
  { 6289, 27, 33, 25, 1, -33 },
  { 6401, 14, 33, 13, 1, -33 },
  { 6459, 36, 24, 39, 1, -24 },
  { 6567, 23, 24, 26, 1, -24 },
  { 6636, 22, 24, 26, 2, -24 },
  { 6702, 26, 34, 26, -2, -24 },
  { 6813, 23, 34, 26, 2, -24 },
  { 6911, 19, 24, 18, 1, -24 },
  { 6968, 19, 24, 21, 1, -24 },
  { 7025, 17, 29, 19, 2, -29 },
  { 7087, 24, 24, 26, 2, -24 },
  { 7159, 23, 24, 23, 2, -24 },
  { 7228, 35, 24, 35, 2, -24 },
  { 7333, 28, 24, 24, -2, -24 },
  { 7417, 28, 34, 23, -3, -24 },
  { 7536, 22, 24, 21, -1, -24 },
  { 7602, 18, 38, 15, 0, -31 },
  { 7688, 6, 43, 24, 9, -33 },
  { 7721, 18, 38, 15, -2, -31 },
  { 7807, 21, 8, 25, 2, -19 },
};

const GFXfont NotoSans_ExtraBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRABOLDITALIC43PT7B_H_
