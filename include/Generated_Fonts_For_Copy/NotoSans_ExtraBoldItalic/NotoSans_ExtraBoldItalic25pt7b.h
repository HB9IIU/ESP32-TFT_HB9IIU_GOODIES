#ifndef _NOTOSANS_EXTRABOLDITALIC25PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x7B, 0xDE, 0xF7, 0x39, 0xCE,
  0x73, 0xB8, 0xEE, 0x70, 0x01, 0xCE, 0x03, 0x8E, 0x03, 0x9C, 0x03, 0x9C,
  0x03, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0E, 0x38, 0x0E, 0x70,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0x39, 0xC0, 0x39, 0xC0, 0x00, 0xC0, 0x0C, 0x03, 0xFC, 0x3F, 0xF3, 0xFF,
  0x1E, 0x89, 0xEC, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x6F, 0x03, 0x7B, 0x1F, 0xDF, 0xFC, 0xFF, 0xC3, 0xFC, 0x03, 0x00, 0x38,
  0x00, 0x1F, 0x01, 0xE1, 0xFC, 0x1E, 0x1F, 0xE0, 0xE0, 0xE7, 0x0E, 0x07,
  0x38, 0xE0, 0x79, 0xCF, 0x03, 0xCE, 0x70, 0x1E, 0xF7, 0x3C, 0x7F, 0x77,
  0xF3, 0xFF, 0xBF, 0x8F, 0x3B, 0xDC, 0x03, 0x9C, 0xF0, 0x3C, 0xE7, 0x01,
  0xC7, 0x38, 0x1C, 0x39, 0xC1, 0xC1, 0xDC, 0x1E, 0x0F, 0xE1, 0xE0, 0x3E,
  0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE3, 0xCF, 0xF1, 0xE7,
  0xFE, 0x79, 0xE7, 0xFC, 0x78, 0xFF, 0x3E, 0x3F, 0x87, 0xC7, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xF7, 0xC0, 0x7B, 0xDC, 0xE7, 0x73, 0x80, 0x07,
  0xC1, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0,
  0x70, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0x81, 0xE0, 0xF0, 0x38, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x47, 0x07,
  0x70, 0xFF, 0x37, 0xFF, 0x0F, 0xF1, 0xF3, 0x7B, 0x87, 0xB8, 0x33, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3C, 0xF7, 0x9E, 0xF3, 0x80,
  0x7F, 0x7E, 0xFE, 0x77, 0xFF, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x7D, 0xF7, 0xC7, 0xBC, 0x3D,
  0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3D, 0xE1, 0xEF, 0x1F, 0x78,
  0xF3, 0xCF, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x7F,
  0x1F, 0xEF, 0xFC, 0xF7, 0x99, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x43, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE0, 0x07, 0xE0, 0xFF, 0xE1, 0xFF,
  0x83, 0xBF, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x83, 0xFC, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xEC, 0x1F, 0x3F, 0xFC, 0xFF,
  0xE1, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF8,
  0x1F, 0xE0, 0xF7, 0x03, 0xBC, 0x1C, 0xF0, 0xF3, 0xC7, 0x8F, 0x3F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xCC,
  0x1F, 0x3F, 0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC7, 0xFE,
  0x3E, 0x13, 0xC0, 0x3E, 0x01, 0xE7, 0x0F, 0xFC, 0xFF, 0xF7, 0xFF, 0xBE,
  0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xFB, 0xE7, 0x8F, 0xFC, 0x7F, 0xC1, 0xFC,
  0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFF,
  0x8F, 0xFE, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xFB, 0xC3, 0xFC, 0x0F, 0x81,
  0xFE, 0x1F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0xFC, 0x7F,
  0xC1, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF9, 0xE7, 0x8F, 0x3C,
  0x7F, 0xE3, 0xFF, 0x1F, 0x7B, 0xF3, 0xFF, 0x9F, 0xFC, 0x39, 0xE0, 0x1E,
  0x01, 0xF2, 0x1F, 0x1F, 0xF8, 0xFF, 0x87, 0xF0, 0x00, 0x1E, 0x3C, 0xF8,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x9E, 0x00, 0x0F, 0x0F,
  0x1F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78,
  0x70, 0xF0, 0xE0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x1F,
  0x07, 0xF3, 0xFC, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x3F, 0x1F, 0xF9,
  0xFF, 0x39, 0xF4, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x3F, 0x07, 0x81, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xE0, 0x1E, 0x3C, 0x00, 0xF3, 0x87,
  0xE7, 0x71, 0xFE, 0x77, 0x3E, 0xE7, 0xE3, 0x8E, 0x7E, 0x70, 0xE7, 0xE7,
  0x1C, 0x7E, 0x71, 0xC7, 0xE7, 0x3C, 0xEE, 0x7F, 0xFC, 0xF3, 0xEF, 0x87,
  0x08, 0x20, 0x78, 0x00, 0x03, 0xE1, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0x0F,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F,
  0xFC, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x3E, 0x3C,
  0xF0, 0xF3, 0xC7, 0xCF, 0xFE, 0x3F, 0xE1, 0xFF, 0xC7, 0x9F, 0x9E, 0x1E,
  0x78, 0x7B, 0xE3, 0xEF, 0x9F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0x03,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xE0, 0x47, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x8C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0xFB, 0xC1, 0xF7, 0x87, 0xDF, 0x1F, 0xBF,
  0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x87, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x04, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xDE, 0x3E, 0x02, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0xFE, 0xF8, 0xFE, 0xF9, 0xFE, 0xF8, 0x3C, 0xF8,
  0x3C, 0x78, 0x3C, 0x7E, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F,
  0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0xF8,
  0xF0, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0x07,
  0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78,
  0x3C, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0x8F, 0x0F, 0x87,
  0x8F, 0x83, 0xCF, 0x83, 0xE7, 0x81, 0xE7, 0xC0, 0xF7, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF,
  0x83, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3E, 0x00, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0xFE, 0xFF, 0xDF, 0xF8, 0x1F,
  0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC3, 0xB8, 0xFE, 0x1F, 0xC7, 0x71, 0xDE, 0x3B, 0x8E, 0xF3, 0xDC,
  0xE7, 0x1E, 0xE7, 0x78, 0xF7, 0x73, 0xC7, 0x3B, 0x9E, 0x79, 0xFC, 0xF3,
  0xCF, 0xC7, 0x1E, 0x7E, 0x78, 0xF3, 0xE3, 0xC7, 0x1F, 0x1E, 0x00, 0x1F,
  0x01, 0xC7, 0xE0, 0xF1, 0xF8, 0x3C, 0x7E, 0x0F, 0x3F, 0xC3, 0xCF, 0xF1,
  0xE3, 0xFC, 0x78, 0xE7, 0x1E, 0x39, 0xE7, 0x9E, 0x79, 0xC7, 0x9E, 0xF1,
  0xE3, 0xFC, 0x70, 0xFF, 0x3C, 0x3F, 0xCF, 0x07, 0xE3, 0xC1, 0xF8, 0xF0,
  0x7E, 0x38, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF7,
  0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0x7C,
  0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xE3, 0xC1, 0xF1, 0xF9, 0xF0,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3F, 0xFD, 0xFF,
  0xE7, 0xFF, 0x1F, 0xE0, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF7, 0xE3,
  0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0x7C, 0x07,
  0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xE3, 0xC1, 0xF1, 0xFB, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0xBF, 0x3E, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x1F, 0x3F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1E, 0x78, 0x79,
  0xE3, 0xE7, 0xCF, 0x8F, 0x3C, 0x3E, 0xF0, 0xFB, 0xC1, 0xF0, 0x03, 0xF0,
  0x3F, 0xF1, 0xFF, 0x87, 0xDE, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF2, 0x07, 0xCF, 0x3E,
  0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x00,
  0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0x80,
  0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x1C,
  0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x38,
  0x1F, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF7, 0x87, 0xC3, 0xEF, 0x0F, 0x87,
  0x9E, 0x3F, 0x0F, 0x3C, 0x7E, 0x3C, 0x79, 0xFC, 0x78, 0xF3, 0xBD, 0xE1,
  0xE7, 0x7B, 0xC3, 0xDE, 0xF7, 0x87, 0xB9, 0xFE, 0x0F, 0xF3, 0xFC, 0x0F,
  0xC7, 0x70, 0x1F, 0x8F, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x03, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80,
  0x79, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3C, 0xF8, 0x0F,
  0x8F, 0x03, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0xF0,
  0xF9, 0xE1, 0xE3, 0xC7, 0x87, 0x9F, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3F, 0x07, 0xE1,
  0xFC, 0x00, 0xE3, 0x8F, 0x3C, 0xF1, 0xC7, 0x1C, 0x71, 0xE7, 0x9E, 0x38,
  0xE3, 0x8F, 0x3C, 0xF0, 0x07, 0xE0, 0xFC, 0x3F, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x07, 0x70, 0x39, 0xC3, 0x8E,
  0x3C, 0x71, 0xC1, 0xDC, 0x0F, 0xE0, 0x70, 0xFF, 0xFF, 0xFC, 0xF3, 0x9E,
  0x70, 0x0F, 0x3C, 0x7E, 0xE3, 0xFF, 0x9F, 0xBE, 0x7C, 0xF9, 0xE3, 0xEF,
  0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x9F, 0x3F, 0xF8, 0x7E, 0xE0,
  0xF7, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7B,
  0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C,
  0x7C, 0xF1, 0xE7, 0xC7, 0x9F, 0x3E, 0x7F, 0xF1, 0xFF, 0x8F, 0x7C, 0x00,
  0x07, 0xE1, 0xFF, 0x3F, 0xE7, 0xEE, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0xC7, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC1, 0xEF, 0x87, 0xFE, 0x1F, 0xFC,
  0x7E, 0xF8, 0xF9, 0xF1, 0xE1, 0xE7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C,
  0x7C, 0x7C, 0xF0, 0xFF, 0xE0, 0xFD, 0xC0, 0xF7, 0x80, 0x07, 0xC0, 0xFF,
  0x8F, 0xFC, 0xF8, 0xF7, 0x8F, 0xBC, 0x7B, 0xFF, 0xDF, 0xFC, 0xFE, 0x07,
  0x80, 0x3E, 0x08, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x00, 0x3E, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x3F, 0x81, 0xFF, 0x07, 0xFC, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x17,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0x07, 0x9E, 0x1F, 0xB8, 0x7F,
  0xF1, 0xFB, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF1, 0xF1, 0xF3, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xDE, 0x00, 0x3C, 0x00,
  0xF0, 0xE3, 0xE1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7B, 0xC1, 0xFF, 0x87, 0xFF, 0x1F,
  0x7C, 0xF8, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0x79, 0xE3, 0xEF, 0x8F, 0x00, 0x0F, 0x0F, 0x0F, 0x06, 0x00,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x78, 0xF8, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE1, 0x7C, 0x3F, 0x87, 0xE0, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x3D, 0xF0, 0x3D, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7D, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0x78,
  0xF8, 0xF8, 0x78, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E,
  0x00, 0x1E, 0xF0, 0xF0, 0x77, 0xE7, 0xE1, 0xFF, 0xFF, 0x87, 0xDF, 0xDF,
  0x3E, 0x3E, 0x7C, 0xF8, 0xF1, 0xF3, 0xC3, 0xC7, 0x8F, 0x1F, 0x1E, 0x3C,
  0x78, 0x79, 0xF1, 0xE1, 0xE7, 0x87, 0x8F, 0x9E, 0x1E, 0x3C, 0x78, 0xF0,
  0xF3, 0xE3, 0xC3, 0xC0, 0x1E, 0xF0, 0x77, 0xE1, 0xFF, 0xC7, 0xDF, 0x3E,
  0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0x79, 0xE1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0xFB, 0xE3, 0xC0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFD, 0xF7,
  0x87, 0xBC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0xBE, 0x7C, 0xFF,
  0xC7, 0xFC, 0x1F, 0xC0, 0x0F, 0x78, 0x1D, 0xF8, 0x3F, 0xF8, 0x7D, 0xF1,
  0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x7C, 0x78, 0xF9,
  0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xBC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x3C, 0x7E, 0xE3, 0xFF, 0x9F,
  0xBE, 0x7C, 0xF9, 0xE1, 0xEF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x9E, 0x3F, 0xF8, 0x7F, 0xE0, 0xF7, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x1E, 0x71, 0xFE, 0x1D, 0xE1, 0xFE, 0x3F,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0x0F, 0xC1, 0xFF, 0x3F, 0xE3, 0xC6, 0x3C, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xC0, 0x3E, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x0E,
  0x03, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x4F, 0xF1, 0xFC, 0x7F, 0x00, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC7, 0x9F, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0xF8,
  0xF3, 0xC7, 0xCF, 0x9F, 0x3F, 0xFC, 0x7E, 0xE1, 0xF3, 0x80, 0xF0, 0x7F,
  0xC1, 0xEF, 0x0F, 0x1C, 0x3C, 0x79, 0xE1, 0xE7, 0x87, 0xBC, 0x1E, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xF0,
  0xF8, 0xFF, 0x0F, 0x8F, 0x71, 0xF1, 0xE7, 0x1F, 0x1E, 0x73, 0xB3, 0xC7,
  0x3F, 0x3C, 0x73, 0xF3, 0x87, 0x77, 0x78, 0x77, 0x77, 0x87, 0xE7, 0xF0,
  0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x1E, 0x1F,
  0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8,
  0xF8, 0x78, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0x81, 0xE3, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x9F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFE, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x80,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C,
  0x07, 0xC1, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xF0,
  0x7C, 0x1F, 0x1F, 0x87, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x83, 0xE0,
  0xF0, 0x38, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
};

const GFXglyph NotoSans_ExtraBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 10, 7, 11, 2, -18 },
  { 28, 16, 18, 16, 0, -18 },
  { 64, 13, 20, 14, 1, -19 },
  { 97, 21, 18, 22, 1, -18 },
  { 145, 18, 18, 18, 0, -18 },
  { 186, 5, 7, 6, 2, -18 },
  { 191, 10, 22, 9, 1, -18 },
  { 219, 10, 22, 9, -2, -18 },
  { 247, 12, 12, 14, 2, -19 },
  { 265, 12, 12, 14, 1, -15 },
  { 283, 6, 6, 7, -1, -3 },
  { 288, 8, 3, 8, 0, -8 },
  { 291, 5, 4, 7, 0, -4 },
  { 294, 14, 18, 11, -1, -18 },
  { 326, 13, 18, 14, 1, -18 },
  { 356, 11, 18, 14, 2, -18 },
  { 381, 15, 18, 14, -1, -18 },
  { 415, 14, 18, 14, 0, -18 },
  { 447, 14, 18, 14, 0, -18 },
  { 479, 14, 18, 14, 0, -18 },
  { 511, 13, 18, 14, 1, -18 },
  { 541, 14, 18, 14, 1, -18 },
  { 573, 13, 18, 14, 1, -18 },
  { 603, 13, 18, 14, 1, -18 },
  { 633, 7, 14, 7, 0, -14 },
  { 646, 8, 17, 7, -1, -14 },
  { 663, 12, 14, 14, 1, -16 },
  { 684, 12, 8, 14, 1, -13 },
  { 696, 12, 14, 14, 1, -16 },
  { 717, 11, 18, 12, 2, -18 },
  { 742, 20, 20, 22, 1, -18 },
  { 792, 17, 18, 16, -2, -18 },
  { 831, 14, 18, 16, 1, -18 },
  { 863, 15, 18, 16, 1, -18 },
  { 897, 15, 18, 17, 1, -18 },
  { 931, 14, 18, 14, 1, -18 },
  { 963, 14, 18, 14, 1, -18 },
  { 995, 16, 18, 17, 1, -18 },
  { 1031, 17, 18, 18, 1, -18 },
  { 1070, 12, 18, 10, -1, -18 },
  { 1097, 13, 23, 9, -4, -18 },
  { 1135, 17, 18, 16, 1, -18 },
  { 1174, 11, 18, 13, 1, -18 },
  { 1199, 21, 18, 22, 1, -18 },
  { 1247, 18, 18, 19, 1, -18 },
  { 1288, 17, 18, 18, 1, -18 },
  { 1327, 14, 18, 15, 1, -18 },
  { 1359, 17, 22, 18, 1, -18 },
  { 1406, 14, 18, 16, 1, -18 },
  { 1438, 14, 18, 13, 0, -18 },
  { 1470, 13, 18, 14, 2, -18 },
  { 1500, 16, 18, 17, 2, -18 },
  { 1536, 15, 18, 15, 2, -18 },
  { 1570, 23, 18, 23, 2, -18 },
  { 1622, 19, 18, 16, -1, -18 },
  { 1665, 15, 18, 15, 2, -18 },
  { 1699, 16, 18, 13, -1, -18 },
  { 1735, 11, 22, 9, -1, -18 },
  { 1766, 6, 18, 11, 3, -18 },
  { 1780, 11, 22, 9, -2, -18 },
  { 1811, 13, 12, 14, 0, -18 },
  { 1831, 11, 2, 11, -2, 2 },
  { 1834, 5, 4, 8, 4, -19 },
  { 1837, 14, 14, 15, 1, -14 },
  { 1862, 14, 19, 15, 0, -19 },
  { 1896, 12, 14, 12, 1, -14 },
  { 1917, 15, 19, 15, 1, -19 },
  { 1953, 13, 14, 14, 1, -14 },
  { 1976, 15, 25, 10, -3, -19 },
  { 2023, 15, 20, 15, 0, -14 },
  { 2061, 14, 19, 15, 0, -19 },
  { 2095, 8, 19, 8, 0, -19 },
  { 2114, 11, 25, 8, -3, -19 },
  { 2149, 16, 19, 15, 0, -19 },
  { 2187, 9, 19, 8, 0, -19 },
  { 2209, 22, 14, 23, 0, -14 },
  { 2248, 14, 14, 15, 0, -14 },
  { 2273, 13, 14, 15, 1, -14 },
  { 2296, 15, 20, 15, -1, -14 },
  { 2334, 14, 20, 15, 1, -14 },
  { 2369, 12, 14, 11, 0, -14 },
  { 2390, 12, 14, 12, 0, -14 },
  { 2411, 10, 17, 11, 1, -17 },
  { 2433, 14, 14, 15, 1, -14 },
  { 2458, 14, 14, 13, 1, -14 },
  { 2483, 20, 14, 20, 1, -14 },
  { 2518, 16, 14, 14, -1, -14 },
  { 2546, 17, 20, 13, -2, -14 },
  { 2589, 12, 14, 12, 0, -14 },
  { 2610, 11, 22, 9, 0, -18 },
  { 2641, 3, 25, 14, 5, -19 },
  { 2651, 10, 22, 9, -1, -18 },
  { 2679, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_ExtraBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRABOLDITALIC25PT7B_H_
