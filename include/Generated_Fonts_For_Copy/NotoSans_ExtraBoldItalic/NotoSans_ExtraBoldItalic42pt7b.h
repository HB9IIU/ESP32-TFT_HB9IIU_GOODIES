#ifndef _NOTOSANS_EXTRABOLDITALIC42PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x7F, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7E, 0xFC, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0x38, 0x61, 0xFC, 0xE0, 0x07, 0xF7, 0x00, 0x1F, 0xDC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xCF,
  0xE0, 0x07, 0x3F, 0xB0, 0x1C, 0xFC, 0xF8, 0x77, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x7E, 0x03, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0xFF,
  0xF8, 0x07, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x07,
  0xE3, 0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x1F, 0x80,
  0x3F, 0x0F, 0x87, 0xC0, 0x0F, 0xC7, 0xE3, 0xE0, 0x03, 0xF1, 0xF9, 0xF0,
  0x00, 0xFC, 0x7C, 0xFC, 0xFF, 0x3F, 0x3F, 0x3E, 0x7F, 0xE7, 0xFF, 0x9F,
  0x3F, 0xF9, 0xFF, 0xEF, 0xDF, 0xFF, 0x3F, 0xF7, 0xE7, 0xEF, 0xC7, 0xF1,
  0xF3, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x1F, 0x00,
  0x3F, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE3, 0xF0, 0x07, 0xC1, 0xF8, 0xFC,
  0x03, 0xF0, 0x7E, 0x3E, 0x01, 0xF8, 0x1F, 0x9F, 0x80, 0x7C, 0x07, 0xEF,
  0xE0, 0x3E, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x3F, 0xF8, 0x0F, 0xC0, 0x07,
  0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x0F,
  0xE3, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x87, 0xF3, 0xFF, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF3, 0xF9, 0xFE, 0x3F, 0xFF, 0x8F, 0xE0, 0xFF, 0xFC, 0x7F, 0x03,
  0xFF, 0xC3, 0xF8, 0x1F, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xCF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x1F, 0xF0, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x03, 0x07, 0xC0, 0x1E, 0x3E, 0x01, 0xFD, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xCF, 0x07, 0xFE, 0x00, 0x7E, 0xF8, 0x0F, 0xF7, 0xC0, 0x3F,
  0x3F, 0x00, 0x70, 0xF8, 0x01, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xDF, 0xE0,
  0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F,
  0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE,
  0x07, 0xFB, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0xBF,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xBF, 0x0F,
  0xDF, 0xC3, 0xC7, 0xF0, 0x61, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0x01, 0x80, 0x7F, 0x00,
  0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7C, 0x7F, 0xC0, 0x40,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x60,
  0x03, 0xFC, 0xF8, 0x3F, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0x80, 0xFC, 0x7E,
  0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1,
  0xF8, 0x3F, 0x8B, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x06,
  0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0xC0, 0x0F, 0xF8, 0xFC,
  0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xF0, 0x21, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xE0, 0x1F,
  0xDF, 0xF0, 0x7E, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0x8F, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF,
  0x3F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0xFF, 0x7F, 0x87, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFE, 0x03, 0xF3,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0xFF, 0x0F, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xE7, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF,
  0x87, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFB, 0xF1, 0xFF, 0xFF,
  0x87, 0xF9, 0xFC, 0x0F, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0xC1, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0x8F, 0xF3, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x01, 0xFF, 0x0F,
  0x8F, 0xC1, 0xFF, 0xF3, 0xF3, 0xE0, 0xFF, 0xF8, 0x7D, 0xF0, 0x7F, 0xFE,
  0x1F, 0x7C, 0x3F, 0x8F, 0x87, 0xDF, 0x1F, 0x83, 0xE1, 0xFF, 0x87, 0xC1,
  0xF0, 0x7F, 0xE1, 0xF0, 0x7C, 0x1F, 0xF8, 0xFC, 0x1F, 0x07, 0xFE, 0x3E,
  0x07, 0xC3, 0xEF, 0x8F, 0x83, 0xE0, 0xFB, 0xE3, 0xE0, 0xF8, 0x7E, 0xF8,
  0xF8, 0x7E, 0x3F, 0x3E, 0x3F, 0x3F, 0xDF, 0x8F, 0x8F, 0xFF, 0xFF, 0xE3,
  0xE1, 0xFF, 0x7F, 0xF0, 0xFC, 0x3F, 0x8F, 0xF0, 0x1F, 0x03, 0xC0, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0xC0, 0x07, 0xE3, 0xF8, 0x00,
  0x7E, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x70, 0x7F, 0x80, 0x08, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01,
  0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFC,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFE, 0x00, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x0F, 0xFF, 0x1F, 0xC1, 0xFF, 0xE7, 0xF8, 0x3F, 0xFC, 0xFF, 0x07,
  0xFF, 0x9F, 0xE1, 0xFF, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC0,
  0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xDF, 0x01, 0xF7, 0xE0, 0x7E, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xC0,
  0xFB, 0xF0, 0x1F, 0xBE, 0x07, 0xDF, 0x80, 0xFD, 0xF0, 0x7C, 0xFC, 0x0F,
  0xEF, 0x83, 0xEF, 0xE0, 0x7E, 0x7C, 0x3F, 0x7F, 0x03, 0xF3, 0xE1, 0xF3,
  0xF0, 0x1F, 0x9F, 0x1F, 0x9F, 0x80, 0xFC, 0xF8, 0xF8, 0xFC, 0x0F, 0xE7,
  0xCF, 0xCF, 0xE0, 0x7E, 0x3E, 0x7C, 0x7F, 0x03, 0xF1, 0xF7, 0xE3, 0xF0,
  0x1F, 0x8F, 0xBE, 0x1F, 0x81, 0xFC, 0x7F, 0xF0, 0xFC, 0x0F, 0xE3, 0xFF,
  0x0F, 0xE0, 0x7E, 0x1F, 0xF8, 0x7F, 0x03, 0xF0, 0xFF, 0x83, 0xF0, 0x1F,
  0x87, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF,
  0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFF,
  0x80, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x0F, 0xDF,
  0xC1, 0xF8, 0x0F, 0xDF, 0xC1, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0xCF,
  0xE3, 0xF8, 0x1F, 0x8F, 0xE3, 0xF8, 0x1F, 0x87, 0xE3, 0xF0, 0x1F, 0x87,
  0xF3, 0xF0, 0x1F, 0x87, 0xF3, 0xF0, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x03,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x7F, 0x01,
  0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xE0, 0x7E, 0x00,
  0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00,
  0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xEF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0x7F,
  0x00, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x87, 0xF8, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xC1, 0xFE, 0x03,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x88, 0x01, 0xFE, 0x38, 0x07, 0xF0, 0xFE,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xF9, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1,
  0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03,
  0xF3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0x03,
  0xF9, 0xF8, 0x03, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xF0, 0x0F, 0xE7, 0xE0,
  0x1F, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0xC0, 0x7F, 0x1F, 0x80, 0xFF, 0x81,
  0xFC, 0x3F, 0x03, 0xFF, 0x03, 0xF8, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0xFC,
  0x1F, 0xFC, 0x1F, 0xC1, 0xF8, 0x3E, 0xF8, 0x3F, 0x83, 0xF0, 0x7D, 0xF0,
  0xFE, 0x07, 0xE1, 0xFB, 0xE1, 0xFC, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0x1F,
  0x8F, 0xCF, 0x8F, 0xE0, 0x3F, 0x1F, 0x9F, 0x1F, 0x80, 0x7E, 0x7E, 0x3E,
  0x7F, 0x00, 0xFC, 0xFC, 0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0xF9, 0xF8, 0x03,
  0xF7, 0xE1, 0xF7, 0xF0, 0x07, 0xEF, 0x83, 0xEF, 0xC0, 0x0F, 0xFF, 0x07,
  0xDF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0xC0,
  0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80,
  0x3F, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xF8,
  0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x01, 0xF7, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1E, 0x03, 0xFC, 0x7E,
  0x0F, 0xFD, 0xF8, 0x3F, 0xFB, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7,
  0xFC, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFE,
  0x07, 0xF3, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0x7F,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xF8,
  0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0xFE, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F,
  0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x7F, 0x07,
  0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xDF, 0xF8, 0x3E, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xC3, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x01,
  0x1F, 0xF3, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xFC, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xE7, 0xF8,
  0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x3F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xC0,
  0x1F, 0xCF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0x7F, 0x9F, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F,
  0x7F, 0x07, 0xF7, 0xFB, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x47,
  0xF8, 0x0C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x10, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0x03, 0xFF, 0x7E, 0x07, 0xFF,
  0x7E, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81,
  0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF7, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xCF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x80, 0x3F,
  0xC0, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xCF, 0xE0,
  0x3F, 0xBF, 0xE0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7,
  0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF0, 0xFF, 0x01, 0xFC, 0x7F, 0x80,
  0x7F, 0x3F, 0xC0, 0x1F, 0xDF, 0xE0, 0x07, 0xEF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC7, 0xF0, 0x3F, 0x81, 0xF9, 0xFF, 0x1F, 0xF8, 0x3F, 0x7F, 0xF7, 0xFF,
  0x87, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF,
  0x1F, 0xC7, 0xF8, 0x7F, 0xC3, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F,
  0x83, 0xFC, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0xF0, 0x3F, 0x7F,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x9F, 0xE3, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F, 0xF7, 0xF8, 0xFF, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x0F,
  0xFD, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC,
  0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE, 0x7F, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFE, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xE7, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xC7, 0xE1, 0xF9, 0xF8,
  0x3F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFE, 0x20,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFE, 0xF8, 0x7F, 0x03, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x80, 0x7F, 0x98, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFD, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x61, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x1F, 0xF1, 0xFE, 0x7F,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x07, 0xFC, 0xFC,
  0x07, 0xF1, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x0F,
  0xE7, 0xF0, 0x3F, 0xC7, 0xE0, 0x7F, 0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xF8,
  0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x83, 0xF9,
  0xF8, 0x3F, 0xE1, 0xFC, 0x7E, 0x1F, 0xF8, 0x7F, 0x1F, 0x87, 0xFE, 0x1F,
  0x87, 0xE1, 0xEF, 0x8F, 0xE1, 0xF8, 0xFB, 0xE3, 0xF0, 0x7E, 0x3E, 0xF9,
  0xFC, 0x1F, 0x9F, 0x3C, 0x7E, 0x07, 0xE7, 0xCF, 0x3F, 0x81, 0xF9, 0xF7,
  0xCF, 0xE0, 0x7E, 0xF9, 0xF3, 0xF0, 0x1F, 0xBE, 0x7D, 0xFC, 0x07, 0xFF,
  0x1F, 0x7E, 0x01, 0xFF, 0xC7, 0xDF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFE,
  0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x20, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x09, 0xFE, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xD0,
  0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 31, 12, 0, -30 },
  { 56, 16, 11, 19, 4, -30 },
  { 78, 27, 30, 27, 1, -30 },
  { 180, 22, 34, 24, 1, -32 },
  { 274, 34, 30, 37, 2, -30 },
  { 402, 29, 30, 30, 1, -30 },
  { 511, 8, 11, 10, 4, -30 },
  { 522, 17, 37, 15, 1, -30 },
  { 601, 16, 38, 15, -3, -31 },
  { 677, 21, 20, 23, 3, -32 },
  { 730, 21, 20, 24, 2, -25 },
  { 783, 11, 10, 12, -2, -5 },
  { 797, 12, 6, 14, 1, -14 },
  { 806, 8, 8, 12, 0, -7 },
  { 814, 24, 30, 19, -2, -30 },
  { 904, 22, 30, 24, 1, -30 },
  { 987, 18, 30, 24, 3, -30 },
  { 1055, 24, 30, 24, -1, -30 },
  { 1145, 23, 30, 24, 0, -30 },
  { 1232, 23, 30, 24, 0, -30 },
  { 1319, 24, 30, 24, 0, -30 },
  { 1409, 22, 30, 24, 2, -30 },
  { 1492, 25, 30, 24, 1, -30 },
  { 1586, 22, 30, 24, 1, -30 },
  { 1669, 21, 30, 24, 2, -30 },
  { 1748, 12, 24, 12, 0, -23 },
  { 1784, 14, 28, 12, -2, -23 },
  { 1833, 21, 23, 24, 2, -27 },
  { 1894, 21, 14, 24, 2, -22 },
  { 1931, 21, 23, 24, 2, -27 },
  { 1992, 18, 31, 20, 3, -30 },
  { 2062, 34, 34, 37, 2, -30 },
  { 2207, 28, 30, 27, -3, -30 },
  { 2312, 25, 30, 26, 1, -30 },
  { 2406, 26, 30, 26, 2, -30 },
  { 2504, 26, 30, 29, 1, -30 },
  { 2602, 23, 30, 23, 1, -30 },
  { 2689, 23, 30, 23, 1, -30 },
  { 2776, 27, 30, 29, 2, -30 },
  { 2878, 29, 30, 30, 1, -30 },
  { 2987, 20, 30, 17, -1, -30 },
  { 3062, 22, 39, 15, -7, -30 },
  { 3170, 29, 30, 27, 1, -30 },
  { 3279, 18, 30, 22, 1, -30 },
  { 3347, 37, 30, 38, 1, -30 },
  { 3486, 32, 30, 32, 1, -30 },
  { 3606, 28, 30, 31, 2, -30 },
  { 3711, 25, 30, 26, 1, -30 },
  { 3805, 28, 37, 31, 2, -30 },
  { 3935, 24, 30, 27, 1, -30 },
  { 4025, 22, 30, 23, 1, -30 },
  { 4108, 23, 30, 23, 3, -30 },
  { 4195, 27, 30, 29, 3, -30 },
  { 4297, 26, 30, 25, 3, -30 },
  { 4395, 39, 30, 38, 3, -30 },
  { 4542, 32, 30, 27, -2, -30 },
  { 4662, 24, 30, 24, 4, -30 },
  { 4752, 27, 30, 23, -2, -30 },
  { 4854, 18, 37, 14, -1, -30 },
  { 4938, 10, 30, 19, 5, -30 },
  { 4976, 18, 37, 14, -3, -30 },
  { 5060, 22, 20, 23, 0, -30 },
  { 5115, 19, 4, 18, -4, 3 },
  { 5125, 9, 7, 14, 6, -32 },
  { 5133, 23, 23, 25, 2, -23 },
  { 5200, 22, 32, 25, 1, -32 },
  { 5288, 19, 23, 21, 2, -23 },
  { 5343, 24, 32, 25, 2, -32 },
  { 5439, 21, 23, 24, 2, -23 },
  { 5500, 25, 42, 16, -4, -32 },
  { 5632, 24, 33, 25, 1, -23 },
  { 5731, 23, 32, 26, 1, -32 },
  { 5823, 13, 32, 13, 1, -32 },
  { 5875, 19, 42, 13, -5, -32 },
  { 5975, 26, 32, 25, 1, -32 },
  { 6079, 13, 32, 13, 1, -32 },
  { 6131, 35, 23, 38, 1, -23 },
  { 6232, 23, 23, 26, 1, -23 },
  { 6299, 21, 23, 25, 2, -23 },
  { 6360, 25, 33, 25, -2, -23 },
  { 6464, 23, 33, 25, 2, -23 },
  { 6559, 19, 23, 18, 1, -23 },
  { 6614, 19, 23, 20, 1, -23 },
  { 6669, 17, 28, 18, 2, -28 },
  { 6729, 23, 23, 26, 2, -23 },
  { 6796, 23, 23, 22, 2, -23 },
  { 6863, 34, 23, 34, 2, -23 },
  { 6961, 27, 23, 23, -2, -23 },
  { 7039, 28, 33, 22, -3, -23 },
  { 7155, 22, 23, 20, -1, -23 },
  { 7219, 18, 37, 15, 0, -30 },
  { 7303, 5, 42, 23, 9, -32 },
  { 7330, 17, 37, 15, -2, -30 },
  { 7409, 21, 8, 24, 2, -19 },
};

const GFXfont NotoSans_ExtraBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRABOLDITALIC42PT7B_H_
