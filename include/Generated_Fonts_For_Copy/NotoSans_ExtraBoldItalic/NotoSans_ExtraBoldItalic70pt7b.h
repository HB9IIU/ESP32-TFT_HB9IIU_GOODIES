#ifndef _NOTOSANS_EXTRABOLDITALIC70PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0xFF, 0xE7, 0xFE, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE7,
  0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x7F,
  0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x3E, 0x1F, 0x00, 0xFF, 0xE3, 0xF0, 0x18, 0x07, 0xFF, 0x1F, 0x00, 0x00,
  0x3F, 0xF8, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x0F, 0xFE, 0x7E,
  0x00, 0x00, 0x7F, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0xFF, 0xF0, 0x00,
  0x03, 0xE3, 0xFF, 0x80, 0x00, 0x1F, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0xFF,
  0xE3, 0x00, 0x0F, 0xC7, 0xFF, 0x1E, 0x00, 0x7C, 0x3F, 0xF8, 0xFE, 0x03,
  0xE7, 0xFF, 0x87, 0xFF, 0xDF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0xFF, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF, 0xF8, 0xFF, 0xCF,
  0xFC, 0x7F, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3,
  0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xFF, 0x87, 0xFC, 0x7F, 0xE1, 0xFF, 0x07,
  0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x40,
  0x0F, 0xF8, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x8F, 0xF0, 0x00,
  0xFF, 0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xF8, 0x1F, 0xF0,
  0x00, 0x3C, 0x07, 0xFC, 0x00, 0x07, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xE3, 0xFF, 0x9F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF9, 0xFF, 0xC3, 0xFE,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF,
  0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xF0,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0x07,
  0xFE, 0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xC0,
  0xFF, 0xF0, 0x18, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8,
  0x0F, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x18, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x30, 0x00, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x07, 0xFF,
  0xE3, 0xF8, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0xFC, 0x38, 0x00, 0x07, 0xFF,
  0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x04, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xFF, 0x01,
  0xFF, 0xDF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xF1,
  0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F,
  0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x80,
  0x3F, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xF0, 0x07,
  0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xFB, 0xFF,
  0x83, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x18, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFE, 0x03, 0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0x0C, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF3,
  0xFC, 0x07, 0xFF, 0x03, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFD, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xBF,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xC0,
  0x3F, 0xDF, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFB, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0x1C, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xF0, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xBF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x80,
  0x0F, 0xFD, 0xFE, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xF7, 0xF8, 0x00,
  0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x07,
  0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x7F,
  0xDF, 0xFC, 0x00, 0x7F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0x9F, 0xE0, 0x0F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0x80, 0x7F, 0xC7,
  0xFE, 0x00, 0x3F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7,
  0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFF,
  0x80, 0x0F, 0xFC, 0x7F, 0x81, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF,
  0x07, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFC, 0x3F, 0xF1, 0xFF, 0xC0,
  0x07, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF3, 0xFE,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x7F, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFD, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE3,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00,
  0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x3F,
  0xFC, 0x00, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x82, 0x00,
  0x00, 0x3F, 0xFC, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xFE,
  0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0B, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xEF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xCF, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0x8F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE,
  0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xE0,
  0x00, 0x7F, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFC,
  0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x0F, 0xF9, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8,
  0x0F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x00,
  0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF,
  0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFE,
  0x01, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xE7, 0xFC,
  0x00, 0x3F, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0xC0,
  0x03, 0xFF, 0xBF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xF0,
  0x07, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8,
  0x1F, 0xFF, 0x80, 0x18, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x20,
  0xFF, 0xF8, 0x00, 0xC0, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xFC, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF8,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F,
  0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0x00, 0x70,
  0x1F, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE3,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0x00, 0x3F, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF7,
  0xFF, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0x83, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0xF0, 0x03, 0xFF,
  0xBF, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x10, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF7,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x87, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xF8,
  0x07, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFE,
  0x3F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x3F,
  0xE7, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFD,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF,
  0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0x1E, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x40, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x9F, 0xFE, 0x01, 0xFF,
  0xBF, 0xFE, 0x01, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x08, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x83, 0xF8, 0x0F, 0xFF, 0x00, 0x78, 0x0F, 0xFF, 0x00, 0x10, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x00, 0xFF, 0xF0, 0xE0, 0x00,
  0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x08, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80,
  0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFE, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF1, 0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0xE0,
  0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xBF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xBF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x7F, 0xC3, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x7F, 0x83, 0xFF, 0x80, 0x7F, 0xE1, 0xFE, 0x7F, 0x87,
  0xFF, 0x00, 0x7F, 0xE1, 0xFE, 0x7F, 0x87, 0xFF, 0x00, 0x7F, 0xE3, 0xFE,
  0x7F, 0x87, 0xFF, 0x00, 0x7F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFE, 0x00, 0x7F,
  0xE7, 0xFC, 0x7F, 0x8F, 0xFE, 0x00, 0x7F, 0xE7, 0xF8, 0x7F, 0x9F, 0xFC,
  0x00, 0x7F, 0xE7, 0xF8, 0x7F, 0x9F, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x7F,
  0x9F, 0xF8, 0x00, 0x7F, 0xEF, 0xF0, 0x7F, 0xBF, 0xF8, 0x00, 0x7F, 0xEF,
  0xF0, 0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xBF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x21, 0xFF, 0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0x80, 0x03, 0xBF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFB, 0x80, 0x01, 0xFF, 0xFE, 0x60, 0x00, 0x0F, 0xFF,
  0x08, 0x00, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 22, 51, 21, 1, -50 },
  { 142, 27, 18, 32, 7, -50 },
  { 203, 45, 50, 45, 1, -50 },
  { 485, 37, 57, 39, 2, -53 },
  { 749, 56, 52, 62, 4, -51 },
  { 1113, 49, 52, 50, 1, -51 },
  { 1432, 13, 18, 17, 7, -50 },
  { 1462, 28, 62, 25, 2, -51 },
  { 1679, 27, 62, 25, -5, -51 },
  { 1889, 34, 35, 38, 6, -54 },
  { 2038, 35, 34, 40, 3, -42 },
  { 2187, 17, 17, 21, -3, -8 },
  { 2224, 20, 10, 23, 1, -24 },
  { 2249, 14, 12, 21, 0, -11 },
  { 2270, 39, 52, 31, -3, -51 },
  { 2524, 37, 52, 39, 2, -51 },
  { 2765, 29, 50, 39, 6, -50 },
  { 2947, 40, 51, 39, -2, -51 },
  { 3202, 38, 52, 39, 0, -51 },
  { 3449, 40, 50, 39, -1, -50 },
  { 3699, 38, 51, 39, 1, -50 },
  { 3942, 37, 52, 39, 3, -51 },
  { 4183, 41, 50, 39, 2, -50 },
  { 4440, 37, 52, 39, 2, -51 },
  { 4681, 35, 52, 39, 3, -51 },
  { 4909, 20, 40, 21, 0, -39 },
  { 5009, 24, 48, 21, -4, -39 },
  { 5153, 35, 37, 40, 3, -44 },
  { 5315, 35, 23, 40, 3, -36 },
  { 5416, 35, 37, 40, 3, -44 },
  { 5578, 30, 52, 33, 5, -51 },
  { 5773, 57, 56, 61, 3, -50 },
  { 6172, 45, 50, 46, -4, -50 },
  { 6454, 42, 50, 44, 1, -50 },
  { 6717, 42, 52, 43, 4, -51 },
  { 6990, 44, 50, 48, 1, -50 },
  { 7265, 40, 50, 39, 1, -50 },
  { 7515, 40, 50, 39, 1, -50 },
  { 7765, 44, 52, 49, 4, -51 },
  { 8051, 49, 50, 49, 1, -50 },
  { 8358, 34, 50, 28, -2, -50 },
  { 8571, 36, 65, 25, -11, -50 },
  { 8864, 50, 50, 45, 1, -50 },
  { 9177, 31, 50, 37, 1, -50 },
  { 9371, 62, 50, 63, 1, -50 },
  { 9759, 53, 50, 54, 1, -50 },
  { 10091, 45, 52, 51, 4, -51 },
  { 10384, 42, 50, 43, 1, -50 },
  { 10647, 45, 63, 51, 4, -51 },
  { 11002, 41, 50, 44, 1, -50 },
  { 11259, 37, 52, 38, 1, -51 },
  { 11500, 36, 50, 38, 6, -50 },
  { 11725, 44, 51, 49, 5, -50 },
  { 12006, 42, 50, 42, 6, -50 },
  { 12269, 64, 50, 64, 6, -50 },
  { 12669, 54, 50, 44, -4, -50 },
  { 13007, 41, 50, 41, 6, -50 },
  { 13264, 44, 50, 38, -3, -50 },
  { 13539, 31, 62, 24, -2, -51 },
  { 13780, 17, 52, 31, 8, -51 },
  { 13891, 31, 62, 24, -5, -51 },
  { 14132, 36, 33, 38, 1, -50 },
  { 14281, 31, 7, 30, -6, 5 },
  { 14309, 16, 12, 24, 10, -54 },
  { 14333, 38, 40, 42, 3, -39 },
  { 14523, 38, 54, 42, 1, -53 },
  { 14780, 32, 40, 35, 3, -39 },
  { 14940, 41, 54, 42, 3, -53 },
  { 15217, 35, 40, 40, 3, -39 },
  { 15392, 42, 71, 27, -7, -54 },
  { 15765, 40, 56, 42, 1, -39 },
  { 16045, 38, 53, 43, 1, -53 },
  { 16297, 23, 54, 22, 1, -54 },
  { 16453, 33, 71, 22, -9, -54 },
  { 16746, 44, 53, 41, 1, -53 },
  { 17038, 23, 53, 22, 1, -53 },
  { 17191, 60, 39, 64, 1, -39 },
  { 17484, 38, 39, 43, 1, -39 },
  { 17670, 36, 40, 42, 3, -39 },
  { 17850, 42, 56, 42, -3, -39 },
  { 18144, 38, 56, 42, 3, -39 },
  { 18410, 32, 39, 30, 1, -39 },
  { 18566, 32, 40, 34, 1, -39 },
  { 18726, 28, 47, 30, 3, -46 },
  { 18891, 38, 39, 43, 4, -38 },
  { 19077, 38, 38, 37, 3, -38 },
  { 19258, 56, 38, 56, 4, -38 },
  { 19524, 46, 38, 38, -4, -38 },
  { 19743, 46, 55, 37, -5, -38 },
  { 20060, 35, 38, 33, -1, -38 },
  { 20227, 30, 61, 25, 0, -50 },
  { 20456, 9, 69, 39, 15, -53 },
  { 20534, 29, 61, 25, -4, -50 },
  { 20756, 35, 13, 40, 3, -31 },
};

const GFXfont NotoSans_ExtraBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRABOLDITALIC70PT7B_H_
