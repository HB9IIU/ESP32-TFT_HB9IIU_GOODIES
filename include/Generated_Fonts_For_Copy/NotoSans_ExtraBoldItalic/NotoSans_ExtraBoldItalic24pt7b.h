#ifndef _NOTOSANS_EXTRABOLDITALIC24PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0xE7,
  0x39, 0xC0, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x18, 0x07, 0x38,
  0x3F, 0xFF, 0x3F, 0xFF, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x72, 0xFF, 0xFC,
  0xFF, 0xFC, 0x1C, 0xE0, 0x1C, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x39, 0xC0,
  0x01, 0x80, 0x38, 0x1F, 0xF3, 0xFF, 0x3F, 0xF7, 0xB0, 0x7B, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x06, 0xEC, 0x5E, 0xFF, 0xEF, 0xFC,
  0x7F, 0x00, 0x80, 0x18, 0x00, 0x1F, 0x03, 0xC3, 0xF8, 0x38, 0x7B, 0x87,
  0x07, 0x38, 0xE0, 0x73, 0x9C, 0x0F, 0x39, 0xC0, 0xE7, 0x38, 0x8F, 0x77,
  0x7E, 0x7E, 0xEF, 0xE7, 0xEE, 0xEF, 0x01, 0xDE, 0x70, 0x39, 0xCF, 0x07,
  0x9C, 0xE0, 0x71, 0xCE, 0x0E, 0x1F, 0xE1, 0xC1, 0xFC, 0x3C, 0x0F, 0x80,
  0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x7B,
  0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC7, 0x9F, 0xE7, 0x9E, 0x7B, 0xCF,
  0x3F, 0xCF, 0x8F, 0xE3, 0xC3, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xDF,
  0x00, 0x7B, 0x9C, 0xEE, 0x70, 0x07, 0x87, 0x87, 0x83, 0x83, 0xC1, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x1C, 0x0E, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x07, 0x80, 0x70,
  0x47, 0x0F, 0x60, 0xFF, 0xF3, 0xFE, 0x1F, 0xE3, 0xF0, 0xFB, 0x03, 0x38,
  0x13, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0xE7, 0x9C, 0xF3, 0x80,
  0x7E, 0xFF, 0xF8, 0x77, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xC1,
  0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00,
  0x03, 0xC3, 0xF1, 0xFD, 0xFE, 0xFF, 0x9D, 0xE4, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xFF, 0xC3, 0x8F, 0x04, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x27, 0xFF,
  0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0x87, 0xFE, 0x10, 0xF0, 0x07,
  0x80, 0x3C, 0x07, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x60, 0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3B, 0xC3, 0xDE, 0x3C, 0xE3, 0xCF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xFF, 0x07,
  0xFC, 0x3F, 0xF0, 0x8F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x60, 0xFB, 0xFF,
  0x9F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7C, 0x03, 0xC0,
  0x3C, 0x01, 0xDF, 0x1F, 0xFC, 0xFF, 0xE7, 0xCF, 0xBC, 0x3D, 0xE1, 0xEF,
  0x1E, 0x78, 0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0x00, 0x3F, 0xFD, 0xFF, 0xE7,
  0xFF, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xC7, 0x3C, 0x73, 0xCF, 0x3F,
  0xE1, 0xFC, 0x1F, 0xC7, 0xFC, 0xF1, 0xEF, 0x1E, 0xE1, 0xEF, 0x1E, 0xFF,
  0xEF, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFE, 0x7F, 0xF7, 0x8F, 0x78, 0xFF,
  0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3F, 0xE0, 0x1E, 0x03, 0xE0,
  0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x1E, 0x7C, 0xF8, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0xE7, 0xCF, 0x00, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87, 0xC0, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x0E, 0x00, 0x80,
  0x00, 0x7F, 0xBF, 0xF7, 0xFD, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x87, 0xC1, 0xC0, 0x1E, 0x38, 0x30, 0xE7,
  0x1F, 0xEE, 0x73, 0xFC, 0x6E, 0x39, 0xC7, 0xE7, 0x1C, 0x6E, 0x71, 0xCE,
  0xE7, 0x1C, 0xEE, 0x73, 0x9C, 0xE7, 0xFF, 0xCE, 0x7D, 0xF8, 0x71, 0x04,
  0x07, 0x80, 0x00, 0x3E, 0x1C, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xF3, 0x81, 0xE7,
  0x07, 0x8E, 0x0F, 0x1C, 0x3C, 0x38, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xEF,
  0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF0, 0x1E, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0xBF, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF0, 0xF1, 0xE1, 0xE3, 0xE7, 0xC7, 0x8F, 0x1F, 0x1F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0x63, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x86, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x1E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1E,
  0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C,
  0x7C, 0x79, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xFE, 0x1F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF9, 0xF8, 0x23, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x7F,
  0xF9, 0xFD, 0xF3, 0xFB, 0xC0, 0xF7, 0xC1, 0xEF, 0x87, 0x8F, 0x8F, 0x1F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xE3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0xF8, 0x7C, 0x00, 0x0F, 0xF1, 0xFF, 0x0F, 0xE0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x7F, 0x87, 0xF8, 0xFF, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0x0F, 0x87, 0x8F,
  0x83, 0xCF, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x03,
  0xC7, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x77,
  0x1D, 0xC1, 0xDC, 0x77, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x73,
  0xC3, 0xDD, 0xCE, 0x0E, 0x7F, 0x78, 0x79, 0xF9, 0xE1, 0xE7, 0xE7, 0x87,
  0x9F, 0x1C, 0x1C, 0x7C, 0x70, 0xF1, 0xE3, 0xC0, 0x0F, 0x81, 0xE1, 0xF0,
  0x38, 0x3F, 0x0F, 0x0F, 0xE1, 0xE1, 0xFC, 0x3C, 0x3B, 0xC7, 0x07, 0x78,
  0xE1, 0xEF, 0x3C, 0x3C, 0xF7, 0x87, 0x9E, 0xF0, 0xF3, 0xDC, 0x1C, 0x3B,
  0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x0F, 0xC3, 0x81, 0xF0, 0xF0, 0x3E,
  0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1E, 0xF8,
  0x3E, 0xF8, 0x3C, 0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F,
  0x9F, 0x3E, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0x81, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3F, 0x1E, 0x3C, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0x7C, 0xFC, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0x3C, 0x7C, 0xF1,
  0xE3, 0xE7, 0x87, 0x9E, 0x1E, 0xF8, 0x7C, 0x07, 0xF8, 0x7F, 0xC7, 0xFC,
  0x3C, 0x23, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x71, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFC, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0x3C, 0x1E, 0x78, 0x7D, 0xF0, 0xF3, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x87, 0x8F, 0x0F, 0x1F, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x1C,
  0x78, 0x73, 0xC1, 0xCF, 0x07, 0x78, 0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE1, 0xEF, 0x0F,
  0x87, 0xBC, 0x3E, 0x1C, 0xF1, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF, 0x3B, 0x9E,
  0x3C, 0xEE, 0x78, 0xF7, 0xBB, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xB8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0x80, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF8, 0xF0, 0x1E,
  0x78, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x07,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x3E, 0x00, 0xF0, 0x7F, 0xE1, 0xE7, 0x8F,
  0x1E, 0x7C, 0x79, 0xE0, 0xEF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x81, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xE0, 0xF8,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xF8, 0x3F,
  0x0F, 0xC0, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x9E, 0x38,
  0xE3, 0x8E, 0x3C, 0x07, 0xE1, 0xF8, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0xEE, 0x07, 0x70, 0x71, 0x87, 0x8E, 0x38, 0x73, 0x83,
  0xBC, 0x0E, 0xFF, 0xFF, 0xF8, 0xF8, 0xE3, 0xC0, 0x1F, 0x39, 0xFF, 0xCF,
  0xFE, 0xF9, 0xE7, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE7, 0x9F,
  0x3F, 0xF8, 0xFF, 0xC7, 0xDC, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E,
  0x70, 0xF3, 0x87, 0xBC, 0x7D, 0xF3, 0xCF, 0xFE, 0x7F, 0xE7, 0xBE, 0x00,
  0x0F, 0xE7, 0xFC, 0xFF, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x13, 0xFE, 0x3F, 0xC3, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x7D, 0xE3, 0xFF, 0x8F, 0xFC, 0x7C, 0xF1, 0xE3, 0xCF,
  0x8F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0x7F, 0xE1,
  0xF7, 0x00, 0x0F, 0xE1, 0xFF, 0x3E, 0xF7, 0x8F, 0x78, 0xFF, 0xFE, 0xFF,
  0xCF, 0xF0, 0xF0, 0x0F, 0x04, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x0F, 0x9C, 0x7F, 0xF1, 0xFF,
  0xCF, 0x9E, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x1C, 0x78, 0xF1, 0xE7,
  0xC7, 0xFF, 0x0F, 0xFC, 0x3E, 0xE0, 0x07, 0x80, 0x1E, 0x38, 0xF0, 0xFF,
  0xC3, 0xFE, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC3,
  0xC0, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC7, 0xC7, 0x9F, 0x0F, 0x7C, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xBC, 0x1E, 0x78, 0x3C, 0xF8, 0x78, 0xF1,
  0xE1, 0xF0, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x1D, 0xF1, 0xF0, 0xEF,
  0xDF, 0x87, 0xFF, 0xFE, 0x7C, 0xF8, 0xF3, 0xC7, 0xC7, 0x9E, 0x3C, 0x3C,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0x78, 0xF3, 0xC7, 0x87, 0x9E, 0x3C,
  0x3C, 0xF1, 0xE3, 0xCF, 0x0F, 0x1E, 0x00, 0x1D, 0xF8, 0x7F, 0xE1, 0xFF,
  0x8F, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0x79, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xF0, 0x0F, 0xC3, 0xFE, 0x3F, 0xF7, 0x8F,
  0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0xFF, 0xE7, 0xFC,
  0x3F, 0x00, 0x0E, 0xF8, 0x3F, 0xF0, 0xFF, 0xC7, 0xCF, 0x1E, 0x3C, 0x78,
  0xF1, 0xC3, 0xC7, 0x0F, 0x3C, 0x7C, 0xF9, 0xE3, 0xFF, 0x8E, 0xFC, 0x7B,
  0xE1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x1F, 0x39, 0xFF, 0xCF, 0xFE, 0xF9, 0xE7, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE,
  0x1C, 0xF1, 0xE7, 0x8F, 0x3F, 0xF8, 0xFF, 0xC7, 0xDC, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1C, 0xE3, 0xBC, 0x7F, 0x9F,
  0xD3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x80, 0x1F, 0xE7, 0xFC, 0xFF, 0x1E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xD0, 0x7B, 0xFF, 0x7F, 0xCF, 0xF0, 0x0E, 0x03, 0x81, 0xC1, 0xFF,
  0xFF, 0xBF, 0xE3, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3F,
  0x87, 0xE1, 0xF8, 0x3C, 0x79, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x8F, 0x3C,
  0x79, 0xE3, 0xDE, 0x1E, 0xF1, 0xF7, 0x9F, 0x3F, 0xF8, 0xFD, 0xC7, 0xDE,
  0x00, 0xF0, 0xFF, 0x87, 0xBC, 0x7C, 0xE3, 0xC7, 0x3E, 0x39, 0xE1, 0xCE,
  0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0xF1,
  0xF1, 0xFF, 0x1F, 0x1E, 0xF1, 0xF3, 0xC7, 0x3F, 0x3C, 0x73, 0xF3, 0x87,
  0x77, 0x78, 0x77, 0x77, 0x07, 0x77, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x00, 0x1E, 0x3F, 0x1F, 0x3C,
  0x0F, 0x78, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0x1E, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x0E, 0x3C, 0x0E, 0x3C, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0xBF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xCF, 0xF8, 0xFF, 0x80, 0x03, 0xC1, 0xF0, 0x7C,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x7C, 0x3F, 0x0F, 0x03, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0xC1, 0xF0,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x78, 0x7E, 0x1E,
  0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x83, 0xC0, 0xC0, 0x00, 0x30,
  0x1F, 0xE3, 0xFF, 0xFC, 0xFF, 0x81, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 17, 7, 0, -17 },
  { 18, 10, 6, 11, 2, -17 },
  { 26, 16, 17, 16, 0, -17 },
  { 60, 12, 19, 14, 1, -18 },
  { 89, 20, 17, 21, 1, -17 },
  { 132, 17, 17, 17, 0, -17 },
  { 169, 5, 6, 6, 2, -17 },
  { 173, 9, 21, 9, 1, -17 },
  { 197, 10, 22, 9, -2, -18 },
  { 225, 12, 11, 13, 2, -18 },
  { 242, 12, 11, 14, 1, -14 },
  { 259, 6, 6, 7, -1, -3 },
  { 264, 7, 3, 8, 0, -8 },
  { 267, 5, 4, 7, 0, -4 },
  { 270, 13, 17, 11, -1, -17 },
  { 298, 12, 17, 14, 1, -17 },
  { 324, 10, 17, 14, 2, -17 },
  { 346, 14, 17, 14, -1, -17 },
  { 376, 13, 17, 14, 0, -17 },
  { 404, 13, 17, 14, 0, -17 },
  { 432, 13, 17, 14, 0, -17 },
  { 460, 13, 17, 14, 1, -17 },
  { 488, 14, 17, 14, 1, -17 },
  { 518, 12, 17, 14, 1, -17 },
  { 544, 12, 17, 14, 1, -17 },
  { 570, 7, 13, 7, 0, -13 },
  { 582, 8, 16, 7, -1, -13 },
  { 598, 12, 13, 14, 1, -15 },
  { 618, 12, 7, 14, 1, -12 },
  { 629, 12, 13, 14, 1, -15 },
  { 649, 10, 17, 11, 2, -17 },
  { 671, 20, 19, 21, 1, -17 },
  { 719, 15, 17, 16, -1, -17 },
  { 751, 15, 17, 15, 0, -17 },
  { 783, 15, 17, 15, 1, -17 },
  { 815, 16, 17, 16, 0, -17 },
  { 849, 14, 17, 13, 0, -17 },
  { 879, 14, 17, 13, 0, -17 },
  { 909, 15, 17, 17, 1, -17 },
  { 941, 17, 17, 17, 0, -17 },
  { 978, 12, 17, 10, -1, -17 },
  { 1004, 13, 22, 8, -4, -17 },
  { 1040, 17, 17, 15, 0, -17 },
  { 1077, 11, 17, 13, 0, -17 },
  { 1101, 22, 17, 21, 0, -17 },
  { 1148, 19, 17, 19, 0, -17 },
  { 1189, 16, 17, 18, 1, -17 },
  { 1223, 15, 17, 15, 0, -17 },
  { 1255, 16, 21, 18, 1, -17 },
  { 1297, 14, 17, 15, 0, -17 },
  { 1327, 13, 17, 13, 0, -17 },
  { 1355, 13, 17, 13, 2, -17 },
  { 1383, 15, 17, 17, 2, -17 },
  { 1415, 14, 17, 14, 2, -17 },
  { 1445, 22, 17, 22, 2, -17 },
  { 1492, 18, 17, 15, -1, -17 },
  { 1531, 14, 17, 14, 2, -17 },
  { 1561, 15, 17, 13, -1, -17 },
  { 1593, 11, 21, 8, -1, -17 },
  { 1622, 6, 17, 11, 3, -17 },
  { 1635, 11, 21, 8, -2, -17 },
  { 1664, 13, 11, 13, 0, -17 },
  { 1682, 11, 2, 10, -2, 2 },
  { 1685, 6, 3, 8, 3, -18 },
  { 1688, 13, 13, 14, 1, -13 },
  { 1710, 13, 18, 14, 0, -18 },
  { 1740, 11, 13, 12, 1, -13 },
  { 1758, 14, 18, 14, 1, -18 },
  { 1790, 12, 13, 14, 1, -13 },
  { 1810, 15, 24, 9, -3, -18 },
  { 1855, 14, 19, 14, 0, -13 },
  { 1889, 14, 18, 15, 0, -18 },
  { 1921, 8, 18, 7, 0, -18 },
  { 1939, 11, 24, 7, -3, -18 },
  { 1972, 15, 18, 14, 0, -18 },
  { 2006, 8, 18, 7, 0, -18 },
  { 2024, 21, 13, 22, 0, -13 },
  { 2059, 14, 13, 15, 0, -13 },
  { 2082, 12, 13, 14, 1, -13 },
  { 2102, 14, 19, 14, -1, -13 },
  { 2136, 13, 19, 14, 1, -13 },
  { 2167, 11, 13, 10, 0, -13 },
  { 2185, 11, 13, 12, 0, -13 },
  { 2203, 10, 16, 10, 1, -16 },
  { 2223, 13, 13, 15, 1, -13 },
  { 2245, 13, 13, 13, 1, -13 },
  { 2267, 20, 13, 19, 1, -13 },
  { 2300, 16, 13, 13, -1, -13 },
  { 2326, 16, 19, 13, -2, -13 },
  { 2364, 12, 13, 11, 0, -13 },
  { 2384, 10, 21, 9, 0, -17 },
  { 2411, 3, 23, 13, 5, -18 },
  { 2420, 10, 21, 9, -1, -17 },
  { 2447, 12, 5, 14, 1, -11 },
};

const GFXfont NotoSans_ExtraBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRABOLDITALIC24PT7B_H_
