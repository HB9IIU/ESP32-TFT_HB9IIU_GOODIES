#ifndef _NOTOSANS_EXTRABOLDITALIC48PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x0C, 0x00, 0x7F,
  0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x3F, 0xBF, 0x8F,
  0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE3,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x0F, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xC1, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0xE3, 0xC0, 0xFF,
  0x38, 0x10, 0x3F, 0x9E, 0x00, 0x0F, 0xE7, 0x80, 0x03, 0xFD, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x73, 0xFC, 0x00, 0x1C, 0xFF, 0x20,
  0x0F, 0x3F, 0xCE, 0x03, 0xCF, 0xE3, 0xF0, 0xF7, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x20, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x07,
  0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xFE, 0x01,
  0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0xFE,
  0x1F, 0x81, 0xF8, 0x03, 0xF8, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xF3, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xCF,
  0xFC, 0xFF, 0xFE, 0x7E, 0x7F, 0xFB, 0xFF, 0xF3, 0xF3, 0xFF, 0xF7, 0xFF,
  0xDF, 0xDF, 0xFF, 0xDF, 0xFE, 0x7E, 0x7F, 0x3F, 0x3F, 0xE3, 0xF3, 0xF8,
  0xFC, 0x1E, 0x1F, 0x8F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC3,
  0xF0, 0x07, 0xF0, 0x7E, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x7E, 0x00, 0xFC,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x7F, 0xFF,
  0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0x00,
  0x07, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xCF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xE0, 0x3F, 0xC3, 0xFF,
  0xF0, 0x3F, 0xC3, 0xFF, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F, 0xE3, 0xFE,
  0x7F, 0xCF, 0xF1, 0xFE, 0x1F, 0xEF, 0xF1, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x06, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x9F, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0x9F, 0x87, 0xFF, 0x80, 0x1F, 0xDF, 0x00,
  0x7F, 0xBF, 0x01, 0xFE, 0x7E, 0x00, 0xF8, 0xFE, 0x00, 0xF0, 0xFC, 0x00,
  0xC1, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE0, 0x1E, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x18, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F,
  0xF7, 0xFC, 0x0F, 0xFB, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFD, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE,
  0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F,
  0xE1, 0xFF, 0x0F, 0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7,
  0xFD, 0xFC, 0x7F, 0x3F, 0xC3, 0xE3, 0xFC, 0x18, 0x3F, 0xC1, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE1, 0xFF, 0x01, 0xF0, 0x3F, 0xE0, 0x18, 0x03, 0xFC,
  0x01, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0x81, 0xFF, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0x00, 0x07, 0xFC, 0xF8, 0x07, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x70, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x88, 0x00, 0x7F, 0xE3, 0xC0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0x00, 0x0F,
  0xE7, 0xFC, 0x07, 0xFB, 0xFF, 0x81, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0xFF, 0x81,
  0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC1,
  0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F, 0xF8, 0xFF, 0x87, 0xF8, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x1F, 0xFB, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xE1, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFD, 0xFE, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF0,
  0x06, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xC0, 0xFF, 0x30, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x01, 0xFF, 0xC3,
  0xF0, 0xFC, 0x0F, 0xFF, 0xE3, 0xF3, 0xF0, 0x3F, 0xFF, 0x87, 0xE7, 0xE0,
  0xFF, 0xFF, 0x0F, 0xDF, 0x83, 0xFE, 0xFE, 0x1F, 0xBF, 0x07, 0xE0, 0xFC,
  0x3F, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0xF8, 0x7F, 0x07, 0xE0, 0xFF, 0xF0,
  0xFC, 0x0F, 0xC1, 0xFF, 0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x3E,
  0x07, 0xDF, 0x8F, 0xC0, 0xFC, 0x1F, 0xBF, 0x1F, 0x81, 0xF8, 0x3F, 0x7E,
  0x3F, 0x07, 0xF0, 0xFC, 0xFC, 0x7F, 0x0F, 0xE3, 0xF9, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0xFF, 0xDF, 0xFE, 0x07,
  0xE1, 0xFF, 0x1F, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00,
  0x3F, 0xE0, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x00, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x18, 0x07, 0xFF, 0x8F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x1F,
  0xF1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0x83, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x78, 0x1F, 0xFC, 0x00,
  0x60, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xFC, 0xFF, 0x83, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xCF, 0xF0,
  0x3F, 0xFF, 0x3F, 0xC0, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xE3, 0xFC, 0x1F,
  0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x06, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8,
  0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF7,
  0xC0, 0x7E, 0xFE, 0x03, 0xF9, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0x7C, 0x0F,
  0xCF, 0xE0, 0x3F, 0x9F, 0x07, 0xF7, 0xF8, 0x0F, 0xE7, 0xE1, 0xF9, 0xFE,
  0x07, 0xF9, 0xF8, 0xFE, 0x7F, 0x01, 0xFE, 0x7E, 0x3F, 0x1F, 0xC0, 0x7F,
  0x1F, 0x8F, 0xC7, 0xF0, 0x1F, 0xC7, 0xE7, 0xE3, 0xFC, 0x07, 0xF1, 0xF9,
  0xF8, 0xFE, 0x03, 0xFC, 0x7E, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xBF, 0x0F,
  0xE0, 0x3F, 0x87, 0xFF, 0x87, 0xF8, 0x0F, 0xE1, 0xFF, 0xE1, 0xFE, 0x03,
  0xF8, 0x7F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0xC0,
  0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xE0, 0x3F, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F,
  0xFF, 0x01, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0x7F, 0x7F, 0x03, 0xFC,
  0x07, 0xF7, 0xF8, 0x3F, 0xC0, 0xFE, 0x7F, 0x83, 0xF8, 0x0F, 0xE3, 0xF8,
  0x3F, 0x80, 0xFE, 0x3F, 0xC3, 0xF8, 0x0F, 0xE3, 0xFC, 0x7F, 0x81, 0xFE,
  0x1F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0xE7, 0xF0,
  0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFF,
  0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFC,
  0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xC7,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x07,
  0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3,
  0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xF8,
  0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xCF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x02, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x20, 0x01, 0xFE, 0x1C, 0x00, 0xFF, 0x0F, 0xC1, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0,
  0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xCF, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0x7E,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xEF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xCF, 0xC3, 0xFC, 0x0F, 0xF0, 0xFC, 0xFC, 0x3F,
  0x80, 0x7F, 0x1F, 0xCF, 0xC7, 0xF8, 0x07, 0xF1, 0xF8, 0xFC, 0x7F, 0x00,
  0x7F, 0x3F, 0x8F, 0xCF, 0xF0, 0x07, 0xF3, 0xF0, 0xFC, 0xFF, 0x00, 0x7E,
  0x7F, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0xFD, 0xFE, 0x00, 0x7E, 0x7E,
  0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x03,
  0xFE, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x20, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x3F, 0xF9, 0xFC, 0x1F, 0xFF, 0x7F,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFE, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x1E, 0x00,
  0x7F, 0xBF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF0, 0x0F, 0xF1, 0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0xC1,
  0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xBF, 0xFE, 0x0F, 0xE7, 0xFE, 0x03, 0xF0, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFC, 0x04, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x10, 0xFF, 0xC1, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xC3, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xFB, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF1, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xDF, 0x80, 0x3F, 0xFB, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x7F, 0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x8F, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x08, 0xFF, 0x80, 0x30,
  0x7F, 0xF3, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF9, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x07,
  0xFF, 0x3F, 0x81, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07,
  0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x20, 0x03, 0xFE,
  0x07, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0x00, 0x7F, 0x9F, 0xF0, 0x1F, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xC3,
  0xFE, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F,
  0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF8, 0x00, 0x78, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x10, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x10, 0x7C, 0x00, 0xF0, 0x03, 0xF0, 0xFF, 0x03, 0xFE, 0x01,
  0xF9, 0xFF, 0xC3, 0xFF, 0x80, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0, 0xFE, 0xFF,
  0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x10, 0x7C, 0x01,
  0xF8, 0xFF, 0xC0, 0x7E, 0x7F, 0xF8, 0x1F, 0xBF, 0xFE, 0x0F, 0xEF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x7F, 0xC1,
  0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0,
  0x1F, 0xF7, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE,
  0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x7F, 0xCF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x02, 0x1E, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x3F, 0x3F, 0xF8,
  0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x81, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x3F, 0xF9, 0xFC, 0x1F, 0xFF, 0x7F,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3,
  0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xF8, 0x0F, 0xFD, 0xFE, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x8F, 0xC1,
  0xFD, 0xFE, 0x0F, 0xCF, 0xF0, 0xFE, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x81, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x83, 0xC7,
  0xF8, 0x04, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF9, 0x00, 0x3F, 0xCC, 0x01, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x41, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8,
  0x7F, 0xC7, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xEF, 0xE0, 0x3F, 0xF9, 0xF8, 0x03, 0xFC, 0x3F, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF9, 0xFC, 0x03,
  0xFC, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00,
  0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xFB, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xEF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xBF, 0x81, 0xFF, 0x83, 0xFC, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF3, 0xF8, 0x3F, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0xE1, 0xFE, 0x3F, 0x87,
  0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0x7E, 0x3F, 0xC3, 0xF8, 0xFD, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF7, 0xE7, 0xF8, 0x3F, 0x8F, 0x9F, 0x9F, 0xE0, 0xFE, 0x7E,
  0x7E, 0x7F, 0x03, 0xF9, 0xF9, 0xFB, 0xFC, 0x0F, 0xEF, 0xC7, 0xEF, 0xE0,
  0x3F, 0xBF, 0x1F, 0xBF, 0x80, 0x7E, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xE1,
  0xF7, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_ExtraBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 16, 35, 14, 0, -34 },
  { 71, 18, 12, 22, 5, -34 },
  { 98, 31, 34, 31, 1, -34 },
  { 230, 26, 39, 27, 1, -36 },
  { 357, 38, 35, 43, 3, -35 },
  { 524, 33, 35, 35, 1, -35 },
  { 669, 8, 12, 12, 5, -34 },
  { 681, 18, 43, 17, 2, -35 },
  { 778, 18, 43, 17, -3, -35 },
  { 875, 23, 24, 26, 4, -37 },
  { 944, 24, 24, 28, 2, -29 },
  { 1016, 12, 12, 14, -2, -6 },
  { 1034, 14, 6, 16, 1, -16 },
  { 1045, 9, 9, 14, 0, -8 },
  { 1056, 27, 35, 21, -2, -35 },
  { 1175, 25, 35, 27, 2, -35 },
  { 1285, 20, 34, 27, 4, -34 },
  { 1370, 27, 35, 27, -1, -35 },
  { 1489, 26, 35, 27, 0, -35 },
  { 1603, 27, 34, 27, 0, -34 },
  { 1718, 26, 34, 27, 1, -34 },
  { 1829, 26, 35, 27, 2, -35 },
  { 1943, 28, 34, 27, 1, -34 },
  { 2062, 26, 35, 27, 1, -35 },
  { 2176, 24, 35, 27, 2, -35 },
  { 2281, 14, 28, 14, 0, -27 },
  { 2330, 17, 33, 14, -3, -27 },
  { 2401, 24, 26, 28, 2, -30 },
  { 2479, 24, 16, 28, 2, -25 },
  { 2527, 24, 26, 28, 2, -30 },
  { 2605, 20, 36, 23, 4, -35 },
  { 2695, 39, 39, 42, 2, -35 },
  { 2886, 31, 34, 31, -3, -34 },
  { 3018, 29, 34, 30, 1, -34 },
  { 3142, 29, 35, 30, 3, -35 },
  { 3269, 30, 34, 33, 1, -34 },
  { 3397, 27, 34, 27, 1, -34 },
  { 3512, 27, 34, 26, 1, -34 },
  { 3627, 30, 35, 33, 3, -35 },
  { 3759, 33, 34, 34, 1, -34 },
  { 3900, 24, 34, 19, -2, -34 },
  { 4002, 25, 44, 17, -8, -34 },
  { 4140, 34, 34, 31, 1, -34 },
  { 4285, 21, 34, 25, 1, -34 },
  { 4375, 42, 34, 43, 1, -34 },
  { 4554, 36, 34, 37, 1, -34 },
  { 4707, 31, 35, 35, 3, -35 },
  { 4843, 28, 34, 30, 1, -34 },
  { 4962, 31, 43, 35, 3, -35 },
  { 5129, 28, 34, 30, 1, -34 },
  { 5248, 25, 35, 26, 1, -35 },
  { 5358, 25, 34, 26, 4, -34 },
  { 5465, 31, 34, 33, 3, -34 },
  { 5597, 29, 34, 29, 4, -34 },
  { 5721, 44, 34, 44, 4, -34 },
  { 5908, 37, 34, 30, -3, -34 },
  { 6066, 28, 34, 28, 4, -34 },
  { 6185, 30, 34, 26, -2, -34 },
  { 6313, 21, 43, 17, -1, -35 },
  { 6426, 12, 35, 21, 5, -35 },
  { 6479, 21, 43, 17, -3, -35 },
  { 6592, 25, 22, 26, 0, -34 },
  { 6661, 21, 4, 20, -4, 4 },
  { 6672, 11, 8, 16, 7, -37 },
  { 6683, 26, 27, 29, 2, -27 },
  { 6771, 26, 36, 29, 1, -36 },
  { 6888, 22, 27, 24, 2, -27 },
  { 6963, 28, 36, 29, 2, -36 },
  { 7089, 24, 27, 27, 2, -27 },
  { 7170, 29, 49, 19, -5, -37 },
  { 7348, 27, 39, 29, 1, -27 },
  { 7480, 26, 36, 29, 1, -36 },
  { 7597, 15, 37, 15, 1, -37 },
  { 7667, 22, 49, 15, -6, -37 },
  { 7802, 30, 36, 28, 1, -36 },
  { 7937, 15, 36, 15, 1, -36 },
  { 8005, 41, 27, 44, 1, -27 },
  { 8144, 26, 27, 29, 1, -27 },
  { 8232, 25, 27, 29, 2, -27 },
  { 8317, 29, 39, 29, -2, -27 },
  { 8459, 26, 39, 29, 2, -27 },
  { 8586, 21, 27, 21, 1, -27 },
  { 8657, 21, 27, 23, 1, -27 },
  { 8728, 19, 32, 21, 2, -32 },
  { 8804, 27, 26, 29, 2, -26 },
  { 8892, 26, 26, 25, 2, -26 },
  { 8977, 38, 26, 39, 3, -26 },
  { 9101, 32, 26, 26, -3, -26 },
  { 9205, 31, 38, 25, -3, -26 },
  { 9353, 25, 26, 23, -1, -26 },
  { 9435, 20, 42, 17, 0, -34 },
  { 9540, 5, 47, 27, 11, -36 },
  { 9570, 20, 42, 17, -3, -34 },
  { 9675, 24, 8, 28, 2, -21 },
};

const GFXfont NotoSans_ExtraBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRABOLDITALIC48PT7B_H_
