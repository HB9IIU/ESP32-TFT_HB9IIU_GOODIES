#ifndef _NOTOSANS_EXTRABOLDITALIC28PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F,
  0x0F, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x60, 0x78, 0x7E, 0x3E, 0x0F, 0x00,
  0x7B, 0xFE, 0x7B, 0xCF, 0x79, 0xEF, 0x39, 0xC7, 0x39, 0xE0, 0x00, 0xE7,
  0x80, 0x79, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCF, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xC7, 0x00, 0x73, 0xC1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x79, 0xC0, 0x1C, 0x70,
  0x07, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x1F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xC7, 0xDB, 0x8F, 0x70, 0x1E, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x6F, 0x00, 0xDE, 0x43,
  0xBC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0xFE, 0x07, 0x87, 0xF8, 0x1C, 0x3C,
  0xF0, 0xE0, 0xF3, 0xC7, 0x83, 0xCE, 0x3C, 0x0E, 0x38, 0xE0, 0x39, 0xE7,
  0x00, 0xE7, 0xBD, 0xFB, 0xFD, 0xEF, 0xEF, 0xF7, 0x7F, 0xDF, 0x3D, 0xEF,
  0x01, 0xE7, 0x3C, 0x0F, 0x3C, 0xF0, 0x38, 0xF3, 0xC1, 0xE3, 0xCF, 0x0F,
  0x0F, 0x78, 0x78, 0x3F, 0xE1, 0xC0, 0x7F, 0x0F, 0x00, 0xF8, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0x9F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C,
  0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x7C, 0xFF, 0x0F,
  0x3F, 0xF3, 0xEF, 0x9F, 0x79, 0xF3, 0xFF, 0x3C, 0x3F, 0xC7, 0xC3, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xE7, 0xC0, 0x7F, 0xBD,
  0xEF, 0x73, 0x80, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0x0F,
  0x04, 0x3C, 0x1C, 0xE0, 0x7F, 0x83, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x1F,
  0x80, 0xF7, 0x07, 0x9C, 0x06, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3E, 0x79, 0xF3,
  0xCF, 0x1E, 0x38, 0x00, 0x7F, 0xBF, 0xBF, 0xC0, 0x13, 0xFF, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x3E, 0x3D, 0xF0,
  0xF7, 0xC3, 0xDF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE3, 0xEF, 0x8F, 0xBE, 0x7E, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x0F,
  0xE0, 0x00, 0xF0, 0x3F, 0x0F, 0xF1, 0xFE, 0x7F, 0xEF, 0xDE, 0x7B, 0xE2,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x06, 0x1F, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x07,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x83, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x40, 0x3E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xEF, 0x03, 0xDE, 0x0F, 0x7C, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x80, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xE3, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0xF8, 0x7B, 0xF8,
  0xFF, 0xF3, 0xFF, 0xF7, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1E, 0x7C,
  0x7C, 0x7D, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7,
  0x8F, 0x8F, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF,
  0x8F, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0x7C, 0x7D,
  0xF0, 0xF7, 0x83, 0xDE, 0x1F, 0x78, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0xFF, 0xE3, 0xFF, 0x8F, 0xF8,
  0x3F, 0xC0, 0x06, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x78, 0xF8, 0xF8, 0xF8, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x03,
  0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x03, 0xE0, 0x0C, 0x00, 0x00, 0x3F, 0xCF, 0xFE, 0x7F, 0xF7, 0xFF, 0x20,
  0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xC0, 0x3C,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7C, 0x03, 0xE1, 0xE0,
  0x03, 0xC7, 0x83, 0xC3, 0x8E, 0x1F, 0xE7, 0xBC, 0x7F, 0xC7, 0x71, 0xE3,
  0x8E, 0xE7, 0x8F, 0x1F, 0xCF, 0x1C, 0x7F, 0x9C, 0x38, 0xFE, 0x38, 0xF1,
  0xDC, 0x71, 0xE7, 0xBC, 0xFF, 0xFE, 0x79, 0xFF, 0xF8, 0x71, 0xF3, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0x02, 0x01, 0xF8, 0x78, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0x9E,
  0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3E, 0x03, 0xCF, 0x00, 0xF7, 0xC0,
  0x3F, 0xF0, 0x0F, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xFC, 0x7C, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x7E, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFE, 0x3F, 0x02, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x08, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF8, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xEF, 0x81,
  0xF7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF0, 0xFC, 0xFF, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xF0, 0x33, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7F, 0xBE, 0x3F, 0xDE, 0x1F, 0xEF,
  0x11, 0xE7, 0x81, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xC0, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x78, 0x1F, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x81, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xF0, 0x00, 0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x81,
  0xF3, 0xF0, 0x3C, 0xFC, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0x78,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC1, 0xFE, 0x3D, 0xC1, 0xDE, 0x3D, 0xC3, 0xFE, 0x3D, 0xC3, 0xBC, 0x3D,
  0xC7, 0xBC, 0x3D, 0xC7, 0x3C, 0x7D, 0xCF, 0x7C, 0x79, 0xCE, 0x78, 0x79,
  0xDE, 0x78, 0x79, 0xFC, 0x78, 0x79, 0xFC, 0x78, 0xF9, 0xF8, 0xF8, 0xF1,
  0xF8, 0xF0, 0xF1, 0xF0, 0xF0, 0xF1, 0xF0, 0xF0, 0x0F, 0x80, 0xF8, 0xFE,
  0x07, 0x87, 0xF0, 0x3C, 0x3F, 0x81, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0xF8,
  0xF7, 0x87, 0x87, 0xBE, 0x3C, 0x3C, 0xF1, 0xE1, 0xE7, 0x9F, 0x0F, 0x3E,
  0xF8, 0xF9, 0xF7, 0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xE1, 0xE1, 0xFF, 0x0F,
  0x07, 0xF8, 0xF8, 0x3F, 0x87, 0x81, 0xFC, 0x3C, 0x07, 0xE1, 0xE0, 0x3F,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F,
  0x9F, 0x81, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x07, 0xEF, 0x81, 0xF3, 0xE0,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x3F, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0x0F, 0x9F, 0x81, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x07, 0xEF, 0x81, 0xF3,
  0xE0, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x3E, 0xF0, 0x3E, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x08,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x20, 0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC,
  0x3F, 0xE0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xE0, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3,
  0xC1, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x7C,
  0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x07, 0xFE,
  0x0F, 0x81, 0xEF, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x3E, 0xF8, 0x7E, 0x0F,
  0x1E, 0x1F, 0x87, 0xC7, 0x8F, 0xE1, 0xE1, 0xE3, 0xB8, 0xF8, 0x79, 0xEE,
  0x3C, 0x1E, 0x7B, 0x9F, 0x07, 0xBC, 0xE7, 0x81, 0xEF, 0x39, 0xE0, 0x7B,
  0x8E, 0xF8, 0x1F, 0xE3, 0xBC, 0x07, 0xF8, 0xEF, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8,
  0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0xBE, 0x0F,
  0x9F, 0x0F, 0x8F, 0x8F, 0x83, 0xC7, 0xC1, 0xE7, 0xC0, 0xFB, 0xC0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0xF1, 0xE3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0xF0, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF,
  0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x78, 0x78, 0xE0, 0x73, 0xC0, 0xEF,
  0x01, 0xE0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0xF9, 0xE3, 0xC7, 0x03, 0x00,
  0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xEF, 0x87, 0x9F, 0x0F, 0x3C,
  0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFF,
  0x1F, 0xDC, 0x1F, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x30, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3F,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E,
  0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0xF3, 0xE0, 0x01, 0xC0,
  0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE1, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x4F, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xF8,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x18,
  0xF0, 0x3F, 0x78, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0x3F, 0x1F, 0x0F, 0x0F,
  0x87, 0x87, 0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8,
  0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xEE, 0x03, 0xEF, 0x00, 0x01, 0xC0, 0x1F,
  0xE1, 0xFF, 0xCF, 0xFF, 0x3E, 0x3D, 0xF0, 0xF7, 0xC7, 0xFF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x31, 0xFF, 0xC3, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0x20, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xEF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x3F, 0x3E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x7C, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0xC1, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x1E, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x38, 0x1F,
  0x7E, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0x01, 0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00,
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC0, 0x00, 0x10, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x87, 0xF8,
  0x3F, 0xC1, 0xFC, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x11, 0xF0, 0xF8, 0x7C, 0x7C,
  0x1F, 0x3E, 0x07, 0x9F, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC7,
  0xC1, 0xE1, 0xF0, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x00, 0x18, 0x08,
  0x1E, 0x7E, 0x7E, 0x1E, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x9F, 0x9F,
  0x1F, 0x1F, 0x0F, 0x3E, 0x1F, 0x1F, 0x3E, 0x1E, 0x1F, 0x3E, 0x1E, 0x1F,
  0x3C, 0x3E, 0x1F, 0x3C, 0x3E, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3C, 0x3E,
  0x7C, 0x7C, 0x3E, 0x78, 0x7C, 0x3C, 0xF8, 0x7C, 0x7C, 0x00, 0x18, 0x1E,
  0x7E, 0x1E, 0xFE, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF,
  0x3E, 0x7D, 0xF0, 0xF7, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87,
  0xFE, 0x3E, 0xFD, 0xF9, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x00, 0x18, 0x07,
  0xBF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF8, 0x78, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0xC7, 0xC7, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7B, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0x00,
  0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xEF, 0x87, 0x9F, 0x0F, 0x3C,
  0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0xDF, 0x8F, 0xFF,
  0x1F, 0xFC, 0x1F, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x18, 0xF3, 0xC7, 0xBE, 0x3F,
  0xE1, 0xFF, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x7F, 0xC7,
  0xFE, 0x7F, 0xE3, 0xE1, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xEE, 0x3F, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x07, 0x00,
  0x70, 0x0F, 0x01, 0xF1, 0x7F, 0xEF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0xD8, 0x7F, 0x87,
  0xF8, 0x3F, 0x80, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8,
  0xF8, 0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0x78, 0xF8, 0x3E, 0xF0,
  0xF9, 0xE1, 0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0,
  0x7B, 0xE0, 0x77, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0xF0, 0xF8, 0x7F, 0xC7, 0xE3, 0xEF, 0x1F, 0x8F, 0xBC, 0x7E,
  0x3C, 0xF3, 0xB9, 0xF3, 0xCE, 0xE7, 0x8F, 0x7B, 0xBE, 0x3D, 0xCE, 0xF0,
  0xF7, 0x3B, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0xF9,
  0xF0, 0x1F, 0x3E, 0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x9E,
  0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xC3, 0xC3,
  0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xFB, 0xE0,
  0x3E, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x7F, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x0F, 0xE0, 0xFC,
  0x0F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x60,
};

const GFXglyph NotoSans_ExtraBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 20, 8, 0, -20 },
  { 24, 11, 7, 13, 3, -20 },
  { 34, 18, 20, 18, 0, -20 },
  { 79, 15, 23, 16, 1, -21 },
  { 123, 22, 20, 25, 2, -20 },
  { 178, 19, 20, 20, 1, -20 },
  { 226, 5, 7, 7, 3, -20 },
  { 231, 11, 24, 10, 1, -20 },
  { 264, 11, 24, 10, -2, -20 },
  { 297, 14, 13, 15, 2, -21 },
  { 320, 14, 14, 16, 1, -17 },
  { 345, 7, 7, 8, -1, -3 },
  { 352, 9, 3, 9, 0, -9 },
  { 356, 5, 5, 8, 0, -5 },
  { 360, 15, 20, 12, -1, -20 },
  { 398, 14, 20, 16, 1, -20 },
  { 433, 12, 20, 16, 2, -20 },
  { 463, 16, 20, 16, -1, -20 },
  { 503, 15, 20, 16, 0, -20 },
  { 541, 15, 20, 16, 0, -20 },
  { 579, 16, 20, 16, 0, -20 },
  { 619, 15, 20, 16, 1, -20 },
  { 657, 16, 20, 16, 1, -20 },
  { 697, 15, 20, 16, 1, -20 },
  { 735, 14, 20, 16, 1, -20 },
  { 770, 8, 16, 8, 0, -16 },
  { 786, 10, 20, 8, -2, -16 },
  { 811, 14, 15, 16, 1, -18 },
  { 838, 14, 9, 16, 1, -14 },
  { 854, 14, 15, 16, 1, -18 },
  { 881, 12, 20, 13, 2, -20 },
  { 911, 23, 23, 25, 1, -20 },
  { 978, 18, 20, 18, -2, -20 },
  { 1023, 16, 20, 18, 1, -20 },
  { 1063, 16, 20, 17, 2, -20 },
  { 1103, 17, 20, 19, 1, -20 },
  { 1146, 15, 20, 15, 1, -20 },
  { 1184, 15, 20, 15, 1, -20 },
  { 1222, 17, 20, 19, 2, -20 },
  { 1265, 19, 20, 20, 1, -20 },
  { 1313, 14, 20, 11, -1, -20 },
  { 1348, 14, 26, 10, -4, -20 },
  { 1394, 19, 20, 18, 1, -20 },
  { 1442, 12, 20, 15, 1, -20 },
  { 1472, 24, 20, 25, 1, -20 },
  { 1532, 21, 20, 22, 1, -20 },
  { 1585, 18, 20, 21, 2, -20 },
  { 1630, 16, 20, 17, 1, -20 },
  { 1670, 18, 25, 21, 2, -20 },
  { 1727, 16, 20, 18, 1, -20 },
  { 1767, 14, 20, 15, 1, -20 },
  { 1802, 15, 20, 15, 2, -20 },
  { 1840, 18, 20, 19, 2, -20 },
  { 1885, 17, 20, 17, 2, -20 },
  { 1928, 26, 20, 26, 2, -20 },
  { 1993, 22, 20, 18, -2, -20 },
  { 2048, 17, 20, 16, 2, -20 },
  { 2091, 18, 20, 15, -1, -20 },
  { 2136, 13, 25, 10, -1, -20 },
  { 2177, 7, 20, 12, 3, -20 },
  { 2195, 12, 25, 10, -2, -20 },
  { 2233, 15, 13, 15, 0, -20 },
  { 2258, 13, 3, 12, -3, 2 },
  { 2263, 6, 4, 9, 4, -21 },
  { 2266, 15, 16, 17, 1, -16 },
  { 2296, 16, 21, 17, 0, -21 },
  { 2338, 13, 16, 14, 1, -16 },
  { 2364, 17, 21, 17, 1, -21 },
  { 2409, 14, 16, 16, 1, -16 },
  { 2437, 17, 28, 11, -3, -21 },
  { 2497, 16, 23, 17, 0, -16 },
  { 2543, 16, 21, 17, 0, -21 },
  { 2585, 9, 22, 9, 0, -22 },
  { 2610, 13, 29, 9, -4, -22 },
  { 2658, 18, 21, 17, 0, -21 },
  { 2706, 10, 21, 9, 0, -21 },
  { 2733, 24, 16, 26, 0, -16 },
  { 2781, 16, 16, 17, 0, -16 },
  { 2813, 14, 16, 17, 1, -16 },
  { 2841, 17, 23, 17, -1, -16 },
  { 2890, 15, 23, 17, 1, -16 },
  { 2934, 13, 16, 12, 0, -16 },
  { 2960, 13, 16, 14, 0, -16 },
  { 2986, 12, 19, 12, 1, -19 },
  { 3015, 16, 15, 17, 1, -15 },
  { 3045, 15, 15, 15, 1, -15 },
  { 3074, 22, 15, 23, 2, -15 },
  { 3116, 19, 15, 15, -2, -15 },
  { 3152, 18, 22, 15, -2, -15 },
  { 3202, 15, 15, 13, -1, -15 },
  { 3231, 12, 24, 10, 0, -20 },
  { 3267, 3, 27, 16, 6, -21 },
  { 3278, 12, 24, 10, -2, -20 },
  { 3314, 14, 5, 16, 1, -12 },
};

const GFXfont NotoSans_ExtraBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRABOLDITALIC28PT7B_H_
