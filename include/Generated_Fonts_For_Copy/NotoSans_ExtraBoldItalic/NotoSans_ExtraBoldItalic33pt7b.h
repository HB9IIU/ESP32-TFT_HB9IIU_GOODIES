#ifndef _NOTOSANS_EXTRABOLDITALIC33PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xE0, 0x7C, 0xFB,
  0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x07, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0x8F,
  0x00, 0x1E, 0x3C, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x7E, 0xC2,
  0x3E, 0x60, 0x1F, 0xB0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xDF, 0x00, 0xCF, 0xB0, 0x67, 0xDF,
  0x7F, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x07, 0xF0, 0x07, 0x83,
  0xFE, 0x03, 0xC1, 0xFF, 0x81, 0xF0, 0x79, 0xF0, 0x78, 0x3E, 0x7C, 0x3C,
  0x0F, 0x9F, 0x1E, 0x03, 0xC7, 0x8F, 0x80, 0xF1, 0xE3, 0xC0, 0x3C, 0x79,
  0xE0, 0x0F, 0x3E, 0xF3, 0xFB, 0xFF, 0x7D, 0xFF, 0xFF, 0xDE, 0xFF, 0xDF,
  0xEF, 0x3E, 0xF3, 0xE7, 0xDF, 0x3C, 0x03, 0xE7, 0x8F, 0x00, 0xF1, 0xE3,
  0xC0, 0x78, 0x78, 0xF0, 0x3E, 0x1E, 0x3C, 0x0F, 0x07, 0x9F, 0x07, 0x81,
  0xEF, 0x83, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF0, 0xF8, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0xDF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0x3F, 0xF0, 0xFD, 0xFF,
  0xE3, 0xF7, 0xEF, 0xDF, 0xBF, 0x3F, 0x7C, 0xF8, 0x7F, 0xF3, 0xE0, 0xFF,
  0x8F, 0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x07, 0xFC, 0xFE, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x61, 0xC0, 0xF9, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0x1F, 0xDE, 0x3F, 0xE0, 0x7D, 0xE0,
  0xFD, 0xF0, 0x38, 0xF0, 0x10, 0xF8, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF1,
  0xF0, 0x7F, 0xDF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBF,
  0x07, 0xDF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7D,
  0xF8, 0x3E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x1F, 0x9F, 0x9F, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x83, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0x3F, 0x7C, 0x71, 0xF0, 0x8F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0x0F, 0xC0, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0x83, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE8, 0x03, 0xFB, 0x81, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBE, 0x03, 0xFF,
  0x81, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x3F, 0x0F, 0x8F, 0x87,
  0xC3, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x10, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF2, 0x00, 0xFC, 0x78, 0x7F, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xF0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x10, 0x1F, 0xBF, 0x07, 0xDF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0x8F, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7,
  0xC3, 0xF1, 0xF9, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1F, 0x9F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x0F, 0xDF, 0x87, 0xEF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xBE, 0x1F, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x87, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x00, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x01,
  0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF,
  0xE6, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF9,
  0xF0, 0x7F, 0xCF, 0x3C, 0x3F, 0xF9, 0xE7, 0x8F, 0xFE, 0x3D, 0xE3, 0xE3,
  0xC7, 0xBC, 0x78, 0x78, 0xF7, 0x9F, 0x0F, 0x1E, 0xE3, 0xC3, 0xC3, 0xFC,
  0x78, 0x78, 0x7F, 0x8F, 0x0F, 0x1E, 0xF1, 0xE3, 0xE7, 0xDE, 0x3F, 0xFF,
  0xF1, 0xE7, 0xFB, 0xFC, 0x3C, 0x7E, 0x7F, 0x07, 0xC3, 0x87, 0x80, 0x78,
  0x00, 0x00, 0x0F, 0xC0, 0x08, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C,
  0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x01,
  0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x07,
  0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE3, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x87, 0xE3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x7E, 0x3E, 0x7F, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0x0C, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0x07, 0xF9, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x7F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3,
  0xF0, 0x1F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x7C, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xE0, 0x30,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x0F,
  0xF9, 0xF8, 0x7F, 0xCF, 0xC3, 0xFE, 0x7E, 0x3F, 0xF3, 0xF1, 0xFF, 0x9F,
  0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0xFE, 0x3F,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x37, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x07,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xF7, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x7B, 0xE0, 0xFF, 0x83, 0xDF, 0x07, 0xBC, 0x3D, 0xF8, 0x7D, 0xE1, 0xEF,
  0x83, 0xEF, 0x1F, 0x7C, 0x1F, 0x78, 0xF3, 0xE0, 0xFB, 0xCF, 0x9F, 0x0F,
  0x9F, 0x79, 0xF0, 0x7C, 0x7F, 0xCF, 0x83, 0xE3, 0xFC, 0x7C, 0x1F, 0x1F,
  0xE3, 0xE0, 0xF8, 0xFE, 0x1F, 0x0F, 0x87, 0xF1, 0xF0, 0x7C, 0x3F, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x0F, 0x87,
  0xF0, 0x0F, 0x83, 0xFC, 0x07, 0xC1, 0xFE, 0x03, 0xE0, 0xFF, 0x01, 0xF0,
  0x7F, 0xC0, 0xF8, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0x7C, 0x3E,
  0x0F, 0xBE, 0x1F, 0x07, 0x9F, 0x1F, 0x87, 0xCF, 0xCF, 0x83, 0xE3, 0xE7,
  0xC1, 0xF1, 0xF3, 0xE0, 0xF8, 0xFD, 0xF0, 0xFC, 0x3E, 0xF0, 0x7C, 0x1F,
  0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x0F, 0x80,
  0xFF, 0x07, 0xC0, 0x7F, 0x83, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x03,
  0xF8, 0xFE, 0x7F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3,
  0xE0, 0xFC, 0x7C, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x03,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xC7,
  0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x03,
  0xF7, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF1, 0xF8, 0x10, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x20, 0x1F, 0x1E, 0x3F, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x80,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xFE,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x0F,
  0xCF, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7D,
  0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xBE,
  0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0xFE, 0x0F, 0xCF, 0x83,
  0xF8, 0x3E, 0x3E, 0x1F, 0xE0, 0xF8, 0xF8, 0x7F, 0x87, 0xE3, 0xE3, 0xFE,
  0x1F, 0x0F, 0x8F, 0x78, 0xFC, 0x3E, 0x3D, 0xE3, 0xE0, 0xF9, 0xF7, 0x8F,
  0x83, 0xE7, 0x9F, 0x7C, 0x0F, 0xBE, 0x7D, 0xF0, 0x3E, 0xF1, 0xFF, 0xC0,
  0xFB, 0xC7, 0xBE, 0x03, 0xFF, 0x1E, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x03,
  0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xFF,
  0x81, 0xFB, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x9E, 0x07,
  0xC7, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0x71, 0xE0, 0x3D, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xFC, 0xF9, 0xF1, 0xF1,
  0xE0, 0x07, 0xF3, 0xC3, 0xFD, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x9F,
  0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0x9F, 0x07, 0xCF,
  0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x9F, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xCF, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x0F, 0xBF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0x3F, 0x1F, 0x87, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0,
  0xFC, 0xF8, 0x7E, 0x7F, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xEF, 0xF8,
  0xF9, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x84, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x18, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x7C, 0x0F,
  0xF7, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x87,
  0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xBE, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xF3, 0xF3, 0xF0, 0xF9, 0xF0, 0x7D, 0xF8, 0x7E, 0xFF, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x21,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xC3, 0xFD, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F,
  0x9F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x9F, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xBE, 0x07, 0xDF, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x80, 0xFC, 0x38, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0xFC, 0x0F, 0xBF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xF8,
  0xFC, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x7F, 0x0F, 0x87, 0xF0, 0x7C, 0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x3F, 0x01,
  0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0xC0, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x0F, 0x9F, 0x87,
  0xE0, 0x79, 0xFE, 0x7F, 0x83, 0xDF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xE0,
  0xF8, 0x3E, 0x3F, 0x07, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC1, 0xF1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7C, 0x1F, 0x07, 0xC7, 0xE0,
  0xF8, 0x3E, 0x00, 0x0F, 0x9F, 0x81, 0xEF, 0xF8, 0x3D, 0xFF, 0x07, 0xFF,
  0xE1, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83, 0xE0, 0x03, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7D, 0xF8,
  0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xEF,
  0xC3, 0xF3, 0xF3, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xDF, 0x80, 0xF7, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFE,
  0x7E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0,
  0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x7F, 0x3F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3E, 0xFE, 0x07, 0xCF, 0x81, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF3, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x1F, 0x9F,
  0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x1F, 0x9F, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xBE, 0x07, 0xDF, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x9E, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC3,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xFD, 0xE3, 0xF0, 0x47, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0xD8, 0x1F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9F, 0x07, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF,
  0x83, 0xF3, 0xE1, 0xF8, 0xF8, 0x7E, 0x3F, 0x3F, 0x8F, 0xFF, 0xE3, 0xFE,
  0xF0, 0x7F, 0xBC, 0x1F, 0x8F, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F,
  0xDF, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF0, 0xF1, 0xF0, 0x79,
  0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x0F,
  0xFE, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0xFB, 0xE1, 0xFC, 0x7E, 0xF8, 0xFF,
  0x1F, 0x3E, 0x3F, 0xCF, 0xCF, 0x9E, 0xF3, 0xE3, 0xE7, 0xBD, 0xF8, 0xFB,
  0xCF, 0x7C, 0x3E, 0xF3, 0xDF, 0x0F, 0xBC, 0xFF, 0x83, 0xFE, 0x3F, 0xE0,
  0xFF, 0x8E, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x1F,
  0x8F, 0xE0, 0x7E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x01, 0xF9,
  0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07,
  0xC3, 0xE0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x11, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x1C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x1F,
  0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x10, 0x01, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 24, 10, 0, -24 },
  { 34, 13, 9, 15, 3, -24 },
  { 49, 22, 24, 21, 0, -24 },
  { 115, 17, 27, 19, 1, -25 },
  { 173, 26, 24, 29, 2, -24 },
  { 251, 22, 24, 24, 1, -24 },
  { 317, 6, 9, 8, 3, -24 },
  { 324, 13, 29, 12, 1, -24 },
  { 372, 13, 29, 12, -2, -24 },
  { 420, 16, 16, 18, 3, -25 },
  { 452, 16, 16, 19, 2, -20 },
  { 484, 9, 8, 10, -2, -4 },
  { 493, 10, 4, 11, 0, -11 },
  { 498, 6, 5, 10, 0, -5 },
  { 502, 18, 24, 15, -1, -24 },
  { 556, 17, 24, 19, 1, -24 },
  { 607, 14, 24, 19, 3, -24 },
  { 649, 19, 24, 19, -1, -24 },
  { 706, 18, 24, 19, 0, -24 },
  { 760, 18, 24, 19, 0, -24 },
  { 814, 19, 24, 19, 0, -24 },
  { 871, 18, 24, 19, 1, -24 },
  { 925, 19, 24, 19, 1, -24 },
  { 982, 17, 24, 19, 1, -24 },
  { 1033, 16, 24, 19, 2, -24 },
  { 1081, 9, 18, 10, 0, -18 },
  { 1102, 11, 22, 10, -2, -18 },
  { 1133, 16, 18, 19, 2, -21 },
  { 1169, 16, 11, 19, 2, -17 },
  { 1191, 16, 18, 19, 2, -21 },
  { 1227, 15, 24, 16, 2, -24 },
  { 1272, 27, 27, 29, 1, -24 },
  { 1364, 21, 24, 21, -2, -24 },
  { 1427, 19, 24, 21, 1, -24 },
  { 1484, 20, 24, 21, 2, -24 },
  { 1544, 20, 24, 22, 1, -24 },
  { 1604, 18, 24, 18, 1, -24 },
  { 1658, 18, 24, 18, 1, -24 },
  { 1712, 21, 24, 23, 2, -24 },
  { 1775, 23, 24, 23, 1, -24 },
  { 1844, 16, 24, 13, -1, -24 },
  { 1892, 17, 31, 12, -5, -24 },
  { 1958, 23, 24, 21, 1, -24 },
  { 2027, 14, 24, 17, 1, -24 },
  { 2069, 29, 24, 29, 1, -24 },
  { 2156, 25, 24, 26, 1, -24 },
  { 2231, 21, 24, 24, 2, -24 },
  { 2294, 19, 24, 20, 1, -24 },
  { 2351, 21, 30, 24, 2, -24 },
  { 2430, 19, 24, 21, 1, -24 },
  { 2487, 17, 24, 18, 1, -24 },
  { 2538, 17, 24, 18, 3, -24 },
  { 2589, 21, 24, 23, 2, -24 },
  { 2652, 20, 24, 20, 3, -24 },
  { 2712, 30, 24, 30, 3, -24 },
  { 2802, 25, 24, 21, -2, -24 },
  { 2877, 19, 24, 19, 3, -24 },
  { 2934, 20, 24, 18, -1, -24 },
  { 2994, 15, 29, 11, -1, -24 },
  { 3049, 8, 24, 15, 4, -24 },
  { 3073, 14, 29, 11, -2, -24 },
  { 3124, 17, 16, 18, 0, -24 },
  { 3158, 15, 3, 14, -3, 3 },
  { 3164, 7, 5, 11, 5, -25 },
  { 3169, 18, 18, 20, 1, -18 },
  { 3210, 18, 25, 20, 0, -25 },
  { 3267, 16, 18, 16, 1, -18 },
  { 3303, 20, 25, 20, 1, -25 },
  { 3366, 17, 18, 19, 1, -18 },
  { 3405, 19, 33, 13, -3, -25 },
  { 3484, 18, 26, 20, 1, -18 },
  { 3543, 19, 25, 20, 0, -25 },
  { 3603, 11, 25, 10, 0, -25 },
  { 3638, 15, 33, 10, -4, -25 },
  { 3700, 21, 25, 20, 0, -25 },
  { 3766, 11, 25, 10, 0, -25 },
  { 3801, 29, 18, 30, 0, -18 },
  { 3867, 19, 18, 20, 0, -18 },
  { 3910, 17, 18, 20, 1, -18 },
  { 3949, 19, 26, 20, -1, -18 },
  { 4011, 18, 26, 20, 1, -18 },
  { 4070, 15, 18, 14, 0, -18 },
  { 4104, 15, 18, 16, 0, -18 },
  { 4138, 14, 22, 14, 1, -22 },
  { 4177, 18, 18, 20, 2, -18 },
  { 4218, 17, 18, 17, 2, -18 },
  { 4257, 26, 18, 27, 2, -18 },
  { 4316, 22, 18, 18, -2, -18 },
  { 4366, 21, 26, 18, -2, -18 },
  { 4435, 17, 18, 16, -1, -18 },
  { 4474, 14, 29, 12, 0, -24 },
  { 4525, 4, 32, 18, 7, -25 },
  { 4541, 14, 29, 12, -2, -24 },
  { 4592, 16, 6, 19, 2, -15 },
};

const GFXfont NotoSans_ExtraBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRABOLDITALIC33PT7B_H_
