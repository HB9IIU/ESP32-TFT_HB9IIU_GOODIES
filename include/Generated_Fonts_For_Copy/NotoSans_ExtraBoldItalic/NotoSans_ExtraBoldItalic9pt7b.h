#ifndef _NOTOSANS_EXTRABOLDITALIC9PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xF4, 0x39, 0xF2, 0xBE, 0x51, 0xC0, 0x13, 0xD4,
  0xE3, 0xFD, 0x88, 0x22, 0x74, 0x7C, 0xEE, 0x55, 0x27, 0x66, 0x10, 0xE6,
  0x8D, 0xFF, 0x67, 0xC0, 0xE0, 0x12, 0x44, 0xCC, 0xC4, 0x23, 0x11, 0x33,
  0x2C, 0x2A, 0x7A, 0x20, 0x27, 0xC8, 0x40, 0xE0, 0xE0, 0xC0, 0x18, 0x8C,
  0x44, 0x62, 0x00, 0x13, 0xD7, 0xBD, 0xE9, 0xC0, 0x7A, 0x66, 0x64, 0x23,
  0xC6, 0x22, 0x63, 0xC0, 0x13, 0xC6, 0xE1, 0x4F, 0xC0, 0x19, 0xD5, 0xAF,
  0x98, 0x7A, 0x1C, 0x39, 0x78, 0x09, 0xD0, 0xFD, 0xED, 0xC0, 0x78, 0xCC,
  0x46, 0x60, 0x13, 0xD2, 0x65, 0x6D, 0xC0, 0x23, 0xD6, 0xB7, 0x8B, 0x80,
  0x68, 0x0C, 0x32, 0x00, 0x6C, 0x09, 0xF8, 0xE1, 0x80, 0xF8, 0x3E, 0x87,
  0x06, 0x6C, 0x00, 0x4F, 0x26, 0xC0, 0x80, 0x3E, 0x5F, 0x75, 0xAA, 0xF6,
  0x44, 0x38, 0x1C, 0x53, 0x4F, 0x7F, 0x10, 0x79, 0xB7, 0x96, 0x5B, 0xC0,
  0x10, 0xF6, 0x10, 0xC1, 0x27, 0x80, 0x79, 0xB4, 0xD3, 0x5B, 0xC0, 0x7B,
  0x1E, 0x84, 0x78, 0x7B, 0x1E, 0xE4, 0x60, 0x08, 0xF6, 0x17, 0xDD, 0x27,
  0x80, 0x65, 0xB7, 0xD3, 0x4B, 0x20, 0x76, 0x66, 0x4E, 0x33, 0x32, 0x26,
  0x6C, 0x6E, 0xF1, 0xC3, 0x85, 0x9B, 0x00, 0x66, 0x44, 0x4F, 0x73, 0x57,
  0x56, 0x5A, 0x5A, 0xD6, 0x76, 0xAD, 0x52, 0xE5, 0xD9, 0x80, 0x10, 0xF6,
  0x51, 0xC5, 0x37, 0x80, 0x79, 0xB5, 0x9C, 0x43, 0x00, 0x10, 0xF6, 0x51,
  0xC5, 0x37, 0x86, 0x08, 0x7B, 0x5E, 0xE5, 0xEC, 0x13, 0xD0, 0xC3, 0x4B,
  0xC0, 0xF6, 0x44, 0xCC, 0xCE, 0xE7, 0x29, 0x78, 0x9C, 0xAD, 0x4E, 0x60,
  0x9B, 0xBA, 0xBE, 0xFC, 0xDC, 0xD8, 0x36, 0x38, 0x61, 0xC2, 0xDD, 0x80,
  0xDF, 0x98, 0x84, 0x60, 0x78, 0x8C, 0xCC, 0x78, 0x76, 0x44, 0x4C, 0x8C,
  0xAF, 0x54, 0x33, 0x13, 0x22, 0x2E, 0x31, 0x95, 0x10, 0xF0, 0xD0, 0x7A,
  0xF7, 0xB7, 0x00, 0x23, 0x1E, 0xB5, 0xEE, 0xC0, 0x7A, 0x31, 0xA7, 0x00,
  0x0C, 0x27, 0x96, 0xDB, 0x67, 0x00, 0x3A, 0xFD, 0x87, 0x00, 0x18, 0x8E,
  0xE2, 0x11, 0x8C, 0xC0, 0x7A, 0xF7, 0xB7, 0x0B, 0xC0, 0x23, 0x1E, 0xD5,
  0xEF, 0x40, 0x65, 0xA5, 0xB0, 0x31, 0x32, 0x26, 0x66, 0xC0, 0x21, 0x86,
  0xD4, 0x73, 0x4D, 0x80, 0x2D, 0xA5, 0xB0, 0x5F, 0x6B, 0x5B, 0xDA, 0xD2,
  0x5B, 0x57, 0xBD, 0x00, 0x72, 0xF7, 0xB7, 0x00, 0x7A, 0xD7, 0xBF, 0x62,
  0x00, 0x7A, 0xF7, 0xB7, 0x08, 0xC0, 0x56, 0x4C, 0xC0, 0x74, 0x63, 0xE0,
  0x2F, 0x44, 0xC6, 0x6A, 0x57, 0xB7, 0x00, 0xDA, 0x9C, 0xC6, 0x00, 0xDB,
  0x5A, 0x6E, 0x6C, 0x6C, 0x5B, 0x88, 0xED, 0x00, 0x6C, 0xA2, 0x8C, 0x30,
  0x8E, 0x00, 0x73, 0x64, 0xF0, 0x36, 0x68, 0x44, 0xC0, 0xFF, 0x80, 0x33,
  0x21, 0x26, 0xC0, 0xEC, 0x80,
};

const GFXglyph NotoSans_ExtraBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 3, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 6, 6, 6, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 8, 7, 8, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 2, 2, 1, -6 },
  { 29, 4, 8, 3, 0, -7 },
  { 33, 4, 8, 3, -1, -7 },
  { 37, 4, 5, 5, 1, -7 },
  { 40, 5, 4, 5, 0, -5 },
  { 43, 2, 2, 3, 0, -1 },
  { 44, 3, 1, 3, 0, -3 },
  { 45, 2, 1, 3, 0, -1 },
  { 46, 5, 7, 4, 0, -7 },
  { 51, 5, 7, 5, 0, -7 },
  { 56, 4, 6, 5, 1, -6 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 6, 5, 0, -6 },
  { 73, 5, 6, 5, 0, -6 },
  { 77, 5, 7, 5, 0, -7 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 5, 7, 5, 0, -7 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 4, 6, 3, -1, -5 },
  { 101, 5, 5, 5, 0, -6 },
  { 105, 5, 3, 5, 0, -5 },
  { 107, 5, 5, 5, 0, -6 },
  { 111, 4, 7, 4, 1, -7 },
  { 115, 8, 7, 8, 0, -6 },
  { 122, 6, 6, 6, -1, -6 },
  { 127, 6, 6, 6, 0, -6 },
  { 132, 6, 7, 6, 0, -7 },
  { 138, 6, 6, 6, 0, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 6, 7, 6, 0, -7 },
  { 157, 6, 6, 6, 0, -6 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 4, 8, 3, -1, -6 },
  { 169, 7, 6, 6, 0, -6 },
  { 175, 4, 6, 5, 0, -6 },
  { 178, 8, 6, 8, 0, -6 },
  { 184, 7, 6, 7, 0, -6 },
  { 190, 6, 7, 7, 0, -7 },
  { 196, 6, 6, 6, 0, -6 },
  { 201, 6, 9, 7, 0, -7 },
  { 208, 5, 6, 6, 0, -6 },
  { 212, 5, 7, 5, 0, -7 },
  { 217, 4, 6, 5, 1, -6 },
  { 220, 5, 6, 6, 1, -6 },
  { 224, 5, 6, 5, 1, -6 },
  { 228, 8, 6, 8, 1, -6 },
  { 234, 7, 6, 6, -1, -6 },
  { 240, 5, 6, 5, 1, -6 },
  { 244, 5, 6, 5, 0, -6 },
  { 248, 4, 8, 3, 0, -7 },
  { 252, 2, 7, 4, 1, -7 },
  { 254, 4, 8, 3, -1, -7 },
  { 258, 5, 4, 5, 0, -6 },
  { 261, 4, 1, 4, -1, 1 },
  { 262, 2, 2, 3, 1, -7 },
  { 263, 5, 5, 5, 0, -5 },
  { 267, 5, 7, 5, 0, -7 },
  { 272, 5, 5, 4, 0, -5 },
  { 276, 6, 7, 5, 0, -7 },
  { 282, 5, 5, 5, 0, -5 },
  { 286, 5, 9, 4, -1, -7 },
  { 292, 5, 7, 5, 0, -5 },
  { 297, 5, 7, 6, 0, -7 },
  { 302, 3, 7, 3, 0, -7 },
  { 305, 4, 9, 3, -1, -7 },
  { 310, 6, 7, 5, 0, -7 },
  { 316, 3, 7, 3, 0, -7 },
  { 319, 8, 5, 8, 0, -5 },
  { 324, 5, 5, 6, 0, -5 },
  { 328, 5, 5, 5, 0, -5 },
  { 332, 5, 7, 5, 0, -5 },
  { 337, 5, 7, 5, 0, -5 },
  { 342, 4, 5, 4, 0, -5 },
  { 345, 4, 5, 4, 0, -5 },
  { 348, 4, 6, 4, 0, -6 },
  { 351, 5, 5, 6, 0, -5 },
  { 355, 5, 5, 5, 0, -5 },
  { 359, 8, 5, 7, 0, -5 },
  { 364, 5, 5, 5, 0, -5 },
  { 368, 6, 7, 5, -1, -5 },
  { 374, 4, 5, 4, 0, -5 },
  { 377, 4, 7, 3, 0, -6 },
  { 381, 1, 9, 5, 2, -7 },
  { 383, 4, 7, 3, -1, -6 },
  { 387, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRABOLDITALIC9PT7B_H_
