#ifndef _NOTOSANS_EXTRABOLDITALIC32PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x7C, 0xFB, 0xE7,
  0x9E, 0x7C, 0xF3, 0xE7, 0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0x00, 0x79,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC0, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x79, 0xE0, 0x03, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x7F, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFD, 0x9C, 0x7C, 0xC0, 0x3E, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0x7C, 0x01, 0x9E, 0x41,
  0xDF, 0x3C, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x0F, 0xF0,
  0x0F, 0x03, 0xFE, 0x07, 0x81, 0xF7, 0x81, 0xE0, 0x79, 0xE0, 0xF0, 0x3E,
  0x78, 0x78, 0x0F, 0x1E, 0x3C, 0x03, 0xC7, 0x8F, 0x00, 0xF3, 0xE7, 0x80,
  0x3C, 0xF3, 0xCF, 0x8F, 0x7D, 0xE7, 0xF3, 0xFE, 0x7B, 0xFE, 0x7F, 0xBD,
  0xF7, 0x8F, 0x9E, 0x79, 0xE0, 0x0F, 0x9E, 0x7C, 0x03, 0xCF, 0x9E, 0x01,
  0xE3, 0xC7, 0x80, 0xF0, 0xF1, 0xE0, 0x7C, 0x3C, 0xF8, 0x1E, 0x0F, 0xBC,
  0x0F, 0x03, 0xFF, 0x07, 0x80, 0x7F, 0x83, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x8F, 0xC7, 0xFC, 0x3E, 0x3F, 0xF0, 0xF9, 0xFF, 0xE7,
  0xCF, 0xCF, 0xFF, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3, 0xE0, 0xFF, 0x0F,
  0xC3, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFE,
  0x7F, 0x00, 0x7D, 0xF7, 0x9E, 0x7B, 0xCF, 0x3C, 0x01, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x02, 0x00, 0x03, 0xC0, 0x0F, 0x82, 0x1E, 0x06, 0x3C, 0x1F, 0x78, 0x3F,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x7F, 0x0B, 0xEE, 0x0F, 0xDE,
  0x07, 0x3C, 0x04, 0x3C, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F,
  0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xF0, 0x7F, 0xDF, 0xF7, 0xF9,
  0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF9, 0xF1, 0xF8, 0xFC, 0xF8, 0x7E, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xEF, 0xC1, 0xF7,
  0xE0, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x7E, 0x7C, 0x3F, 0x3F, 0x3F,
  0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xF8, 0x0F,
  0xC1, 0xFE, 0x3F, 0xE3, 0xFF, 0x7F, 0xFB, 0xF7, 0xCF, 0x7E, 0x63, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x07, 0xCF, 0xC1, 0xC1,
  0xF0, 0x20, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0,
  0x71, 0xF8, 0x20, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x40, 0x1F, 0xB8, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xDF,
  0x01, 0xE7, 0xC0, 0xFB, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x87,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x20, 0x0F,
  0xCE, 0x07, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xFE, 0x08, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0xF8, 0x3E, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xE3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F,
  0x7E, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0x80, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0xBF,
  0x07, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFF, 0x3F, 0x3F, 0x7E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0xBE,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x81, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F, 0xE1, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFF, 0x38, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xE1,
  0xFC, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0xF0,
  0xFF, 0xCF, 0x3C, 0x7F, 0xF3, 0xDE, 0x3E, 0x3C, 0x77, 0x8F, 0x1E, 0x1D,
  0xC7, 0x87, 0x87, 0x71, 0xE1, 0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x3C,
  0x3F, 0xC7, 0x8F, 0x1E, 0xF1, 0xFF, 0xDF, 0x1C, 0x7F, 0xFF, 0xC7, 0x8F,
  0xDF, 0xC1, 0xE1, 0xC1, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x00, 0xF9,
  0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03,
  0xE0, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0xBE, 0x00, 0xFF, 0xF0,
  0x07, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xF9, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7F, 0x1F,
  0x87, 0xE3, 0xF0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF1, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFE, 0x7C, 0x7F, 0x01, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x43, 0xFC, 0x38, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xF0, 0x3F,
  0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xC1,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFF, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xF3, 0xC3, 0xF8,
  0x04, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0xEF, 0xC7, 0xFC, 0xF8, 0x7F, 0xCF, 0x87, 0xFC, 0xF8, 0x0F, 0xCF,
  0x80, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFF, 0x1F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF8, 0x0F, 0x87, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC1,
  0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xE0,
  0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x01, 0xF0, 0xFC, 0x07,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x81,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xFC, 0x1E,
  0xF0, 0xFF, 0xC1, 0xEF, 0x0F, 0x7C, 0x3E, 0xF1, 0xF7, 0xC3, 0xEF, 0x1E,
  0xF8, 0x3E, 0xF3, 0xEF, 0x83, 0xEF, 0x3C, 0xF8, 0x7C, 0xF7, 0xCF, 0x87,
  0xCF, 0x78, 0xF0, 0x7C, 0xFF, 0x9F, 0x07, 0xCF, 0xF1, 0xF0, 0x78, 0xFF,
  0x1F, 0x0F, 0x8F, 0xE1, 0xF0, 0xF8, 0xFE, 0x1E, 0x0F, 0x8F, 0xC3, 0xE0,
  0xF8, 0xFC, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0,
  0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x1F, 0xF0, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x1E, 0x7C, 0x7C, 0x3E, 0x7C,
  0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x3E, 0xF8, 0x3E, 0x3E, 0xF8, 0x7C, 0x3E,
  0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x1F,
  0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFE, 0xFF, 0x1F, 0xC1, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01,
  0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x7C,
  0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E,
  0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3,
  0xE1, 0xF8, 0xFC, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0xFF, 0x1F, 0xC1,
  0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xBF,
  0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F,
  0xDF, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0xCF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x9F, 0xC7, 0xE1,
  0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C,
  0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBE, 0x07,
  0xEF, 0x80, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1,
  0xF8, 0xE1, 0xF8, 0x10, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x40, 0x7E, 0x38, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3F, 0x9F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E,
  0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x3C, 0x7C, 0x07, 0x8F, 0x80, 0xF3, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x07,
  0xEF, 0x83, 0xF8, 0x3E, 0x7C, 0x1F, 0xC3, 0xF3, 0xE1, 0xFE, 0x1F, 0x1F,
  0x0F, 0xF0, 0xF8, 0xF8, 0xF7, 0x8F, 0x87, 0xC7, 0xBC, 0x7C, 0x3E, 0x7D,
  0xE7, 0xE1, 0xF3, 0xCF, 0x3E, 0x0F, 0x9E, 0x79, 0xF0, 0x7D, 0xF3, 0xDF,
  0x03, 0xEF, 0x1E, 0xF8, 0x1F, 0xF8, 0xF7, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xBC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F,
  0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80,
  0x07, 0xEF, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x87,
  0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x0F, 0x3C, 0x0F, 0x9E, 0x07,
  0x8F, 0x07, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x3B, 0xE0, 0x1E,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xF9, 0xF1, 0xF3, 0xE3, 0xC3, 0xC0,
  0x03, 0xC7, 0xC1, 0xFD, 0xF1, 0xFF, 0x78, 0x7F, 0xFE, 0x3F, 0xBF, 0x8F,
  0xC7, 0xE7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1,
  0xF3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xBC, 0x07, 0xCF, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF9, 0xE0, 0x3E, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE1, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF9,
  0xFC, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xBF, 0xC3, 0xE7, 0xE0, 0x01,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xF9, 0xC7, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC2, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0xF3, 0xF0, 0x3F, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFE, 0xFE, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xFC,
  0x1F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xEF, 0x00, 0xF9, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x7F, 0x7F, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x04, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x27, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC7,
  0xC3, 0xFD, 0xF1, 0xFF, 0x78, 0x7F, 0xFE, 0x3F, 0xBF, 0x8F, 0xC7, 0xE7,
  0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0,
  0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC,
  0x07, 0xDF, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x80, 0xF8, 0x3D, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF9,
  0xF0, 0x3E, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFE, 0xFC, 0x7E, 0x1F,
  0x1F, 0x87, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF3, 0xF0, 0xFC, 0x00, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xE1, 0xF0,
  0xFE, 0x0F, 0x87, 0xE0, 0x7C, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7E, 0x01,
  0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3E,
  0x1F, 0x81, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x07, 0xE0, 0x0F, 0x1F, 0x07, 0x80, 0xF3, 0xF9, 0xFE, 0x0F,
  0x7F, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xF1, 0xF8, 0x7E,
  0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF0, 0xFC, 0x3E, 0x3F, 0x0F, 0xC3, 0xE3,
  0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x7E, 0x3E, 0x1F,
  0x87, 0xC7, 0xE1, 0xF8, 0x7C, 0x7E, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x0F, 0xCF, 0xC3, 0xF0, 0xF8, 0x0F, 0x1F, 0x03, 0xCF, 0xE0,
  0xF7, 0xFC, 0x3F, 0xFF, 0x1F, 0xEF, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C,
  0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFB, 0xF1, 0xF0,
  0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xFE, 0x0F, 0xBF, 0x07, 0xDF,
  0x87, 0xEF, 0xC3, 0xF3, 0xE3, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0xF7, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFE, 0xFE, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x07,
  0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x7F, 0x3F,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xDF, 0x81, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xC1, 0xFD, 0xF0, 0xFF, 0x78,
  0x7F, 0xFE, 0x3F, 0xBF, 0x8F, 0xC7, 0xE7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xDF, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x1E, 0x1E, 0x7C, 0x3D, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFC, 0x87, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xF0, 0xC7,
  0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x0F, 0x98, 0x1F, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x43, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xEF, 0xC3, 0xF7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x7E, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F,
  0xCF, 0x87, 0xE7, 0xC7, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0x7C, 0x3F,
  0x3E, 0x00, 0xFC, 0x0F, 0xDF, 0x07, 0xE7, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0x3E,
  0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x3F,
  0x07, 0xFE, 0x1F, 0x87, 0xDF, 0x1F, 0xC3, 0xEF, 0x8F, 0xE3, 0xF7, 0xC7,
  0x71, 0xF3, 0xE7, 0xF9, 0xF9, 0xF3, 0xFC, 0xF8, 0xFB, 0xDE, 0x7C, 0x7D,
  0xEF, 0x7C, 0x3E, 0xE7, 0xBE, 0x1F, 0xF3, 0xDE, 0x0F, 0xF9, 0xFF, 0x07,
  0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x3E, 0x1F, 0xC1, 0xF8, 0xFC,
  0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xEF, 0x80, 0x7E, 0x7C, 0x07, 0xE3, 0xF0, 0x7F, 0x1F,
  0x87, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1,
  0xF0, 0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x81,
  0xFE, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x03,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x02, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 23, 9, 0, -23 },
  { 33, 13, 8, 15, 3, -23 },
  { 46, 21, 23, 21, 0, -23 },
  { 107, 17, 26, 18, 1, -24 },
  { 163, 26, 23, 28, 2, -23 },
  { 238, 22, 23, 23, 1, -23 },
  { 302, 6, 8, 8, 3, -23 },
  { 308, 13, 28, 11, 1, -23 },
  { 354, 12, 28, 11, -2, -23 },
  { 396, 15, 16, 17, 3, -25 },
  { 426, 15, 15, 19, 2, -19 },
  { 455, 9, 8, 9, -2, -4 },
  { 464, 10, 5, 10, 0, -11 },
  { 471, 6, 5, 9, 0, -5 },
  { 475, 17, 23, 14, -1, -23 },
  { 524, 17, 23, 18, 1, -23 },
  { 573, 13, 23, 18, 3, -23 },
  { 611, 18, 23, 18, -1, -23 },
  { 663, 17, 23, 18, 0, -23 },
  { 712, 18, 23, 18, 0, -23 },
  { 764, 18, 23, 18, 0, -23 },
  { 816, 17, 23, 18, 1, -23 },
  { 865, 18, 23, 18, 1, -23 },
  { 917, 17, 23, 18, 1, -23 },
  { 966, 16, 23, 18, 1, -23 },
  { 1012, 9, 18, 9, 0, -18 },
  { 1033, 11, 22, 9, -2, -18 },
  { 1064, 15, 17, 19, 2, -20 },
  { 1096, 15, 10, 19, 2, -16 },
  { 1115, 15, 17, 19, 2, -20 },
  { 1147, 14, 23, 15, 2, -23 },
  { 1188, 26, 26, 28, 1, -23 },
  { 1273, 21, 23, 21, -2, -23 },
  { 1334, 19, 23, 20, 1, -23 },
  { 1389, 19, 23, 20, 2, -23 },
  { 1444, 20, 23, 22, 1, -23 },
  { 1502, 18, 23, 18, 1, -23 },
  { 1554, 18, 23, 18, 1, -23 },
  { 1606, 20, 23, 22, 2, -23 },
  { 1664, 22, 23, 23, 1, -23 },
  { 1728, 16, 23, 13, -1, -23 },
  { 1774, 16, 30, 11, -5, -23 },
  { 1834, 22, 23, 20, 1, -23 },
  { 1898, 14, 23, 17, 1, -23 },
  { 1939, 28, 23, 29, 1, -23 },
  { 2020, 24, 23, 25, 1, -23 },
  { 2089, 21, 23, 23, 2, -23 },
  { 2150, 19, 23, 20, 1, -23 },
  { 2205, 21, 28, 23, 2, -23 },
  { 2279, 18, 23, 20, 1, -23 },
  { 2331, 17, 23, 17, 1, -23 },
  { 2380, 16, 23, 17, 3, -23 },
  { 2426, 21, 23, 22, 2, -23 },
  { 2487, 19, 23, 19, 3, -23 },
  { 2542, 29, 23, 29, 3, -23 },
  { 2626, 25, 23, 20, -2, -23 },
  { 2698, 18, 23, 19, 3, -23 },
  { 2750, 20, 23, 17, -1, -23 },
  { 2808, 14, 28, 11, -1, -23 },
  { 2857, 9, 23, 14, 3, -23 },
  { 2883, 14, 28, 11, -2, -23 },
  { 2932, 17, 15, 17, 0, -23 },
  { 2964, 14, 3, 14, -3, 2 },
  { 2970, 7, 6, 11, 5, -25 },
  { 2976, 18, 18, 19, 1, -18 },
  { 3017, 18, 24, 19, 0, -24 },
  { 3071, 15, 18, 16, 1, -18 },
  { 3105, 19, 24, 19, 1, -24 },
  { 3162, 16, 18, 18, 1, -18 },
  { 3198, 19, 32, 13, -3, -24 },
  { 3274, 18, 26, 19, 1, -18 },
  { 3333, 18, 24, 20, 0, -24 },
  { 3387, 11, 25, 10, 0, -25 },
  { 3422, 15, 33, 10, -4, -25 },
  { 3484, 21, 24, 19, 0, -24 },
  { 3547, 11, 24, 10, 0, -24 },
  { 3580, 28, 18, 29, 0, -18 },
  { 3643, 18, 18, 20, 0, -18 },
  { 3684, 17, 18, 19, 1, -18 },
  { 3723, 19, 26, 19, -1, -18 },
  { 3785, 18, 26, 19, 1, -18 },
  { 3844, 15, 18, 14, 0, -18 },
  { 3878, 15, 18, 16, 0, -18 },
  { 3912, 13, 21, 14, 1, -21 },
  { 3947, 17, 18, 20, 2, -18 },
  { 3986, 18, 18, 17, 1, -18 },
  { 4027, 25, 18, 26, 2, -18 },
  { 4084, 21, 18, 18, -2, -18 },
  { 4132, 21, 26, 17, -2, -18 },
  { 4201, 17, 18, 15, -1, -18 },
  { 4240, 14, 28, 11, 0, -23 },
  { 4289, 4, 31, 18, 7, -24 },
  { 4305, 14, 28, 11, -2, -23 },
  { 4354, 15, 6, 19, 2, -14 },
};

const GFXfont NotoSans_ExtraBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRABOLDITALIC32PT7B_H_
