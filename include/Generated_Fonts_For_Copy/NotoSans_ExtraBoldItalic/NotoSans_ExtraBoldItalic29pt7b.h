#ifndef _NOTOSANS_EXTRABOLDITALIC29PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x79, 0xEF, 0x3F, 0xCF, 0x79, 0xEF, 0x3D, 0xE7,
  0xB8, 0xE7, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x9E, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x07, 0x9E, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE0, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x07, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xE7, 0xFF, 0x8F, 0xB1, 0x1E, 0x60, 0x3F, 0xC0, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xDF, 0x01, 0xBE, 0xC3,
  0x7D, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x83, 0xF8, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1F, 0x00, 0x78, 0x7F, 0x01, 0xE1, 0xFF, 0x07, 0x83, 0xDE,
  0x0E, 0x0F, 0x3C, 0x3C, 0x1E, 0x78, 0xF0, 0x3C, 0xF3, 0xC0, 0x71, 0xE7,
  0x00, 0xE7, 0x9E, 0x71, 0xEF, 0x7B, 0xFB, 0xFD, 0xEF, 0xFF, 0xFB, 0x9E,
  0xF3, 0xCF, 0x79, 0xE0, 0x3C, 0xF3, 0xC0, 0x71, 0xE7, 0x81, 0xE3, 0x8F,
  0x07, 0x87, 0x1C, 0x1E, 0x0E, 0x78, 0x38, 0x1F, 0xF0, 0xF0, 0x3F, 0xC3,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0x1E, 0x01, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF7, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0x01, 0x1F, 0xC1, 0xE7, 0xFE, 0x3E, 0xFD, 0xF3, 0xCF,
  0x9F, 0xFC, 0xF8, 0xFF, 0x8F, 0x87, 0xF8, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xC0, 0x7B, 0xFD, 0xEF, 0x7B,
  0x9C, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x07, 0x04, 0x3C, 0x1C, 0xF0, 0x7F, 0x83, 0xFF, 0xF3,
  0xFF, 0xC1, 0xFF, 0x1F, 0xDC, 0xFF, 0x07, 0xDE, 0x0E, 0x78, 0x18, 0xF0,
  0x03, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x3E, 0x79, 0xF3, 0xCF, 0x9E, 0x38, 0x00,
  0x7F, 0xBF, 0xDF, 0xDF, 0xE0, 0x31, 0xEF, 0xFE, 0xF8, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xF3,
  0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x81, 0xFC,
  0x1F, 0xE3, 0xFF, 0x7F, 0xF9, 0xF7, 0x86, 0x7C, 0x23, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE0, 0x71, 0xF8, 0x30, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0C,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x07,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x80,
  0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xBE, 0x0F, 0xBC, 0x0F, 0x7C, 0x1E, 0x7C, 0x3C, 0x7C, 0x78, 0x78, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x80,
  0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE, 0x7C, 0xFC, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xE3, 0xE7, 0xC3, 0xCF,
  0x8F, 0x8F, 0xBE, 0x1F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xC7, 0xEF,
  0x9F, 0x0F, 0xBE, 0x1F, 0x78, 0x3E, 0xF8, 0x7D, 0xF9, 0xF3, 0xFF, 0xE3,
  0xFF, 0x81, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7,
  0xE7, 0xCF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x7E, 0xF8, 0xFD, 0xFF,
  0xF3, 0xFF, 0xE3, 0xFF, 0xC3, 0xEF, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF1,
  0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xFC, 0xF8, 0xF8,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x0F, 0xE0, 0x1E,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0x1F, 0xFC, 0xFF, 0xE3, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xE0, 0xFC, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x3F, 0xCE,
  0x38, 0x7F, 0xCF, 0x78, 0xFF, 0xCF, 0x71, 0xE3, 0x8F, 0x73, 0xC3, 0x8F,
  0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8E, 0xF3, 0x87, 0x1E, 0xF3, 0xCF, 0x1C,
  0xF3, 0xFF, 0xFC, 0xF1, 0xFB, 0xF8, 0x78, 0xF3, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x80, 0x3F, 0x8F, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3,
  0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0xBE, 0x01, 0xFF, 0xC0, 0x3E, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x3F, 0xFF,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x78, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF8,
  0x73, 0xF0, 0x09, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x08, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x3F, 0x87, 0xC3,
  0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C,
  0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x83, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x1F, 0xEF, 0x8F, 0xFB,
  0xE3, 0xFC, 0xF8, 0xFF, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xFC,
  0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x3E, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFE, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0xF8,
  0x7E, 0x0F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F,
  0x7E, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0,
  0x78, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3,
  0xDE, 0x1E, 0xF1, 0xEF, 0x0F, 0x79, 0xEF, 0x87, 0xBC, 0xF7, 0xC7, 0xDE,
  0xF3, 0xC3, 0xEF, 0x79, 0xE1, 0xE7, 0xB8, 0xF0, 0xF3, 0xFC, 0xF8, 0x79,
  0xFC, 0x7C, 0x7C, 0xFE, 0x3C, 0x3E, 0x7E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xE0, 0xFC, 0x07, 0x87,
  0xF8, 0x3E, 0x1F, 0xE0, 0xF8, 0x7F, 0x83, 0xC1, 0xFF, 0x0F, 0x0F, 0xFC,
  0x3C, 0x3E, 0xF1, 0xF0, 0xF3, 0xE7, 0xC3, 0xCF, 0x9E, 0x0F, 0x1E, 0x78,
  0x7C, 0x79, 0xE1, 0xF1, 0xFF, 0x87, 0x83, 0xFE, 0x1E, 0x0F, 0xF0, 0x78,
  0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x81, 0xFC, 0x3C, 0x07, 0xF0, 0xF0, 0x1F,
  0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x8F,
  0xDF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0,
  0x7E, 0xFC, 0x3F, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x1F, 0x8F, 0xFF,
  0xC7, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x8F, 0xDF, 0x81, 0xF7,
  0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xFC, 0x3F,
  0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xF1,
  0xC7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x81, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x83, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7,
  0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x7C, 0x78, 0x1F,
  0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x1F, 0x3C,
  0x1F, 0x83, 0xE7, 0x83, 0xF0, 0xF8, 0xF0, 0xFE, 0x1F, 0x1E, 0x1F, 0xC3,
  0xC3, 0xC7, 0xF8, 0xF8, 0x78, 0xFF, 0x1F, 0x0F, 0x1D, 0xE7, 0xC1, 0xE7,
  0xBC, 0xF8, 0x3C, 0xF7, 0x9E, 0x07, 0xBC, 0xF7, 0xC0, 0xF7, 0x9E, 0xF0,
  0x1F, 0xE3, 0xDE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x87, 0xC3, 0xC7, 0xE1,
  0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x00, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xEE, 0x07, 0x9C,
  0x0E, 0x3C, 0x3C, 0x38, 0xF0, 0x71, 0xC0, 0xF7, 0x81, 0xFE, 0x01, 0xC0,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0xF0, 0xF0, 0x07, 0xCF, 0x0F,
  0xEF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF8, 0x7F, 0x78, 0x3E, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C,
  0x1F, 0x3C, 0x3E, 0x7E, 0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xF3,
  0xF0, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x08, 0x7F, 0xE1,
  0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFF, 0x1F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xF3, 0xC0, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF1, 0xF9, 0xF7,
  0xE3, 0xEF, 0x87, 0xDF, 0x3F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x03, 0xE0,
  0x07, 0xC0, 0x47, 0xC7, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x00,
  0x03, 0xE7, 0x87, 0xFB, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3E, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x30, 0x3E, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x3E, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0xF8, 0x7C, 0x07, 0x81, 0xF0,
  0xFC, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0xF8, 0x7C, 0x1F,
  0x1F, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E,
  0x00, 0x0F, 0x3E, 0x3F, 0x0F, 0x7F, 0x3F, 0x87, 0xBF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0xF8, 0x7C, 0x3E, 0x7C,
  0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x9F, 0x0F, 0x0F, 0x8F, 0x0F, 0x87, 0xCF,
  0x87, 0xC3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF9,
  0xF0, 0xF8, 0x7C, 0x0F, 0x7E, 0x1E, 0xFF, 0x1E, 0xFF, 0x1F, 0xFF, 0x1F,
  0x9F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0xF8, 0x7C, 0x07,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF7, 0xE3, 0xEF, 0x87, 0xDF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3, 0xE7, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0xBE, 0x07, 0xBF, 0x83, 0xFF, 0xE1,
  0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x07, 0xC7, 0x87, 0xC7, 0xE3, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF7,
  0xF0, 0x79, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFE,
  0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0xF8, 0x3C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3E, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x3C, 0x7F, 0xE1, 0xEF, 0x87, 0xFE, 0x1F,
  0xC8, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xF0, 0x7F, 0xF3,
  0xFF, 0x8F, 0x8C, 0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xC0, 0x1F, 0x20, 0x7C, 0xF3, 0xF3, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xE3, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xF8,
  0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x7C, 0x78, 0x7C, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3E,
  0x78, 0xF8, 0x1F, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x7C, 0x78, 0x7C, 0x78,
  0xF8, 0x7C, 0xF8, 0x7D, 0xF0, 0x7D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF0, 0xFC, 0x3F,
  0xE1, 0xF8, 0xFB, 0xC3, 0xF1, 0xF7, 0x8F, 0xE3, 0xCF, 0x1F, 0xCF, 0x9E,
  0x7F, 0x9E, 0x3C, 0xEF, 0x7C, 0x79, 0xDE, 0xF0, 0xF7, 0xBB, 0xE1, 0xEE,
  0x77, 0x83, 0xFC, 0xEF, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x7C, 0x7C,
  0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFB,
  0xC0, 0x1F, 0xBE, 0x03, 0xF3, 0xE0, 0x3E, 0x1F, 0x0F, 0xC1, 0xF0, 0x1F,
  0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x87, 0xC0, 0xF8, 0xF8, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8,
  0x00, 0x70, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x7C, 0x07, 0xC0, 0xFE,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0C, 0x00, 0x1C, 0x02, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 21, 9, 0, -21 },
  { 28, 11, 8, 13, 3, -21 },
  { 39, 19, 21, 19, 0, -21 },
  { 89, 15, 24, 16, 1, -22 },
  { 134, 23, 21, 26, 2, -21 },
  { 195, 20, 21, 21, 1, -21 },
  { 248, 5, 8, 7, 3, -21 },
  { 253, 11, 26, 10, 1, -21 },
  { 289, 11, 26, 10, -2, -21 },
  { 325, 14, 14, 16, 2, -22 },
  { 350, 15, 14, 17, 1, -17 },
  { 377, 7, 7, 9, -1, -3 },
  { 384, 9, 4, 9, 0, -10 },
  { 389, 6, 5, 9, 0, -5 },
  { 393, 16, 21, 13, -1, -21 },
  { 435, 15, 21, 16, 1, -21 },
  { 475, 13, 21, 16, 2, -21 },
  { 510, 17, 21, 16, -1, -21 },
  { 555, 16, 21, 16, 0, -21 },
  { 597, 16, 21, 16, 0, -21 },
  { 639, 16, 21, 16, 0, -21 },
  { 681, 16, 21, 16, 1, -21 },
  { 723, 17, 21, 16, 1, -21 },
  { 768, 15, 21, 16, 1, -21 },
  { 808, 15, 21, 16, 1, -21 },
  { 848, 8, 16, 9, 0, -16 },
  { 864, 10, 20, 9, -2, -16 },
  { 889, 15, 15, 17, 1, -18 },
  { 918, 15, 9, 17, 1, -15 },
  { 935, 15, 15, 17, 1, -18 },
  { 964, 13, 21, 14, 2, -21 },
  { 999, 24, 24, 25, 1, -21 },
  { 1071, 19, 21, 19, -2, -21 },
  { 1121, 17, 21, 18, 1, -21 },
  { 1166, 17, 21, 18, 2, -21 },
  { 1211, 18, 21, 20, 1, -21 },
  { 1259, 16, 21, 16, 1, -21 },
  { 1301, 16, 21, 16, 1, -21 },
  { 1343, 18, 21, 20, 2, -21 },
  { 1391, 20, 21, 21, 1, -21 },
  { 1444, 14, 21, 12, -1, -21 },
  { 1481, 15, 27, 10, -5, -21 },
  { 1532, 20, 21, 19, 1, -21 },
  { 1585, 12, 21, 15, 1, -21 },
  { 1617, 25, 21, 26, 1, -21 },
  { 1683, 22, 21, 22, 1, -21 },
  { 1741, 18, 21, 21, 2, -21 },
  { 1789, 17, 21, 18, 1, -21 },
  { 1834, 18, 26, 21, 2, -21 },
  { 1893, 16, 21, 18, 1, -21 },
  { 1935, 15, 21, 16, 1, -21 },
  { 1975, 16, 21, 16, 2, -21 },
  { 2017, 18, 21, 20, 2, -21 },
  { 2065, 18, 21, 17, 2, -21 },
  { 2113, 27, 21, 26, 2, -21 },
  { 2184, 23, 21, 18, -2, -21 },
  { 2245, 17, 21, 17, 2, -21 },
  { 2290, 18, 21, 16, -1, -21 },
  { 2338, 13, 26, 10, -1, -21 },
  { 2381, 8, 21, 13, 3, -21 },
  { 2402, 13, 26, 10, -2, -21 },
  { 2445, 15, 14, 16, 0, -21 },
  { 2472, 13, 3, 12, -3, 2 },
  { 2477, 7, 4, 10, 4, -22 },
  { 2481, 16, 16, 17, 1, -16 },
  { 2513, 16, 22, 17, 0, -22 },
  { 2557, 14, 16, 14, 1, -16 },
  { 2585, 17, 22, 17, 1, -22 },
  { 2632, 15, 16, 16, 1, -16 },
  { 2662, 17, 29, 11, -3, -22 },
  { 2724, 17, 23, 17, 0, -16 },
  { 2773, 16, 22, 18, 0, -22 },
  { 2817, 10, 22, 9, 0, -22 },
  { 2845, 14, 29, 9, -4, -22 },
  { 2896, 19, 22, 17, 0, -22 },
  { 2949, 10, 22, 9, 0, -22 },
  { 2977, 25, 16, 27, 0, -16 },
  { 3027, 16, 16, 18, 0, -16 },
  { 3059, 15, 16, 17, 1, -16 },
  { 3089, 17, 23, 17, -1, -16 },
  { 3138, 16, 23, 17, 1, -16 },
  { 3184, 14, 16, 12, 0, -16 },
  { 3212, 14, 16, 14, 0, -16 },
  { 3240, 12, 19, 13, 1, -19 },
  { 3269, 16, 16, 18, 1, -16 },
  { 3301, 16, 16, 15, 1, -16 },
  { 3333, 23, 16, 23, 2, -16 },
  { 3379, 20, 16, 16, -2, -16 },
  { 3419, 19, 23, 15, -2, -16 },
  { 3474, 15, 16, 14, -1, -16 },
  { 3504, 12, 26, 10, 0, -21 },
  { 3543, 4, 29, 16, 6, -22 },
  { 3558, 12, 26, 10, -2, -21 },
  { 3597, 15, 5, 17, 1, -13 },
};

const GFXfont NotoSans_ExtraBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRABOLDITALIC29PT7B_H_
