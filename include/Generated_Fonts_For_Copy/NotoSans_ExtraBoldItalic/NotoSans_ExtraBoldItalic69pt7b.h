#ifndef _NOTOSANS_EXTRABOLDITALIC69PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF,
  0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3, 0xFF, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFE, 0x7C, 0x0F, 0x00,
  0xFF, 0xE3, 0xE0, 0x10, 0x07, 0xFF, 0x1F, 0x00, 0x00, 0x3F, 0xF1, 0xF8,
  0x00, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0x0F, 0xFE, 0x7C, 0x00, 0x00, 0x7F,
  0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0x9F, 0xFC, 0x00, 0x00, 0x7C, 0x7F, 0xE0, 0x00, 0x03, 0xE3, 0xFF,
  0x00, 0x00, 0x3F, 0x1F, 0xF8, 0x40, 0x01, 0xF0, 0xFF, 0xC3, 0xC0, 0x0F,
  0x8F, 0xFE, 0x1F, 0x80, 0x7C, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC7, 0xFC, 0x3F, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF8,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xBF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x60, 0x07, 0xF8,
  0x00, 0x3C, 0x03, 0xFC, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x0F, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0xE0, 0x18, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFD, 0xFE, 0x00, 0x1F,
  0xFC, 0x7F, 0x80, 0x1F, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0xFE, 0x0F, 0xF8, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x07, 0x01, 0xFF, 0x00,
  0x01, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x8F, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x7F, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE,
  0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x07, 0xFC, 0x7F, 0xF8, 0x3F, 0xC3, 0xFF,
  0x80, 0xF8, 0x1F, 0xFC, 0x03, 0x80, 0xFF, 0xE0, 0x10, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xCF, 0xFF,
  0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x06, 0x00, 0x1F, 0xFF, 0x00, 0x10,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x88, 0x00, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x01, 0xFF, 0xF0, 0xFE,
  0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xCF, 0xFF, 0xF8, 0x00,
  0x20, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x82, 0x00,
  0x00, 0x3F, 0xFE, 0x0E, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x0F, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0xF0, 0x03, 0xFF, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF,
  0x7F, 0xF8, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xDF, 0xFE, 0x01,
  0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0xFF, 0xE0,
  0x7F, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFD, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFF, 0xF1, 0xF8, 0x03, 0xFF,
  0xC3, 0x80, 0x0F, 0xFF, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x87,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x80, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0xFF,
  0xFC, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xFF,
  0xE3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x8F,
  0xFF, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x08, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x80,
  0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFF, 0x00, 0x3F,
  0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3,
  0xFC, 0x07, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xF8,
  0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xF0, 0xFF,
  0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0xC3, 0xFC, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07,
  0xFB, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xDF, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xE0, 0x07,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x3F,
  0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x9F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x40, 0x00, 0x0F, 0xFF, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x1F, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE4,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00,
  0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xBF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xF9,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x8F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC7, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFE, 0x00, 0x0F,
  0xFC, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x7F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F,
  0xCF, 0xF8, 0x0F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xF7,
  0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xBF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x7F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF1,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFF, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF,
  0xE0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xFF,
  0x00, 0x7F, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0xC0, 0x07, 0xFF,
  0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x81, 0x80, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xCF, 0xFF, 0xFC, 0x01, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x78, 0x1F, 0xFF, 0x00, 0x08,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0xFF, 0xFC, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xF8, 0x01, 0xFF,
  0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xE7,
  0xFC, 0x00, 0x0F, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x1F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x81,
  0xFF, 0xF0, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x83, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFE,
  0x00, 0x7F, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0x00, 0x07,
  0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0x8F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x70, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xFF, 0xE0,
  0x07, 0xFF, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xF9,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xC7, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0xF8, 0x01, 0xFF, 0x9F,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFD, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF,
  0xF3, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00,
  0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0xCF, 0xFF,
  0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xBC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0xF0,
  0x00, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xF9,
  0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0xE0, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x7F,
  0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x80, 0x7F, 0xEF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF9, 0xC0, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xF0, 0x3F, 0xFC, 0x00, 0xC0,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x88, 0x00, 0x0F, 0xFF, 0x1C, 0x00, 0x1F,
  0xFE, 0x3F, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x08, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x1F,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF,
  0x3F, 0xE0, 0x1F, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xF8, 0x01,
  0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xDF,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xF7,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFF, 0x80,
  0x7F, 0xE3, 0xFE, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F,
  0xFC, 0x01, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xE3,
  0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0x87, 0xF9, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x0F, 0xF3, 0xFF, 0x00, 0x1F, 0xFB, 0xFC, 0x1F, 0xEF, 0xFE, 0x00,
  0x3F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xBF,
  0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x81,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x43, 0xFF, 0x80, 0x00, 0x13, 0xFF, 0xFC, 0x00, 0x0D, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFB, 0x00, 0x00, 0xFF, 0xF8, 0x80,
  0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 22, 50, 20, 1, -49 },
  { 139, 27, 18, 31, 6, -49 },
  { 200, 44, 49, 45, 1, -49 },
  { 470, 37, 56, 39, 2, -52 },
  { 729, 55, 51, 61, 4, -50 },
  { 1080, 48, 51, 50, 1, -50 },
  { 1386, 13, 18, 17, 6, -49 },
  { 1416, 27, 61, 25, 2, -50 },
  { 1622, 27, 61, 25, -5, -50 },
  { 1828, 33, 34, 38, 6, -53 },
  { 1969, 34, 33, 40, 3, -41 },
  { 2110, 17, 17, 20, -3, -8 },
  { 2147, 20, 9, 23, 1, -23 },
  { 2170, 13, 12, 20, 0, -11 },
  { 2190, 38, 51, 31, -3, -50 },
  { 2433, 36, 51, 39, 2, -50 },
  { 2663, 29, 49, 39, 6, -49 },
  { 2841, 39, 50, 39, -2, -50 },
  { 3085, 38, 51, 39, 0, -50 },
  { 3328, 39, 49, 39, -1, -49 },
  { 3567, 38, 50, 39, 1, -49 },
  { 3805, 37, 51, 39, 3, -50 },
  { 4041, 40, 49, 39, 2, -49 },
  { 4286, 36, 51, 39, 2, -50 },
  { 4516, 34, 51, 39, 3, -50 },
  { 4733, 20, 40, 20, 0, -39 },
  { 4833, 24, 48, 20, -4, -39 },
  { 4977, 34, 38, 40, 3, -44 },
  { 5139, 34, 22, 40, 3, -35 },
  { 5233, 34, 38, 40, 3, -44 },
  { 5395, 30, 51, 33, 5, -50 },
  { 5587, 56, 56, 60, 3, -50 },
  { 5979, 45, 49, 45, -4, -49 },
  { 6255, 41, 49, 43, 1, -49 },
  { 6507, 41, 51, 43, 4, -50 },
  { 6769, 44, 49, 47, 1, -49 },
  { 7039, 39, 49, 38, 1, -49 },
  { 7278, 39, 49, 38, 1, -49 },
  { 7517, 43, 51, 48, 4, -50 },
  { 7792, 48, 49, 49, 1, -49 },
  { 8086, 34, 49, 28, -2, -49 },
  { 8295, 36, 64, 24, -11, -49 },
  { 8583, 49, 49, 44, 1, -49 },
  { 8884, 31, 49, 36, 1, -49 },
  { 9074, 61, 49, 62, 1, -49 },
  { 9448, 53, 49, 53, 1, -49 },
  { 9773, 45, 51, 51, 4, -50 },
  { 10060, 41, 49, 43, 1, -49 },
  { 10312, 45, 62, 51, 4, -50 },
  { 10661, 40, 49, 44, 1, -49 },
  { 10906, 37, 51, 37, 1, -50 },
  { 11142, 37, 49, 37, 5, -49 },
  { 11369, 45, 50, 48, 4, -49 },
  { 11651, 41, 49, 42, 6, -49 },
  { 11903, 63, 49, 63, 6, -49 },
  { 12289, 53, 49, 44, -4, -49 },
  { 12614, 40, 49, 40, 6, -49 },
  { 12859, 44, 49, 37, -3, -49 },
  { 13129, 30, 61, 24, -2, -50 },
  { 13358, 18, 51, 31, 7, -50 },
  { 13473, 30, 61, 24, -5, -50 },
  { 13702, 35, 32, 38, 1, -49 },
  { 13842, 31, 7, 29, -6, 5 },
  { 13870, 15, 11, 23, 10, -53 },
  { 13891, 37, 40, 41, 3, -39 },
  { 14076, 38, 53, 41, 1, -52 },
  { 14328, 32, 40, 34, 3, -39 },
  { 14488, 40, 53, 41, 3, -52 },
  { 14753, 35, 40, 39, 3, -39 },
  { 14928, 41, 70, 27, -7, -53 },
  { 15287, 40, 56, 41, 1, -39 },
  { 15567, 38, 52, 42, 1, -52 },
  { 15814, 22, 53, 21, 1, -53 },
  { 15960, 32, 70, 21, -9, -53 },
  { 16240, 43, 52, 41, 1, -52 },
  { 16520, 23, 52, 21, 1, -52 },
  { 16670, 59, 39, 63, 1, -39 },
  { 16958, 38, 39, 42, 1, -39 },
  { 17144, 35, 40, 41, 3, -39 },
  { 17319, 41, 56, 41, -2, -39 },
  { 17606, 37, 56, 41, 3, -39 },
  { 17865, 31, 39, 30, 1, -39 },
  { 18017, 31, 40, 34, 1, -39 },
  { 18172, 28, 47, 30, 3, -46 },
  { 18337, 37, 39, 42, 4, -38 },
  { 18518, 37, 38, 36, 3, -38 },
  { 18694, 55, 38, 55, 4, -38 },
  { 18956, 46, 38, 38, -4, -38 },
  { 19175, 45, 55, 37, -5, -38 },
  { 19485, 35, 38, 33, -1, -38 },
  { 19652, 29, 60, 25, 0, -49 },
  { 19870, 8, 68, 39, 15, -52 },
  { 19938, 29, 60, 25, -4, -49 },
  { 20156, 34, 13, 40, 3, -31 },
};

const GFXfont NotoSans_ExtraBoldItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRABOLDITALIC69PT7B_H_
