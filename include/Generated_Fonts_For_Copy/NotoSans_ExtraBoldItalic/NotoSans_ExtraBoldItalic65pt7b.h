#ifndef _NOTOSANS_EXTRABOLDITALIC65PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07,
  0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xCF, 0x87, 0xC0, 0x7F, 0xE3, 0xE0, 0x20, 0x3F, 0xF9, 0xF0,
  0x00, 0x0F, 0xFC, 0x7C, 0x00, 0x03, 0xFF, 0x9F, 0x00, 0x00, 0xFF, 0xE7,
  0xC0, 0x00, 0x1F, 0xFD, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0xF8, 0x00, 0x03, 0xE7,
  0xFE, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x00, 0x7C, 0x3F, 0xE2, 0x00, 0x1F,
  0x1F, 0xF8, 0xF0, 0x07, 0xC7, 0xFE, 0x3F, 0x81, 0xF3, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x20, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F,
  0xE0, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xFF, 0x8F, 0xF9, 0xFF, 0x1F, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0xE1, 0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x7F, 0xFB,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF9, 0xFE, 0x03, 0xFF,
  0xF8, 0x02, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFD, 0xFC, 0x00, 0x1F, 0xFD,
  0xFE, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x01, 0xC0, 0xFF, 0x80, 0x00, 0x80,
  0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x3F,
  0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0x83, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3, 0xFF,
  0x81, 0xFC, 0x3F, 0xF8, 0x0F, 0x03, 0xFF, 0x00, 0xC0, 0x7F, 0xF0, 0x08,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x03,
  0xFF, 0x80, 0x04, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0x00,
  0xE0, 0x03, 0xFF, 0x80, 0x08, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xCC, 0x00, 0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x3F,
  0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x03, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x18,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x08, 0x00, 0x01, 0xFF, 0xE0,
  0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x08, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xFE, 0x01, 0xFF,
  0x9F, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0,
  0x03, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFD, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFF,
  0x01, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x07,
  0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x03,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0x7F, 0xF8, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF7, 0xFE, 0x1F, 0xFF, 0xF7, 0xFE, 0x0F, 0xFF, 0xEF,
  0xFE, 0x07, 0xFF, 0x8F, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0x1E, 0x00, 0x7F, 0xF1, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xFE, 0x01, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xF1, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFC, 0x7F, 0x81, 0xFF, 0xC3, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xF8,
  0x1F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFD, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0xFF,
  0x07, 0xFC, 0x03, 0xF8, 0x07, 0xF7, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xBF, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFD, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xEF, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x7F, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF3, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x9F, 0xC1, 0xFE,
  0x03, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC7, 0xF8,
  0x3F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x3F, 0xC1, 0xFF, 0xF9, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x08,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xE0,
  0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F,
  0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x00, 0x10, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x20, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xC0, 0x1F, 0xE7, 0xFE, 0x00, 0xFF,
  0xDF, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFF,
  0x00, 0x3F, 0xE7, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x07,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF9, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0x03, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0x83, 0xFE, 0x3F, 0xF0,
  0x03, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF1, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFC, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFE, 0x7F, 0x83, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xBF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0x03,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF7,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFB, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xCF,
  0xFE, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF,
  0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x38, 0x01,
  0xFF, 0xC0, 0x01, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x40, 0x00, 0x1F, 0xFC,
  0x0F, 0x00, 0x03, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xDF, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF9, 0xFE,
  0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x1F, 0xF1, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE,
  0x1F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xE7, 0xFC, 0x1F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x81, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x1F, 0xEF, 0xFC,
  0x00, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xCF, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0x87, 0xFC,
  0x03, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF7,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xDF, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xF3, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xC0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xF0, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF,
  0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0xF8, 0x07, 0xFC,
  0x3F, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0x7F, 0xFC,
  0x01, 0x83, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x02, 0x0F, 0xFF, 0x00, 0x30, 0x3F, 0xFF, 0x07, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC3,
  0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFD,
  0xFF, 0x00, 0x03, 0xFF, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x3F, 0xFC, 0x03,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x60, 0xFF, 0xF0, 0x01, 0xE0, 0x7F, 0xFE, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x10, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC3, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF7, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xE7, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x80, 0x00, 0x7F, 0xF0, 0x06, 0x00, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x9F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x87, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x1F, 0xF7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x01,
  0xFF, 0x1F, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x80,
  0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF,
  0x8F, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xF0, 0x01, 0xFF,
  0xCF, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xF8,
  0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF0, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xF7, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x03, 0xFE, 0x3F,
  0xF8, 0x00, 0x0E, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x03,
  0xFE, 0x7F, 0xF0, 0x1F, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x08, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFC, 0x0F, 0xFE, 0x01, 0xE0, 0xFF, 0xF0, 0x02, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x20, 0x00, 0x7F,
  0xF1, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x87, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x05, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0xFF,
  0x80, 0x3F, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x0F,
  0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xC0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xEF, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xCF, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x8F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFE, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFD, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xDF, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFD,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7,
  0xF9, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0x9F, 0xE7, 0xFF, 0x00, 0x7F,
  0xCF, 0xF1, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x1F, 0xE7, 0xFE, 0x00,
  0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFE, 0x1F, 0xEF, 0xFC,
  0x00, 0x7F, 0xDF, 0xC1, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC1, 0xFD, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x1F,
  0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xF1,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x08, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x02, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x1F, 0xFE, 0x00,
  0x01, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0x7F,
  0xF8, 0x80, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 20, 47, 19, 1, -46 },
  { 119, 26, 16, 29, 6, -46 },
  { 171, 42, 46, 42, 1, -46 },
  { 413, 34, 53, 37, 2, -49 },
  { 639, 52, 48, 58, 4, -47 },
  { 951, 45, 48, 47, 1, -47 },
  { 1221, 12, 16, 16, 6, -46 },
  { 1245, 26, 57, 23, 2, -47 },
  { 1431, 25, 57, 23, -4, -47 },
  { 1610, 32, 32, 35, 5, -50 },
  { 1738, 32, 32, 38, 3, -39 },
  { 1866, 16, 16, 19, -3, -8 },
  { 1898, 19, 9, 21, 1, -22 },
  { 1920, 13, 12, 19, 0, -11 },
  { 1940, 36, 48, 29, -3, -47 },
  { 2156, 34, 48, 37, 2, -47 },
  { 2360, 28, 46, 37, 5, -46 },
  { 2521, 37, 47, 37, -2, -47 },
  { 2739, 35, 48, 37, 0, -47 },
  { 2949, 37, 46, 37, -1, -46 },
  { 3162, 36, 47, 37, 1, -46 },
  { 3374, 34, 48, 37, 3, -47 },
  { 3578, 38, 46, 37, 2, -46 },
  { 3797, 34, 48, 37, 2, -47 },
  { 4001, 32, 48, 37, 3, -47 },
  { 4193, 19, 37, 19, 0, -36 },
  { 4281, 23, 44, 19, -4, -36 },
  { 4408, 32, 35, 38, 3, -41 },
  { 4548, 32, 21, 38, 3, -33 },
  { 4632, 32, 35, 38, 3, -41 },
  { 4772, 28, 48, 31, 5, -47 },
  { 4940, 53, 53, 57, 3, -47 },
  { 5292, 42, 46, 42, -4, -46 },
  { 5534, 39, 46, 41, 1, -46 },
  { 5759, 39, 48, 40, 4, -47 },
  { 5993, 41, 46, 44, 1, -46 },
  { 6229, 37, 46, 36, 1, -46 },
  { 6442, 37, 46, 36, 1, -46 },
  { 6655, 40, 48, 45, 4, -47 },
  { 6895, 45, 46, 46, 1, -46 },
  { 7154, 32, 46, 26, -2, -46 },
  { 7338, 33, 60, 23, -10, -46 },
  { 7586, 46, 46, 42, 1, -46 },
  { 7851, 29, 46, 34, 1, -46 },
  { 8018, 57, 46, 58, 1, -46 },
  { 8346, 50, 46, 50, 1, -46 },
  { 8634, 42, 48, 48, 4, -47 },
  { 8886, 39, 46, 40, 1, -46 },
  { 9111, 42, 58, 48, 4, -47 },
  { 9416, 38, 46, 41, 1, -46 },
  { 9635, 35, 48, 35, 1, -47 },
  { 9845, 34, 46, 35, 5, -46 },
  { 10041, 42, 47, 45, 4, -46 },
  { 10288, 40, 46, 39, 5, -46 },
  { 10518, 60, 46, 59, 5, -46 },
  { 10863, 50, 46, 41, -4, -46 },
  { 11151, 38, 46, 38, 6, -46 },
  { 11370, 40, 46, 35, -2, -46 },
  { 11600, 28, 58, 22, -1, -47 },
  { 11803, 17, 48, 29, 7, -47 },
  { 11905, 28, 58, 22, -4, -47 },
  { 12108, 33, 31, 35, 1, -47 },
  { 12236, 29, 6, 28, -6, 5 },
  { 12258, 15, 11, 22, 9, -50 },
  { 12279, 35, 37, 39, 3, -36 },
  { 12441, 35, 50, 39, 1, -49 },
  { 12660, 30, 37, 32, 3, -36 },
  { 12799, 38, 50, 39, 3, -49 },
  { 13037, 32, 37, 37, 3, -36 },
  { 13185, 39, 66, 25, -7, -50 },
  { 13507, 37, 52, 39, 1, -36 },
  { 13748, 36, 49, 40, 1, -49 },
  { 13969, 21, 50, 20, 1, -50 },
  { 14101, 30, 66, 20, -8, -50 },
  { 14349, 41, 49, 38, 1, -49 },
  { 14601, 21, 49, 20, 1, -49 },
  { 14730, 55, 36, 59, 1, -36 },
  { 14978, 36, 36, 40, 1, -36 },
  { 15140, 33, 37, 39, 3, -36 },
  { 15293, 38, 52, 39, -2, -36 },
  { 15540, 35, 52, 39, 3, -36 },
  { 15768, 29, 36, 28, 1, -36 },
  { 15899, 29, 37, 32, 1, -36 },
  { 16034, 26, 44, 28, 3, -43 },
  { 16177, 36, 37, 40, 3, -36 },
  { 16344, 35, 36, 34, 3, -36 },
  { 16502, 52, 36, 52, 4, -36 },
  { 16736, 43, 36, 36, -4, -36 },
  { 16930, 42, 52, 35, -4, -36 },
  { 17203, 33, 36, 31, -1, -36 },
  { 17352, 28, 56, 23, 0, -46 },
  { 17548, 8, 64, 36, 14, -49 },
  { 17612, 27, 56, 23, -4, -46 },
  { 17801, 32, 12, 38, 3, -29 },
};

const GFXfont NotoSans_ExtraBoldItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRABOLDITALIC65PT7B_H_
