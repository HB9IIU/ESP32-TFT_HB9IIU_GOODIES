#ifndef _NOTOSANS_EXTRABOLDITALIC45PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x08, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF1, 0xF9, 0xFC, 0x7E,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x3F,
  0x0F, 0x8F, 0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F,
  0x09, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xF0, 0x00, 0x3E,
  0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xE7, 0x0C, 0x1F, 0xE7, 0x00, 0x1F, 0xCF, 0x00,
  0x1F, 0xEF, 0x00, 0x1F, 0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x39, 0xFC, 0x00, 0x39, 0xFC,
  0x80, 0x39, 0xFC, 0xE0, 0x79, 0xFC, 0xFF, 0x77, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x1F, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0xFE, 0x00,
  0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0x0F, 0xE3,
  0xF0, 0x3E, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0xFC, 0x00,
  0xFC, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE1, 0xF0, 0x00, 0xF8, 0x7E, 0x3F,
  0x00, 0x0F, 0x87, 0xE7, 0xE1, 0xE0, 0xF8, 0xFC, 0xFC, 0x7F, 0x8F, 0xDF,
  0xCF, 0xDF, 0xFC, 0xFF, 0xF9, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0x3F, 0xFE,
  0x7F, 0xF7, 0xE7, 0xF7, 0xF3, 0xFC, 0x7E, 0x7E, 0x3F, 0x03, 0x0F, 0xCF,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0x0F, 0xC0, 0xFC, 0x7E,
  0x00, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF0, 0x0F,
  0xDF, 0xC0, 0x7E, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0x81, 0xFE, 0x3F, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF,
  0x1F, 0xC7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE1, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF,
  0xFC, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xC1, 0xFE, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF, 0xF0,
  0x07, 0xFF, 0x0F, 0xF0, 0x3F, 0x9F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x06, 0x07, 0xC0, 0x3C, 0x3E, 0x01, 0xF9,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFE, 0x04, 0x7F, 0xF8, 0x07, 0xF7,
  0xC0, 0x7F, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0x87, 0xE0, 0x08, 0x3F, 0x00,
  0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0xFB,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x3F, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xF8, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8,
  0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xE7, 0xF1,
  0xF9, 0xFE, 0x1C, 0x3F, 0x81, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xE0, 0xFF, 0x01, 0xE0, 0x3F, 0x80, 0x40, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xC0, 0xFF,
  0x01, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x80, 0x03, 0xFC, 0xE0, 0x07, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xBF, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xC7, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0E, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x80, 0x07, 0xF8, 0xE0, 0x1F,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xDE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F,
  0xE0, 0x7F, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0x87, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x03, 0xFC,
  0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFF, 0x7F, 0xCF, 0xF0, 0xFF, 0x7F, 0x81, 0xFD, 0xFE, 0x07,
  0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xF7,
  0xF0, 0x3F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xDF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFB, 0xF8, 0x1F, 0x8F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x80, 0x00, 0x00,
  0x7C, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xBF, 0xF1, 0xC0, 0xFF, 0x10, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x7E, 0x1F, 0xC0, 0x3E, 0x03, 0xF1, 0xF8, 0x1F, 0xFF, 0x3F, 0x3F,
  0x03, 0xFF, 0xE1, 0xF3, 0xE0, 0xFF, 0xFE, 0x1F, 0x7E, 0x0F, 0xFF, 0xE1,
  0xF7, 0xC1, 0xF8, 0x7E, 0x1F, 0x7C, 0x3F, 0x07, 0xC1, 0xFF, 0xC3, 0xF0,
  0x7C, 0x1F, 0xFC, 0x7E, 0x07, 0xC1, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0xF8,
  0x7C, 0x0F, 0xC3, 0xFF, 0x87, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x1F, 0x83,
  0xEF, 0x87, 0xC1, 0xF8, 0x7E, 0xF8, 0x7E, 0x3F, 0x8F, 0xCF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7F, 0xF7, 0xFF, 0x0F, 0xC3, 0xFE, 0x7F, 0xE0, 0x7E,
  0x1F, 0xC3, 0xFC, 0x07, 0xE0, 0x20, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x78, 0x0F, 0xF8, 0x00, 0x81,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x40, 0x7F,
  0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x7F,
  0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xF8, 0x0F, 0xFC,
  0x3F, 0x81, 0xFF, 0x87, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xC0, 0x38, 0x0F, 0xF8, 0x00, 0x40, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xFC, 0x7F, 0x83,
  0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0x1F, 0xC0, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF,
  0x8F, 0xF0, 0x7F, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0x80, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F,
  0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF1, 0xFF,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x0F, 0xDF, 0x01,
  0xFB, 0xF0, 0x3F, 0xBE, 0x03, 0xFF, 0xE0, 0x7F, 0x7C, 0x0F, 0xDF, 0xC0,
  0xFE, 0xF8, 0x1F, 0xBF, 0x81, 0xFD, 0xF0, 0x7E, 0x7F, 0x03, 0xF3, 0xE0,
  0xFD, 0xFC, 0x0F, 0xE7, 0xC1, 0xF3, 0xF8, 0x1F, 0xCF, 0x87, 0xE7, 0xF0,
  0x3F, 0x9F, 0x0F, 0x8F, 0xE0, 0x7F, 0x3E, 0x3F, 0x1F, 0x80, 0xFC, 0x7C,
  0x7C, 0x7F, 0x03, 0xF8, 0xF9, 0xF8, 0xFE, 0x07, 0xF1, 0xF3, 0xE1, 0xFC,
  0x0F, 0xE3, 0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xFF, 0x0F, 0xE0, 0x3F, 0x0F,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xF0, 0x7F,
  0x03, 0xF8, 0x7F, 0xE0, 0xFE, 0x07, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xC1,
  0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xF0,
  0x01, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF,
  0xE0, 0x0F, 0xE0, 0x7F, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0x01, 0xFB, 0xF8, 0x1F, 0xC0, 0xFE, 0xFE, 0x07, 0xF0,
  0x3F, 0xBF, 0x81, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x03, 0xF9, 0xFC, 0x3F,
  0x80, 0xFC, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0xFE, 0x07, 0xF0, 0xFE, 0x7F, 0x01, 0xFC, 0x3F, 0x9F, 0xC0, 0x7E, 0x07,
  0xF7, 0xF0, 0x3F, 0x81, 0xFD, 0xFC, 0x0F, 0xE0, 0x7F, 0x7E, 0x03, 0xF8,
  0x0F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF8, 0x1F,
  0xC0, 0x3F, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0x80, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x7F, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03,
  0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xF0, 0x1C, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xC0, 0x0F, 0xF0, 0xF0, 0x1F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0,
  0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xCF,
  0xE0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x0F,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x3F, 0xC0,
  0x3F, 0xDF, 0xC0, 0x3F, 0xE0, 0x1F, 0xEF, 0xE0, 0x1F, 0xF0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF3, 0xF8, 0x0F, 0xFC, 0x07, 0xF1, 0xFC, 0x07,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFF, 0x81,
  0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFB, 0xF0, 0xFF, 0x07, 0xF0, 0xFD, 0xF8, 0x7F, 0x03, 0xF8, 0x7E,
  0xFC, 0x3F, 0x81, 0xFC, 0x7E, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x3F, 0x1F,
  0xC0, 0x7F, 0x3F, 0x9F, 0x9F, 0xC0, 0x3F, 0x9F, 0x8F, 0xCF, 0xE0, 0x1F,
  0xDF, 0xC7, 0xE7, 0xF0, 0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x07, 0xF7, 0xE1,
  0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF1,
  0xFC, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFD,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0xF9, 0xF0, 0x01,
  0xF9, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x3F, 0x03, 0xFF, 0x3F, 0x07, 0xFF,
  0x3F, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xF7, 0xE0, 0x1F, 0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF3,
  0xF0, 0x07, 0xF7, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0x80, 0xFF, 0x3F, 0x80,
  0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFC, 0xFF, 0xC0, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x81, 0x87, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x61, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0xE7, 0xF0, 0x1F, 0xFD, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F,
  0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xE0, 0x07, 0xF9, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xC7, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x7F, 0x81, 0xFD, 0xFE,
  0x0F, 0xF7, 0xF1, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x06, 0x3F, 0xE0, 0x78, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF9, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x23, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0xFF, 0x8F, 0xC0, 0xFF, 0xE7,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xC7,
  0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE,
  0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x08, 0x01, 0xFE, 0x07, 0x81, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF1, 0xF8, 0x07, 0xF7, 0xFC, 0x0F, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF8, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x11, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x01, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFD, 0xFE, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xE0, 0x1F, 0x9F, 0xF0,
  0x7F, 0xC0, 0xFE, 0xFF, 0xE3, 0xFF, 0x83, 0xF7, 0xFF, 0xDF, 0xFE, 0x0F,
  0xDF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F, 0xFE,
  0x3F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x7F,
  0x81, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC0,
  0xFE, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x07,
  0xF1, 0xFE, 0x07, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xF0, 0x3F,
  0x8F, 0xF0, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE7, 0xFC, 0x0F, 0xEF, 0xFE,
  0x0F, 0xDF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF,
  0x1F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF,
  0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xF8, 0xFF, 0x9F, 0xE0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F,
  0xE7, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xBF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x7F,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0x00,
  0xFE, 0x7F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x03,
  0xFF, 0x3F, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF,
  0x01, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xF7, 0xF0, 0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xE1, 0xF0, 0x7E,
  0x7F, 0x0F, 0xEF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFE, 0x3C, 0x3F, 0xC0, 0x43, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x80, 0x3F, 0xCF, 0x07,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xEF, 0xC0, 0x7F, 0xE7,
  0xE0, 0x1F, 0xE3, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F,
  0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F,
  0x7F, 0x80, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0x80, 0xFE, 0xFE, 0x0F, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF,
  0x81, 0xFC, 0xFE, 0x0F, 0xF8, 0x3F, 0xCF, 0xE1, 0xFF, 0x83, 0xF8, 0xFE,
  0x1F, 0xF8, 0x7F, 0x8F, 0xE3, 0xFF, 0x87, 0xF0, 0xFE, 0x3E, 0xF8, 0x7F,
  0x0F, 0xE3, 0xEF, 0x8F, 0xE0, 0xFE, 0x7E, 0xF8, 0xFE, 0x0F, 0xE7, 0xCF,
  0x9F, 0xC0, 0xFE, 0xFC, 0xF9, 0xFC, 0x0F, 0xEF, 0x8F, 0xBF, 0x80, 0xFE,
  0xF8, 0xFB, 0xF8, 0x0F, 0xFF, 0x8F, 0xBF, 0x00, 0xFD, 0xF0, 0xFF, 0xF0,
  0x0F, 0xDF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8,
  0x03, 0xF8, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x47, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x05, 0xFF, 0xC0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xA0, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 33, 13, 0, -32 },
  { 63, 18, 11, 20, 4, -32 },
  { 88, 29, 32, 29, 1, -32 },
  { 204, 24, 37, 25, 1, -34 },
  { 315, 36, 33, 40, 3, -33 },
  { 464, 31, 33, 32, 1, -33 },
  { 592, 9, 11, 11, 4, -32 },
  { 605, 17, 40, 16, 2, -33 },
  { 690, 17, 40, 16, -3, -33 },
  { 775, 21, 22, 24, 4, -34 },
  { 833, 22, 22, 26, 2, -27 },
  { 894, 11, 11, 13, -2, -5 },
  { 910, 13, 6, 15, 1, -15 },
  { 920, 9, 8, 13, 0, -7 },
  { 929, 25, 32, 20, -2, -32 },
  { 1029, 24, 33, 25, 1, -33 },
  { 1128, 19, 32, 25, 4, -32 },
  { 1204, 25, 33, 25, -1, -33 },
  { 1308, 24, 33, 25, 0, -33 },
  { 1407, 25, 32, 25, 0, -32 },
  { 1507, 24, 32, 25, 1, -32 },
  { 1603, 24, 33, 25, 2, -33 },
  { 1702, 26, 32, 25, 1, -32 },
  { 1806, 24, 33, 25, 1, -33 },
  { 1905, 22, 33, 25, 2, -33 },
  { 1996, 13, 26, 13, 0, -25 },
  { 2039, 15, 31, 13, -2, -25 },
  { 2098, 22, 24, 26, 2, -28 },
  { 2164, 22, 14, 26, 2, -23 },
  { 2203, 22, 24, 26, 2, -28 },
  { 2269, 20, 34, 21, 3, -33 },
  { 2354, 36, 36, 39, 2, -32 },
  { 2516, 29, 32, 29, -3, -32 },
  { 2632, 27, 32, 28, 1, -32 },
  { 2740, 28, 33, 28, 2, -33 },
  { 2856, 28, 32, 31, 1, -32 },
  { 2968, 25, 32, 25, 1, -32 },
  { 3068, 25, 32, 25, 1, -32 },
  { 3168, 29, 33, 31, 2, -33 },
  { 3288, 31, 32, 32, 1, -32 },
  { 3412, 22, 32, 18, -1, -32 },
  { 3500, 23, 42, 16, -7, -32 },
  { 3621, 32, 32, 29, 1, -32 },
  { 3749, 20, 32, 23, 1, -32 },
  { 3829, 39, 32, 40, 1, -32 },
  { 3985, 34, 32, 35, 1, -32 },
  { 4121, 30, 33, 33, 2, -33 },
  { 4245, 27, 32, 28, 1, -32 },
  { 4353, 30, 41, 33, 2, -33 },
  { 4507, 26, 32, 29, 1, -32 },
  { 4611, 24, 33, 24, 1, -33 },
  { 4710, 23, 32, 24, 4, -32 },
  { 4802, 29, 32, 31, 3, -32 },
  { 4918, 27, 32, 27, 4, -32 },
  { 5026, 41, 32, 41, 4, -32 },
  { 5190, 35, 32, 29, -3, -32 },
  { 5330, 26, 32, 26, 4, -32 },
  { 5434, 29, 32, 24, -2, -32 },
  { 5550, 20, 40, 15, -1, -33 },
  { 5650, 11, 32, 20, 5, -32 },
  { 5694, 19, 40, 15, -3, -33 },
  { 5789, 24, 21, 24, 0, -32 },
  { 5852, 20, 4, 19, -4, 4 },
  { 5862, 11, 7, 15, 6, -34 },
  { 5872, 24, 25, 27, 2, -25 },
  { 5947, 24, 34, 27, 1, -34 },
  { 6049, 21, 25, 22, 2, -25 },
  { 6115, 26, 34, 27, 2, -34 },
  { 6226, 22, 25, 26, 2, -25 },
  { 6295, 27, 45, 18, -5, -34 },
  { 6447, 25, 36, 27, 1, -25 },
  { 6560, 24, 34, 28, 1, -34 },
  { 6662, 14, 35, 14, 1, -35 },
  { 6724, 21, 46, 14, -6, -35 },
  { 6845, 28, 34, 27, 1, -34 },
  { 6964, 14, 34, 14, 1, -34 },
  { 7024, 38, 25, 41, 1, -25 },
  { 7143, 24, 25, 28, 1, -25 },
  { 7218, 23, 25, 27, 2, -25 },
  { 7290, 27, 36, 27, -2, -25 },
  { 7412, 24, 36, 27, 2, -25 },
  { 7520, 20, 25, 19, 1, -25 },
  { 7583, 20, 25, 22, 1, -25 },
  { 7646, 18, 30, 19, 2, -30 },
  { 7714, 25, 25, 28, 2, -25 },
  { 7793, 24, 25, 24, 2, -25 },
  { 7868, 36, 25, 36, 3, -25 },
  { 7981, 29, 25, 25, -2, -25 },
  { 8072, 29, 36, 24, -3, -25 },
  { 8203, 23, 25, 21, -1, -25 },
  { 8275, 19, 39, 16, 0, -32 },
  { 8368, 5, 44, 25, 10, -34 },
  { 8396, 18, 39, 16, -2, -32 },
  { 8484, 22, 8, 26, 2, -20 },
};

const GFXfont NotoSans_ExtraBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRABOLDITALIC45PT7B_H_
