#ifndef _NOTOSANS_EXTRABOLDITALIC57PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xCF, 0xC0,
  0x7F, 0xCF, 0x81, 0x00, 0xFF, 0x9E, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x03,
  0xFE, 0x78, 0x00, 0x07, 0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3D,
  0xFF, 0x80, 0x00, 0x79, 0xFF, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x01, 0xE3,
  0xFC, 0x70, 0x07, 0xCF, 0xF8, 0x78, 0x0F, 0x1F, 0xF0, 0xFF, 0x9F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE3, 0xFC,
  0x3F, 0x83, 0xFC, 0x7F, 0x8F, 0xE3, 0xFF, 0x8F, 0xF3, 0xFE, 0x7F, 0x1F,
  0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0xF3, 0xFF, 0xF3, 0xF8, 0xFF, 0x3F,
  0xC7, 0xFF, 0x9F, 0xE7, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0x00, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xFB, 0xFF, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0x9F, 0xF8,
  0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xE0, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x0C, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xFB, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0xFC, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x7E, 0x00, 0xFF, 0xCF, 0xE0, 0x0F, 0xF1,
  0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0x83, 0xF8, 0x00, 0x60, 0x7F, 0x80,
  0x04, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xC7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x7F, 0x83, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F,
  0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF,
  0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xF8, 0x3F, 0x8F, 0xF8, 0x3E, 0x0F,
  0xF8, 0x1C, 0x1F, 0xF8, 0x10, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x00,
  0x70, 0x03, 0xFF, 0x00, 0x20, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x08, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x78,
  0x0F, 0xFE, 0x00, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x40, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x7F, 0xF1, 0xFC,
  0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x40, 0x00, 0x3F, 0xF0, 0xE0, 0x01,
  0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x1C, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0x81, 0xFF,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0,
  0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xF7,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x3F,
  0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0x3F, 0xE0, 0xFF, 0xE7, 0xFC,
  0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x0C, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0x1E, 0x01, 0xFF, 0x8C, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xC3, 0xFC, 0x07, 0xFF,
  0xFC, 0x3F, 0x87, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0x07, 0xFC, 0x1F,
  0x81, 0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFB, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF7, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xEF, 0xE1, 0xFE, 0x03, 0xF0,
  0x1F, 0x9F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x7E, 0x0F, 0xE0, 0x3F, 0x81, 0xFD, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF3, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x07, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xC1, 0xFE, 0x7F, 0xF3, 0xFC,
  0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0xEF, 0xFF, 0xE0,
  0x7F, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x3F, 0xF8, 0x00, 0x08, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0x18, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0x8F, 0xFC,
  0x07, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xF8,
  0xFF, 0xC0, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFD, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x7F,
  0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xEF,
  0xF8, 0x07, 0xFD, 0xFC, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0x01, 0xFC,
  0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xF0, 0x07, 0xF9, 0xFC, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0x07,
  0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0xC3, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF0,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFC, 0x7F, 0x8F, 0xF8, 0x07, 0xFC, 0x7F,
  0x1F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xCF, 0xF0, 0xFF, 0x80, 0x7F, 0xC7,
  0xF3, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFD, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x7F, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF8,
  0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE7, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0,
  0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8,
  0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x01,
  0xF0, 0x1F, 0xF8, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x08, 0x00, 0x0F, 0xFC, 0x30,
  0x00, 0x3F, 0xE0, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x7F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x8F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x0F,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFD, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xF9,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x9F, 0xC1, 0xFF, 0x00, 0xFF, 0x87,
  0xF9, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x1F, 0xC3, 0xFE, 0x00, 0xFF,
  0x8F, 0xF1, 0xFC, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x1F, 0xC7, 0xFC, 0x00,
  0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0xC0, 0x07, 0xF9, 0xFC, 0x1F, 0xCF, 0xF8,
  0x00, 0x7F, 0xBF, 0xC1, 0xFC, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x1F, 0xCF,
  0xF0, 0x00, 0x7F, 0xBF, 0x81, 0xFD, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x1F,
  0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF, 0xC3, 0xFE,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xC1, 0xFC, 0x03, 0xFF, 0xC7, 0xF8,
  0x0F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00,
  0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0x9F, 0xE0,
  0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F,
  0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF,
  0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0x01, 0xFE,
  0x3F, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x60, 0x7F, 0xF0, 0x7C, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3E, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F,
  0xFC, 0xFF, 0x80, 0x1F, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xEF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x9F,
  0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xCF, 0xFC,
  0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x20, 0x7F, 0xF0, 0x07, 0x03, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x82, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x20, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x7F, 0x00, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0x7F, 0xC0, 0x0F, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x80, 0x01, 0xFF, 0x80, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x7F, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF,
  0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x21, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x03,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC, 0x03,
  0xFC, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0x07,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x7F,
  0xE0, 0x0F, 0xF3, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF,
  0xC0, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3,
  0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07,
  0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF,
  0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF9, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x07, 0xF9,
  0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF7, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xFC,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xC1,
  0xFC, 0x03, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xE1,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x1F,
  0xF8, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xFC,
  0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xDF,
  0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xC1, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x40, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xE0, 0x78, 0x1F, 0xF8, 0x06, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE2, 0x00, 0x1F, 0xF8, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x30, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1,
  0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0x8F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFC,
  0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0x87, 0xF8, 0x07, 0xFE, 0x1F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xBF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF3, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0x07, 0xFE, 0x1F, 0xE0,
  0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F,
  0xDF, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x1F, 0xE1, 0xFD,
  0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xE7, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0x9F,
  0x8F, 0xF8, 0x07, 0xF8, 0xFE, 0x7E, 0x3F, 0xE0, 0x1F, 0xE7, 0xF1, 0xF8,
  0xFF, 0x00, 0x7F, 0x9F, 0xC7, 0xE7, 0xFC, 0x01, 0xFE, 0x7E, 0x1F, 0x9F,
  0xE0, 0x07, 0xFB, 0xF8, 0x7E, 0x7F, 0x80, 0x1F, 0xEF, 0xE1, 0xFB, 0xFC,
  0x00, 0x7F, 0xBF, 0x07, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x1F, 0xBF, 0xC0,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF9, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x17, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0xC8,
  0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 42, 17, 1, -41 },
  { 96, 23, 15, 26, 5, -41 },
  { 140, 36, 41, 37, 1, -41 },
  { 325, 31, 46, 32, 1, -43 },
  { 504, 46, 42, 51, 3, -41 },
  { 746, 40, 42, 41, 1, -41 },
  { 956, 11, 15, 14, 5, -41 },
  { 977, 22, 50, 20, 2, -41 },
  { 1115, 22, 51, 20, -4, -42 },
  { 1256, 27, 28, 31, 5, -44 },
  { 1351, 28, 28, 33, 3, -34 },
  { 1449, 15, 14, 17, -3, -7 },
  { 1476, 16, 8, 19, 1, -19 },
  { 1492, 11, 10, 17, 0, -9 },
  { 1506, 32, 41, 25, -3, -41 },
  { 1670, 30, 42, 32, 2, -41 },
  { 1828, 24, 41, 32, 5, -41 },
  { 1951, 32, 41, 32, -1, -41 },
  { 2115, 31, 42, 32, 0, -41 },
  { 2278, 32, 41, 32, -1, -41 },
  { 2442, 31, 42, 32, 1, -41 },
  { 2605, 31, 42, 32, 2, -41 },
  { 2768, 33, 41, 32, 2, -41 },
  { 2938, 31, 42, 32, 1, -41 },
  { 3101, 28, 42, 32, 3, -41 },
  { 3248, 16, 33, 17, 0, -32 },
  { 3314, 19, 39, 17, -3, -32 },
  { 3407, 28, 31, 33, 3, -36 },
  { 3516, 28, 18, 33, 3, -29 },
  { 3579, 28, 31, 33, 3, -36 },
  { 3688, 25, 42, 27, 4, -41 },
  { 3820, 47, 46, 50, 2, -41 },
  { 4091, 36, 41, 37, -3, -41 },
  { 4276, 34, 41, 36, 1, -41 },
  { 4451, 35, 42, 35, 3, -41 },
  { 4635, 36, 41, 39, 1, -41 },
  { 4820, 32, 41, 31, 1, -41 },
  { 4984, 32, 41, 31, 1, -41 },
  { 5148, 36, 42, 40, 3, -41 },
  { 5337, 40, 41, 40, 1, -41 },
  { 5542, 28, 41, 23, -2, -41 },
  { 5686, 29, 53, 20, -9, -41 },
  { 5879, 40, 41, 36, 1, -41 },
  { 6084, 25, 41, 30, 1, -41 },
  { 6213, 50, 41, 51, 1, -41 },
  { 6470, 43, 41, 44, 1, -41 },
  { 6691, 37, 42, 42, 3, -41 },
  { 6886, 34, 41, 35, 1, -41 },
  { 7061, 37, 51, 42, 3, -41 },
  { 7297, 33, 41, 36, 1, -41 },
  { 7467, 30, 42, 31, 1, -41 },
  { 7625, 31, 41, 31, 4, -41 },
  { 7784, 36, 42, 40, 4, -41 },
  { 7973, 34, 41, 34, 5, -41 },
  { 8148, 52, 41, 52, 5, -41 },
  { 8415, 44, 41, 36, -3, -41 },
  { 8641, 33, 41, 33, 5, -41 },
  { 8811, 36, 41, 31, -2, -41 },
  { 8996, 24, 50, 20, -1, -41 },
  { 9146, 15, 41, 25, 6, -41 },
  { 9223, 25, 50, 20, -4, -41 },
  { 9380, 30, 27, 31, 0, -41 },
  { 9482, 25, 6, 24, -5, 4 },
  { 9501, 13, 9, 19, 8, -44 },
  { 9516, 31, 33, 34, 2, -32 },
  { 9644, 31, 44, 34, 1, -43 },
  { 9815, 27, 33, 28, 2, -32 },
  { 9927, 34, 44, 34, 2, -43 },
  { 10114, 29, 33, 32, 2, -32 },
  { 10234, 34, 58, 22, -6, -44 },
  { 10481, 32, 46, 34, 1, -32 },
  { 10665, 31, 43, 35, 1, -43 },
  { 10832, 18, 44, 18, 1, -44 },
  { 10931, 26, 58, 18, -7, -44 },
  { 11120, 36, 43, 34, 1, -43 },
  { 11314, 19, 43, 18, 1, -43 },
  { 11417, 48, 32, 52, 1, -32 },
  { 11609, 31, 32, 35, 1, -32 },
  { 11733, 30, 33, 34, 2, -32 },
  { 11857, 34, 46, 34, -2, -32 },
  { 12053, 31, 46, 34, 2, -32 },
  { 12232, 26, 32, 24, 1, -32 },
  { 12336, 26, 33, 28, 1, -32 },
  { 12444, 23, 39, 25, 2, -38 },
  { 12557, 31, 32, 35, 3, -31 },
  { 12681, 30, 31, 30, 3, -31 },
  { 12798, 46, 31, 46, 3, -31 },
  { 12977, 37, 31, 31, -3, -31 },
  { 13121, 37, 45, 30, -4, -31 },
  { 13330, 29, 31, 27, -1, -31 },
  { 13443, 24, 50, 20, 0, -41 },
  { 13593, 7, 56, 32, 12, -43 },
  { 13642, 24, 50, 20, -3, -41 },
  { 13792, 28, 10, 33, 3, -25 },
};

const GFXfont NotoSans_ExtraBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRABOLDITALIC57PT7B_H_
