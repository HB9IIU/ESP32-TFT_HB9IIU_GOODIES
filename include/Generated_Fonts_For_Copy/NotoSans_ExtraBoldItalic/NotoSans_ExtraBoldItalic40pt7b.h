#ifndef _NOTOSANS_EXTRABOLDITALIC40PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x7E, 0xFC, 0xFD, 0xF9, 0xFB, 0xE3, 0xF7, 0xC7, 0xDF, 0x8F,
  0xBE, 0x1F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0,
  0x07, 0xC3, 0xC0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE0, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xDC, 0x30, 0xFC, 0xE0, 0x07, 0xE7, 0x00, 0x3F, 0xB8,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xEF, 0xE0, 0x07, 0x7F,
  0x40, 0x73, 0xF3, 0x83, 0x9F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xF8, 0x00,
  0xF8, 0x1F, 0xFC, 0x01, 0xF0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x07,
  0xC0, 0x7E, 0x7C, 0x07, 0xC0, 0x7C, 0x7E, 0x0F, 0x80, 0x7C, 0x7C, 0x1F,
  0x00, 0xFC, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x7C,
  0x00, 0xF8, 0xFC, 0xF8, 0x70, 0xF8, 0xF9, 0xF1, 0xFC, 0xFD, 0xF9, 0xF7,
  0xFE, 0x7F, 0xF3, 0xE7, 0xFF, 0x7F, 0xF7, 0xCF, 0xFF, 0x3F, 0xEF, 0xDF,
  0x9F, 0x1F, 0x8F, 0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3E, 0x3F,
  0x1F, 0x00, 0x7E, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x3E,
  0x3F, 0x01, 0xF0, 0x3E, 0x3E, 0x03, 0xF0, 0x3F, 0x7E, 0x03, 0xE0, 0x3F,
  0xFE, 0x07, 0xC0, 0x1F, 0xFC, 0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x0F,
  0xC3, 0xFF, 0x83, 0xF8, 0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0x0F, 0xCF, 0xF7,
  0xF3, 0xFB, 0xFC, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xCF, 0xE0, 0xFF, 0xF1,
  0xFC, 0x1F, 0xFC, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xC7, 0xF8, 0x7E, 0xFD, 0xFB, 0xE7, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3,
  0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x20, 0x7C, 0x07, 0x87, 0x80,
  0x7E, 0x78, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xF8, 0xE1, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF3,
  0xE0, 0x1E, 0x3E, 0x00, 0xC3, 0xE0, 0x04, 0x3F, 0x00, 0x01, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x08, 0x7E, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8,
  0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFE, 0x03,
  0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F,
  0x07, 0xF3, 0xF8, 0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFD,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0x3F, 0x0F, 0x1F, 0x82, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xF8, 0x7F, 0x80, 0xC0, 0x7F, 0x01, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x30, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC8,
  0x00, 0xFF, 0x3C, 0x07, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E,
  0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x04,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC8, 0x00, 0xFF, 0x3C, 0x0F, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0x38, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC7, 0x00, 0xFD, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83,
  0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xF3, 0xF8, 0x7F, 0x1F,
  0xC7, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFC, 0xFF, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFD, 0xFE,
  0x7F, 0x07, 0xE7, 0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xF7, 0xE3, 0xFE, 0xFE, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x88, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x7E, 0x0F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xF3, 0xFC, 0xC0, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x03, 0xFC, 0x1F,
  0x3E, 0x0F, 0xFF, 0x1F, 0x7E, 0x1F, 0xFF, 0x1F, 0x7C, 0x3F, 0xFF, 0x1F,
  0x7C, 0x7E, 0x1F, 0x0F, 0xF8, 0x7C, 0x1E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F,
  0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF0, 0xF0, 0x7C, 0x1E,
  0xF1, 0xF0, 0x7C, 0x3E, 0xF1, 0xF0, 0x7C, 0x3E, 0xF0, 0xF8, 0xFC, 0xFC,
  0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0xFF, 0xF0, 0xF8, 0x7F, 0x9F, 0xE0,
  0x7C, 0x3E, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x06, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC7, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x1F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x1C, 0x1F, 0xE0, 0x04, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x20, 0x7F, 0xC3, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x1F, 0xE3, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0xF1, 0xFC, 0x1F,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE0, 0x18, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0xFB, 0xFC, 0x3F, 0xFD, 0xFC,
  0x1F, 0xFC, 0xFE, 0x0F, 0xFE, 0x7F, 0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x0F, 0xF0, 0x07, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0xFD, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0x7E, 0x07, 0xDF, 0x07, 0xEF, 0xC1, 0xFB, 0xE0, 0xFB, 0xF0, 0x3F, 0x7C,
  0x3F, 0x7E, 0x07, 0xEF, 0x87, 0xCF, 0xC0, 0xFD, 0xF1, 0xF9, 0xF8, 0x3F,
  0xBE, 0x3E, 0x7F, 0x07, 0xE7, 0xCF, 0xCF, 0xC0, 0xFC, 0xF9, 0xF1, 0xF8,
  0x1F, 0x8F, 0x7E, 0x3F, 0x03, 0xF1, 0xEF, 0x87, 0xE0, 0xFC, 0x3F, 0xF1,
  0xF8, 0x1F, 0x87, 0xFC, 0x3F, 0x03, 0xF0, 0xFF, 0x87, 0xE0, 0x7E, 0x1F,
  0xE0, 0xFC, 0x0F, 0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFC,
  0x0F, 0xF0, 0x03, 0xF0, 0x7F, 0xC0, 0x0F, 0xC1, 0xFF, 0x80, 0x7E, 0x07,
  0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0x7F, 0xF0, 0x1F, 0x83, 0xFF,
  0xC0, 0xFE, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0, 0xFD, 0xF8,
  0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0x1F, 0x9F, 0x87, 0xF0, 0x7E, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x7E, 0x07, 0xE3, 0xF1, 0xF8, 0x3F, 0x8F, 0xE7, 0xE0,
  0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F,
  0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80,
  0x7F, 0xE0, 0x7E, 0x01, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x0F, 0xC0, 0x1F,
  0xF8, 0x3F, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE1,
  0xFF, 0x1F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F,
  0xC7, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0,
  0x1F, 0xE1, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x0F, 0xF1, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0x01, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE3, 0x00, 0xFF, 0x1F, 0x0F, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x87,
  0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFD, 0xFC, 0x07, 0xF8, 0x0F, 0xEF, 0xE0,
  0x3F, 0xC0, 0x7E, 0x7F, 0x01, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFF, 0x83, 0xF8, 0x7E, 0x0F, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F,
  0xE0, 0xFC, 0x1F, 0x87, 0xDF, 0x0F, 0xE0, 0xFC, 0x3E, 0xF8, 0x7E, 0x07,
  0xE3, 0xF7, 0xC7, 0xF0, 0x3F, 0x1F, 0x3E, 0x3F, 0x01, 0xF8, 0xF9, 0xF1,
  0xF8, 0x0F, 0xCF, 0xCF, 0x9F, 0xC0, 0x7E, 0x7C, 0x7C, 0xFC, 0x03, 0xF7,
  0xE3, 0xEF, 0xE0, 0x1F, 0xBE, 0x1F, 0x7E, 0x00, 0xFF, 0xF0, 0xFB, 0xF0,
  0x07, 0xDF, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x3F,
  0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F,
  0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E,
  0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x9E, 0x00,
  0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0xF0, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF3, 0xF0, 0x07, 0xFF, 0x00, 0x3E, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x1F, 0x87,
  0xE3, 0xF0, 0xF8, 0x3E, 0x03, 0xF8, 0xF8, 0x3F, 0xE7, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xE7, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xDF, 0x07, 0xFC, 0xF8, 0x0F,
  0xCF, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x7E, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xF8,
  0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0xBF, 0x83, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x9F, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0x9F, 0xF0, 0x7C, 0x7F, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xF0, 0xC7, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x08, 0xFF, 0x0E, 0x3F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF9,
  0xF8, 0x0F, 0xFB, 0xF0, 0x3F, 0xF7, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xF9, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1,
  0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFE, 0xF8, 0x03, 0xF1,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xCF, 0xF3, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFC, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF9, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xEF, 0xC0, 0x3F, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x82, 0x00, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x3F, 0x7F, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7E,
  0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F,
  0x03, 0xF9, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07,
  0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF0, 0x3F, 0x80, 0x00, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x03,
  0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0x7E, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0x8F, 0xE0, 0x7E, 0x03, 0xE7, 0xFC, 0x7F, 0xC0,
  0xFB, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFC, 0xFF, 0xC7, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF0,
  0x7F, 0x3F, 0x81, 0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0x07, 0xE3, 0xF8, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x03, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x7E,
  0x07, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x07, 0xE3,
  0xF8, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0x8F, 0xE0, 0x3E, 0x7F, 0xC0, 0xFB, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03,
  0xF9, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFE, 0xFC, 0x0F, 0xEF, 0xE1, 0xFE, 0xFE, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xE3, 0xF0,
  0x07, 0xCF, 0xF0, 0x0F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xE7, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFB, 0xFF, 0x03, 0xF7, 0xFC, 0x07, 0xE7, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0xF8, 0x3F, 0xE7, 0xC3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xE7, 0xF9, 0xFE, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F,
  0xCF, 0xE0, 0x7E, 0x7E, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFD, 0xF8,
  0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xCF, 0xC3, 0xE7, 0xE0, 0xFB, 0xF8,
  0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xCF, 0x0F, 0xE0, 0x43, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x80, 0x7F, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x10, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0x8F,
  0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE,
  0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFB, 0xF0, 0x7F, 0xEF,
  0xC0, 0xFE, 0x3E, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFD,
  0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07,
  0xEF, 0xE0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F,
  0xF0, 0x7E, 0xFC, 0x1F, 0xF0, 0xFE, 0xFC, 0x1F, 0xF0, 0xFC, 0x7C, 0x3F,
  0xF1, 0xFC, 0x7E, 0x3F, 0xE1, 0xF8, 0x7E, 0x7D, 0xE3, 0xF8, 0x7E, 0x7D,
  0xE3, 0xF0, 0x7E, 0x79, 0xE3, 0xF0, 0x7E, 0xF9, 0xE7, 0xE0, 0x7E, 0xF9,
  0xE7, 0xE0, 0x7C, 0xF1, 0xEF, 0xC0, 0x7D, 0xF1, 0xEF, 0xC0, 0x7D, 0xF1,
  0xEF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xF9, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7,
  0xE0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x7F,
  0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x80, 0x3F, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 29, 12, 0, -29 },
  { 49, 15, 11, 18, 4, -29 },
  { 70, 25, 29, 26, 1, -29 },
  { 161, 21, 32, 23, 1, -30 },
  { 245, 32, 29, 36, 2, -29 },
  { 361, 27, 29, 29, 1, -29 },
  { 459, 7, 11, 10, 4, -29 },
  { 469, 16, 35, 14, 1, -29 },
  { 539, 16, 35, 14, -3, -29 },
  { 609, 20, 20, 22, 3, -31 },
  { 659, 20, 20, 23, 2, -24 },
  { 709, 10, 10, 12, -2, -5 },
  { 722, 11, 5, 13, 1, -13 },
  { 729, 8, 7, 12, 0, -7 },
  { 736, 23, 29, 18, -2, -29 },
  { 820, 21, 29, 23, 1, -29 },
  { 897, 17, 29, 23, 3, -29 },
  { 959, 23, 29, 23, -1, -29 },
  { 1043, 22, 29, 23, 0, -29 },
  { 1123, 22, 29, 23, 0, -29 },
  { 1203, 22, 29, 23, 0, -29 },
  { 1283, 21, 29, 23, 2, -29 },
  { 1360, 23, 29, 23, 1, -29 },
  { 1444, 21, 29, 23, 1, -29 },
  { 1521, 20, 29, 23, 2, -29 },
  { 1594, 11, 22, 12, 0, -22 },
  { 1625, 13, 27, 12, -2, -22 },
  { 1669, 20, 21, 23, 2, -25 },
  { 1722, 20, 13, 23, 2, -21 },
  { 1755, 20, 21, 23, 2, -25 },
  { 1808, 17, 30, 19, 3, -29 },
  { 1872, 32, 33, 35, 2, -29 },
  { 2004, 25, 29, 26, -2, -29 },
  { 2095, 24, 29, 25, 1, -29 },
  { 2182, 24, 29, 25, 2, -29 },
  { 2269, 25, 29, 27, 1, -29 },
  { 2360, 22, 29, 22, 1, -29 },
  { 2440, 22, 29, 22, 1, -29 },
  { 2520, 25, 29, 28, 2, -29 },
  { 2611, 27, 29, 28, 1, -29 },
  { 2709, 19, 29, 16, -1, -29 },
  { 2778, 20, 38, 14, -6, -29 },
  { 2873, 28, 29, 26, 1, -29 },
  { 2975, 17, 29, 21, 1, -29 },
  { 3037, 35, 29, 36, 1, -29 },
  { 3164, 30, 29, 31, 1, -29 },
  { 3273, 26, 29, 29, 2, -29 },
  { 3368, 24, 29, 25, 1, -29 },
  { 3455, 26, 36, 29, 2, -29 },
  { 3572, 23, 29, 25, 1, -29 },
  { 3656, 21, 29, 22, 1, -29 },
  { 3733, 21, 29, 22, 3, -29 },
  { 3810, 25, 29, 28, 3, -29 },
  { 3901, 24, 29, 24, 3, -29 },
  { 3988, 37, 29, 37, 3, -29 },
  { 4123, 30, 29, 25, -2, -29 },
  { 4232, 24, 29, 23, 3, -29 },
  { 4319, 25, 29, 21, -1, -29 },
  { 4410, 17, 36, 14, -1, -29 },
  { 4487, 10, 29, 18, 4, -29 },
  { 4524, 18, 36, 14, -3, -29 },
  { 4605, 21, 19, 22, 0, -29 },
  { 4655, 18, 4, 17, -4, 3 },
  { 4664, 9, 7, 13, 6, -31 },
  { 4672, 21, 22, 24, 2, -22 },
  { 4730, 21, 30, 24, 1, -30 },
  { 4809, 18, 22, 20, 2, -22 },
  { 4859, 23, 30, 24, 2, -30 },
  { 4946, 20, 22, 23, 2, -22 },
  { 5001, 24, 41, 16, -4, -31 },
  { 5124, 22, 32, 24, 1, -22 },
  { 5212, 22, 30, 24, 1, -30 },
  { 5295, 12, 31, 12, 1, -31 },
  { 5342, 19, 41, 12, -5, -31 },
  { 5440, 25, 30, 24, 1, -30 },
  { 5534, 13, 30, 12, 1, -30 },
  { 5583, 34, 22, 37, 1, -22 },
  { 5677, 22, 22, 24, 1, -22 },
  { 5738, 20, 22, 24, 2, -22 },
  { 5793, 23, 32, 24, -1, -22 },
  { 5885, 21, 32, 24, 2, -22 },
  { 5969, 18, 22, 17, 1, -22 },
  { 6019, 18, 22, 19, 1, -22 },
  { 6069, 16, 27, 17, 2, -27 },
  { 6123, 22, 22, 24, 2, -22 },
  { 6184, 21, 22, 21, 2, -22 },
  { 6242, 32, 22, 32, 2, -22 },
  { 6330, 26, 22, 22, -2, -22 },
  { 6402, 26, 32, 21, -3, -22 },
  { 6506, 21, 22, 19, -1, -22 },
  { 6564, 17, 35, 14, 0, -29 },
  { 6639, 5, 39, 22, 9, -30 },
  { 6664, 16, 35, 14, -2, -29 },
  { 6734, 20, 7, 23, 2, -18 },
};

const GFXfont NotoSans_ExtraBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRABOLDITALIC40PT7B_H_
