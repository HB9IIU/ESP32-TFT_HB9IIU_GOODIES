#ifndef _NOTOSANS_EXTRABOLDITALIC13PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x76, 0x66, 0x0E, 0xC0, 0x7E, 0xF4, 0x1B, 0x0D, 0x1F, 0xEF,
  0xE3, 0x47, 0xF8, 0xB0, 0xD8, 0x68, 0x00, 0x0C, 0x3C, 0xFB, 0x47, 0x87,
  0x87, 0xCB, 0xFC, 0x60, 0x80, 0x71, 0xB4, 0xCD, 0x62, 0xD6, 0xFF, 0xC6,
  0xB1, 0x2C, 0x8B, 0x63, 0x80, 0x1E, 0x1B, 0x0D, 0x87, 0x87, 0x9F, 0x7F,
  0x3D, 0xFC, 0x7F, 0x80, 0x7B, 0x00, 0x1C, 0xC2, 0x18, 0x61, 0x0C, 0x30,
  0x41, 0x86, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x66, 0x33, 0x30, 0x1A, 0x4F,
  0x4F, 0xF1, 0x60, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x36, 0x6C, 0xF0,
  0xF8, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x3E, 0xED,
  0x9B, 0x36, 0x7C, 0xFB, 0xBE, 0x78, 0x1D, 0xEF, 0xA6, 0x38, 0xC3, 0x0C,
  0x70, 0x3E, 0xFC, 0x18, 0x71, 0xC7, 0x1C, 0x7E, 0xFC, 0x7E, 0x4C, 0x19,
  0xE3, 0xC1, 0x83, 0xFE, 0xF8, 0x0E, 0x1C, 0x79, 0xE6, 0xDF, 0xFF, 0x8E,
  0x18, 0x3E, 0x7C, 0xC3, 0xE7, 0xC1, 0xC3, 0xFE, 0xF8, 0x3D, 0xCC, 0x3E,
  0xFF, 0x3D, 0xFE, 0xF0, 0x7F, 0x7E, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x70,
  0xE0, 0x3E, 0x6D, 0xD9, 0xE3, 0xCD, 0xF1, 0xF6, 0x7C, 0x7B, 0xBC, 0xF3,
  0xFD, 0xB1, 0xBE, 0xF0, 0x77, 0x00, 0x0E, 0xC0, 0x39, 0xC0, 0x00, 0x39,
  0x8C, 0xC0, 0x04, 0x77, 0x30, 0x78, 0x70, 0x40, 0xFF, 0xF0, 0x3F, 0xFC,
  0x83, 0x83, 0x83, 0x7B, 0x88, 0x00, 0xF9, 0x71, 0x8E, 0x61, 0x80, 0x30,
  0xC0, 0x3F, 0x98, 0x3C, 0xFF, 0x69, 0xB2, 0x6D, 0xBB, 0xFB, 0x6C, 0xE2,
  0x1F, 0x80, 0x07, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0xF8, 0xFC, 0xC6, 0xE3,
  0x80, 0x3F, 0x37, 0x33, 0x7E, 0x7E, 0x66, 0x66, 0x7E, 0xFC, 0x3F, 0x76,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x3E, 0x3F, 0x33, 0x73, 0x63,
  0x63, 0x67, 0x7E, 0xFC, 0x3F, 0x3E, 0x30, 0x7E, 0x7C, 0x60, 0x60, 0x7C,
  0xFC, 0x3F, 0x3E, 0x30, 0x72, 0x7C, 0x60, 0x60, 0x60, 0xE0, 0x3F, 0x72,
  0xE0, 0xC0, 0xCE, 0xD6, 0xC6, 0xFE, 0x7C, 0x31, 0x98, 0xCC, 0xEF, 0xE7,
  0xF3, 0x19, 0x8C, 0xCE, 0xE6, 0x00, 0x7C, 0xC3, 0x0C, 0x31, 0xC6, 0x3C,
  0xF0, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x73, 0xC7, 0x00,
  0x33, 0x9B, 0x8D, 0x8F, 0x87, 0xC3, 0x61, 0xB8, 0xCC, 0xE7, 0x00, 0x30,
  0xC3, 0x1C, 0x61, 0x86, 0x1F, 0xFC, 0x38, 0xF3, 0x8E, 0x39, 0xE6, 0x9E,
  0x6B, 0x66, 0xBC, 0x6E, 0xC6, 0xEC, 0xCC, 0xC0, 0x38, 0xCE, 0x32, 0xCD,
  0xB6, 0x6D, 0x99, 0xE6, 0x79, 0x9C, 0xC7, 0x00, 0x3E, 0x77, 0xE3, 0xC3,
  0xC3, 0xC7, 0xC6, 0xFE, 0x7C, 0x3E, 0x3F, 0x33, 0x77, 0x7E, 0x7C, 0x60,
  0x60, 0xE0, 0x3E, 0x77, 0xE3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0x7C, 0x1C,
  0x0E, 0x3E, 0x37, 0x33, 0x77, 0x7E, 0x7C, 0x6E, 0x66, 0xE7, 0x3E, 0xED,
  0xC3, 0x83, 0xC3, 0x83, 0x7E, 0xF8, 0xFF, 0xF8, 0xC1, 0x83, 0x0E, 0x18,
  0x30, 0x60, 0x63, 0x63, 0x67, 0xE6, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0xC7,
  0xC6, 0xCE, 0xCC, 0xD8, 0x58, 0x50, 0x70, 0x60, 0xC6, 0x3C, 0xE6, 0xCE,
  0x6D, 0xEC, 0xDE, 0xCD, 0x6C, 0xF7, 0x8E, 0x78, 0xE7, 0x00, 0x39, 0xC6,
  0x61, 0xF0, 0x38, 0x0E, 0x07, 0x83, 0x71, 0xCC, 0xE3, 0x00, 0xE7, 0x6C,
  0x6C, 0x78, 0x70, 0x30, 0x70, 0x60, 0x60, 0x7F, 0x7E, 0x0C, 0x1C, 0x38,
  0x70, 0x60, 0xFC, 0xFC, 0x39, 0x88, 0xC6, 0x31, 0x98, 0xC6, 0x38, 0xC4,
  0x66, 0x66, 0x62, 0x30, 0x3C, 0x21, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xCE,
  0x00, 0x08, 0x38, 0xF1, 0x26, 0x58, 0xC0, 0xFC, 0xCC, 0x77, 0xFB, 0x36,
  0x6D, 0xDF, 0x3E, 0x00, 0x30, 0x60, 0xC1, 0xF7, 0x6C, 0xD9, 0xB3, 0x7D,
  0xB8, 0x7F, 0xAC, 0x30, 0xC3, 0xCF, 0x00, 0x06, 0x0C, 0x1B, 0xEF, 0xD9,
  0xB3, 0x66, 0xF9, 0xF0, 0x7F, 0xBC, 0xFE, 0xC3, 0xEF, 0x80, 0x0E, 0x3C,
  0x61, 0xF3, 0xC7, 0x0C, 0x18, 0x30, 0x61, 0xC7, 0x0E, 0x00, 0x3B, 0x7E,
  0x66, 0x66, 0x6E, 0x7C, 0x7C, 0x0C, 0xFC, 0xF8, 0x30, 0x60, 0xC1, 0xF7,
  0x6C, 0xD9, 0xB3, 0x6F, 0x98, 0x33, 0x03, 0x76, 0x66, 0x6C, 0x0C, 0x30,
  0x03, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x3C, 0xE0, 0x30, 0x30, 0x30, 0x37,
  0x7E, 0x7C, 0x78, 0x6C, 0x6C, 0xCE, 0x33, 0x33, 0x76, 0x66, 0x6C, 0x2E,
  0xEE, 0xED, 0x99, 0xB3, 0x36, 0x66, 0xDD, 0xF3, 0x30, 0x2E, 0xED, 0x9B,
  0x36, 0x6D, 0xF3, 0x00, 0x7B, 0xBC, 0xF3, 0xCF, 0xEF, 0x00, 0x2E, 0xED,
  0x9B, 0x36, 0x6F, 0xB7, 0x60, 0xC1, 0x80, 0x77, 0xFB, 0x36, 0x6C, 0xDF,
  0x3E, 0x0C, 0x18, 0x70, 0x2D, 0xF7, 0x18, 0x61, 0x8C, 0x00, 0x7D, 0x97,
  0x0E, 0x1B, 0xEF, 0x80, 0x10, 0xC7, 0xFE, 0x61, 0x86, 0x1E, 0x78, 0xEF,
  0x9B, 0x36, 0x6D, 0xDF, 0xBA, 0x00, 0xCF, 0xBB, 0x66, 0xCF, 0x1E, 0x38,
  0x00, 0xDC, 0xF7, 0x6D, 0xDB, 0xFC, 0xEF, 0x3B, 0x8E, 0xE0, 0x33, 0x8F,
  0x87, 0x83, 0x83, 0xC1, 0xB3, 0x98, 0x33, 0x99, 0x8D, 0x86, 0xC3, 0xC1,
  0xE0, 0x60, 0x70, 0xF0, 0x70, 0x00, 0x7D, 0xF1, 0x8C, 0x63, 0xEF, 0x80,
  0x1C, 0xC3, 0x0C, 0xE3, 0x06, 0x18, 0x61, 0x86, 0x00, 0xFF, 0xF8, 0x38,
  0x61, 0x84, 0x18, 0x73, 0x0C, 0x23, 0x8E, 0x00, 0xE7, 0xF8, 0x80,
};

const GFXglyph NotoSans_ExtraBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 3, 6, 1, -9 },
  { 8, 9, 9, 8, 0, -9 },
  { 19, 7, 11, 7, 0, -10 },
  { 29, 10, 9, 12, 1, -9 },
  { 41, 9, 9, 9, 0, -9 },
  { 52, 3, 3, 3, 1, -9 },
  { 54, 6, 11, 5, 0, -9 },
  { 63, 5, 11, 5, -1, -9 },
  { 70, 6, 6, 7, 1, -10 },
  { 75, 6, 7, 8, 1, -8 },
  { 81, 4, 4, 4, -1, -2 },
  { 83, 4, 1, 4, 0, -4 },
  { 84, 3, 2, 4, 0, -2 },
  { 85, 8, 9, 6, -1, -9 },
  { 94, 7, 9, 7, 0, -9 },
  { 102, 6, 9, 7, 1, -9 },
  { 109, 7, 9, 7, 0, -9 },
  { 117, 7, 9, 7, 0, -9 },
  { 125, 7, 9, 7, 0, -9 },
  { 133, 7, 9, 7, 0, -9 },
  { 141, 6, 9, 7, 1, -9 },
  { 148, 8, 9, 7, 0, -9 },
  { 157, 7, 9, 7, 0, -9 },
  { 165, 6, 9, 7, 1, -9 },
  { 172, 4, 7, 4, 0, -7 },
  { 176, 5, 9, 4, -1, -7 },
  { 182, 6, 7, 8, 1, -8 },
  { 188, 6, 5, 8, 1, -7 },
  { 192, 6, 7, 8, 1, -8 },
  { 198, 6, 9, 6, 1, -9 },
  { 205, 10, 10, 11, 1, -9 },
  { 218, 9, 9, 8, -1, -9 },
  { 229, 8, 9, 8, 0, -9 },
  { 238, 8, 9, 8, 1, -9 },
  { 247, 8, 9, 9, 0, -9 },
  { 256, 8, 9, 7, 0, -9 },
  { 265, 8, 9, 7, 0, -9 },
  { 274, 8, 9, 9, 1, -9 },
  { 283, 9, 9, 9, 0, -9 },
  { 294, 6, 9, 5, 0, -9 },
  { 301, 7, 12, 5, -2, -9 },
  { 312, 9, 9, 8, 0, -9 },
  { 323, 6, 9, 7, 0, -9 },
  { 330, 12, 9, 12, 0, -9 },
  { 344, 10, 9, 10, 0, -9 },
  { 356, 8, 9, 10, 1, -9 },
  { 365, 8, 9, 8, 0, -9 },
  { 374, 8, 11, 10, 1, -9 },
  { 385, 8, 9, 8, 0, -9 },
  { 394, 7, 9, 7, 0, -9 },
  { 402, 7, 9, 7, 1, -9 },
  { 410, 8, 9, 9, 1, -9 },
  { 419, 8, 9, 8, 1, -9 },
  { 428, 12, 9, 12, 1, -9 },
  { 442, 10, 9, 8, -1, -9 },
  { 454, 8, 9, 8, 1, -9 },
  { 463, 8, 9, 7, 0, -9 },
  { 472, 5, 11, 4, 0, -9 },
  { 479, 4, 9, 6, 1, -9 },
  { 484, 6, 11, 4, -1, -9 },
  { 493, 7, 6, 7, 0, -9 },
  { 499, 6, 1, 6, -1, 1 },
  { 500, 3, 2, 4, 2, -10 },
  { 501, 7, 7, 8, 1, -7 },
  { 508, 7, 10, 8, 0, -10 },
  { 517, 6, 7, 6, 1, -7 },
  { 523, 7, 10, 8, 1, -10 },
  { 532, 6, 7, 7, 1, -7 },
  { 538, 7, 13, 5, -1, -10 },
  { 550, 8, 10, 8, 0, -7 },
  { 560, 7, 10, 8, 0, -10 },
  { 569, 4, 10, 4, 0, -10 },
  { 574, 6, 13, 4, -2, -10 },
  { 584, 8, 10, 8, 0, -10 },
  { 594, 4, 10, 4, 0, -10 },
  { 599, 11, 7, 12, 0, -7 },
  { 609, 7, 7, 8, 0, -7 },
  { 616, 6, 7, 8, 1, -7 },
  { 622, 7, 10, 8, 0, -7 },
  { 631, 7, 10, 8, 1, -7 },
  { 640, 6, 7, 6, 0, -7 },
  { 646, 6, 7, 6, 0, -7 },
  { 652, 6, 9, 6, 0, -9 },
  { 659, 7, 7, 8, 1, -7 },
  { 666, 7, 7, 7, 1, -7 },
  { 673, 10, 7, 10, 1, -7 },
  { 682, 9, 7, 7, -1, -7 },
  { 690, 9, 10, 7, -1, -7 },
  { 702, 6, 7, 6, 0, -7 },
  { 708, 6, 11, 5, 0, -9 },
  { 717, 1, 13, 7, 3, -10 },
  { 719, 6, 11, 5, -1, -9 },
  { 728, 6, 3, 8, 1, -6 },
};

const GFXfont NotoSans_ExtraBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRABOLDITALIC13PT7B_H_
