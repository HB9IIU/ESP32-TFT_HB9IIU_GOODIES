#ifndef _NOTOSANS_EXTRABOLDITALIC55PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x3F, 0xC7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xE0,
  0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xBC, 0xFC, 0x07, 0xFC,
  0xF0, 0x60, 0x3F, 0xE3, 0xC0, 0x00, 0xFF, 0x9E, 0x00, 0x03, 0xFE, 0x78,
  0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x0F,
  0x1F, 0xE0, 0x00, 0x3C, 0x7F, 0x8C, 0x00, 0xF1, 0xFE, 0x3C, 0x03, 0xCF,
  0xF8, 0xFF, 0x1F, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0xCF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x87,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00,
  0x0F, 0xE1, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x0F,
  0xE1, 0xFC, 0x7F, 0x1F, 0xFC, 0xFF, 0x3F, 0xCF, 0xE7, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xCF, 0xFF, 0xF7, 0xFF, 0xF3,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F, 0x1F, 0xE7, 0xF1, 0xFF, 0x8F, 0xE3,
  0xFC, 0x7F, 0x07, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFE, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x20, 0x1F, 0xC0, 0x0F, 0x03, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0xCF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xDF,
  0x80, 0x0F, 0xFB, 0xF8, 0x03, 0xFE, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3C, 0x1F, 0xC0, 0x01, 0x03, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00,
  0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0x0F, 0x87, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x7F, 0x83, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xBF, 0xE3, 0xFE, 0x7F, 0x87, 0xF9, 0xFF, 0x07,
  0xC3, 0xFE, 0x06, 0x07, 0xFC, 0x08, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x0F, 0xFE, 0x01, 0xF8, 0x0F, 0xFC, 0x01, 0xC0, 0x1F, 0xF8, 0x01, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xFC,
  0x01, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC8, 0x00, 0x03, 0xFF, 0x30, 0x00,
  0x1F, 0xF8, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x40, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0C, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE2, 0x00, 0x03, 0xFF,
  0x0C, 0x00, 0x1F, 0xFC, 0x3E, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0x80, 0x0F, 0xF9,
  0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0x00, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF,
  0x87, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE3,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xC3, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF,
  0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F,
  0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFB, 0xFE, 0x1F, 0xFE, 0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x01, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x05, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1E, 0x03, 0xFF, 0x18, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0,
  0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0x0F, 0xE0, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F,
  0x03, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0x3F, 0x83,
  0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xDF, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7E, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF7, 0xE0, 0xFE, 0x03,
  0xF0, 0x3F, 0xBF, 0x07, 0xF0, 0x1F, 0x81, 0xFD, 0xF8, 0x7F, 0x01, 0xFC,
  0x0F, 0xDF, 0xC3, 0xF8, 0x0F, 0xE0, 0x7E, 0xFE, 0x1F, 0xC0, 0x7E, 0x07,
  0xF7, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0xBF, 0x87, 0xF0, 0x3F, 0x83, 0xF9,
  0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE1,
  0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0x3F, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0x08, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x80, 0x0E, 0x03, 0xFF, 0x80, 0x01, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0x80, 0x7F, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xE0,
  0x3F, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0xFE, 0x3F,
  0xF0, 0x3F, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFB, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF8,
  0x07, 0xF9, 0xF8, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xF8, 0x0F, 0xEF, 0xF8,
  0x07, 0xF9, 0xF8, 0x1F, 0xCF, 0xF8, 0x0F, 0xF9, 0xF8, 0x1F, 0xCF, 0xF0,
  0x0F, 0xF9, 0xF8, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xF8, 0x3F, 0x8F, 0xF0,
  0x0F, 0xF1, 0xF8, 0x7F, 0x1F, 0xF0, 0x0F, 0xF1, 0xF8, 0x7F, 0x1F, 0xF0,
  0x1F, 0xF1, 0xFC, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFC, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFD, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFD, 0xFC, 0x3F, 0xE0,
  0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0x80,
  0x7F, 0xC1, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0xC0, 0x7F, 0x80,
  0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x0F,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x80,
  0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x00, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC7, 0xF8, 0x03, 0xFC, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xF0, 0x3F, 0xEF, 0xF8, 0x07,
  0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xE1, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03,
  0xE0, 0x3F, 0xE0, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC2, 0x00, 0x07, 0xFE, 0x1E, 0x00, 0x7F, 0xE0,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xD0, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFF,
  0x80, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x3F, 0xBF, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x80, 0xFF,
  0x07, 0xFB, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFC, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x3F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xCF, 0xE1, 0xFF, 0x00,
  0xFF, 0x0F, 0xE3, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x0F, 0xE7, 0xFC,
  0x00, 0xFF, 0x3F, 0x83, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F,
  0x80, 0x0F, 0xF7, 0xF8, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFC, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x82, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x41, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xF8,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x0F,
  0xFF, 0x3F, 0xC0, 0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFE, 0x1F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC,
  0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xE0,
  0x3F, 0xFF, 0x7F, 0x00, 0x7F, 0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0x80,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0x0F, 0xF0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0x80, 0xFF, 0x3F, 0xFC,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFC, 0x06, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x81,
  0xFF, 0x81, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x07,
  0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x07,
  0xFE, 0x00, 0x60, 0x7F, 0xF8, 0x7E, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x84, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xC1, 0xFC, 0x01, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF,
  0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x07,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0xF8, 0x01, 0xFF,
  0xDF, 0xF0, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x04, 0x00, 0x1F,
  0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x83, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFB,
  0xFF, 0xC0, 0x3F, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x02, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xE3, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE1, 0xFF,
  0x80, 0x3F, 0x8F, 0xFF, 0x00, 0xFE, 0x7F, 0xFE, 0x07, 0xFB, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x01,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0xC7, 0xFE,
  0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x87, 0xFC, 0x00, 0x1F, 0xCF, 0xFF, 0x00, 0x0F, 0xEF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x3F, 0xE0, 0x40, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0x87, 0xF0, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFE, 0xFF, 0x03,
  0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x01,
  0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F,
  0xC7, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0xF7, 0xFC,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x70, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0xE0, 0x7F, 0xBF, 0xF0, 0x3F, 0xDF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xC1,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x3C, 0x1F, 0xF0, 0x04, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE2, 0x00, 0x1F, 0xF1, 0x80, 0x1F, 0xF8, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x41, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x81,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x08, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0,
  0xFF, 0x81, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFD, 0xFC, 0x07, 0xFF,
  0xF7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFC, 0xFF, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xEF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F,
  0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xFF, 0xE1, 0xFF, 0x07, 0xF8, 0x7E, 0xFE,
  0x1F, 0xF0, 0x7F, 0x87, 0xEF, 0xC3, 0xFE, 0x07, 0xF8, 0xFE, 0xFC, 0x3F,
  0xE0, 0x7F, 0x8F, 0xCF, 0xC7, 0xFC, 0x07, 0xF9, 0xFC, 0xFC, 0x7F, 0xC0,
  0x7F, 0x9F, 0xCF, 0xC7, 0xF8, 0x07, 0xF9, 0xF8, 0xFC, 0xFF, 0x80, 0x7F,
  0xBF, 0x8F, 0xCF, 0xF0, 0x07, 0xFB, 0xF0, 0xFC, 0xFF, 0x00, 0x7F, 0xBF,
  0x0F, 0xDF, 0xE0, 0x07, 0xFF, 0xF0, 0xFD, 0xFE, 0x00, 0x7F, 0x7E, 0x0F,
  0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x01, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x80, 0x03, 0xFF,
  0x10, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 18, 40, 16, 0, -39 },
  { 91, 22, 14, 25, 5, -39 },
  { 130, 35, 39, 36, 1, -39 },
  { 301, 30, 45, 31, 1, -42 },
  { 470, 44, 41, 49, 3, -40 },
  { 696, 38, 41, 40, 1, -40 },
  { 891, 10, 14, 14, 5, -39 },
  { 909, 21, 49, 20, 2, -40 },
  { 1038, 22, 49, 20, -4, -40 },
  { 1173, 27, 27, 30, 4, -42 },
  { 1265, 27, 27, 32, 3, -33 },
  { 1357, 14, 13, 16, -3, -6 },
  { 1380, 16, 7, 18, 1, -18 },
  { 1394, 11, 10, 16, 0, -9 },
  { 1408, 30, 40, 24, -2, -40 },
  { 1558, 28, 41, 31, 2, -40 },
  { 1702, 23, 39, 31, 5, -39 },
  { 1815, 31, 40, 31, -1, -40 },
  { 1970, 30, 41, 31, 0, -40 },
  { 2124, 31, 39, 31, -1, -39 },
  { 2276, 30, 40, 31, 1, -39 },
  { 2426, 30, 41, 31, 2, -40 },
  { 2580, 31, 39, 31, 2, -39 },
  { 2732, 30, 41, 31, 1, -40 },
  { 2886, 27, 41, 31, 3, -40 },
  { 3025, 16, 32, 16, 0, -31 },
  { 3089, 19, 38, 16, -3, -31 },
  { 3180, 27, 30, 32, 3, -35 },
  { 3282, 27, 18, 32, 3, -28 },
  { 3343, 27, 30, 32, 3, -35 },
  { 3445, 24, 41, 26, 4, -40 },
  { 3568, 45, 45, 48, 2, -40 },
  { 3822, 35, 39, 36, -3, -39 },
  { 3993, 33, 39, 34, 1, -39 },
  { 4154, 33, 41, 34, 3, -40 },
  { 4324, 35, 39, 37, 1, -39 },
  { 4495, 31, 39, 30, 1, -39 },
  { 4647, 31, 39, 30, 1, -39 },
  { 4799, 35, 41, 38, 3, -40 },
  { 4979, 38, 39, 39, 1, -39 },
  { 5165, 27, 39, 22, -2, -39 },
  { 5297, 29, 51, 19, -9, -39 },
  { 5482, 39, 39, 35, 1, -39 },
  { 5673, 24, 39, 29, 1, -39 },
  { 5790, 48, 39, 49, 1, -39 },
  { 6024, 42, 39, 43, 1, -39 },
  { 6229, 36, 41, 40, 3, -40 },
  { 6414, 33, 39, 34, 1, -39 },
  { 6575, 36, 49, 40, 3, -40 },
  { 6796, 32, 39, 35, 1, -39 },
  { 6952, 29, 41, 30, 1, -40 },
  { 7101, 29, 39, 30, 4, -39 },
  { 7243, 35, 40, 38, 4, -39 },
  { 7418, 33, 39, 33, 5, -39 },
  { 7579, 50, 39, 50, 5, -39 },
  { 7823, 42, 39, 35, -3, -39 },
  { 8028, 32, 39, 32, 5, -39 },
  { 8184, 34, 39, 30, -2, -39 },
  { 8350, 24, 49, 19, -1, -40 },
  { 8497, 14, 40, 24, 6, -40 },
  { 8567, 24, 49, 19, -4, -40 },
  { 8714, 29, 25, 30, 0, -39 },
  { 8805, 25, 5, 23, -5, 4 },
  { 8821, 12, 9, 19, 8, -42 },
  { 8835, 30, 32, 33, 2, -31 },
  { 8955, 30, 43, 33, 1, -42 },
  { 9117, 26, 32, 27, 2, -31 },
  { 9221, 33, 43, 33, 2, -42 },
  { 9399, 28, 32, 31, 2, -31 },
  { 9511, 33, 55, 22, -6, -42 },
  { 9738, 31, 44, 33, 1, -31 },
  { 9909, 30, 42, 34, 1, -42 },
  { 10067, 17, 42, 17, 1, -42 },
  { 10157, 26, 55, 17, -7, -42 },
  { 10336, 34, 42, 33, 1, -42 },
  { 10515, 18, 42, 17, 1, -42 },
  { 10610, 47, 31, 50, 1, -31 },
  { 10793, 30, 31, 34, 1, -31 },
  { 10910, 28, 32, 33, 2, -31 },
  { 11022, 33, 44, 33, -2, -31 },
  { 11204, 30, 44, 33, 2, -31 },
  { 11369, 25, 31, 24, 1, -31 },
  { 11466, 25, 32, 27, 1, -31 },
  { 11566, 23, 37, 24, 2, -36 },
  { 11673, 30, 31, 34, 3, -30 },
  { 11790, 29, 30, 29, 3, -30 },
  { 11899, 44, 30, 44, 3, -30 },
  { 12064, 36, 30, 30, -3, -30 },
  { 12199, 36, 43, 29, -4, -30 },
  { 12393, 28, 30, 26, -1, -30 },
  { 12498, 23, 48, 20, 0, -39 },
  { 12636, 7, 54, 31, 12, -42 },
  { 12684, 23, 48, 20, -3, -39 },
  { 12822, 27, 10, 32, 3, -24 },
};

const GFXfont NotoSans_ExtraBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRABOLDITALIC55PT7B_H_
