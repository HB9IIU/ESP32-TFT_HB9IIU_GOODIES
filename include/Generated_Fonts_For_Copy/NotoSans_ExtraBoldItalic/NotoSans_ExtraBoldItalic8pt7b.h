#ifndef _NOTOSANS_EXTRABOLDITALIC8PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xBC, 0x29, 0x9E, 0xAF, 0xB0, 0x27, 0x63, 0xB6,
  0x64, 0xD2, 0xB3, 0xD2, 0xA9, 0x80, 0x31, 0x67, 0x1B, 0xDB, 0xE0, 0xC0,
  0x29, 0x69, 0x10, 0x22, 0x33, 0x22, 0xC0, 0x6F, 0xCA, 0x22, 0xF2, 0xE0,
  0xC0, 0xC0, 0x12, 0x24, 0x48, 0x35, 0xDD, 0xD6, 0x3F, 0xA5, 0x80, 0x75,
  0x12, 0x4F, 0x75, 0x37, 0x1F, 0x13, 0x5F, 0xF2, 0x7A, 0x18, 0xE1, 0x70,
  0x3B, 0x1D, 0xAD, 0x38, 0x78, 0x8C, 0x46, 0x60, 0x35, 0x77, 0x9F, 0x75,
  0xD7, 0x3E, 0x43, 0x43, 0x80, 0x16, 0xE1, 0xFF, 0x86, 0x3C, 0xF5, 0xC1,
  0x00, 0x18, 0xCD, 0xED, 0x5B, 0xC8, 0x0E, 0x00, 0x31, 0x9C, 0xAF, 0xCC,
  0x72, 0xD6, 0xED, 0xF8, 0x3B, 0x51, 0x8C, 0x38, 0x72, 0xD2, 0x9D, 0xF8,
  0x7A, 0x1C, 0xEC, 0x78, 0x7A, 0x10, 0xEC, 0x60, 0x3B, 0x51, 0xB5, 0xBC,
  0x6D, 0x27, 0x9E, 0xDB, 0x60, 0x76, 0x44, 0x4E, 0x33, 0x22, 0x26, 0x4C,
  0x6D, 0x67, 0x1C, 0xD3, 0x60, 0x64, 0x44, 0xCF, 0x66, 0xCD, 0xAB, 0x7F,
  0x56, 0x80, 0x65, 0x97, 0x57, 0xDA, 0x60, 0x39, 0xA4, 0xF3, 0xC9, 0xC0,
  0x72, 0xD6, 0xEC, 0x60, 0x39, 0xA4, 0xF3, 0xC9, 0xC1, 0x80, 0x72, 0xD6,
  0xED, 0x6C, 0x35, 0x63, 0x3E, 0xF4, 0x44, 0xC8, 0xDC, 0xA5, 0x2B, 0x70,
  0x99, 0xAA, 0xCC, 0x93, 0x6A, 0xD6, 0xED, 0x9B, 0x00, 0x4D, 0xE3, 0x1C,
  0x52, 0x60, 0x9B, 0xA4, 0xCC, 0x78, 0x88, 0xCC, 0x78, 0x69, 0x2D, 0x30,
  0xAA, 0x50, 0x31, 0x22, 0x22, 0xE0, 0x22, 0x59, 0xF0, 0xC0, 0x7E, 0xB4,
  0xE0, 0x64, 0x75, 0xDF, 0x7C, 0xC6, 0x08, 0xDD, 0xAD, 0x38, 0x7F, 0xC7,
  0x19, 0x9C, 0x42, 0x31, 0x98, 0x7E, 0xB4, 0xE3, 0x70, 0x62, 0x1E, 0xAD,
  0x68, 0x61, 0x2D, 0x80, 0x30, 0x22, 0x66, 0x4C, 0x62, 0x54, 0xCF, 0x68,
  0x69, 0x2D, 0x80, 0x7E, 0xA7, 0x5E, 0xA0, 0x7A, 0xB5, 0xA0, 0x7D, 0xD7,
  0x75, 0xDB, 0x88, 0x7E, 0xB4, 0xE3, 0x10, 0x74, 0xCC, 0x76, 0x2E, 0x7E,
  0x4C, 0x60, 0x5A, 0xB4, 0xE0, 0xDB, 0x98, 0xC0, 0xD6, 0xE9, 0xE2, 0xC0,
  0x5B, 0x19, 0x60, 0x6C, 0xE3, 0x0C, 0x23, 0x00, 0x76, 0x4E, 0x2D, 0x64,
  0xB0, 0xFF, 0x49, 0x35, 0xA0, 0x5B,
};

const GFXglyph NotoSans_ExtraBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 6, 5, 0, -6 },
  { 12, 7, 6, 7, 0, -6 },
  { 18, 6, 6, 6, 0, -6 },
  { 23, 1, 2, 2, 1, -6 },
  { 24, 3, 7, 3, 0, -6 },
  { 27, 4, 7, 3, -1, -6 },
  { 31, 4, 4, 4, 1, -6 },
  { 33, 4, 4, 5, 0, -5 },
  { 35, 2, 2, 2, 0, -1 },
  { 36, 2, 1, 3, 0, -3 },
  { 37, 2, 1, 2, 0, -1 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 5, 0, -6 },
  { 44, 3, 6, 5, 1, -6 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 4, 6, 5, 0, -6 },
  { 71, 4, 6, 5, 0, -6 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 2, 5, 2, 0, -4 },
  { 77, 4, 4, 5, 0, -5 },
  { 79, 4, 2, 5, 0, -4 },
  { 80, 4, 4, 5, 0, -5 },
  { 82, 3, 6, 4, 1, -6 },
  { 85, 7, 7, 7, 0, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 5, 6, 5, 0, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 5, 6, 4, 0, -6 },
  { 112, 5, 6, 4, 0, -6 },
  { 116, 5, 6, 6, 0, -6 },
  { 120, 6, 6, 6, 0, -6 },
  { 125, 4, 6, 3, 0, -6 },
  { 128, 4, 8, 3, -1, -6 },
  { 132, 6, 6, 5, 0, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 7, 6, 7, 0, -6 },
  { 146, 6, 6, 6, 0, -6 },
  { 151, 6, 6, 6, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 6, 7, 6, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 4, 6, 4, 0, -6 },
  { 173, 4, 6, 4, 1, -6 },
  { 176, 5, 6, 6, 1, -6 },
  { 180, 4, 6, 5, 1, -6 },
  { 183, 7, 6, 7, 1, -6 },
  { 189, 6, 6, 5, 0, -6 },
  { 194, 4, 6, 5, 1, -6 },
  { 197, 5, 6, 4, 0, -6 },
  { 201, 3, 7, 3, 0, -6 },
  { 204, 2, 6, 4, 1, -6 },
  { 206, 4, 7, 3, -1, -6 },
  { 210, 4, 4, 4, 0, -6 },
  { 212, 4, 1, 3, -1, 0 },
  { 213, 2, 1, 3, 1, -6 },
  { 214, 5, 4, 5, 0, -4 },
  { 217, 4, 6, 5, 0, -6 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 5, 6, 5, 0, -6 },
  { 226, 4, 4, 5, 0, -4 },
  { 228, 5, 8, 3, -1, -6 },
  { 233, 5, 6, 5, 0, -4 },
  { 237, 5, 6, 5, 0, -6 },
  { 241, 3, 6, 2, 0, -6 },
  { 244, 4, 8, 2, -1, -6 },
  { 248, 5, 6, 5, 0, -6 },
  { 252, 3, 6, 2, 0, -6 },
  { 255, 7, 4, 7, 0, -4 },
  { 259, 5, 4, 5, 0, -4 },
  { 262, 4, 4, 5, 0, -4 },
  { 264, 4, 6, 5, 0, -4 },
  { 267, 5, 6, 5, 0, -4 },
  { 271, 4, 4, 3, 0, -4 },
  { 273, 4, 4, 4, 0, -4 },
  { 275, 4, 5, 3, 0, -5 },
  { 278, 5, 4, 5, 0, -4 },
  { 281, 5, 4, 4, 0, -4 },
  { 284, 7, 4, 6, 0, -4 },
  { 288, 5, 4, 4, 0, -4 },
  { 291, 6, 6, 4, -1, -4 },
  { 296, 4, 4, 4, 0, -4 },
  { 298, 3, 7, 3, 0, -6 },
  { 301, 1, 8, 4, 2, -6 },
  { 302, 3, 7, 3, 0, -6 },
  { 305, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRABOLDITALIC8PT7B_H_
