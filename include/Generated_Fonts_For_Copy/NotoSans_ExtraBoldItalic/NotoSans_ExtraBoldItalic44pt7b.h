#ifndef _NOTOSANS_EXTRABOLDITALIC44PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x04,
  0x00, 0x3F, 0x1F, 0xBF, 0x9F, 0xDF, 0x8F, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3,
  0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xF7, 0x7C, 0x1F, 0xEF, 0x0C, 0x1F, 0xCE, 0x00, 0x1F,
  0xCE, 0x00, 0x1F, 0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3B, 0xFC, 0x00, 0x39, 0xFC, 0x80,
  0x79, 0xFC, 0xE0, 0x73, 0xF8, 0xFC, 0x77, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x7F, 0xC0, 0x03, 0xF0, 0x0F,
  0xFE, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x3F, 0x3F, 0x01, 0xF0, 0x07, 0xE3, 0xF0,
  0x3E, 0x00, 0x7E, 0x3F, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x7C,
  0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xF1, 0xF0, 0x00, 0xFC, 0x3E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE7, 0xE3, 0xF8, 0x7C, 0xFE, 0x7C, 0xFF, 0xC7, 0xFF, 0xCF,
  0xDF, 0xFE, 0x7F, 0xFD, 0xFB, 0xFF, 0xE3, 0xFF, 0xBF, 0x3F, 0xFF, 0x1F,
  0xE3, 0xE7, 0xF3, 0xF0, 0x7C, 0x7E, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE3,
  0xF0, 0x01, 0xF8, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0x0F, 0xC0, 0xFC, 0x7E, 0x00,
  0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF0, 0x07, 0xFF,
  0xC0, 0x7E, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0x0F, 0xFF, 0x83, 0xFC, 0x7F, 0xFE, 0x0F, 0xE3, 0xFF, 0xFC,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0xFF, 0x1F, 0xEF, 0xF3, 0xFC, 0x3F, 0xFF,
  0x8F, 0xE0, 0x7F, 0xFC, 0x3F, 0x80, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0x83,
  0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xC7, 0xFC, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x04, 0x07, 0xC0,
  0x38, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0xEF, 0x00, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFE, 0x7C,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x3E, 0x03, 0xF9, 0xF8, 0x07, 0x8F,
  0xC0, 0x18, 0x3F, 0x00, 0x41, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0x00, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x3F, 0xBF, 0xFF,
  0xFF, 0xF7, 0xF9, 0xF8, 0x20, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F,
  0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0,
  0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x01, 0xFE, 0xFE, 0x03,
  0xFD, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F,
  0xBF, 0xC0, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x1F, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x1F, 0x9F, 0xC7, 0xC7, 0xF0, 0xC1, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF7,
  0xFE, 0x03, 0xC0, 0xFF, 0x00, 0xC0, 0x7F, 0x80, 0x40, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xE1, 0xFF, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x80, 0x03, 0xFC, 0xE0, 0x07,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xF3,
  0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x80, 0x07, 0xF8, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x38, 0x07,
  0xF3, 0xFC, 0x0F, 0xEF, 0xFC, 0x1F, 0xBF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0x8F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07,
  0xF1, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF1, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xC7, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x87, 0xF8, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0x9F, 0xE0, 0xFF,
  0x7F, 0x81, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F,
  0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFE, 0xFE, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x0F, 0x7F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x1F, 0x81, 0xFC, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x87, 0xF8, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xF8, 0x7E, 0x3F, 0x03,
  0xFF, 0xE3, 0xE3, 0xE0, 0x7F, 0xFE, 0x3E, 0x7E, 0x0F, 0xFF, 0xC3, 0xF7,
  0xC1, 0xFC, 0x7C, 0x3F, 0x7C, 0x3F, 0x07, 0xC3, 0xFF, 0xC3, 0xE0, 0xFC,
  0x3F, 0xF8, 0x7E, 0x0F, 0x83, 0xEF, 0x87, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C,
  0x0F, 0x83, 0xEF, 0x8F, 0xC1, 0xF8, 0x7E, 0xF8, 0xFC, 0x1F, 0x07, 0xCF,
  0x8F, 0xC3, 0xF0, 0xFC, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0x87, 0xFF, 0xFF,
  0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFE, 0xFF, 0xE0, 0x7C, 0x1F,
  0xC7, 0xF8, 0x07, 0xE0, 0x30, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8,
  0x3F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xC7, 0xE0, 0x7F, 0xC0, 0x1C, 0x1F, 0xF0, 0x00, 0x83,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x08, 0x0F, 0xF8, 0x07, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xFC, 0x3F, 0x80,
  0xFF, 0x87, 0xF8, 0x1F, 0xF8, 0x7F, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xC0, 0x0C,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFF,
  0xE7, 0xF8, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xC7, 0xF0, 0x7F, 0xFC, 0xFF,
  0x07, 0xFF, 0xCF, 0xF0, 0x7F, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07,
  0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0x83, 0xFE,
  0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xF7, 0xE0, 0x3F, 0xFE, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xBF, 0x80, 0xFD, 0xF8, 0x3F, 0x7F, 0x01,
  0xFB, 0xF0, 0x7C, 0xFE, 0x07, 0xF7, 0xE1, 0xF9, 0xF8, 0x0F, 0xE7, 0xC3,
  0xE7, 0xF0, 0x1F, 0xCF, 0x8F, 0xCF, 0xE0, 0x3F, 0x1F, 0x1F, 0x1F, 0xC0,
  0x7E, 0x3E, 0x7E, 0x3F, 0x01, 0xFC, 0x7C, 0xF8, 0x7E, 0x03, 0xF8, 0xFB,
  0xF1, 0xFC, 0x07, 0xF1, 0xF7, 0xE3, 0xF8, 0x0F, 0xC3, 0xFF, 0x87, 0xF0,
  0x3F, 0x87, 0xFF, 0x0F, 0xC0, 0x7F, 0x0F, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0x1F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF8, 0x07,
  0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x1F, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x80,
  0xFE, 0x07, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFB, 0xF8,
  0x3F, 0x81, 0xF9, 0xFC, 0x1F, 0xC0, 0xFC, 0xFE, 0x0F, 0xE0, 0x7E, 0x3F,
  0x07, 0xE0, 0x7F, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE3, 0xF8, 0x1F, 0xC3,
  0xF1, 0xFC, 0x0F, 0xC1, 0xFC, 0xFC, 0x07, 0xE0, 0xFE, 0x7E, 0x07, 0xF0,
  0x7F, 0x3F, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x3F,
  0x80, 0x7F, 0xF8, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFC, 0x0F,
  0xE0, 0x07, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F,
  0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFD, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00,
  0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xCF, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF9,
  0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0x3E, 0x07, 0xF0, 0x0C, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x80, 0x0F, 0xE1,
  0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F,
  0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xF0,
  0x1F, 0x83, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xBE, 0x0F, 0xE0, 0xFE, 0x1F, 0xBE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xBE, 0x1F, 0xC0, 0xFE, 0x3F, 0x3E, 0x1F, 0xC0, 0xFE, 0x3F, 0x3E,
  0x1F, 0xC0, 0xFE, 0x3F, 0x3E, 0x3F, 0x80, 0xFE, 0x7E, 0x3E, 0x3F, 0x80,
  0xFE, 0x7E, 0x3E, 0x7F, 0x00, 0xFE, 0xFC, 0x3E, 0x7F, 0x00, 0xFE, 0xFC,
  0x3E, 0x7E, 0x00, 0xFC, 0xF8, 0x3E, 0xFE, 0x00, 0xFD, 0xF8, 0x3E, 0xFE,
  0x00, 0xFD, 0xF8, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F,
  0x80, 0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xF0, 0x03, 0xFF,
  0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x20,
  0x00, 0x01, 0xFE, 0x3F, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0x7E, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF7, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF7, 0xE0, 0x1F, 0xC7,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0xC0, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81,
  0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFC, 0xFF,
  0xC0, 0xFC, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xF3, 0xC3, 0xFC, 0x04,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x20, 0x7F,
  0x00, 0x7F, 0x3F, 0xC0, 0x7F, 0xEF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xDF, 0x80, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3,
  0xFE, 0x1F, 0xCF, 0xF0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x04, 0x3F,
  0xE0, 0x70, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFE, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x33, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0xFF, 0xEF, 0xC0, 0xFF, 0xF7,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x08, 0x01, 0xFE, 0x07, 0x83, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x40, 0x07, 0xF7, 0xF8, 0x0F,
  0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x00, 0x70, 0x07, 0xE0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF0, 0x7F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x3E, 0x1F, 0xC0, 0xFF, 0x03, 0xF3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xBF, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xEF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xE7, 0xFF, 0x9F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFF, 0x83, 0xF8, 0xFF, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xFE, 0x7F,
  0x81, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xFE, 0x7F, 0x81,
  0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xC7, 0xF8, 0x0F,
  0xCF, 0xFC, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF3, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x7F, 0x81, 0xFD, 0xFE, 0x07, 0xF7,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xF0, 0xFF,
  0x3F, 0xE7, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x1F, 0xC0,
  0x07, 0xE7, 0xFC, 0x00, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0x00, 0xFE,
  0xFF, 0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFE,
  0x3F, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xE7, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x3E,
  0x0F, 0xEF, 0xE0, 0xFD, 0xFE, 0x0F, 0xDF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE4, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x3F, 0xC1, 0xC3, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x80, 0x3F, 0x8E, 0x07, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF8, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFB, 0xF0, 0x7F, 0xFB,
  0xF0, 0x3F, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x7F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF7,
  0xE0, 0x7F, 0xC0, 0xFE, 0x7E, 0x07, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0xC1,
  0xFC, 0x7E, 0x0F, 0xFC, 0x3F, 0xC7, 0xE0, 0xFF, 0xC3, 0xF8, 0x7E, 0x1F,
  0x7C, 0x7F, 0x87, 0xE1, 0xF7, 0xC7, 0xF0, 0x7E, 0x3F, 0xFC, 0x7F, 0x07,
  0xE3, 0xEF, 0xCF, 0xE0, 0x7E, 0x3E, 0xFC, 0xFE, 0x07, 0xE7, 0xEF, 0xDF,
  0xC0, 0x7E, 0x7C, 0xF9, 0xFC, 0x07, 0xEF, 0xCF, 0x9F, 0x80, 0x7E, 0xF8,
  0xFB, 0xF8, 0x07, 0xEF, 0x8F, 0xBF, 0x00, 0x7F, 0xF8, 0xFB, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0x80, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7E,
  0x3F, 0x80, 0x03, 0xF3, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x09, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xE0, 0x05, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE8, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 32, 13, 0, -31 },
  { 61, 17, 11, 20, 4, -31 },
  { 85, 28, 31, 28, 1, -31 },
  { 194, 24, 36, 25, 1, -33 },
  { 302, 36, 32, 39, 2, -32 },
  { 446, 30, 32, 32, 1, -32 },
  { 566, 8, 11, 11, 4, -31 },
  { 577, 17, 39, 16, 2, -32 },
  { 660, 17, 39, 16, -3, -32 },
  { 743, 21, 22, 24, 4, -34 },
  { 801, 22, 21, 25, 2, -26 },
  { 859, 11, 11, 13, -2, -5 },
  { 875, 12, 6, 14, 1, -15 },
  { 884, 9, 8, 13, 0, -7 },
  { 893, 25, 32, 20, -2, -32 },
  { 993, 23, 32, 25, 1, -32 },
  { 1085, 18, 31, 25, 4, -31 },
  { 1155, 25, 32, 25, -1, -32 },
  { 1255, 24, 32, 25, 0, -32 },
  { 1351, 24, 31, 25, 0, -31 },
  { 1444, 24, 31, 25, 1, -31 },
  { 1537, 23, 32, 25, 2, -32 },
  { 1629, 26, 31, 25, 1, -31 },
  { 1730, 24, 32, 25, 1, -32 },
  { 1826, 22, 32, 25, 2, -32 },
  { 1914, 13, 26, 13, 0, -25 },
  { 1957, 15, 31, 13, -2, -25 },
  { 2016, 22, 24, 25, 2, -28 },
  { 2082, 22, 15, 25, 2, -23 },
  { 2124, 22, 24, 25, 2, -28 },
  { 2190, 19, 33, 21, 3, -32 },
  { 2269, 36, 36, 39, 2, -32 },
  { 2431, 29, 31, 29, -3, -31 },
  { 2544, 26, 31, 28, 1, -31 },
  { 2645, 27, 32, 27, 2, -32 },
  { 2753, 28, 31, 30, 1, -31 },
  { 2862, 25, 31, 24, 1, -31 },
  { 2959, 25, 31, 24, 1, -31 },
  { 3056, 28, 32, 31, 2, -32 },
  { 3168, 30, 31, 31, 1, -31 },
  { 3285, 21, 31, 18, -1, -31 },
  { 3367, 23, 41, 15, -7, -31 },
  { 3485, 31, 31, 28, 1, -31 },
  { 3606, 19, 31, 23, 1, -31 },
  { 3680, 39, 31, 39, 1, -31 },
  { 3832, 33, 31, 34, 1, -31 },
  { 3960, 29, 32, 32, 2, -32 },
  { 4076, 26, 31, 27, 1, -31 },
  { 4177, 29, 39, 32, 2, -32 },
  { 4319, 25, 31, 28, 1, -31 },
  { 4416, 23, 32, 24, 1, -32 },
  { 4508, 24, 31, 24, 3, -31 },
  { 4601, 28, 31, 31, 3, -31 },
  { 4710, 26, 31, 26, 4, -31 },
  { 4811, 40, 31, 40, 4, -31 },
  { 4966, 34, 31, 28, -3, -31 },
  { 5098, 25, 31, 26, 4, -31 },
  { 5195, 28, 31, 24, -2, -31 },
  { 5304, 19, 39, 15, -1, -32 },
  { 5397, 11, 32, 20, 5, -32 },
  { 5441, 19, 39, 15, -3, -32 },
  { 5534, 23, 21, 24, 0, -32 },
  { 5595, 20, 4, 19, -4, 3 },
  { 5605, 10, 7, 15, 6, -34 },
  { 5614, 24, 25, 26, 2, -25 },
  { 5689, 24, 33, 26, 1, -33 },
  { 5788, 20, 25, 22, 2, -25 },
  { 5851, 26, 33, 26, 2, -33 },
  { 5959, 22, 25, 25, 2, -25 },
  { 6028, 27, 45, 17, -5, -34 },
  { 6180, 25, 36, 26, 1, -25 },
  { 6293, 24, 33, 27, 1, -33 },
  { 6392, 14, 34, 14, 1, -34 },
  { 6452, 21, 45, 14, -6, -34 },
  { 6571, 27, 33, 26, 1, -33 },
  { 6683, 14, 33, 14, 1, -33 },
  { 6741, 37, 25, 40, 1, -25 },
  { 6857, 24, 25, 27, 1, -25 },
  { 6932, 22, 25, 26, 2, -25 },
  { 7001, 27, 36, 26, -2, -25 },
  { 7123, 24, 36, 26, 2, -25 },
  { 7231, 20, 25, 19, 1, -25 },
  { 7294, 20, 25, 21, 1, -25 },
  { 7357, 18, 29, 19, 2, -29 },
  { 7423, 24, 24, 27, 2, -24 },
  { 7495, 24, 24, 23, 2, -24 },
  { 7567, 36, 24, 35, 2, -24 },
  { 7675, 29, 24, 24, -2, -24 },
  { 7762, 29, 35, 23, -3, -24 },
  { 7889, 23, 24, 21, -1, -24 },
  { 7958, 19, 38, 16, 0, -31 },
  { 8049, 5, 43, 25, 10, -33 },
  { 8076, 18, 38, 16, -2, -31 },
  { 8162, 22, 7, 25, 2, -19 },
};

const GFXfont NotoSans_ExtraBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRABOLDITALIC44PT7B_H_
