#ifndef _NOTOSANS_EXTRABOLDITALIC60PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x7F, 0x87, 0xFD, 0xFF, 0x0F, 0xF3, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F,
  0xCF, 0xF0, 0xFF, 0x9F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF9,
  0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7B,
  0xF8, 0x0F, 0xFC, 0xF8, 0x38, 0x0F, 0xF8, 0xF8, 0x08, 0x0F, 0xF8, 0xF0,
  0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x0F, 0xF9, 0xF0, 0x00, 0x0F, 0xFD, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xBF, 0xF8, 0x00, 0x07, 0x9F,
  0xF8, 0x00, 0x07, 0x8F, 0xF8, 0x00, 0x0F, 0x8F, 0xF8, 0x80, 0x0F, 0x8F,
  0xF8, 0xE0, 0x0F, 0x1F, 0xF0, 0xFE, 0x0F, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x7F, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xFF, 0x0F, 0xF3, 0xFE,
  0x7F, 0x9F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x3F, 0xCF, 0xF9, 0xFE, 0x1F, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0x03, 0xFE,
  0x1F, 0xC3, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x1F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x40, 0x3F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0xDF, 0xFC, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xEF, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0xC0, 0x1F, 0xC0, 0x07, 0x81, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1C, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF9, 0xFC,
  0x01, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xC3, 0xFC, 0x00,
  0x3C, 0x0F, 0xF0, 0x00, 0xE0, 0x7F, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x07,
  0x81, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F,
  0xE7, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x00,
  0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x07,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB,
  0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xC7, 0xFF, 0x7F, 0xE1, 0xFF, 0x3F, 0xF0, 0xFE, 0x1F,
  0xF0, 0x3C, 0x1F, 0xF8, 0x1C, 0x0F, 0xFC, 0x04, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xF0,
  0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x60, 0x03, 0xFF, 0x00, 0x08, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0x38, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x60, 0x00, 0x1F, 0xFE, 0x3E, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xE7, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x3F, 0xF8, 0x3C, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x17,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xF8, 0x07, 0xFD, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x01, 0xFF,
  0x9F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xF7,
  0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0,
  0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xF9, 0xFF,
  0x03, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x20, 0x03, 0xFF, 0xC0, 0xF9, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0x80, 0xFF, 0xC3, 0x00, 0x3F, 0xF0, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7C, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFF,
  0xE0, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x7F, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x3F, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0x7F, 0x81, 0xFF, 0x8F, 0xF0, 0x7F, 0x7F, 0x03, 0xFE, 0x0F,
  0xE0, 0x7F, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0xFE, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0xFE, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0xFE, 0x1F, 0xF1, 0xFF,
  0x8F, 0xF8, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0x8F,
  0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0x08, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x30, 0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE,
  0x00, 0x0E, 0x01, 0xFF, 0xE0, 0x00, 0x08, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F,
  0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xE3, 0xFF, 0x80, 0xFF,
  0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x7D, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00,
  0x1F, 0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x7F,
  0x00, 0x3F, 0xBF, 0xE0, 0x0F, 0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F,
  0xDF, 0xC0, 0x1F, 0xCF, 0xF8, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xE7, 0xF0, 0x0F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0x80, 0xFF, 0x3F,
  0xE0, 0x0F, 0xF9, 0xFC, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xE0, 0x7F,
  0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xF8,
  0x3F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFE, 0x1F, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF0, 0x03,
  0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0x7F, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xBF, 0xC3,
  0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFD, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xDF,
  0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0xF8, 0x07, 0xFF, 0x00, 0x18, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x80,
  0x00, 0x7F, 0xE0, 0xF0, 0x00, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFB,
  0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xF0, 0x07, 0xF8,
  0x3F, 0xCF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x9F, 0xE1, 0xFF, 0x80,
  0x1F, 0xE1, 0xFF, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x7F, 0x87,
  0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x1F, 0xE1,
  0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0x07, 0xF9, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x0F, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xF9, 0xFF,
  0x03, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x7F, 0xC0, 0x1F, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x81, 0x00, 0x01, 0xFF, 0x1F, 0xE0,
  0x01, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF,
  0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFF,
  0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF, 0x80,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x60, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x04,
  0x1F, 0xFC, 0x03, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFB,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0x9F, 0xE0, 0x01,
  0xFF, 0xE7, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xE0,
  0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x06, 0x0F, 0xFF, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x02, 0xD0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x40, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xC3, 0xFC, 0x01, 0xFF, 0xF9, 0xFF,
  0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x08, 0x00, 0x0F, 0xFC, 0x03, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x18,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xF0, 0x07, 0xFE, 0xFF,
  0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0x87, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x3F, 0xCF, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0x8F, 0xFF,
  0x00, 0x7F, 0x8F, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF,
  0x80, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xBF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xFC, 0x00, 0x3F,
  0xCF, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xFE,
  0x00, 0xFF, 0xDF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFD, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xC0, 0x3F, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xC1, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8,
  0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFB, 0xFF, 0x80,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x82, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x07, 0x83, 0xFF, 0x00, 0x20, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x80, 0x03, 0xFF, 0x18, 0x00,
  0x7F, 0xE3, 0xE0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x40, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0xF0, 0x7F, 0xFB, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFC,
  0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x80, 0x3F,
  0xE3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F,
  0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFB,
  0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFB, 0xF8, 0x7F, 0xE0, 0x7F, 0xC7, 0xFB,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xF3, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xF3,
  0xF8, 0xFF, 0x80, 0x7F, 0xCF, 0xE3, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xE3,
  0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xE3, 0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xC3,
  0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xC3, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0x83,
  0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x83,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xA0, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 44, 18, 1, -43 },
  { 106, 23, 16, 27, 6, -43 },
  { 152, 38, 43, 39, 1, -43 },
  { 357, 32, 49, 34, 2, -46 },
  { 553, 49, 44, 53, 3, -43 },
  { 823, 42, 45, 43, 1, -44 },
  { 1060, 11, 16, 15, 6, -43 },
  { 1082, 23, 52, 21, 2, -43 },
  { 1232, 23, 53, 21, -4, -44 },
  { 1385, 29, 29, 33, 5, -46 },
  { 1491, 29, 29, 35, 3, -36 },
  { 1597, 15, 15, 18, -3, -7 },
  { 1626, 17, 8, 20, 1, -20 },
  { 1643, 12, 11, 18, 0, -10 },
  { 1660, 34, 43, 27, -3, -43 },
  { 1843, 31, 45, 34, 2, -44 },
  { 2018, 25, 43, 34, 5, -43 },
  { 2153, 34, 43, 34, -2, -43 },
  { 2336, 33, 44, 34, 0, -43 },
  { 2518, 34, 43, 34, -1, -43 },
  { 2701, 33, 44, 34, 1, -43 },
  { 2883, 33, 45, 34, 2, -44 },
  { 3069, 34, 43, 34, 2, -43 },
  { 3252, 31, 45, 34, 2, -44 },
  { 3427, 30, 45, 34, 3, -44 },
  { 3596, 17, 34, 18, 0, -33 },
  { 3669, 20, 41, 18, -3, -33 },
  { 3772, 29, 32, 35, 3, -38 },
  { 3888, 29, 20, 35, 3, -31 },
  { 3961, 29, 32, 35, 3, -38 },
  { 4077, 26, 44, 28, 4, -43 },
  { 4220, 48, 48, 53, 3, -43 },
  { 4508, 39, 43, 39, -4, -43 },
  { 4718, 36, 43, 38, 1, -43 },
  { 4912, 36, 45, 37, 3, -44 },
  { 5115, 38, 43, 41, 1, -43 },
  { 5320, 34, 43, 33, 1, -43 },
  { 5503, 34, 43, 33, 1, -43 },
  { 5686, 38, 45, 42, 3, -44 },
  { 5900, 42, 43, 42, 1, -43 },
  { 6126, 29, 43, 24, -2, -43 },
  { 6282, 31, 56, 21, -10, -43 },
  { 6499, 42, 43, 38, 1, -43 },
  { 6725, 27, 43, 31, 1, -43 },
  { 6871, 53, 43, 54, 1, -43 },
  { 7156, 46, 43, 46, 1, -43 },
  { 7404, 39, 45, 44, 3, -44 },
  { 7624, 36, 43, 37, 1, -43 },
  { 7818, 39, 54, 44, 3, -44 },
  { 8082, 35, 43, 38, 1, -43 },
  { 8271, 32, 44, 32, 1, -43 },
  { 8447, 31, 43, 32, 5, -43 },
  { 8614, 38, 44, 42, 4, -43 },
  { 8823, 36, 43, 36, 5, -43 },
  { 9017, 55, 43, 55, 5, -43 },
  { 9313, 47, 43, 38, -4, -43 },
  { 9566, 35, 43, 35, 5, -43 },
  { 9755, 37, 43, 32, -2, -43 },
  { 9954, 26, 53, 21, -1, -43 },
  { 10127, 16, 43, 27, 6, -43 },
  { 10213, 26, 53, 21, -4, -43 },
  { 10386, 32, 28, 33, 0, -43 },
  { 10498, 26, 5, 25, -5, 5 },
  { 10515, 13, 10, 20, 9, -46 },
  { 10532, 32, 35, 36, 3, -34 },
  { 10672, 32, 47, 36, 1, -46 },
  { 10860, 27, 35, 30, 3, -34 },
  { 10979, 35, 47, 36, 3, -46 },
  { 11185, 30, 35, 34, 3, -34 },
  { 11317, 36, 60, 23, -6, -46 },
  { 11587, 34, 48, 36, 1, -34 },
  { 11791, 33, 46, 37, 1, -46 },
  { 11981, 19, 46, 19, 1, -46 },
  { 12091, 28, 60, 19, -8, -46 },
  { 12301, 38, 46, 35, 1, -46 },
  { 12520, 20, 46, 19, 1, -46 },
  { 12635, 51, 34, 55, 1, -34 },
  { 12852, 33, 34, 37, 1, -34 },
  { 12993, 30, 35, 36, 3, -34 },
  { 13125, 35, 48, 36, -2, -34 },
  { 13335, 32, 48, 36, 3, -34 },
  { 13527, 27, 34, 26, 1, -34 },
  { 13642, 27, 35, 29, 1, -34 },
  { 13761, 25, 41, 26, 2, -40 },
  { 13890, 33, 34, 37, 3, -33 },
  { 14031, 32, 33, 32, 3, -33 },
  { 14163, 48, 33, 48, 3, -33 },
  { 14361, 39, 33, 33, -3, -33 },
  { 14522, 39, 47, 32, -4, -33 },
  { 14752, 30, 33, 29, -1, -33 },
  { 14876, 25, 52, 21, 0, -43 },
  { 15039, 7, 59, 33, 13, -45 },
  { 15091, 25, 52, 21, -3, -43 },
  { 15254, 29, 11, 35, 3, -27 },
};

const GFXfont NotoSans_ExtraBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRABOLDITALIC60PT7B_H_
