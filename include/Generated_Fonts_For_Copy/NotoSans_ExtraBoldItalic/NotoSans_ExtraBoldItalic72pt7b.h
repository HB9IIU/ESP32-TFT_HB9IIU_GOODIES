#ifndef _NOTOSANS_EXTRABOLDITALIC72PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF3, 0xFF,
  0x87, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF,
  0xE7, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x7F,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xE0, 0xF8, 0x07, 0xFF, 0x8F, 0x80,
  0x60, 0x1F, 0xFC, 0x3E, 0x00, 0x00, 0x7F, 0xF1, 0xF8, 0x00, 0x01, 0xFF,
  0xC7, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x7C, 0x00,
  0x00, 0x7F, 0xFD, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0x00, 0xF9, 0xFF, 0xE0,
  0x00, 0x07, 0xE3, 0xFF, 0x80, 0x00, 0x1F, 0x8F, 0xFE, 0x20, 0x00, 0x7C,
  0x3F, 0xF8, 0xE0, 0x01, 0xF0, 0xFF, 0xE3, 0xE0, 0x07, 0xC7, 0xFF, 0x8F,
  0xF8, 0x3F, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0x1F, 0xFD, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F,
  0xE3, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x0F, 0xF8, 0x00,
  0x3E, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xF1, 0xFE, 0x00, 0x1F,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xC0,
  0x00, 0xF8, 0x0F, 0xF8, 0x00, 0x0E, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xCF,
  0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01,
  0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F,
  0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x07,
  0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xF9, 0xFF,
  0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFF,
  0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF,
  0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xCF,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0xE0, 0x7F, 0x07, 0xFF,
  0x80, 0xF0, 0x1F, 0xFC, 0x03, 0x80, 0xFF, 0xF0, 0x08, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x38, 0x00, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x01,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x40, 0x00, 0x00, 0xFF, 0xF8, 0xC0,
  0x00, 0x03, 0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0xFF, 0xE3, 0xFE, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF7, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x20, 0x00, 0x00, 0xFF, 0xF8, 0x60,
  0x00, 0x03, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xFF, 0xC1, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0xFC, 0x03,
  0xFF, 0xBF, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x0B, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F,
  0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xFC,
  0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xF3, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0x80,
  0x7F, 0xF8, 0x78, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xE3, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xF8,
  0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFB, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xEF,
  0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0xBF, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE7, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFC, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x9F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0x3F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xC0,
  0x00, 0x04, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x18, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xDF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF,
  0xBF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xF3,
  0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xFB,
  0xFE, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F,
  0xF8, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x9F,
  0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF,
  0x80, 0x0F, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F,
  0x81, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFC,
  0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xF8, 0x7F, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x0F, 0xF0, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF3,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xBF,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF1,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF9, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF3, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xDF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xEF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xBF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xFF,
  0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFD,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFD, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x9F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x7F, 0xE3, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFF, 0xC0,
  0x00, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF,
  0x81, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xEF, 0xFE,
  0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xEF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xDF, 0xFE,
  0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0xFE, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0xC0, 0x03,
  0xFF, 0xBF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xBF, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xF0,
  0x07, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x02, 0x07, 0xFF, 0xE0, 0x07, 0x01, 0xFF, 0xF8, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xFF,
  0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF,
  0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFE,
  0x7F, 0xFC, 0x1F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xC0, 0x7F, 0xFC, 0x00, 0x3C, 0x07, 0xFF, 0xF0, 0x3F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x60, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3B, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xE0,
  0x03, 0xFF, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFF, 0x9F, 0xFC, 0x00, 0x0F,
  0xFF, 0x8F, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xF1,
  0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xBF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF1, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF,
  0xC7, 0xFF, 0xF8, 0x00, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xFF,
  0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F,
  0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xFC,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFE,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFE, 0xFF,
  0xF0, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF,
  0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFC,
  0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xFF, 0xF8, 0x00, 0x3F, 0xF7,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF9, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xEF,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFC,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFE, 0xFF,
  0xF0, 0x01, 0xFF, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x78, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x80,
  0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0,
  0x0F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFC, 0x07, 0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0xC0, 0x06, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x86,
  0x00, 0x03, 0xFF, 0xC3, 0xC0, 0x03, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x70, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0xFE, 0x3F, 0xE0,
  0x07, 0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xF3, 0xFF,
  0x80, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xF3,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F,
  0xEF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x0F, 0xFB, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x3F, 0xE1,
  0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xCF, 0xF8, 0xFF, 0xF0, 0x07, 0xFE, 0x1F,
  0xF3, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x9F,
  0xF0, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xF8, 0x3F, 0xCF, 0xFC, 0x00,
  0x1F, 0xFB, 0xFE, 0x0F, 0xF7, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x03, 0xFD,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x9F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x73, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x23, 0xFF, 0xE0,
  0x00, 0x0D, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFB, 0x80, 0x07, 0xFF, 0xFE, 0x40, 0x00, 0x1F, 0xFF, 0x88, 0x00, 0x00,
  0x7F, 0x80,
};

const GFXglyph NotoSans_ExtraBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 23, 52, 21, 1, -51 },
  { 151, 28, 18, 33, 7, -51 },
  { 214, 46, 51, 47, 1, -51 },
  { 508, 38, 59, 41, 2, -55 },
  { 789, 58, 53, 64, 4, -52 },
  { 1174, 50, 53, 52, 1, -52 },
  { 1506, 13, 18, 18, 7, -51 },
  { 1536, 28, 63, 26, 3, -52 },
  { 1757, 28, 64, 26, -5, -53 },
  { 1981, 35, 35, 39, 6, -55 },
  { 2135, 35, 35, 42, 4, -43 },
  { 2289, 19, 17, 21, -4, -8 },
  { 2330, 21, 10, 23, 1, -24 },
  { 2357, 14, 13, 21, 0, -12 },
  { 2380, 40, 53, 32, -3, -52 },
  { 2645, 38, 53, 41, 2, -52 },
  { 2897, 30, 51, 41, 6, -51 },
  { 3089, 41, 52, 41, -2, -52 },
  { 3356, 39, 53, 41, 0, -52 },
  { 3615, 41, 51, 41, -1, -51 },
  { 3877, 39, 52, 41, 1, -51 },
  { 4131, 38, 53, 41, 3, -52 },
  { 4383, 42, 51, 41, 2, -51 },
  { 4651, 38, 53, 41, 2, -52 },
  { 4903, 36, 53, 41, 3, -52 },
  { 5142, 21, 41, 21, 0, -40 },
  { 5250, 25, 49, 21, -4, -40 },
  { 5404, 35, 38, 42, 4, -45 },
  { 5571, 35, 23, 42, 4, -37 },
  { 5672, 35, 38, 42, 4, -45 },
  { 5839, 31, 53, 34, 5, -52 },
  { 6045, 59, 59, 63, 3, -52 },
  { 6481, 46, 51, 47, -4, -51 },
  { 6775, 42, 51, 45, 2, -51 },
  { 7043, 43, 53, 45, 4, -52 },
  { 7328, 45, 51, 49, 2, -51 },
  { 7615, 40, 51, 40, 2, -51 },
  { 7870, 40, 51, 40, 2, -51 },
  { 8125, 45, 53, 50, 4, -52 },
  { 8424, 49, 51, 51, 2, -51 },
  { 8737, 35, 51, 29, -2, -51 },
  { 8961, 37, 67, 25, -11, -51 },
  { 9271, 50, 51, 46, 2, -51 },
  { 9590, 31, 51, 38, 2, -51 },
  { 9788, 63, 51, 64, 2, -51 },
  { 10190, 54, 51, 56, 2, -51 },
  { 10535, 47, 53, 53, 4, -52 },
  { 10847, 42, 51, 44, 2, -51 },
  { 11115, 47, 64, 53, 4, -52 },
  { 11491, 41, 51, 46, 2, -51 },
  { 11753, 39, 53, 39, 1, -52 },
  { 12012, 38, 51, 39, 6, -51 },
  { 12255, 46, 52, 50, 5, -51 },
  { 12554, 43, 51, 43, 6, -51 },
  { 12829, 66, 51, 66, 6, -51 },
  { 13250, 55, 51, 46, -4, -51 },
  { 13601, 42, 51, 42, 6, -51 },
  { 13869, 45, 51, 39, -3, -51 },
  { 14156, 32, 64, 25, -2, -52 },
  { 14412, 18, 53, 32, 8, -52 },
  { 14532, 31, 64, 25, -5, -52 },
  { 14780, 37, 34, 39, 1, -52 },
  { 14938, 33, 6, 30, -7, 6 },
  { 14963, 17, 11, 24, 10, -55 },
  { 14987, 39, 41, 43, 3, -40 },
  { 15187, 39, 56, 43, 1, -55 },
  { 15460, 33, 41, 36, 3, -40 },
  { 15630, 42, 56, 43, 3, -55 },
  { 15924, 36, 41, 41, 3, -40 },
  { 16109, 43, 72, 28, -7, -55 },
  { 16496, 41, 57, 43, 1, -40 },
  { 16789, 40, 55, 44, 1, -55 },
  { 17064, 23, 55, 22, 1, -55 },
  { 17223, 33, 72, 22, -9, -55 },
  { 17520, 45, 55, 43, 1, -55 },
  { 17830, 24, 55, 22, 1, -55 },
  { 17995, 61, 40, 66, 1, -40 },
  { 18300, 40, 40, 44, 1, -40 },
  { 18500, 37, 41, 43, 3, -40 },
  { 18690, 43, 57, 43, -3, -40 },
  { 18997, 39, 57, 43, 3, -40 },
  { 19275, 33, 40, 31, 1, -40 },
  { 19440, 33, 41, 35, 1, -40 },
  { 19610, 29, 49, 31, 3, -48 },
  { 19788, 39, 41, 44, 4, -40 },
  { 19988, 39, 40, 38, 3, -40 },
  { 20183, 58, 40, 58, 4, -40 },
  { 20473, 48, 40, 40, -4, -40 },
  { 20713, 47, 57, 38, -5, -40 },
  { 21048, 36, 40, 34, -1, -40 },
  { 21228, 31, 62, 26, 0, -51 },
  { 21469, 8, 71, 40, 16, -55 },
  { 21540, 30, 62, 26, -4, -51 },
  { 21773, 35, 13, 42, 4, -32 },
};

const GFXfont NotoSans_ExtraBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRABOLDITALIC72PT7B_H_
