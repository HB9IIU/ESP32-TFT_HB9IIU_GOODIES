#ifndef _NOTOSANS_EXTRABOLDITALIC16PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x67, 0x39, 0x80, 0x67, 0x38, 0x6E, 0xD9, 0xB6, 0x60,
  0x0D, 0xC1, 0xB0, 0x26, 0xBF, 0xE1, 0xB0, 0x36, 0x3F, 0xF7, 0xFE, 0x36,
  0x04, 0xC1, 0xB0, 0x00, 0x06, 0x0F, 0xCF, 0xE6, 0x93, 0x41, 0xE0, 0x7C,
  0x1E, 0x8B, 0x7F, 0xBF, 0x82, 0x01, 0x00, 0x10, 0x13, 0xC3, 0x3B, 0x31,
  0x9B, 0x0D, 0x98, 0x6D, 0xBB, 0xFB, 0xE5, 0xBB, 0x0D, 0x98, 0xCD, 0x8C,
  0x7C, 0xC1, 0xC0, 0x06, 0x03, 0xF0, 0x6E, 0x1C, 0xC1, 0xB8, 0x3E, 0x0F,
  0x3B, 0xF7, 0xE7, 0xDC, 0x71, 0xFE, 0x3F, 0xE0, 0x6D, 0xE0, 0x1C, 0x63,
  0x1C, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x00, 0x18, 0x60,
  0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x8E, 0x31, 0x8C, 0x00, 0x0C, 0x4C,
  0xE8, 0x7F, 0x3B, 0x7C, 0x2E, 0x08, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x37, 0x6E, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0x81, 0xC0, 0xC0,
  0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x00, 0x0C, 0x3E,
  0x7F, 0xE7, 0xE7, 0xE7, 0xC7, 0xC6, 0xCE, 0xCE, 0xFC, 0x78, 0x1E, 0x7F,
  0xF3, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE0, 0x0C, 0x1F, 0x9F, 0xE4,
  0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xDF, 0xC0, 0x0C, 0x1F,
  0x8F, 0xE0, 0x70, 0x30, 0xF0, 0xF8, 0x0E, 0x07, 0x43, 0xBF, 0x9F, 0x80,
  0x07, 0x83, 0x83, 0xC3, 0x63, 0x73, 0xBB, 0x9B, 0xFE, 0xFF, 0x07, 0x03,
  0x80, 0x1F, 0x9F, 0xCE, 0x06, 0x07, 0xE3, 0xF8, 0x1C, 0x0E, 0x87, 0x7F,
  0x3F, 0x00, 0x07, 0x3F, 0x7F, 0x70, 0xE8, 0xDE, 0xFE, 0xE6, 0xC6, 0xCE,
  0xFE, 0x7C, 0x3F, 0xDF, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x1C, 0x0F, 0x00, 0x06, 0x0F, 0x8E, 0xE6, 0x73, 0xB0, 0xF8, 0xF8,
  0xEE, 0x63, 0x73, 0x9F, 0xC7, 0xC0, 0x18, 0x7E, 0x7E, 0xE7, 0xE7, 0xE7,
  0xFE, 0x76, 0x0E, 0x1C, 0xFC, 0xF0, 0x31, 0xCC, 0x00, 0x01, 0x9C, 0xE0,
  0x18, 0x71, 0x80, 0x00, 0x00, 0x1C, 0x71, 0x8C, 0x00, 0x03, 0x0F, 0x3E,
  0xF0, 0xE0, 0x78, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x3E, 0xF0, 0xC0, 0x80, 0x19, 0xFD, 0xF8, 0x70,
  0xE7, 0x9C, 0x30, 0x00, 0xC3, 0x87, 0x00, 0x01, 0x00, 0xFF, 0x0E, 0x1C,
  0xC0, 0x6C, 0xFD, 0xEE, 0xCF, 0x66, 0x7B, 0x36, 0xDB, 0xB6, 0xFF, 0x30,
  0x00, 0xE1, 0x03, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0xFC, 0x37, 0x1D, 0xC6,
  0x73, 0xFC, 0xFF, 0x7F, 0xDC, 0x3E, 0x0C, 0x1F, 0x8F, 0xF3, 0x9C, 0xE7,
  0x3F, 0x8F, 0xC7, 0x39, 0xCE, 0x73, 0x9F, 0xCF, 0xE0, 0x06, 0x07, 0xF3,
  0xF9, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x47, 0xE0, 0xF8,
  0x1F, 0x8F, 0xF3, 0x9C, 0xE3, 0x30, 0xCC, 0x77, 0x1D, 0xC7, 0x77, 0x9F,
  0xCF, 0xE0, 0x1F, 0x9F, 0xCE, 0x07, 0x03, 0xF1, 0xF9, 0xC0, 0xE0, 0x70,
  0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0xCE, 0x07, 0x03, 0xF1, 0xF9, 0xFC, 0xE0,
  0x70, 0x30, 0x38, 0x00, 0x07, 0x07, 0xF3, 0xF9, 0xC0, 0xE0, 0x39, 0xEE,
  0x7B, 0xBE, 0xE3, 0xB8, 0xE7, 0xF0, 0xFC, 0x18, 0xE7, 0x1C, 0xE3, 0x9C,
  0x73, 0xFC, 0x7F, 0x9C, 0x73, 0x8E, 0x71, 0x8C, 0x33, 0x8E, 0x00, 0x1F,
  0x1E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x7C, 0xFC, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x8F,
  0xC7, 0xC0, 0x18, 0xF3, 0x9C, 0x3B, 0x83, 0xF0, 0x36, 0x03, 0xE0, 0x7F,
  0x07, 0x70, 0x77, 0x06, 0x38, 0xE3, 0x80, 0x18, 0x70, 0xE1, 0xC3, 0x06,
  0x1C, 0x38, 0x70, 0xFF, 0xF8, 0x1C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x1F,
  0x34, 0xD8, 0xDB, 0x67, 0x7B, 0x99, 0xEE, 0x67, 0x31, 0x9C, 0xCE, 0x67,
  0x00, 0x1C, 0x33, 0xC3, 0x3E, 0x73, 0x67, 0x36, 0x63, 0x76, 0x73, 0x67,
  0x3E, 0x63, 0xE6, 0x3C, 0xE1, 0xC0, 0x06, 0x07, 0xE3, 0xFD, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xE7, 0xF0, 0xF8, 0x1F, 0x8F, 0xF3,
  0x9C, 0xE7, 0x33, 0xCF, 0xE7, 0xF1, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x06,
  0x07, 0xE3, 0xFD, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xE7,
  0xF0, 0xF8, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0x8F, 0xE3, 0x9C, 0xE7, 0x33,
  0x8F, 0xC7, 0xE1, 0xDC, 0x77, 0x18, 0xEE, 0x38, 0x06, 0x0F, 0xCF, 0xC6,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x43, 0x3F, 0x9F, 0x80, 0x7F, 0xFF,
  0x86, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x71,
  0xDC, 0x77, 0x1D, 0xC6, 0x61, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0x3F, 0xC7,
  0xE0, 0xE1, 0xF8, 0xE6, 0x31, 0x9C, 0x66, 0x1B, 0x86, 0xC1, 0xB0, 0x78,
  0x1E, 0x07, 0x00, 0xE3, 0x8F, 0xC7, 0x1B, 0x9E, 0x77, 0x3C, 0xCE, 0xDB,
  0x8D, 0xB6, 0x1F, 0x6C, 0x3C, 0xF8, 0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x00,
  0x1C, 0x71, 0xCE, 0x0D, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x81, 0xF8,
  0x3B, 0x87, 0x1C, 0xE1, 0xC0, 0xE3, 0xDC, 0xC7, 0x71, 0xF8, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x00, 0x1F, 0xCF, 0xF0, 0x38, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0xEF, 0xF0, 0x1E, 0x78, 0xC1,
  0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x1E, 0x3C, 0x00, 0xCC,
  0xCC, 0xE6, 0x66, 0x66, 0x77, 0x1E, 0x3C, 0x30, 0x60, 0xC1, 0x87, 0x0C,
  0x18, 0x30, 0xE1, 0x83, 0x1E, 0x3C, 0x00, 0x0E, 0x0E, 0x1E, 0x32, 0x33,
  0x63, 0xE3, 0xFF, 0xF8, 0xE7, 0x3B, 0x7F, 0xF7, 0xE7, 0xE6, 0xC6, 0xEE,
  0xFE, 0xFE, 0x18, 0x1C, 0x0E, 0x07, 0xE3, 0xF9, 0xDD, 0xCE, 0xE7, 0x73,
  0xBB, 0x9F, 0xDF, 0xC0, 0x3E, 0xFF, 0xCF, 0x0C, 0x18, 0x39, 0x7E, 0x7C,
  0x03, 0x81, 0xC0, 0xE7, 0x67, 0xF7, 0xBB, 0x9D, 0xCC, 0xC6, 0x77, 0x3F,
  0x9F, 0xC0, 0x1E, 0x7F, 0xE7, 0xE7, 0xFE, 0xF0, 0xC2, 0xFC, 0x7C, 0x03,
  0xC1, 0xE0, 0x60, 0x3E, 0x1F, 0x83, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x0F, 0x83, 0x80, 0x1D, 0x9F, 0xDE, 0xEE, 0x77,
  0x33, 0x19, 0xDC, 0xFE, 0x7F, 0x03, 0x23, 0x9F, 0x87, 0x80, 0x18, 0x1C,
  0x0E, 0x07, 0xE3, 0xF9, 0xDD, 0xCE, 0xE7, 0x73, 0xB1, 0x99, 0xDC, 0xE0,
  0x19, 0xC0, 0x73, 0x99, 0xCE, 0x73, 0x19, 0xC0, 0x06, 0x0C, 0x00, 0x70,
  0xE1, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x3C, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE7, 0x33, 0x8D, 0xC7, 0xE1, 0xF8, 0x7E, 0x19, 0x86, 0x73,
  0x9E, 0x19, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x19, 0xC0, 0x37, 0x38, 0xFF,
  0xF3, 0xBD, 0xDC, 0xE7, 0x73, 0x9D, 0xCE, 0x66, 0x31, 0x99, 0xCE, 0xE7,
  0x38, 0x37, 0x1F, 0xCE, 0xEE, 0x77, 0x3B, 0x9D, 0x8C, 0xCE, 0xE7, 0x00,
  0x3C, 0x7E, 0xE7, 0xE7, 0xE7, 0xC7, 0xCE, 0xFE, 0x7C, 0x1B, 0x87, 0xF1,
  0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xB8, 0xFE, 0x7F, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x00, 0x3B, 0x7F, 0xF7, 0xE7, 0xE6, 0xC6, 0xEE, 0xFE, 0x7E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x36, 0x7C, 0xFB, 0x87, 0x0E, 0x18, 0x30, 0xE0, 0x3E,
  0xFD, 0xCB, 0xC3, 0xC3, 0xE3, 0xFE, 0xFC, 0x30, 0xC7, 0xFF, 0x61, 0x8E,
  0x38, 0xE3, 0xEF, 0x80, 0x73, 0xB1, 0x99, 0xDC, 0xEE, 0x77, 0x33, 0xB9,
  0xFC, 0xF6, 0x00, 0xC7, 0xC7, 0xEE, 0xEE, 0xFC, 0xFC, 0x78, 0x70, 0x70,
  0xC7, 0x3E, 0x7B, 0xB3, 0xDD, 0xB6, 0xCD, 0xBE, 0x6D, 0xE3, 0xCF, 0x1E,
  0x70, 0xE3, 0x80, 0x39, 0xE3, 0x38, 0x7E, 0x0F, 0x80, 0xE0, 0x3C, 0x0F,
  0xC3, 0xB8, 0xF3, 0x80, 0x31, 0xCC, 0x73, 0xB8, 0xEE, 0x3B, 0x0F, 0xC1,
  0xE0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xC0, 0xE0, 0x00, 0x3F, 0x7F, 0x0E,
  0x1C, 0x38, 0x38, 0x70, 0xFE, 0xFC, 0x1E, 0x38, 0x61, 0xC3, 0x9E, 0x30,
  0x70, 0x70, 0xC1, 0x83, 0x87, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x18,
  0x78, 0x70, 0xC1, 0x83, 0x83, 0x9E, 0x30, 0x60, 0xC3, 0x8E, 0x10, 0x00,
  0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 5, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 11, 11, 10, 0, -11 },
  { 28, 9, 13, 9, 0, -12 },
  { 43, 13, 12, 14, 1, -12 },
  { 63, 11, 12, 12, 0, -12 },
  { 80, 3, 4, 4, 1, -11 },
  { 82, 6, 15, 6, 1, -12 },
  { 94, 6, 15, 6, -1, -12 },
  { 106, 8, 8, 9, 1, -12 },
  { 114, 8, 8, 9, 1, -10 },
  { 122, 4, 4, 5, -1, -2 },
  { 124, 5, 2, 5, 0, -5 },
  { 126, 3, 3, 5, 0, -3 },
  { 128, 9, 12, 7, -1, -12 },
  { 142, 8, 12, 9, 1, -12 },
  { 154, 7, 11, 9, 1, -11 },
  { 164, 9, 12, 9, 0, -12 },
  { 178, 9, 12, 9, 0, -12 },
  { 192, 9, 11, 9, 0, -11 },
  { 205, 9, 11, 9, 0, -11 },
  { 218, 8, 12, 9, 1, -12 },
  { 230, 10, 11, 9, 0, -11 },
  { 244, 9, 12, 9, 0, -12 },
  { 258, 8, 12, 9, 1, -12 },
  { 270, 5, 9, 5, 0, -9 },
  { 276, 6, 11, 5, -1, -9 },
  { 285, 8, 9, 9, 1, -10 },
  { 294, 8, 5, 9, 1, -8 },
  { 299, 8, 9, 9, 1, -10 },
  { 308, 7, 12, 8, 1, -12 },
  { 319, 13, 13, 14, 1, -12 },
  { 341, 10, 11, 10, -1, -11 },
  { 355, 10, 11, 10, 0, -11 },
  { 369, 10, 12, 10, 1, -12 },
  { 384, 10, 11, 11, 0, -11 },
  { 398, 9, 11, 9, 0, -11 },
  { 411, 9, 11, 9, 0, -11 },
  { 424, 10, 12, 11, 1, -12 },
  { 439, 11, 11, 11, 0, -11 },
  { 455, 8, 11, 6, -1, -11 },
  { 466, 9, 14, 6, -3, -11 },
  { 482, 12, 11, 10, 0, -11 },
  { 499, 7, 11, 8, 0, -11 },
  { 509, 14, 11, 14, 0, -11 },
  { 529, 12, 11, 12, 0, -11 },
  { 546, 10, 12, 12, 1, -12 },
  { 561, 10, 11, 10, 0, -11 },
  { 575, 10, 15, 12, 1, -12 },
  { 594, 10, 11, 10, 0, -11 },
  { 608, 9, 12, 9, 0, -12 },
  { 622, 9, 11, 9, 1, -11 },
  { 635, 10, 11, 11, 1, -11 },
  { 649, 10, 11, 10, 1, -11 },
  { 663, 15, 11, 15, 1, -11 },
  { 684, 12, 11, 10, -1, -11 },
  { 701, 10, 11, 9, 1, -11 },
  { 715, 10, 11, 9, -1, -11 },
  { 729, 7, 15, 6, 0, -12 },
  { 743, 4, 12, 7, 2, -12 },
  { 749, 7, 15, 6, -1, -12 },
  { 763, 8, 7, 9, 0, -11 },
  { 770, 7, 2, 7, -1, 1 },
  { 772, 4, 2, 5, 2, -12 },
  { 773, 8, 9, 10, 1, -9 },
  { 782, 9, 12, 10, 0, -12 },
  { 796, 7, 9, 8, 1, -9 },
  { 804, 9, 12, 10, 1, -12 },
  { 818, 8, 9, 9, 1, -9 },
  { 827, 10, 16, 6, -2, -12 },
  { 847, 9, 13, 10, 0, -9 },
  { 862, 9, 12, 10, 0, -12 },
  { 876, 5, 12, 5, 0, -12 },
  { 884, 7, 16, 5, -2, -12 },
  { 898, 10, 12, 9, 0, -12 },
  { 913, 5, 12, 5, 0, -12 },
  { 921, 14, 9, 15, 0, -9 },
  { 937, 9, 9, 10, 0, -9 },
  { 948, 8, 9, 10, 1, -9 },
  { 957, 10, 13, 10, -1, -9 },
  { 974, 8, 13, 10, 1, -9 },
  { 987, 7, 9, 7, 0, -9 },
  { 995, 7, 9, 8, 0, -9 },
  { 1003, 6, 11, 7, 1, -11 },
  { 1012, 9, 9, 10, 1, -9 },
  { 1023, 8, 9, 8, 1, -9 },
  { 1032, 13, 9, 13, 1, -9 },
  { 1047, 11, 9, 9, -1, -9 },
  { 1060, 10, 13, 9, -1, -9 },
  { 1077, 8, 9, 8, 0, -9 },
  { 1086, 7, 14, 6, 0, -11 },
  { 1099, 2, 16, 9, 3, -12 },
  { 1103, 7, 14, 6, -1, -11 },
  { 1116, 8, 3, 9, 1, -7 },
};

const GFXfont NotoSans_ExtraBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRABOLDITALIC16PT7B_H_
