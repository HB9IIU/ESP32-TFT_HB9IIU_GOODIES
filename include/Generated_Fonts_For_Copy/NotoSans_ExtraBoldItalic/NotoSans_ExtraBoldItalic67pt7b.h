#ifndef _NOTOSANS_EXTRABOLDITALIC67PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xE7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC7, 0xC1, 0xE0, 0x3F, 0xF1, 0xF0, 0x08,
  0x07, 0xFE, 0x3E, 0x00, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x3F, 0xF8, 0xF8,
  0x00, 0x03, 0xFF, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x7F, 0xE0, 0x00, 0x0F, 0x8F, 0xFC, 0x00,
  0x01, 0xF1, 0xFF, 0x88, 0x00, 0x3E, 0x3F, 0xF1, 0x80, 0x07, 0xC7, 0xFE,
  0x3E, 0x01, 0xF1, 0xFF, 0xC7, 0xFC, 0x3E, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF1, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x81,
  0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF,
  0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xF3, 0xFE, 0x3F, 0xF3, 0xFE,
  0x1F, 0xFF, 0x8F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC,
  0x1F, 0xF0, 0x0C, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE3,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x38,
  0x07, 0xF8, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xC0, 0x10, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFC, 0x0F,
  0xF8, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x06, 0x03, 0xFF, 0x00, 0x01, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0xF8, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xFE,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0x9F,
  0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF,
  0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF0, 0x01,
  0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF8,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF,
  0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x07,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x03, 0xFE, 0x3F,
  0xF8, 0x1F, 0xC1, 0xFF, 0x80, 0x7C, 0x1F, 0xFC, 0x03, 0x80, 0xFF, 0xE0,
  0x08, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x07,
  0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00,
  0x38, 0x00, 0x7F, 0xF0, 0x00, 0x40, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0xF0, 0x01, 0x80, 0x07, 0xFF, 0x00, 0x10, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC8, 0x00, 0x00, 0x7F, 0xFC, 0xE0, 0x00, 0x07, 0xFF, 0x8F, 0x80, 0x01,
  0xFF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x88,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x78, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x08, 0x00, 0x00,
  0xFF, 0xF0, 0x60, 0x00, 0x0F, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0xF8, 0x1F,
  0xFC, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x9F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0,
  0x1F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0,
  0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF,
  0xE0, 0x7F, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x7F, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0x9F, 0xF8,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x1C, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC1, 0x00, 0x0F, 0xFF,
  0xC0, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xFE, 0x3C, 0x00, 0x7F, 0xF0,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x7F, 0xC3,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x83,
  0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xF3, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFC, 0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x0F, 0xF7, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x3F,
  0xC1, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE3, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xE7, 0xFF,
  0xCF, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x07, 0xF8,
  0x1F, 0xFF, 0x9F, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x30, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x00, 0x04, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xFF,
  0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x08, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xD0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFD, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x0F, 0xFB,
  0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFC, 0xFF,
  0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x80, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xCF, 0xF0, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9,
  0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xC7, 0xF8, 0x1F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x07,
  0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xE3, 0xFC, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x0F, 0xF1, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xEF, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x87, 0xFD, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xBF, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC7,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x00,
  0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xDF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x3F,
  0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x9F, 0xFC,
  0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFC, 0x00, 0x30,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x3F,
  0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x07,
  0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xBF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFE,
  0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xF0, 0x01, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x3F,
  0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x3F,
  0xE0, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x07, 0xFB, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0xC7, 0xFF,
  0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF,
  0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xE1, 0xFF, 0x00, 0x7F,
  0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFD, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0xFF,
  0xCF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xFC, 0x00,
  0x0F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0xBF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xE0, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x02, 0x07, 0xFF, 0xC0, 0x1C, 0x0F, 0xFF,
  0xE3, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x7F,
  0xF0, 0x03, 0xFF, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xCF, 0xF8,
  0x00, 0x1F, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xCF,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xE7, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x04, 0x1F, 0xFE, 0x00, 0x06, 0x07,
  0xFF, 0x80, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x83, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xFE,
  0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xF3, 0xFF, 0x00,
  0xFF, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0C,
  0x00, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF7, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x81, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F,
  0xFD, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x3F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE1,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xFC, 0x00,
  0x7F, 0xC7, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF,
  0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFD, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xF1, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0,
  0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x1F, 0xFE,
  0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0xC0, 0x00, 0xFF,
  0x9F, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0xFE, 0x00, 0x3F, 0xF3,
  0xFF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xF3,
  0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF8,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xF3, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x07, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0x01, 0xFF, 0x3F,
  0xF8, 0x07, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE7, 0xFC, 0x0F, 0xFE, 0x01, 0xF0, 0x3F,
  0xF8, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x88, 0x00, 0x0F, 0xFE, 0x30, 0x00, 0x7F, 0xF8, 0xF8, 0x03,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xE8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x20, 0x3F, 0xFE,
  0x78, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0xFF, 0x80,
  0x7F, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xF1,
  0xFF, 0x00, 0x3F, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x87,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xF3,
  0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x7F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81, 0xFD, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xEF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x7F, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF,
  0x80, 0x7F, 0xC3, 0xFC, 0xFF, 0x1F, 0xFC, 0x03, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x3F, 0xCF, 0xFE, 0x00, 0xFF, 0x9F, 0xF1,
  0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x0F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7,
  0xF8, 0x7F, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0x80, 0x0F,
  0xFB, 0xFC, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x07, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x87, 0xFF, 0x00, 0x00, 0x4F, 0xFF, 0xF0,
  0x00, 0x6F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xB8, 0x00, 0x3F, 0xFF, 0x90, 0x00,
  0x03, 0xFF, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 21, 49, 20, 1, -48 },
  { 130, 27, 17, 30, 6, -48 },
  { 188, 43, 48, 43, 1, -48 },
  { 446, 35, 55, 38, 2, -51 },
  { 687, 54, 50, 60, 4, -49 },
  { 1025, 47, 50, 48, 1, -49 },
  { 1319, 13, 17, 17, 6, -48 },
  { 1347, 26, 59, 24, 2, -48 },
  { 1539, 26, 60, 24, -5, -49 },
  { 1734, 33, 33, 36, 5, -51 },
  { 1871, 33, 33, 39, 3, -40 },
  { 2008, 17, 17, 20, -3, -8 },
  { 2045, 19, 10, 22, 1, -23 },
  { 2069, 13, 12, 20, 0, -11 },
  { 2089, 37, 49, 30, -3, -48 },
  { 2316, 35, 50, 38, 2, -49 },
  { 2535, 29, 48, 38, 5, -48 },
  { 2709, 38, 49, 38, -2, -49 },
  { 2942, 36, 50, 38, 0, -49 },
  { 3167, 38, 48, 38, -1, -48 },
  { 3395, 37, 49, 38, 1, -48 },
  { 3622, 36, 50, 38, 3, -49 },
  { 3847, 39, 48, 38, 2, -48 },
  { 4081, 35, 50, 38, 2, -49 },
  { 4300, 33, 50, 38, 3, -49 },
  { 4507, 19, 38, 20, 0, -37 },
  { 4598, 23, 46, 20, -4, -37 },
  { 4731, 33, 36, 39, 3, -42 },
  { 4880, 33, 21, 39, 3, -34 },
  { 4967, 33, 36, 39, 3, -42 },
  { 5116, 29, 50, 32, 5, -49 },
  { 5298, 54, 54, 59, 3, -48 },
  { 5663, 43, 48, 44, -4, -48 },
  { 5921, 40, 48, 42, 1, -48 },
  { 6161, 40, 50, 42, 4, -49 },
  { 6411, 42, 48, 46, 1, -48 },
  { 6663, 38, 48, 37, 1, -48 },
  { 6891, 38, 48, 37, 1, -48 },
  { 7119, 42, 50, 47, 4, -49 },
  { 7382, 47, 48, 47, 1, -48 },
  { 7664, 33, 48, 27, -2, -48 },
  { 7862, 35, 63, 24, -11, -48 },
  { 8138, 47, 48, 43, 1, -48 },
  { 8420, 30, 48, 35, 1, -48 },
  { 8600, 59, 48, 60, 1, -48 },
  { 8954, 51, 48, 52, 1, -48 },
  { 9260, 43, 50, 49, 4, -49 },
  { 9529, 40, 48, 41, 1, -48 },
  { 9769, 43, 60, 49, 4, -49 },
  { 10092, 39, 48, 42, 1, -48 },
  { 10326, 36, 50, 36, 1, -49 },
  { 10551, 36, 48, 36, 5, -48 },
  { 10767, 43, 49, 47, 4, -48 },
  { 11031, 41, 48, 40, 5, -48 },
  { 11277, 61, 48, 61, 6, -48 },
  { 11643, 52, 48, 42, -4, -48 },
  { 11955, 39, 48, 39, 6, -48 },
  { 12189, 42, 48, 36, -2, -48 },
  { 12441, 29, 59, 23, -1, -48 },
  { 12655, 17, 49, 30, 7, -48 },
  { 12760, 28, 59, 23, -4, -48 },
  { 12967, 34, 31, 36, 1, -48 },
  { 13099, 30, 6, 28, -6, 5 },
  { 13122, 15, 10, 23, 10, -51 },
  { 13141, 36, 38, 40, 3, -37 },
  { 13312, 36, 52, 40, 1, -51 },
  { 13546, 31, 38, 33, 3, -37 },
  { 13694, 39, 52, 40, 3, -51 },
  { 13948, 33, 38, 38, 3, -37 },
  { 14105, 40, 67, 26, -7, -51 },
  { 14440, 38, 53, 40, 1, -37 },
  { 14692, 37, 51, 41, 1, -51 },
  { 14928, 22, 51, 21, 1, -51 },
  { 15069, 32, 67, 21, -9, -51 },
  { 15337, 42, 51, 40, 1, -51 },
  { 15605, 22, 51, 21, 1, -51 },
  { 15746, 57, 37, 61, 1, -37 },
  { 16010, 37, 37, 41, 1, -37 },
  { 16182, 34, 38, 40, 3, -37 },
  { 16344, 39, 53, 40, -2, -37 },
  { 16603, 36, 53, 40, 3, -37 },
  { 16842, 30, 37, 29, 1, -37 },
  { 16981, 30, 38, 33, 1, -37 },
  { 17124, 27, 45, 29, 3, -44 },
  { 17276, 37, 38, 41, 3, -37 },
  { 17452, 36, 37, 35, 3, -37 },
  { 17619, 53, 37, 54, 4, -37 },
  { 17865, 45, 37, 37, -4, -37 },
  { 18074, 43, 53, 36, -4, -37 },
  { 18359, 34, 37, 32, -1, -37 },
  { 18517, 28, 59, 24, 0, -48 },
  { 18724, 8, 66, 37, 15, -51 },
  { 18790, 28, 59, 24, -4, -48 },
  { 18997, 33, 12, 39, 3, -30 },
};

const GFXfont NotoSans_ExtraBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRABOLDITALIC67PT7B_H_
