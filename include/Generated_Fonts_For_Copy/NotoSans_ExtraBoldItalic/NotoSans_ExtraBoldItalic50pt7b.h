#ifndef _NOTOSANS_EXTRABOLDITALIC50PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x7F, 0x8F, 0xEF, 0xF1,
  0xFD, 0xFC, 0x7F, 0xBF, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87,
  0xE7, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xEF, 0x1E, 0x07, 0xF9, 0xE0, 0x40, 0xFF, 0x3C, 0x00, 0x1F,
  0xE7, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1E, 0xFF, 0x80, 0x03, 0xCF, 0xF0, 0x00, 0x79, 0xFE, 0x40, 0x0E,
  0x3F, 0xCF, 0x01, 0xCF, 0xF1, 0xFC, 0x7B, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0x80, 0x3F,
  0x9F, 0x80, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x00,
  0xFE, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x9F, 0xC3,
  0xF0, 0xFC, 0x7F, 0x1F, 0x8F, 0xF8, 0xFE, 0xFF, 0x3F, 0x3F, 0xFC, 0xFF,
  0xFE, 0x7F, 0x3F, 0xFE, 0x7F, 0xFE, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0xFC,
  0xFF, 0xFF, 0x3F, 0xF9, 0xF8, 0xFE, 0x7F, 0x0F, 0xE3, 0xF9, 0xFC, 0x3F,
  0x00, 0x07, 0xF1, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x7F, 0x00, 0x0F,
  0xC1, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xF0,
  0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x3F,
  0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0xDF, 0xF1, 0xFE, 0x1F, 0xF1,
  0xFF, 0x7F, 0xC7, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9,
  0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x20, 0x1F, 0x80, 0x38, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x7F, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x7F,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xDF, 0x80, 0x7F, 0xCF, 0xC0,
  0x3F, 0x8F, 0xC0, 0x0F, 0x0F, 0xE0, 0x07, 0x07, 0xE0, 0x02, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC0,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x80, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFC, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F,
  0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFF,
  0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFE,
  0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07,
  0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xF7,
  0xF8, 0xFF, 0x3F, 0xC3, 0xE1, 0xFE, 0x0E, 0x1F, 0xF0, 0x40, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xC3, 0xFF, 0x00,
  0xF0, 0x1F, 0xF0, 0x06, 0x00, 0xFF, 0x00, 0x40, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x07, 0x01, 0xFF, 0x00, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x40, 0x00, 0x7F, 0xCE,
  0x00, 0x1F, 0xF9, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F,
  0xC7, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x40, 0x00, 0xFF, 0x8C, 0x00,
  0x7F, 0xE1, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x08,
  0x00, 0x7F, 0x9F, 0xF0, 0x0F, 0xE7, 0xFF, 0x03, 0xFD, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF,
  0x8F, 0xFC, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC2,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF,
  0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFD, 0xFE, 0x03,
  0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7, 0xF8, 0x3F,
  0xF3, 0xFC, 0x03, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0x07, 0xFF, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFE,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0x80, 0xFF, 0x30, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x83,
  0xF0, 0x0F, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0xFF, 0xC7, 0xE3, 0xF8, 0x1F,
  0xFF, 0xE1, 0xF9, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7E, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xBF,
  0x0F, 0xE0, 0xFC, 0x0F, 0xDF, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0x87, 0xF0,
  0x3F, 0x07, 0xEF, 0xC3, 0xF0, 0x1F, 0x83, 0xF7, 0xE1, 0xF8, 0x1F, 0x81,
  0xFB, 0xF0, 0xFC, 0x0F, 0xC1, 0xFD, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0xFC,
  0x3F, 0x07, 0xF0, 0xFE, 0x7E, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xE1, 0xFF, 0xDF, 0xFE,
  0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x01, 0xFC, 0x0F, 0x80, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x04, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x7C,
  0x1F, 0xFC, 0x00, 0x60, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x40, 0x7F, 0xE0, 0x0E, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xFE, 0x03, 0xFC, 0x07, 0xFE,
  0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0,
  0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFE, 0x03,
  0xFF, 0x83, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x00, 0x10, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xF3, 0xFE, 0x07, 0xFF, 0xE7, 0xFC,
  0x1F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0x1F, 0xE0, 0x7F, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x03,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x02, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFD,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xFC,
  0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7E, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xE0, 0x3F, 0x7F, 0x80, 0xFF, 0x7E, 0x07, 0xF7, 0xF8, 0x0F, 0xF7,
  0xE0, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0,
  0xFC, 0xFF, 0x00, 0xFE, 0x7E, 0x1F, 0xCF, 0xF0, 0x1F, 0xE7, 0xE1, 0xF8,
  0xFF, 0x01, 0xFE, 0x7E, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE3, 0xF0, 0xFE,
  0x01, 0xFC, 0x7F, 0x7F, 0x1F, 0xE0, 0x3F, 0xC7, 0xF7, 0xE1, 0xFE, 0x03,
  0xFC, 0x7F, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFF, 0xC1, 0xFC, 0x03, 0xF8,
  0x7F, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x3F,
  0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xF8,
  0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFC,
  0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0,
  0x7F, 0x7F, 0x80, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFC, 0x07, 0xF7, 0xF8,
  0x0F, 0xE0, 0x1F, 0xCF, 0xE0, 0x7F, 0x80, 0x7F, 0x3F, 0xC1, 0xFE, 0x03,
  0xFC, 0xFF, 0x07, 0xF8, 0x0F, 0xF1, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F, 0x8F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0xFE, 0x01, 0xFE, 0x0F, 0xF3,
  0xF8, 0x07, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x1F,
  0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x87,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8,
  0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC3, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x01,
  0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x3C, 0x0F,
  0xF8, 0x01, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC3, 0x00, 0x0F, 0xF0, 0xF0, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE3,
  0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xCF, 0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0x03, 0xFF, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xDF, 0x83, 0xFC, 0x07, 0xF0,
  0x7F, 0x7E, 0x0F, 0xF0, 0x1F, 0xC1, 0xFB, 0xF8, 0x3F, 0xC0, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xBF, 0x87, 0xF8, 0x07, 0xF1, 0xFC,
  0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF3, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0x8F,
  0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x1F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x7E,
  0x7F, 0x00, 0x1F, 0xDF, 0xC1, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x07, 0xEF,
  0xF0, 0x01, 0xFD, 0xF8, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFD, 0xFE, 0x00, 0x7F, 0xE7, 0xF8, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE7, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x83,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xF7,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xF1, 0xFC, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F,
  0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xC7, 0xFC,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x9F, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x80,
  0x7F, 0xE7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xF0, 0x03,
  0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xFC, 0x3F,
  0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0xE7, 0xF8,
  0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xF8,
  0x7F, 0x81, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0x7F, 0xFC, 0x0F,
  0xE7, 0xFF, 0x01, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFC, 0x0C, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x06, 0x0F, 0xFC,
  0x7C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xE1, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFF, 0xDF, 0xE0, 0x1F,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F,
  0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xE1, 0xFE, 0x3F,
  0xE0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x83, 0xFE, 0x01, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x82, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x01,
  0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0x87, 0xFC, 0x07, 0xF8,
  0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xE0, 0x0F,
  0xF9, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x7F, 0xC0, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF1,
  0xF8, 0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x87,
  0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0x3F, 0xF8, 0x7F,
  0xF8, 0x1F, 0xDF, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0,
  0xFF, 0xF1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xFC,
  0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xF1, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x3F, 0xF0, 0x1F, 0xCF, 0xFF, 0x03, 0xFB,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x7F, 0xC0,
  0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF,
  0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB,
  0xFE, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F,
  0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x1F, 0xF1, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xF9, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFC, 0x01,
  0xFE, 0x7F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE0, 0x40, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x0F,
  0xFF, 0x3F, 0x83, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80,
  0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x07,
  0xF1, 0xFE, 0x00, 0x10, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xC7,
  0xF0, 0x7F, 0x3F, 0xC1, 0xFD, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFE, 0x08, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x04, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x80, 0x1F, 0xF3, 0x80, 0x7F,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0xC6, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F,
  0xF8, 0x7F, 0x83, 0xFF, 0x0F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xE0, 0x7F, 0xF9, 0xFC, 0x0F, 0xFE, 0x3F,
  0x00, 0x7F, 0x87, 0xE0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xEF,
  0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xF8, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC,
  0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xF7, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFF, 0x03, 0xFC,
  0xFF, 0x07, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xBF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xBF, 0x1F, 0xE0, 0xFF, 0x1F, 0xBF, 0x1F, 0xE0, 0xFF,
  0x3F, 0x3F, 0x3F, 0xC0, 0xFF, 0x3F, 0x3F, 0x3F, 0xC0, 0x7F, 0x7F, 0x3F,
  0x3F, 0x80, 0x7F, 0x7E, 0x3F, 0x7F, 0x80, 0x7F, 0x7E, 0x3F, 0x7F, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x7E, 0xFC,
  0x3E, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03,
  0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x01,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x9F,
  0xFE, 0x00, 0xDF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x80, 0x00, 0xF8,
  0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 17, 37, 15, 0, -36 },
  { 80, 19, 13, 23, 5, -36 },
  { 111, 32, 36, 32, 1, -36 },
  { 255, 27, 41, 28, 1, -38 },
  { 394, 40, 36, 45, 3, -36 },
  { 574, 35, 37, 36, 1, -36 },
  { 736, 9, 13, 12, 5, -36 },
  { 751, 19, 44, 18, 2, -36 },
  { 856, 19, 45, 18, -3, -37 },
  { 963, 24, 24, 27, 4, -38 },
  { 1035, 25, 24, 29, 2, -30 },
  { 1110, 12, 12, 15, -2, -6 },
  { 1128, 14, 7, 16, 1, -17 },
  { 1141, 10, 9, 15, 0, -8 },
  { 1153, 28, 36, 22, -2, -36 },
  { 1279, 26, 37, 28, 2, -36 },
  { 1400, 21, 36, 28, 4, -36 },
  { 1495, 28, 36, 28, -1, -36 },
  { 1621, 27, 37, 28, 0, -36 },
  { 1746, 28, 36, 28, 0, -36 },
  { 1872, 27, 37, 28, 1, -36 },
  { 1997, 27, 37, 28, 2, -36 },
  { 2122, 29, 36, 28, 1, -36 },
  { 2253, 27, 37, 28, 1, -36 },
  { 2378, 25, 37, 28, 2, -36 },
  { 2494, 14, 29, 15, 0, -28 },
  { 2545, 17, 34, 15, -3, -28 },
  { 2618, 25, 27, 29, 2, -32 },
  { 2703, 25, 16, 29, 2, -26 },
  { 2753, 25, 27, 29, 2, -32 },
  { 2838, 21, 37, 24, 4, -36 },
  { 2936, 41, 41, 44, 2, -36 },
  { 3147, 32, 36, 33, -3, -36 },
  { 3291, 30, 36, 31, 1, -36 },
  { 3426, 30, 37, 31, 3, -36 },
  { 3565, 31, 36, 34, 1, -36 },
  { 3705, 28, 36, 28, 1, -36 },
  { 3831, 28, 36, 28, 1, -36 },
  { 3957, 31, 37, 35, 3, -36 },
  { 4101, 35, 36, 35, 1, -36 },
  { 4259, 25, 36, 20, -2, -36 },
  { 4372, 26, 47, 18, -8, -36 },
  { 4525, 35, 36, 32, 1, -36 },
  { 4683, 22, 36, 26, 1, -36 },
  { 4782, 44, 36, 45, 1, -36 },
  { 4980, 38, 36, 39, 1, -36 },
  { 5151, 32, 37, 37, 3, -36 },
  { 5299, 30, 36, 31, 1, -36 },
  { 5434, 32, 45, 37, 3, -36 },
  { 5614, 29, 36, 32, 1, -36 },
  { 5745, 26, 37, 27, 1, -36 },
  { 5866, 26, 36, 27, 4, -36 },
  { 5983, 32, 37, 35, 3, -36 },
  { 6131, 30, 36, 30, 4, -36 },
  { 6266, 46, 36, 46, 4, -36 },
  { 6473, 39, 36, 32, -3, -36 },
  { 6649, 30, 36, 29, 4, -36 },
  { 6784, 32, 36, 27, -2, -36 },
  { 6928, 22, 44, 17, -1, -36 },
  { 7049, 13, 36, 22, 5, -36 },
  { 7108, 21, 44, 17, -3, -36 },
  { 7224, 26, 24, 27, 0, -36 },
  { 7302, 23, 5, 21, -5, 4 },
  { 7317, 11, 8, 17, 7, -38 },
  { 7328, 27, 29, 30, 2, -28 },
  { 7426, 27, 39, 30, 1, -38 },
  { 7558, 23, 29, 25, 2, -28 },
  { 7642, 30, 39, 30, 2, -38 },
  { 7789, 25, 29, 28, 2, -28 },
  { 7880, 30, 50, 20, -5, -38 },
  { 8068, 28, 40, 30, 1, -28 },
  { 8208, 27, 38, 31, 1, -38 },
  { 8337, 16, 38, 16, 1, -38 },
  { 8413, 23, 50, 16, -6, -38 },
  { 8557, 31, 38, 30, 1, -38 },
  { 8705, 16, 38, 16, 1, -38 },
  { 8781, 42, 28, 46, 1, -28 },
  { 8928, 27, 28, 31, 1, -28 },
  { 9023, 26, 29, 30, 2, -28 },
  { 9118, 30, 40, 30, -2, -28 },
  { 9268, 27, 40, 30, 2, -28 },
  { 9403, 22, 28, 21, 1, -28 },
  { 9480, 22, 29, 24, 1, -28 },
  { 9560, 20, 34, 22, 2, -33 },
  { 9645, 27, 28, 31, 3, -27 },
  { 9740, 27, 27, 26, 2, -27 },
  { 9832, 40, 27, 40, 3, -27 },
  { 9967, 33, 27, 27, -3, -27 },
  { 10079, 32, 39, 27, -3, -27 },
  { 10235, 26, 27, 24, -1, -27 },
  { 10323, 21, 44, 18, 0, -36 },
  { 10439, 6, 49, 28, 11, -38 },
  { 10476, 21, 44, 18, -3, -36 },
  { 10592, 25, 9, 29, 2, -22 },
};

const GFXfont NotoSans_ExtraBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRABOLDITALIC50PT7B_H_
