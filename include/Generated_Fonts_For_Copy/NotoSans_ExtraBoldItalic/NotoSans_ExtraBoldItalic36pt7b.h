#ifndef _NOTOSANS_EXTRABOLDITALIC36PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x3E, 0x7D, 0xF9, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C,
  0xF9, 0xF3, 0xE7, 0x8F, 0x9E, 0x3C, 0x78, 0xF3, 0xC3, 0xC0, 0x00, 0x3C,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x01, 0xE3, 0xC0, 0x03, 0xE3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x0F, 0x8F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x01,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFD, 0xC6, 0x1F,
  0x30, 0x07, 0xE6, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1D, 0xF0, 0x03,
  0x3F, 0x40, 0xE7, 0xCF, 0x1D, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0xFF, 0x80, 0x3C, 0x0F, 0xFC, 0x03, 0xE0,
  0x7F, 0xF0, 0x3E, 0x07, 0xCF, 0x81, 0xE0, 0x3E, 0x7C, 0x1E, 0x03, 0xE3,
  0xE1, 0xF0, 0x1F, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0xF0, 0x07, 0xC7, 0x8F,
  0x00, 0x3E, 0x7C, 0xF8, 0xE1, 0xF3, 0xEF, 0x9F, 0xCF, 0xFE, 0x79, 0xFF,
  0x3F, 0xF7, 0xDF, 0xFD, 0xFF, 0x7D, 0xFB, 0xE3, 0xE7, 0xCF, 0x9F, 0x00,
  0x3C, 0x78, 0xF8, 0x03, 0xE7, 0xC7, 0xC0, 0x3E, 0x3E, 0x3E, 0x03, 0xE1,
  0xF1, 0xF0, 0x1E, 0x0F, 0x9F, 0x01, 0xF0, 0x7C, 0xF8, 0x1F, 0x03, 0xFF,
  0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0x00, 0x7F, 0xC0, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC3, 0xF8, 0xFF, 0xE1, 0xF8, 0xFF, 0xF0, 0xFC, 0xFF,
  0xFC, 0xFC, 0xFE, 0x7F, 0xFE, 0x7E, 0x1F, 0xFE, 0x3F, 0x0F, 0xFE, 0x1F,
  0x83, 0xFF, 0x0F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0x00, 0x3E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x06, 0x1F, 0x03, 0xCF, 0x03,
  0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE3, 0xFE,
  0x33, 0xFF, 0x03, 0xF7, 0xC1, 0xF3, 0xE0, 0x38, 0xF0, 0x08, 0x7C, 0x00,
  0x30, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0,
  0xF8, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xEF, 0xFC, 0x3C, 0xFF, 0xFF,
  0xFF, 0xEF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0x9F, 0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xF7,
  0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF,
  0xE3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7,
  0xFF, 0xBF, 0xFF, 0x7F, 0x7E, 0x7C, 0xF8, 0x63, 0xF0, 0x87, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x7C, 0x3F, 0x03, 0x03, 0xF0, 0x10, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x70, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xC0, 0x1F,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0,
  0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F, 0x81, 0xF1, 0xF8,
  0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0C, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0xC0, 0x3F, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF3, 0xE0,
  0x3E, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xC1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF7, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE,
  0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF9,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xF9, 0xFC, 0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3E, 0x7E, 0x07,
  0xCF, 0xC1, 0xF9, 0xFC, 0x7F, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0x7E, 0x1F, 0x9F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFE, 0x3B, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE1, 0xF0, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x80, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF3, 0xFF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEE, 0x0F, 0xD0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0xFE,
  0x1E, 0x3C, 0x1F, 0xFC, 0xF3, 0xE1, 0xFF, 0xC7, 0xDE, 0x1F, 0xFE, 0x1F,
  0xF1, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x8F, 0xF8, 0xF8, 0x78, 0x7F, 0xC7,
  0x83, 0xC3, 0xDE, 0x3C, 0x1E, 0x1E, 0xF1, 0xE1, 0xF1, 0xF7, 0x8F, 0x0F,
  0x8F, 0x3C, 0x7C, 0xFC, 0xF9, 0xE3, 0xFF, 0xFF, 0x8F, 0x1F, 0xEF, 0xF8,
  0x7C, 0x7E, 0x3F, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x10, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0x80, 0xFC,
  0x1F, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE1,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x81, 0xC3, 0xFC,
  0x01, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x01, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x1F, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0x81,
  0xFC, 0x7E, 0x1F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0x07, 0xF0, 0x02,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0xFF, 0xCF, 0xE1, 0xFF, 0x9F, 0x83, 0xFF, 0x3F, 0x0F, 0xFE, 0x7E,
  0x1F, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0,
  0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0x83, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xF0, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x08, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8,
  0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xBE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E,
  0xF8, 0x3D, 0xF0, 0x7D, 0xF0, 0xFB, 0xE0, 0xFB, 0xE1, 0xEF, 0xC1, 0xF7,
  0xC7, 0xDF, 0x87, 0xEF, 0x8F, 0x3F, 0x0F, 0xDF, 0x3E, 0x7C, 0x1F, 0x3E,
  0x78, 0xF8, 0x3E, 0x7D, 0xF3, 0xF0, 0x7C, 0xFB, 0xC7, 0xE1, 0xF9, 0xFF,
  0x8F, 0x83, 0xF3, 0xFE, 0x1F, 0x07, 0xC7, 0xFC, 0x3E, 0x0F, 0x8F, 0xF0,
  0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF0, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFC,
  0x1F, 0xE0, 0x1F, 0x87, 0xFC, 0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8,
  0x1F, 0x83, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x1F, 0xFE, 0x0F, 0x83,
  0xE7, 0xC1, 0xF0, 0x7C, 0xF8, 0x7E, 0x0F, 0x9F, 0x8F, 0xC1, 0xF3, 0xF1,
  0xF0, 0x7E, 0x3E, 0x3E, 0x0F, 0xC7, 0xE7, 0xC1, 0xF0, 0xFD, 0xF8, 0x3E,
  0x0F, 0xBF, 0x07, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x03, 0xFF,
  0x07, 0xC0, 0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x3F, 0x01, 0xFF, 0x07, 0xE0,
  0x1F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x3F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00, 0x7E, 0xFE,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xE3, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x0F, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x3F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x3F,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC,
  0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0x87, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x40,
  0x1F, 0x8C, 0x07, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F,
  0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFE, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0xC1, 0xF0, 0x7E,
  0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF1, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x0F, 0xDF, 0x81, 0xFC,
  0x07, 0xEF, 0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x7F,
  0x83, 0xF1, 0xF8, 0x3F, 0xC1, 0xF8, 0xFC, 0x3F, 0xE0, 0xFC, 0x7E, 0x1E,
  0xF0, 0xFC, 0x3F, 0x1F, 0x78, 0x7E, 0x1F, 0x8F, 0xBC, 0x7E, 0x0F, 0xCF,
  0x9E, 0x3F, 0x07, 0xE7, 0xCF, 0x1F, 0x03, 0xF3, 0xE7, 0x9F, 0x81, 0xFB,
  0xE3, 0xCF, 0x80, 0x7D, 0xF1, 0xEF, 0xC0, 0x3F, 0xF0, 0xF7, 0xE0, 0x1F,
  0xF8, 0x7B, 0xE0, 0x0F, 0x78, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x9F, 0x81, 0xFC,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x7E, 0x07, 0xE7,
  0xE0, 0x3F, 0x7F, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0xF8, 0xF0, 0x1E,
  0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF3, 0xE0,
  0x1F, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E,
  0x7E, 0x3E, 0x1F, 0x0F, 0x03, 0xE3, 0xE1, 0xFE, 0x7C, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xF7, 0xF0, 0x7E, 0xFC,
  0x0F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x7E, 0x3F, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFE,
  0xF8, 0x1F, 0x9F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0xF8, 0x1F,
  0xBF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF8, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xFD, 0xF8,
  0x3F, 0xBF, 0x07, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0x7F, 0xC3, 0xC7, 0xE0, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x02, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x08, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0xFC, 0x0F, 0xF7,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xF1, 0xFC, 0x3F,
  0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xFB,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xCF, 0x80,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x9F, 0xDF,
  0xC3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x23, 0xF8, 0x38,
  0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFE, 0x20, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x23, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0x9F, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E,
  0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x80, 0x7E,
  0x0C, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0xFC, 0x1F,
  0xBF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFC, 0x7E, 0x7F,
  0x0F, 0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x00, 0x01, 0x80, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x00,
  0x00, 0x02, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x81, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0x7E, 0x1F, 0xC1, 0xF8,
  0xFE, 0x07, 0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0x1F, 0x83, 0xF0, 0x7C, 0xFF, 0x1F, 0xE1, 0xF7,
  0xFC, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F,
  0xE3, 0xF3, 0xF8, 0x7F, 0x0F, 0xCF, 0xE1, 0xF8, 0x3F, 0x3F, 0x07, 0xE0,
  0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0x7C, 0x1F, 0x9F, 0x83, 0xF0, 0x7E,
  0x7E, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x1F, 0xBF,
  0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF8, 0x3F, 0x3F, 0x07, 0xE1, 0xFC, 0x0F, 0x1F, 0x83, 0xE7, 0xF8, 0x7D,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x8F, 0xCF, 0xE1, 0xF9, 0xFC,
  0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF,
  0x07, 0xEF, 0xC3, 0xF3, 0xFB, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x03, 0xC7, 0xC0, 0x3E, 0xFF, 0x01, 0xF7, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7C, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE3, 0xE1, 0xFE,
  0x7C, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x83,
  0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xF7, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC1, 0xFE, 0xF8, 0x1F, 0xBF, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x9F, 0x1F, 0x3F, 0x1F, 0x7E, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xF8, 0xE1, 0xFC, 0x10, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF2, 0x01, 0xF9, 0xC1, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFC, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFB, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x7F, 0x8F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x9F,
  0x03, 0xF1, 0xE0, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE3, 0xF0, 0x7C, 0x7E,
  0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x81, 0xFF, 0xE0, 0xFC, 0x1F, 0xBF, 0x0F,
  0xE0, 0xFD, 0xF8, 0x7F, 0x0F, 0xCF, 0xC7, 0xF8, 0x7E, 0x7E, 0x3F, 0xC3,
  0xE3, 0xF1, 0xFE, 0x3F, 0x1F, 0x9E, 0xF1, 0xF0, 0xFC, 0xF7, 0x9F, 0x87,
  0xEF, 0xBC, 0xF8, 0x1F, 0x79, 0xEF, 0xC0, 0xFB, 0xCF, 0x7E, 0x07, 0xFC,
  0x7B, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0x07, 0xF0, 0xFE, 0x03, 0xF1,
  0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF, 0xC0, 0x3F, 0x8F, 0xE0, 0x7F, 0x07,
  0xE0, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x01, 0xF0, 0xFC,
  0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x07, 0xFA, 0x00,
  0x20,
};

const GFXglyph NotoSans_ExtraBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 26, 11, 0, -26 },
  { 40, 14, 10, 16, 3, -26 },
  { 58, 24, 26, 23, 0, -26 },
  { 136, 19, 29, 20, 1, -27 },
  { 205, 29, 26, 32, 2, -26 },
  { 300, 25, 26, 26, 1, -26 },
  { 382, 7, 10, 9, 3, -26 },
  { 391, 14, 32, 13, 1, -26 },
  { 447, 14, 32, 13, -2, -26 },
  { 503, 17, 18, 20, 3, -28 },
  { 542, 17, 17, 21, 2, -21 },
  { 579, 9, 9, 11, -2, -4 },
  { 590, 11, 5, 12, 0, -12 },
  { 597, 7, 6, 11, 0, -6 },
  { 603, 21, 26, 16, -2, -26 },
  { 672, 19, 26, 20, 1, -26 },
  { 734, 15, 26, 20, 3, -26 },
  { 783, 20, 26, 20, -1, -26 },
  { 848, 20, 26, 20, 0, -26 },
  { 913, 20, 26, 20, 0, -26 },
  { 978, 20, 26, 20, 0, -26 },
  { 1043, 20, 26, 20, 1, -26 },
  { 1108, 21, 26, 20, 1, -26 },
  { 1177, 19, 26, 20, 1, -26 },
  { 1239, 18, 26, 20, 2, -26 },
  { 1298, 10, 20, 11, 0, -20 },
  { 1323, 12, 25, 11, -2, -20 },
  { 1361, 17, 20, 21, 2, -23 },
  { 1404, 17, 11, 21, 2, -18 },
  { 1428, 17, 20, 21, 2, -23 },
  { 1471, 15, 26, 17, 3, -26 },
  { 1520, 29, 29, 32, 2, -26 },
  { 1626, 23, 26, 23, -2, -26 },
  { 1701, 21, 26, 23, 1, -26 },
  { 1770, 22, 26, 22, 2, -26 },
  { 1842, 22, 26, 24, 1, -26 },
  { 1914, 20, 26, 20, 1, -26 },
  { 1979, 20, 26, 20, 1, -26 },
  { 2044, 23, 26, 25, 2, -26 },
  { 2119, 25, 26, 25, 1, -26 },
  { 2201, 17, 26, 15, -1, -26 },
  { 2257, 19, 34, 13, -6, -26 },
  { 2338, 25, 26, 23, 1, -26 },
  { 2420, 16, 26, 19, 1, -26 },
  { 2472, 31, 26, 32, 1, -26 },
  { 2573, 27, 26, 28, 1, -26 },
  { 2661, 23, 26, 26, 2, -26 },
  { 2736, 21, 26, 22, 1, -26 },
  { 2805, 23, 32, 26, 2, -26 },
  { 2897, 21, 26, 23, 1, -26 },
  { 2966, 19, 26, 19, 1, -26 },
  { 3028, 19, 26, 19, 3, -26 },
  { 3090, 23, 26, 25, 2, -26 },
  { 3165, 22, 26, 22, 3, -26 },
  { 3237, 33, 26, 33, 3, -26 },
  { 3345, 28, 26, 23, -2, -26 },
  { 3436, 21, 26, 21, 3, -26 },
  { 3505, 22, 26, 19, -1, -26 },
  { 3577, 16, 32, 12, -1, -26 },
  { 3641, 9, 26, 16, 4, -26 },
  { 3671, 15, 32, 12, -2, -26 },
  { 3731, 19, 17, 20, 0, -26 },
  { 3772, 16, 3, 15, -3, 3 },
  { 3778, 8, 6, 12, 5, -28 },
  { 3784, 19, 20, 22, 2, -20 },
  { 3832, 19, 27, 22, 1, -27 },
  { 3897, 16, 20, 18, 2, -20 },
  { 3937, 21, 27, 22, 2, -27 },
  { 4008, 18, 20, 20, 2, -20 },
  { 4053, 22, 37, 14, -4, -28 },
  { 4155, 20, 29, 22, 1, -20 },
  { 4228, 19, 27, 22, 1, -27 },
  { 4293, 11, 28, 11, 1, -28 },
  { 4332, 17, 37, 11, -5, -28 },
  { 4411, 22, 27, 21, 1, -27 },
  { 4486, 12, 27, 11, 0, -27 },
  { 4527, 30, 20, 33, 1, -20 },
  { 4602, 19, 20, 22, 1, -20 },
  { 4650, 18, 20, 21, 2, -20 },
  { 4695, 21, 29, 22, -1, -20 },
  { 4772, 19, 29, 22, 2, -20 },
  { 4841, 16, 20, 15, 1, -20 },
  { 4881, 17, 20, 18, 0, -20 },
  { 4924, 15, 24, 16, 1, -24 },
  { 4969, 20, 20, 22, 2, -20 },
  { 5019, 19, 20, 19, 2, -20 },
  { 5067, 29, 20, 29, 2, -20 },
  { 5140, 24, 20, 20, -2, -20 },
  { 5200, 23, 29, 19, -2, -20 },
  { 5284, 19, 20, 17, -1, -20 },
  { 5332, 15, 32, 13, 0, -26 },
  { 5392, 4, 35, 20, 8, -27 },
  { 5410, 15, 32, 13, -2, -26 },
  { 5470, 17, 7, 21, 2, -16 },
};

const GFXfont NotoSans_ExtraBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRABOLDITALIC36PT7B_H_
