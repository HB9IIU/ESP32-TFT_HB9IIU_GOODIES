#ifndef _NOTOSANS_EXTRABOLDITALIC49PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x08,
  0x00, 0x7F, 0x9F, 0xEF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xE1,
  0xF8, 0xFC, 0x3F, 0x3F, 0x8F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0x00, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x3C, 0x30,
  0x3F, 0xCE, 0x00, 0x0F, 0xE3, 0x80, 0x03, 0xFD, 0xE0, 0x00, 0xFF, 0x78,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0xFF, 0x00, 0x07, 0x1F,
  0xC8, 0x01, 0xC7, 0xF3, 0x80, 0xF3, 0xFC, 0xFE, 0x3D, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x00, 0x7F,
  0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xE3,
  0xF0, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x7E,
  0x00, 0xFE, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0xFC,
  0x00, 0x1F, 0x87, 0xE3, 0xF8, 0x30, 0x3F, 0x1F, 0xCF, 0xE3, 0xFC, 0x7E,
  0x3F, 0x9F, 0x9F, 0xFC, 0xFF, 0xFE, 0x7E, 0x7F, 0xFD, 0xFF, 0xF9, 0xFD,
  0xFF, 0xF9, 0xFF, 0xF7, 0xF3, 0xFF, 0xF9, 0xFF, 0xCF, 0xCF, 0xE3, 0xF1,
  0xFE, 0x3F, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0xFE,
  0x00, 0x7F, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xE0,
  0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x07, 0xF8, 0x7F, 0xFF,
  0x81, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xC7, 0xFC,
  0xFF, 0x9F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x1F, 0xF8, 0x7F, 0xBF,
  0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x40, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x20, 0x3F, 0x00, 0x38,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0xBE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0x0E, 0x0F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x7F,
  0xDF, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x0F, 0xE0, 0x02,
  0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0x0F,
  0xE7, 0xFB, 0xFF, 0xFF, 0xBF, 0xEF, 0xF9, 0xFC, 0x1C, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xFC,
  0x07, 0xFB, 0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFE,
  0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0xFF,
  0x8F, 0xF0, 0x7F, 0xC7, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xE7, 0xF8, 0x7E, 0x7F, 0x83, 0xC3, 0xFC,
  0x0C, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0,
  0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7C, 0x1F, 0xF8, 0x06, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF2, 0x00, 0x03, 0xFE, 0x60, 0x00, 0xFF, 0x8F, 0xC0, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xBF,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x1F,
  0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x02,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE2, 0x00,
  0x0F, 0xF8, 0x60, 0x03, 0xFF, 0x0F, 0x81, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0x02, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF1, 0xF8, 0x03, 0xF9, 0xFF, 0x81, 0xFE, 0xFF, 0xF0, 0x7F, 0x7F,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xFC, 0xFF,
  0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFC,
  0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0,
  0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0x83, 0xFC, 0x1F,
  0xE1, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFB,
  0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0x7F, 0xC3, 0xFF,
  0x3F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF7, 0xF0, 0x3F, 0xF7, 0xF8, 0x07, 0xE3, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x86, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xF8, 0x3F, 0xE7, 0x00, 0xFF, 0x20, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7F, 0xFC, 0x7E, 0x1F, 0x81, 0xFF, 0xFC, 0x3F, 0x3F,
  0x03, 0xFF, 0xFC, 0x3F, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0x7E, 0x0F, 0xF0,
  0xF8, 0x3F, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x7E, 0x1F, 0x81, 0xF8, 0x3F,
  0x7C, 0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x3F, 0x01, 0xF0, 0x3F, 0xFC, 0x3F,
  0x03, 0xF0, 0x3E, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x03, 0xF0,
  0x7E, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7E, 0x1F, 0xFD, 0xFF, 0xE0, 0x7E, 0x0F, 0xF9, 0xFF, 0x80,
  0x7F, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x3F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0,
  0x7F, 0x81, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xFC, 0x0F, 0xFC,
  0x01, 0xE0, 0xFF, 0xC0, 0x02, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x01, 0xFF,
  0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x40, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xF9, 0xFC, 0x0F, 0xFE, 0x00, 0x70, 0x7F, 0xF0, 0x00, 0x41,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0x3F, 0xC0, 0xFF,
  0xFC, 0xFF, 0x03, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F,
  0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0C, 0x3F, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xC1, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x80,
  0x7E, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03, 0xF7,
  0xF0, 0x0F, 0xEF, 0xC0, 0xFE, 0xFE, 0x03, 0xFD, 0xF8, 0x1F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x07, 0xF7, 0xF8, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x01, 0xFC,
  0xFC, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0x87, 0xE3, 0xF8, 0x0F, 0xF3, 0xF1,
  0xFC, 0xFF, 0x01, 0xFC, 0x7E, 0x3F, 0x1F, 0xE0, 0x3F, 0x8F, 0xCF, 0xE3,
  0xF8, 0x07, 0xF1, 0xF9, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x7F, 0x1F, 0xE0,
  0x3F, 0xC7, 0xEF, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0xF8, 0x7F, 0x80, 0xFE,
  0x1F, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0x7F,
  0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFF, 0x81,
  0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xF0,
  0x01, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x01,
  0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x01,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x01, 0xFD,
  0xFC, 0x07, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xC0, 0x7F, 0x7F, 0x81, 0xFC,
  0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x3F, 0xCF, 0xF0, 0x7F, 0x01, 0xFC, 0x7F,
  0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x8F, 0xE0, 0x3F, 0xC3, 0xFC, 0x7F, 0x01, 0xFE, 0x0F, 0xE7,
  0xF8, 0x0F, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0x03, 0xFD, 0xFC, 0x07, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xFC, 0x07, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xE0, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xDF,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F,
  0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFC, 0xFF,
  0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81,
  0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0x7F,
  0xC7, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE3, 0xF0, 0x3F, 0xE0, 0x18, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x08, 0x00, 0x7F, 0xC3, 0x80, 0x1F, 0xF0, 0xFF, 0x3F,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0,
  0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x87, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x0F, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xE1, 0xFE, 0x07, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xF7, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xBF, 0x07, 0xF8, 0x0F,
  0xE1, 0xFD, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xCF, 0xC3, 0xFC, 0x03, 0xF8,
  0xFE, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xF3, 0xF1, 0xFE, 0x00, 0xFE, 0x7F,
  0x1F, 0x8F, 0xF0, 0x07, 0xF3, 0xF8, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x87,
  0xE7, 0xF8, 0x01, 0xFD, 0xFC, 0x3F, 0x3F, 0x80, 0x0F, 0xEF, 0xC1, 0xFB,
  0xFC, 0x00, 0x7F, 0xFE, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0x7E, 0xFE,
  0x00, 0x1F, 0xBF, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFB, 0xFC, 0x00, 0xFF, 0x9F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xE7, 0xC0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0xFE,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xEF, 0xE0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x9F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFF,
  0x0F, 0xE0, 0x3F, 0xF1, 0xF8, 0x0F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0x87,
  0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F,
  0xC7, 0xFC, 0x07, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFC, 0x03, 0xFF,
  0x3F, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFF,
  0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x03,
  0xFE, 0x3F, 0xC0, 0xFF, 0x9F, 0xF0, 0x7F, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0x83,
  0xF9, 0xFF, 0xC0, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFE, 0x1E, 0x1F, 0xF8, 0x04, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0x0F, 0xFC, 0x3E, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF9, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80,
  0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0x00, 0x3F, 0xF3, 0xF0, 0x00,
  0xFF, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFC, 0x7F,
  0xC1, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xE0, 0x7F, 0x9F,
  0xE0, 0x7F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0x0F, 0xFC, 0x03, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xFC, 0x7E, 0x01, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF0, 0x7F,
  0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFE, 0x01, 0xFF, 0xBF, 0xC0, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x80, 0x07, 0xF8, 0x0E, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x03, 0xFD, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x01,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x38, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x03, 0xF9, 0xFF, 0x83, 0xFF, 0x81, 0xFD, 0xFF, 0xE3,
  0xFF, 0xC0, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF9, 0xFF, 0xF3, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0x8F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x0F, 0xF1,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE0, 0x7F, 0xCF,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x7F, 0xF0,
  0x1F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0x9F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3,
  0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC,
  0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x7F,
  0xC1, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0xDF, 0xF0, 0x7F, 0xCF, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFF, 0x00, 0x3F, 0xBF,
  0xF8, 0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0x00, 0xFF, 0x7F, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xF1, 0xF8, 0x0F, 0xFF, 0x7F, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFE, 0x7F, 0xE1,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFC,
  0x03, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x7F, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xEC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xCF, 0xC3, 0xFE, 0x07, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x20, 0x07, 0xF8, 0xC0, 0x1F,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x60, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xE0, 0x3F,
  0xFD, 0xFC, 0x07, 0xFF, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC7, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0xF0,
  0x3F, 0xCF, 0xE0, 0x7F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0xC1, 0xFE, 0x3F,
  0x83, 0xFF, 0x83, 0xFC, 0x7F, 0x07, 0xDF, 0x07, 0xF8, 0xFE, 0x1F, 0xBE,
  0x1F, 0xE1, 0xFC, 0x3F, 0x7C, 0x3F, 0xC3, 0xF8, 0x7C, 0xF8, 0xFF, 0x07,
  0xF1, 0xF9, 0xF1, 0xFE, 0x0F, 0xE3, 0xF7, 0xE7, 0xF8, 0x1F, 0xCF, 0xCF,
  0xCF, 0xF0, 0x3F, 0x9F, 0x9F, 0x9F, 0xC0, 0x3F, 0x3F, 0x3F, 0x7F, 0x80,
  0x7E, 0xFC, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0xFD, 0xFC, 0x01, 0xFB, 0xE1,
  0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x3F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x01,
  0x3F, 0xF0, 0x01, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 36, 14, 0, -35 },
  { 73, 19, 13, 22, 5, -35 },
  { 104, 31, 35, 32, 1, -35 },
  { 240, 26, 40, 28, 1, -37 },
  { 370, 39, 35, 44, 3, -35 },
  { 541, 34, 36, 35, 1, -36 },
  { 694, 9, 13, 12, 5, -35 },
  { 709, 19, 43, 17, 2, -35 },
  { 812, 19, 44, 17, -3, -36 },
  { 917, 24, 24, 27, 4, -38 },
  { 989, 24, 24, 28, 2, -29 },
  { 1061, 12, 12, 14, -2, -6 },
  { 1079, 14, 6, 16, 1, -16 },
  { 1090, 10, 9, 14, 0, -8 },
  { 1102, 27, 35, 22, -2, -35 },
  { 1221, 25, 36, 28, 2, -36 },
  { 1334, 21, 35, 28, 4, -35 },
  { 1426, 27, 35, 28, -1, -35 },
  { 1545, 27, 35, 28, 0, -35 },
  { 1664, 27, 35, 28, 0, -35 },
  { 1783, 27, 35, 28, 1, -35 },
  { 1902, 26, 36, 28, 2, -36 },
  { 2019, 29, 35, 28, 1, -35 },
  { 2146, 26, 36, 28, 1, -36 },
  { 2263, 25, 36, 28, 2, -36 },
  { 2376, 14, 28, 14, 0, -27 },
  { 2425, 17, 33, 14, -3, -27 },
  { 2496, 24, 26, 28, 2, -31 },
  { 2574, 24, 16, 28, 2, -25 },
  { 2622, 24, 26, 28, 2, -31 },
  { 2700, 21, 36, 23, 4, -35 },
  { 2795, 40, 39, 43, 2, -35 },
  { 2990, 32, 35, 32, -3, -35 },
  { 3130, 29, 35, 31, 1, -35 },
  { 3257, 29, 36, 30, 3, -36 },
  { 3388, 31, 35, 33, 1, -35 },
  { 3524, 28, 35, 27, 1, -35 },
  { 3647, 27, 35, 27, 1, -35 },
  { 3766, 30, 36, 34, 3, -36 },
  { 3901, 34, 35, 35, 1, -35 },
  { 4050, 24, 35, 20, -2, -35 },
  { 4155, 26, 46, 17, -8, -35 },
  { 4305, 34, 35, 31, 1, -35 },
  { 4454, 22, 35, 26, 1, -35 },
  { 4551, 43, 35, 44, 1, -35 },
  { 4740, 37, 35, 38, 1, -35 },
  { 4902, 31, 36, 36, 3, -36 },
  { 5042, 29, 35, 30, 1, -35 },
  { 5169, 31, 44, 36, 3, -36 },
  { 5340, 28, 35, 31, 1, -35 },
  { 5463, 26, 35, 26, 1, -35 },
  { 5577, 26, 35, 27, 4, -35 },
  { 5691, 32, 35, 34, 3, -35 },
  { 5831, 30, 35, 30, 4, -35 },
  { 5963, 45, 35, 45, 4, -35 },
  { 6160, 38, 35, 31, -3, -35 },
  { 6327, 29, 35, 29, 4, -35 },
  { 6454, 31, 35, 26, -2, -35 },
  { 6590, 21, 43, 17, -1, -35 },
  { 6703, 13, 35, 22, 5, -35 },
  { 6760, 21, 43, 17, -3, -35 },
  { 6873, 26, 23, 27, 0, -35 },
  { 6948, 21, 4, 21, -4, 4 },
  { 6959, 11, 8, 17, 7, -38 },
  { 6970, 27, 27, 29, 2, -27 },
  { 7062, 26, 37, 29, 1, -37 },
  { 7183, 23, 27, 24, 2, -27 },
  { 7261, 29, 37, 29, 2, -37 },
  { 7396, 25, 27, 28, 2, -27 },
  { 7481, 29, 49, 19, -5, -37 },
  { 7659, 28, 39, 29, 1, -27 },
  { 7796, 27, 37, 30, 1, -37 },
  { 7921, 15, 38, 15, 1, -38 },
  { 7993, 23, 50, 15, -6, -38 },
  { 8137, 30, 37, 29, 1, -37 },
  { 8276, 16, 37, 15, 1, -37 },
  { 8350, 41, 27, 45, 1, -27 },
  { 8489, 27, 27, 30, 1, -27 },
  { 8581, 25, 27, 29, 2, -27 },
  { 8666, 29, 39, 29, -2, -27 },
  { 8808, 27, 39, 29, 2, -27 },
  { 8940, 22, 27, 21, 1, -27 },
  { 9015, 22, 27, 24, 1, -27 },
  { 9090, 20, 32, 21, 2, -32 },
  { 9170, 27, 27, 30, 2, -27 },
  { 9262, 27, 27, 26, 2, -27 },
  { 9354, 39, 27, 39, 3, -27 },
  { 9486, 33, 27, 27, -3, -27 },
  { 9598, 32, 39, 26, -3, -27 },
  { 9754, 25, 27, 23, -1, -27 },
  { 9839, 21, 43, 18, 0, -35 },
  { 9952, 6, 48, 27, 11, -37 },
  { 9988, 21, 43, 18, -3, -35 },
  { 10101, 24, 9, 28, 2, -22 },
};

const GFXfont NotoSans_ExtraBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRABOLDITALIC49PT7B_H_
