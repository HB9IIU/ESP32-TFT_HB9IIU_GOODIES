#ifndef _NOTOSANS_EXTRABOLDITALIC15PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x67, 0x39, 0x80, 0x07, 0x38, 0x6D, 0xB6, 0xF6, 0x0D,
  0x83, 0x61, 0x91, 0xFF, 0x7F, 0xC4, 0xCF, 0xFB, 0xFE, 0x36, 0x19, 0x06,
  0xC0, 0x04, 0x3F, 0x3F, 0x7C, 0x38, 0x3E, 0x0F, 0x0F, 0xF7, 0xFE, 0x10,
  0x10, 0x30, 0x67, 0x8C, 0xD9, 0x8D, 0xB0, 0xDB, 0x4F, 0x6F, 0x6D, 0xB0,
  0x9B, 0x19, 0xB3, 0x1E, 0x61, 0xE0, 0x0E, 0x03, 0xE0, 0xEC, 0x1D, 0x81,
  0xF0, 0x79, 0xDF, 0xB7, 0x3E, 0xE7, 0x8F, 0xF1, 0xF7, 0x00, 0x6D, 0xE0,
  0x19, 0x9C, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0x8E, 0x00, 0x18, 0x61, 0xC3,
  0x0C, 0x31, 0xC6, 0x18, 0x63, 0x1C, 0xE0, 0x1C, 0xB3, 0xF9, 0xF7, 0x8D,
  0x82, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x00, 0x37, 0x6C, 0x7F,
  0x80, 0xFC, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x38, 0x00, 0x0E, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x67, 0xE7, 0x66,
  0x7E, 0x3C, 0x0E, 0x39, 0xF7, 0x65, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xC0,
  0x1E, 0x7F, 0x37, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x1E,
  0x7F, 0x27, 0x03, 0x0E, 0x3C, 0x0E, 0x07, 0x87, 0xFE, 0xFC, 0x03, 0x07,
  0x0F, 0x1F, 0x3E, 0x36, 0x66, 0xFF, 0xFF, 0x0C, 0x0C, 0x1F, 0x3F, 0x30,
  0x30, 0x3C, 0x7E, 0x07, 0x07, 0x86, 0xFE, 0xFC, 0x1F, 0x3E, 0x70, 0xE0,
  0xDC, 0xFE, 0xCE, 0xCE, 0xCE, 0xFC, 0x78, 0x3F, 0x9F, 0xD0, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x30, 0x38, 0x38, 0x3C, 0x00, 0x1E, 0x3F, 0x33, 0x33,
  0x3F, 0x1C, 0x7E, 0x67, 0xE7, 0x7E, 0x7C, 0x3C, 0xFF, 0xBE, 0x3C, 0xFF,
  0xFF, 0x86, 0x1D, 0xF3, 0xC0, 0x37, 0x00, 0x00, 0xEE, 0x19, 0xC0, 0x00,
  0x01, 0xCC, 0x66, 0x00, 0x06, 0x3D, 0xE7, 0x0F, 0x07, 0xC1, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x71, 0xFE, 0x30, 0x40, 0x39,
  0xF9, 0x38, 0x61, 0xC7, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x07, 0x83, 0xFC,
  0x70, 0x66, 0x7B, 0xCF, 0xBD, 0x93, 0x93, 0x39, 0x36, 0xDD, 0xCC, 0x88,
  0x61, 0x03, 0xF0, 0x03, 0x81, 0xE0, 0xF8, 0x36, 0x1D, 0x86, 0x63, 0x98,
  0xFE, 0x7F, 0xD8, 0x7E, 0x1C, 0x1F, 0x1F, 0xCE, 0xE6, 0x33, 0xFB, 0xF1,
  0xDC, 0xE6, 0x63, 0x3F, 0xBF, 0x80, 0x1F, 0x1F, 0xDC, 0x4C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xE2, 0x7F, 0x1F, 0x80, 0x1E, 0x0F, 0xE3, 0xB8, 0xC7,
  0x31, 0xDC, 0x77, 0x1D, 0xCE, 0x67, 0x9F, 0xCF, 0xC0, 0x1F, 0x9F, 0x8E,
  0x06, 0x03, 0xF3, 0xF1, 0xC0, 0xE0, 0x60, 0x3F, 0x3F, 0x80, 0x1F, 0x9F,
  0x8E, 0x06, 0x03, 0x13, 0xF1, 0xF8, 0xE0, 0x60, 0x30, 0x38, 0x00, 0x0F,
  0x1F, 0xDE, 0x4C, 0x0E, 0x07, 0x7F, 0x3D, 0x86, 0xE7, 0x7F, 0x9F, 0xC0,
  0x18, 0xE7, 0x18, 0xE3, 0x18, 0xE3, 0xFC, 0xFF, 0x9F, 0xE3, 0x8C, 0x63,
  0x8C, 0x73, 0x8E, 0x00, 0x3E, 0xFC, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x71,
  0xF3, 0xE0, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x61,
  0xCF, 0x9E, 0x00, 0x18, 0xE7, 0x38, 0xEE, 0x1B, 0x83, 0x60, 0xFC, 0x1F,
  0x83, 0xB0, 0x67, 0x0C, 0xE3, 0x8E, 0x00, 0x18, 0x70, 0xE1, 0x83, 0x0E,
  0x1C, 0x38, 0x60, 0xFF, 0xF8, 0x1C, 0x39, 0xE3, 0xCF, 0x1E, 0x79, 0xB3,
  0xCF, 0xBE, 0x59, 0xF6, 0xCD, 0xA6, 0x6F, 0x73, 0x7B, 0xBB, 0x98, 0x1C,
  0x73, 0xC6, 0x3C, 0x63, 0xE6, 0x3E, 0xE7, 0x6E, 0x76, 0xC6, 0x7C, 0x63,
  0xC6, 0x3C, 0xE3, 0xC0, 0x0E, 0x0F, 0xE7, 0x39, 0x87, 0xE1, 0xF8, 0x6C,
  0x1B, 0x0E, 0xE7, 0x3F, 0xC7, 0xE0, 0x1E, 0x1F, 0xCE, 0xE6, 0x33, 0x3B,
  0xFD, 0xFC, 0xE0, 0x60, 0x30, 0x38, 0x00, 0x0F, 0x0F, 0xE7, 0x39, 0x87,
  0xE1, 0xF8, 0x6C, 0x1B, 0x0E, 0xE7, 0x3F, 0xC7, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x1E, 0x1F, 0xCE, 0xE6, 0x73, 0x3B, 0xF9, 0xF8, 0xEC, 0x67, 0x33,
  0xB8, 0xE0, 0x1E, 0x3F, 0x31, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x8E, 0xFE,
  0xFC, 0x7F, 0xFF, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60,
  0x71, 0xDC, 0x67, 0x19, 0x8E, 0x63, 0xB8, 0xCE, 0x33, 0x9C, 0xE7, 0x3F,
  0x87, 0xC0, 0xE1, 0xF1, 0xF8, 0xDC, 0xE6, 0x63, 0x71, 0xB0, 0xF8, 0x78,
  0x3C, 0x1C, 0x00, 0xE3, 0x1F, 0x9C, 0x7E, 0x71, 0xB9, 0xCE, 0xEF, 0x33,
  0xBD, 0xCF, 0xB6, 0x3E, 0xD8, 0x73, 0xC1, 0xCF, 0x07, 0x3C, 0x00, 0x18,
  0x71, 0xCE, 0x1D, 0xC0, 0xD8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB0, 0x3B,
  0x87, 0x38, 0xE1, 0xC0, 0xE3, 0xB3, 0x99, 0xCF, 0xC7, 0xC1, 0xC0, 0xE0,
  0x60, 0x30, 0x38, 0x1C, 0x00, 0x1F, 0xC7, 0xF2, 0x38, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x1F, 0xCF, 0xF0, 0x3C, 0xF3, 0x0C, 0x31, 0x86,
  0x18, 0x61, 0x8C, 0x30, 0xF0, 0xDB, 0x6D, 0xDB, 0x6D, 0x80, 0x1C, 0xF0,
  0xC3, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0xF0, 0x04, 0x0C, 0x1E, 0x16,
  0x36, 0x62, 0xE3, 0xFF, 0xF0, 0xE3, 0x7B, 0x7E, 0xE6, 0xC6, 0xCE, 0xCE,
  0xFC, 0xFC, 0x38, 0x38, 0x30, 0x3F, 0x3F, 0x73, 0x63, 0x63, 0x67, 0x7E,
  0xDC, 0x7E, 0xFB, 0x86, 0x0C, 0x18, 0x3E, 0x3C, 0x03, 0x03, 0x07, 0x7F,
  0x7E, 0xE6, 0xC6, 0xCE, 0xCE, 0xFC, 0xFC, 0x3E, 0xEF, 0x9F, 0xFF, 0x98,
  0x3F, 0x3E, 0x07, 0x83, 0xC3, 0x83, 0xE1, 0xF0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x06, 0x03, 0x0B, 0x87, 0x81, 0x80, 0x3D, 0x9F, 0x9C, 0xCC, 0x66,
  0x73, 0x39, 0xF8, 0xEC, 0x06, 0x47, 0x3F, 0x06, 0x00, 0x38, 0x38, 0x30,
  0x3F, 0x3F, 0x73, 0x73, 0x63, 0x67, 0x67, 0xE6, 0x11, 0xC6, 0x13, 0x19,
  0xCE, 0x63, 0x19, 0xC0, 0x04, 0x1C, 0x18, 0x10, 0xC1, 0x87, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x9E, 0x3C, 0x60, 0x38, 0x0E, 0x03, 0x04, 0xCE, 0x37,
  0x1F, 0x87, 0xC1, 0xF0, 0x6E, 0x19, 0x8E, 0x70, 0x39, 0xCE, 0x63, 0x39,
  0xCC, 0x63, 0x38, 0x3F, 0x79, 0xFF, 0xDC, 0xEE, 0xE6, 0x76, 0x33, 0xB3,
  0x99, 0x9C, 0xDC, 0xCE, 0x3F, 0x3F, 0x73, 0x73, 0x63, 0x67, 0x67, 0xE6,
  0x7E, 0xFF, 0x9E, 0x3C, 0x79, 0xFF, 0x3C, 0x1F, 0x8F, 0xCE, 0x66, 0x33,
  0x19, 0x9C, 0xFC, 0xFC, 0x70, 0x30, 0x18, 0x1C, 0x00, 0x7B, 0x7E, 0xE6,
  0xC6, 0xCE, 0xCE, 0xFC, 0xEC, 0x1C, 0x1C, 0x18, 0x18, 0x3E, 0x7D, 0xC3,
  0x86, 0x0C, 0x18, 0x70, 0x3E, 0xE9, 0xC3, 0xE1, 0xC1, 0xBF, 0x7C, 0x30,
  0xCF, 0xFE, 0x63, 0x8E, 0x30, 0xF3, 0xC0, 0x67, 0x67, 0xE6, 0xE6, 0xCE,
  0xCE, 0xFE, 0xFC, 0xC7, 0xCE, 0xCC, 0xDC, 0xD8, 0xF8, 0x70, 0x70, 0xCE,
  0x7C, 0xE6, 0xDE, 0xED, 0xEC, 0xD7, 0xCF, 0x78, 0xF7, 0x8E, 0x70, 0x39,
  0xC6, 0xE1, 0xF0, 0x38, 0x1E, 0x0F, 0x87, 0x73, 0x9C, 0x31, 0xCC, 0xE3,
  0x30, 0xFC, 0x3E, 0x07, 0x81, 0xC0, 0x70, 0x18, 0x3E, 0x0F, 0x03, 0x00,
  0x7E, 0xFC, 0x71, 0xC3, 0x0E, 0x3F, 0x7E, 0x0C, 0x71, 0x8E, 0x30, 0xCE,
  0x38, 0x61, 0x86, 0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xE1, 0x86,
  0x18, 0x61, 0xC7, 0x30, 0xC3, 0x3C, 0xE0, 0x63, 0xFE, 0x78,
};

const GFXglyph NotoSans_ExtraBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 6, 4, 7, 1, -11 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 8, 12, 8, 0, -11 },
  { 37, 12, 11, 13, 1, -11 },
  { 54, 11, 11, 11, 0, -11 },
  { 70, 3, 4, 4, 1, -11 },
  { 72, 5, 13, 5, 1, -11 },
  { 81, 6, 13, 5, -1, -11 },
  { 91, 7, 7, 8, 1, -11 },
  { 98, 7, 7, 9, 1, -9 },
  { 105, 4, 4, 4, -1, -2 },
  { 107, 5, 2, 5, 0, -5 },
  { 109, 3, 2, 4, 0, -2 },
  { 110, 9, 11, 7, -1, -11 },
  { 123, 8, 11, 8, 0, -11 },
  { 134, 7, 11, 8, 1, -11 },
  { 144, 8, 11, 8, 0, -11 },
  { 155, 8, 11, 8, 0, -11 },
  { 166, 8, 11, 8, 0, -11 },
  { 177, 8, 11, 8, 0, -11 },
  { 188, 8, 11, 8, 1, -11 },
  { 199, 9, 11, 8, 0, -11 },
  { 212, 8, 11, 8, 0, -11 },
  { 223, 7, 11, 8, 1, -11 },
  { 233, 4, 8, 4, 0, -8 },
  { 237, 5, 10, 4, -1, -8 },
  { 244, 7, 8, 9, 1, -9 },
  { 251, 7, 5, 9, 1, -8 },
  { 256, 7, 8, 9, 1, -9 },
  { 263, 7, 11, 7, 1, -11 },
  { 273, 12, 12, 13, 1, -11 },
  { 291, 10, 11, 10, -1, -11 },
  { 305, 9, 11, 9, 0, -11 },
  { 318, 9, 11, 9, 1, -11 },
  { 331, 10, 11, 10, 0, -11 },
  { 345, 9, 11, 8, 0, -11 },
  { 358, 9, 11, 8, 0, -11 },
  { 371, 9, 11, 10, 1, -11 },
  { 384, 11, 11, 11, 0, -11 },
  { 400, 7, 11, 6, 0, -11 },
  { 410, 7, 14, 5, -2, -11 },
  { 423, 11, 11, 10, 0, -11 },
  { 439, 7, 11, 8, 0, -11 },
  { 449, 13, 11, 13, 0, -11 },
  { 467, 12, 11, 12, 0, -11 },
  { 484, 10, 11, 11, 1, -11 },
  { 498, 9, 11, 9, 0, -11 },
  { 511, 10, 14, 11, 1, -11 },
  { 529, 9, 11, 10, 0, -11 },
  { 542, 8, 11, 8, 0, -11 },
  { 553, 8, 11, 8, 1, -11 },
  { 564, 10, 11, 10, 1, -11 },
  { 578, 9, 11, 9, 1, -11 },
  { 591, 14, 11, 14, 1, -11 },
  { 611, 12, 11, 10, -1, -11 },
  { 628, 9, 11, 9, 1, -11 },
  { 641, 10, 11, 8, -1, -11 },
  { 655, 6, 13, 5, 0, -11 },
  { 665, 3, 11, 7, 2, -11 },
  { 670, 6, 13, 5, -1, -11 },
  { 680, 8, 7, 8, 0, -11 },
  { 687, 6, 2, 6, -1, 1 },
  { 689, 4, 2, 5, 2, -11 },
  { 690, 8, 8, 9, 1, -8 },
  { 698, 8, 11, 9, 0, -11 },
  { 709, 7, 8, 7, 1, -8 },
  { 716, 8, 11, 9, 1, -11 },
  { 727, 7, 8, 9, 1, -8 },
  { 734, 9, 15, 6, -2, -11 },
  { 751, 9, 12, 9, 0, -8 },
  { 765, 8, 11, 9, 0, -11 },
  { 776, 5, 12, 5, 0, -12 },
  { 784, 7, 16, 5, -2, -12 },
  { 798, 10, 11, 9, 0, -11 },
  { 812, 5, 11, 5, 0, -11 },
  { 819, 13, 8, 14, 0, -8 },
  { 832, 8, 8, 9, 0, -8 },
  { 840, 7, 8, 9, 1, -8 },
  { 847, 9, 12, 9, -1, -8 },
  { 861, 8, 12, 9, 1, -8 },
  { 873, 7, 8, 6, 0, -8 },
  { 880, 7, 8, 7, 0, -8 },
  { 887, 6, 10, 6, 1, -10 },
  { 895, 8, 8, 9, 1, -8 },
  { 903, 8, 8, 8, 1, -8 },
  { 911, 12, 8, 12, 1, -8 },
  { 923, 10, 8, 8, -1, -8 },
  { 933, 10, 12, 8, -1, -8 },
  { 948, 7, 8, 7, 0, -8 },
  { 955, 6, 13, 5, 0, -11 },
  { 965, 2, 14, 8, 3, -11 },
  { 969, 6, 13, 5, -1, -11 },
  { 979, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_ExtraBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRABOLDITALIC15PT7B_H_
