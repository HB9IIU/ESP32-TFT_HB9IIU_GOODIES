#ifndef _NOTOSANS_CONDENSED_THIN8PT7B_H_
#define _NOTOSANS_CONDENSED_THIN8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x66, 0xF6, 0xFA, 0x7B, 0x17, 0xC0, 0xD5, 0x2D, 0xD2,
  0xAC, 0x4A, 0x4D, 0xAF, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0xE8, 0x4B, 0xA0,
  0xC0, 0xC0, 0x80, 0x55, 0xA0, 0x76, 0xDB, 0xC0, 0xFC, 0xE4, 0x95, 0xC0,
  0xE4, 0xB3, 0xC0, 0x22, 0x6A, 0xF2, 0xF3, 0x13, 0xC0, 0x73, 0x5B, 0xC0,
  0xE4, 0xA4, 0x80, 0x75, 0xDB, 0xC0, 0x56, 0xF2, 0xC0, 0x10, 0x18, 0x2B,
  0x10, 0xFC, 0x8C, 0xE0, 0xD5, 0xA0, 0x32, 0x6F, 0xBD, 0xD1, 0xC0, 0x44,
  0x6E, 0xA9, 0xD6, 0xFB, 0xC0, 0x78, 0x88, 0x87, 0xD6, 0xDB, 0x80, 0xEE,
  0xB0, 0xEB, 0xA0, 0x78, 0x89, 0x97, 0xB7, 0xDB, 0x40, 0xEA, 0xB0, 0xFE,
  0xFA, 0xF0, 0xAA, 0xB0, 0x99, 0x9B, 0xBD, 0xB6, 0xFF, 0x40, 0x79, 0x99,
  0x97, 0xFE, 0xA0, 0x79, 0x99, 0x95, 0x30, 0xFE, 0xF0, 0x73, 0x13, 0xC0,
  0xE9, 0x24, 0x80, 0xB6, 0xDB, 0xC0, 0xB6, 0xD4, 0x80, 0xA6, 0x9A, 0xAE,
  0x49, 0x40, 0xB5, 0x2B, 0x40, 0xB7, 0x24, 0x80, 0xE5, 0x29, 0xC0, 0xFE,
  0xA5, 0x50, 0xD5, 0x5C, 0x4E, 0x80, 0xE0, 0xC0, 0x6E, 0xF0, 0xAF, 0xF0,
  0xF2, 0x70, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0xFA, 0xA0, 0xF6, 0xF3, 0xC0,
  0xAF, 0xF0, 0xBC, 0xBF, 0xBA, 0xB0, 0xFC, 0xFD, 0xDD, 0xFF, 0xF6, 0xF0,
  0xFF, 0xA0, 0xF6, 0xF2, 0x40, 0xF0, 0xF8, 0xF0, 0xEA, 0xC0, 0xFF, 0xB7,
  0x20, 0xBF, 0xF5, 0xA9, 0x50, 0xB5, 0x25, 0x00, 0xDB, 0x57, 0x54, 0xFF,
  0x95, 0x5C, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 6, 4, 0, -6 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 0, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 3, 2, 3, 0, -6 },
  { 22, 3, 4, 4, 0, -5 },
  { 24, 1, 2, 1, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 2, 6, 3, 0, -6 },
  { 29, 3, 6, 4, 0, -6 },
  { 32, 1, 6, 4, 1, -6 },
  { 33, 3, 6, 4, 0, -6 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 0, -6 },
  { 45, 3, 6, 4, 0, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 0, -6 },
  { 57, 1, 4, 2, 0, -4 },
  { 58, 1, 5, 2, 0, -4 },
  { 59, 3, 4, 4, 0, -5 },
  { 61, 3, 2, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -5 },
  { 64, 2, 6, 2, 0, -6 },
  { 66, 5, 7, 5, 0, -6 },
  { 71, 4, 6, 4, 0, -6 },
  { 74, 3, 6, 4, 1, -6 },
  { 77, 4, 6, 4, 0, -6 },
  { 80, 3, 6, 4, 1, -6 },
  { 83, 2, 6, 3, 1, -6 },
  { 85, 2, 6, 3, 1, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 3, 6, 4, 1, -6 },
  { 93, 2, 6, 2, 0, -6 },
  { 95, 1, 7, 2, 0, -6 },
  { 96, 2, 6, 3, 1, -6 },
  { 98, 2, 6, 3, 1, -6 },
  { 100, 4, 6, 6, 1, -6 },
  { 103, 3, 6, 5, 1, -6 },
  { 106, 4, 6, 5, 0, -6 },
  { 109, 2, 6, 4, 1, -6 },
  { 111, 4, 7, 5, 0, -6 },
  { 115, 2, 6, 4, 1, -6 },
  { 117, 3, 6, 3, 0, -6 },
  { 120, 3, 6, 3, 0, -6 },
  { 123, 3, 6, 4, 1, -6 },
  { 126, 3, 6, 3, 0, -6 },
  { 129, 6, 6, 6, 0, -6 },
  { 134, 3, 6, 3, 0, -6 },
  { 137, 3, 6, 3, 0, -6 },
  { 140, 3, 6, 3, 0, -6 },
  { 143, 1, 7, 2, 1, -6 },
  { 144, 2, 6, 3, 0, -6 },
  { 146, 2, 7, 2, 0, -6 },
  { 148, 3, 3, 4, 0, -6 },
  { 150, 3, 1, 3, 0, 0 },
  { 151, 2, 1, 2, 0, -6 },
  { 152, 3, 4, 3, 0, -4 },
  { 154, 2, 6, 4, 1, -6 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 3, 6, 4, 0, -6 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 2, 6, 2, 0, -6 },
  { 165, 3, 6, 4, 0, -4 },
  { 168, 2, 6, 4, 1, -6 },
  { 170, 1, 6, 1, 0, -6 },
  { 171, 1, 8, 1, 0, -6 },
  { 172, 2, 6, 3, 1, -6 },
  { 174, 1, 6, 1, 0, -6 },
  { 175, 4, 4, 5, 1, -4 },
  { 177, 2, 4, 4, 1, -4 },
  { 178, 3, 4, 4, 0, -4 },
  { 180, 2, 6, 4, 1, -4 },
  { 182, 3, 6, 4, 0, -4 },
  { 185, 1, 4, 2, 1, -4 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 2, 5, 2, 0, -5 },
  { 190, 2, 4, 4, 1, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 4, 4, 5, 0, -4 },
  { 195, 3, 4, 3, 0, -4 },
  { 197, 3, 6, 3, 0, -4 },
  { 200, 2, 4, 3, 0, -4 },
  { 201, 2, 7, 3, 0, -6 },
  { 203, 1, 8, 3, 1, -6 },
  { 204, 2, 7, 3, 0, -6 },
  { 206, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_Thin8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_THIN8PT7B_H_
