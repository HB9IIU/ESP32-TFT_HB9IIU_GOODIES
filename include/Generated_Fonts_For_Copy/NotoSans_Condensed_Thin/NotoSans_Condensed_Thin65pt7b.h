#ifndef _NOTOSANS_CONDENSED_THIN65PT7B_H_
#define _NOTOSANS_CONDENSED_THIN65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin65pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x69, 0x24,
  0x92, 0x49, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1A, 0x03, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34,
  0x06, 0x80, 0xD0, 0x1A, 0x03, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30,
  0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0C, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00, 0x18,
  0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x02,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xC6, 0x1F, 0x0E, 0x0C, 0x04,
  0x18, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x40,
  0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x8C, 0x00, 0x03, 0xD8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xBC,
  0x00, 0x03, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x02, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC8, 0x03,
  0x07, 0x1F, 0x06, 0x38, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x10, 0x03, 0xDC, 0x00, 0x04, 0x00, 0x60, 0xC0,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x02, 0x01, 0x80, 0x04, 0x00, 0xC0,
  0x10, 0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x20, 0x03, 0x00, 0x10, 0x0C,
  0x00, 0x60, 0x02, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x60, 0x01, 0x80, 0x08,
  0x0C, 0x00, 0x30, 0x01, 0x01, 0x00, 0x06, 0x00, 0x20, 0x60, 0x00, 0xC0,
  0x04, 0x08, 0x00, 0x18, 0x00, 0x83, 0x00, 0x03, 0x00, 0x10, 0x60, 0x20,
  0x20, 0x06, 0x08, 0x3F, 0x04, 0x00, 0xC3, 0x0C, 0x30, 0x80, 0x18, 0x63,
  0x03, 0x18, 0x03, 0x18, 0x60, 0x33, 0x00, 0x43, 0x18, 0x06, 0x20, 0x18,
  0x43, 0x00, 0x46, 0x02, 0x18, 0x40, 0x0C, 0x60, 0xC3, 0x08, 0x01, 0x8F,
  0xF0, 0xC3, 0x00, 0x30, 0x7C, 0x18, 0x60, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0xC0, 0x00, 0xC1, 0x80, 0x08, 0x00, 0x18, 0x30, 0x01, 0x00, 0x06, 0x06,
  0x00, 0x20, 0x00, 0xC0, 0xC0, 0x04, 0x00, 0x10, 0x18, 0x00, 0x80, 0x06,
  0x03, 0x00, 0x10, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x18, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x08, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x60, 0x04, 0x00, 0x18, 0x18, 0x01, 0x80, 0x01, 0x86, 0x00, 0x30,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x04, 0x60, 0x06, 0x00,
  0x46, 0x00, 0x30, 0x0C, 0xC0, 0x03, 0x00, 0xCC, 0x00, 0x18, 0x0C, 0xC0,
  0x00, 0xC0, 0x88, 0x00, 0x0C, 0x18, 0x80, 0x00, 0x61, 0x88, 0x00, 0x03,
  0x10, 0x80, 0x00, 0x13, 0x08, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xB0, 0x60, 0x00,
  0x31, 0x83, 0x00, 0x06, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0xE0, 0x78, 0x06,
  0x07, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x00, 0xFF, 0xD5, 0x55, 0x55, 0x00,
  0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x40, 0x20, 0x2F, 0x82, 0x0F, 0x0E, 0x27, 0x80, 0x1F, 0xC0, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0x98, 0x00, 0x10, 0x80, 0x03, 0x04, 0x00, 0x60,
  0x60, 0x0C, 0x03, 0x00, 0x80, 0x18, 0x18, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61,
  0x84, 0x30, 0xC3, 0x08, 0x61, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x07, 0x00,
  0x30, 0x07, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x20, 0x00,
  0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x62, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x10, 0x30, 0x00, 0x60, 0x30, 0x00, 0x80, 0x70, 0x03, 0x00, 0x70, 0x0C,
  0x00, 0x78, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0,
  0x3B, 0x06, 0x30, 0xC3, 0x38, 0x37, 0x03, 0xE0, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0x1C,
  0x1C, 0x00, 0x30, 0x20, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0x80, 0x1C, 0x38, 0x00,
  0x38, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0xE0, 0x0E, 0x03, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xE0, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x0E, 0x00, 0x3F, 0xFF, 0x80,
  0xF8, 0x07, 0x81, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x20, 0x00, 0xE0, 0xF0, 0x0F, 0x00, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1C, 0x01, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x7F, 0xC0, 0x87, 0x83,
  0x82, 0x30, 0x03, 0x09, 0x80, 0x06, 0x2C, 0x00, 0x0C, 0xA0, 0x00, 0x13,
  0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00,
  0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x3F, 0xF0,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03,
  0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x77, 0x00, 0x03, 0x83, 0x80, 0x0C, 0x03,
  0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x61, 0xC0, 0x01, 0x81, 0xC0, 0x07, 0x01, 0xE0, 0x38, 0x00, 0xFF,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xE0, 0x18,
  0x06, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x04, 0x40, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x76, 0x00, 0x01, 0x58, 0x00, 0x0D, 0x30, 0x00,
  0x2C, 0x60, 0x01, 0xB0, 0xC0, 0x1C, 0xC1, 0xF7, 0xC3, 0x03, 0xFE, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x80, 0x78, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x5F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x08, 0x71, 0xC7, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x08,
  0x61, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x01, 0xFF, 0x00, 0x63,
  0x00, 0x0F, 0x1E, 0x01, 0x8C, 0x00, 0x60, 0x18, 0x02, 0x20, 0x03, 0x00,
  0x60, 0x0D, 0x80, 0x18, 0x01, 0x00, 0x36, 0x00, 0x60, 0x04, 0x00, 0xD8,
  0x03, 0x00, 0x10, 0x03, 0x60, 0x0C, 0x00, 0x40, 0x0D, 0x80, 0x20, 0x01,
  0x00, 0x34, 0x01, 0x80, 0x0C, 0x00, 0xD0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x0C,
  0x00, 0xF0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x0F, 0x00,
  0x60, 0x03, 0x00, 0x34, 0x01, 0x80, 0x0C, 0x00, 0xD0, 0x06, 0x00, 0x70,
  0x02, 0x40, 0x18, 0x01, 0xC0, 0x19, 0x80, 0x30, 0x05, 0x00, 0x66, 0x00,
  0xC0, 0x36, 0x03, 0x18, 0x01, 0x80, 0x98, 0x0C, 0x60, 0x07, 0x0E, 0x30,
  0x60, 0x80, 0x0F, 0xF0, 0x7F, 0x03, 0x00, 0x0F, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80,
  0x08, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0x00, 0x1F, 0x82, 0x00,
  0x03, 0x84, 0x00, 0x03, 0x88, 0x00, 0x03, 0x10, 0x00, 0x03, 0x20, 0x00,
  0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x01, 0x84,
  0x00, 0x0E, 0x08, 0x00, 0xF8, 0x1F, 0xFF, 0x80, 0x20, 0x07, 0xE0, 0x40,
  0x00, 0x70, 0x80, 0x00, 0x71, 0x00, 0x00, 0x32, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x19, 0x00, 0x00, 0x62, 0x00, 0x01, 0x84, 0x00, 0x0E, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x08, 0x03, 0xC0, 0x3C, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0,
  0xFF, 0xFC, 0x00, 0x40, 0x0F, 0xC0, 0x20, 0x00, 0x70, 0x10, 0x00, 0x0C,
  0x08, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x64, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x30, 0x80, 0x00, 0x38, 0x40, 0x00, 0x38, 0x20,
  0x00, 0x38, 0x10, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0xFF, 0xA0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xD0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xC3,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0xCE, 0x38, 0xFF, 0x00, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xC8, 0x00, 0x07, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2,
  0x00, 0x06, 0x08, 0x00, 0x38, 0x20, 0x00, 0xC0, 0x80, 0x06, 0x02, 0x00,
  0x38, 0x08, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x80, 0x30, 0x02, 0x01, 0xC0,
  0x08, 0x06, 0x00, 0x20, 0x30, 0x00, 0x81, 0xC0, 0x02, 0x0E, 0x00, 0x08,
  0x30, 0x00, 0x21, 0x80, 0x00, 0x8F, 0x00, 0x02, 0x3C, 0x00, 0x09, 0x98,
  0x00, 0x2C, 0x60, 0x00, 0xB0, 0xC0, 0x03, 0x81, 0x80, 0x0C, 0x06, 0x00,
  0x20, 0x0C, 0x00, 0x80, 0x30, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20,
  0x03, 0x00, 0x80, 0x06, 0x02, 0x00, 0x18, 0x08, 0x00, 0x30, 0x20, 0x00,
  0xC0, 0x80, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x10,
  0x80, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x06, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x30, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1E, 0x80, 0x00, 0x00, 0x05, 0xB0, 0x00, 0x00, 0x03, 0x6C, 0x00,
  0x00, 0x00, 0xD9, 0x00, 0x00, 0x00, 0x66, 0x60, 0x00, 0x00, 0x19, 0x98,
  0x00, 0x00, 0x06, 0x62, 0x00, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x00, 0xC6,
  0x30, 0x00, 0x00, 0x31, 0x84, 0x00, 0x00, 0x18, 0x61, 0x80, 0x00, 0x06,
  0x18, 0x60, 0x00, 0x01, 0x86, 0x08, 0x00, 0x00, 0xC1, 0x83, 0x00, 0x00,
  0x30, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x10, 0x00, 0x06, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x81, 0x80, 0x00, 0x60, 0x60, 0x20, 0x00, 0x30, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x40, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x80, 0x0C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x02, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x30, 0x01, 0x80, 0x06,
  0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x18, 0x00, 0x61, 0x80, 0x06, 0x00,
  0x08, 0xC0, 0x01, 0x80, 0x03, 0x30, 0x00, 0x60, 0x00, 0xCC, 0x00, 0x18,
  0x00, 0x1E, 0x00, 0x06, 0x00, 0x07, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x74, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x0E,
  0x60, 0x00, 0x07, 0x10, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC2, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x70, 0x40, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x08, 0x00,
  0x0E, 0x06, 0x00, 0x07, 0x01, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x30,
  0x00, 0xE0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0xC0,
  0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x1C,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x0D, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x04, 0x01, 0xF8, 0x20, 0x00,
  0xE1, 0x00, 0x01, 0x88, 0x00, 0x06, 0x40, 0x00, 0x32, 0x00, 0x00, 0xD0,
  0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0xC8, 0x00, 0x06,
  0x40, 0x00, 0x62, 0x00, 0x06, 0x10, 0x00, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x02, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0x02, 0x00,
  0x7C, 0x08, 0x00, 0x38, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x00,
  0x88, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48,
  0x00, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00,
  0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x02,
  0x20, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00, 0x06, 0x08, 0x00, 0x70, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x80, 0x08, 0x02, 0x00, 0x30, 0x08, 0x00, 0x40, 0x20, 0x01, 0x80,
  0x80, 0x06, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0x80,
  0x01, 0x82, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x80, 0x00,
  0x62, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0xF0, 0x01, 0x87,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x80, 0x00, 0xE3, 0xE0, 0x1F, 0x03, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x38,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x04, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x10, 0x01, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x90, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x24, 0x00, 0x01, 0x84, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x19, 0x80, 0x00, 0x41, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x20, 0x00, 0x30, 0x20, 0x00, 0x21, 0x80, 0x01,
  0x81, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x01, 0x00, 0x06, 0x08, 0x00, 0x30, 0x0C,
  0x00, 0x20, 0x60, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00, 0x08, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x40, 0x06, 0x00, 0x40, 0x04,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x00, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0x10, 0x18, 0x00, 0x80, 0xC0,
  0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x01, 0x83, 0x00, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x04,
  0x18, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x80, 0x01, 0x84, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x00, 0x23, 0x00,
  0x01, 0x18, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x01, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x21, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x18, 0x00, 0x06, 0x04, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x08, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x43, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0xF0, 0x0E, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0xFF, 0xE0, 0xF8, 0x0C, 0x38, 0x01, 0x9C, 0x00, 0x37, 0x00, 0x06, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7B, 0x00,
  0x1B, 0x70, 0x06, 0x67, 0x01, 0x8C, 0x7F, 0xE1, 0x80, 0xE0, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x0F, 0xE0, 0x30, 0xFF, 0xE0, 0xC6, 0x01, 0xC3, 0x30, 0x01,
  0x8D, 0x80, 0x03, 0x34, 0x00, 0x0C, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0x6E,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xBC, 0x00, 0x0C,
  0xD0, 0x00, 0x33, 0x60, 0x01, 0x88, 0xC0, 0x0C, 0x21, 0xC0, 0xE0, 0x83,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0E, 0x00,
  0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x0C, 0x07, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x1F, 0x81, 0x81, 0xFF, 0xC3, 0x07, 0x01, 0xC6, 0x1C, 0x00, 0xCC, 0x70,
  0x00, 0xD8, 0xC0, 0x00, 0xB3, 0x00, 0x01, 0xE6, 0x00, 0x01, 0xC8, 0x00,
  0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0xF1, 0x80, 0x03, 0x63, 0x00, 0x04, 0xC3, 0x00, 0x19, 0x83, 0x80,
  0xE3, 0x03, 0xFF, 0x06, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x70, 0x1C, 0x03, 0x80, 0x30, 0x1C, 0x00, 0x60, 0x60, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x00, 0x98, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0xB0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x10, 0x0E, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0xFF, 0x01, 0x81, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x0C, 0x1C, 0x03, 0x18, 0x60,
  0x03, 0x31, 0x80, 0x03, 0x63, 0x00, 0x02, 0xCC, 0x00, 0x07, 0x98, 0x00,
  0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40,
  0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x73, 0x00,
  0x01, 0xE6, 0x00, 0x02, 0xC6, 0x00, 0x0D, 0x8C, 0x00, 0x33, 0x0C, 0x00,
  0xC6, 0x0E, 0x07, 0x8C, 0x0F, 0xFC, 0x18, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x7C, 0x03, 0xC0, 0x3F,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0xFC, 0x0C, 0x3F, 0xF0, 0xC7, 0x03, 0x8C,
  0xC0, 0x0C, 0xD8, 0x00, 0x6D, 0x00, 0x06, 0xF0, 0x00, 0x2E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x67, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x03, 0x03, 0xC1, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0xE7, 0xE1, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0x8C,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x31, 0xE0, 0x0C, 0xD8, 0x03, 0x23, 0x00, 0xD8, 0xC0, 0x3C, 0x18, 0x0E,
  0x06, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0xF8, 0x10, 0xFF, 0xC0, 0xFF, 0xC2, 0x38, 0x1C, 0x38, 0x1C,
  0x4C, 0x01, 0x86, 0x00, 0xC9, 0x00, 0x19, 0x80, 0x19, 0x60, 0x01, 0x60,
  0x01, 0xA8, 0x00, 0x28, 0x00, 0x37, 0x00, 0x07, 0x00, 0x02, 0xC0, 0x00,
  0xE0, 0x00, 0x58, 0x00, 0x18, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x01, 0xE0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x08,
  0x3F, 0xF0, 0x87, 0x01, 0x88, 0xC0, 0x0C, 0x98, 0x00, 0x6B, 0x00, 0x06,
  0xA0, 0x00, 0x2A, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x03,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x11, 0x00, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x60,
  0x0F, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x02,
  0x0F, 0xFE, 0x08, 0x70, 0x1C, 0x23, 0x00, 0x18, 0x98, 0x00, 0x32, 0x40,
  0x00, 0xCB, 0x00, 0x01, 0xA8, 0x00, 0x06, 0xA0, 0x00, 0x0B, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0xCD, 0x80, 0x03, 0x36, 0x00,
  0x18, 0xCC, 0x00, 0xC3, 0x1C, 0x0E, 0x0C, 0x3F, 0xF0, 0x30, 0x0E, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x0C, 0x1C, 0x07, 0x18,
  0x70, 0x03, 0x31, 0x80, 0x03, 0x63, 0x00, 0x02, 0xCC, 0x00, 0x07, 0x98,
  0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x40, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x73,
  0x00, 0x01, 0xE6, 0x00, 0x02, 0xC6, 0x00, 0x0D, 0x8C, 0x00, 0x33, 0x0E,
  0x00, 0xC6, 0x0E, 0x07, 0x0C, 0x0F, 0xFC, 0x18, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0xF6, 0x0F, 0xE8, 0x60, 0x63, 0x00, 0xD8, 0x03,
  0x40, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x70, 0x07,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0xC0, 0x03, 0x9F,
  0x01, 0xE0, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF,
  0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x10, 0x3F, 0x80, 0x38,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF6, 0x00, 0x0B, 0x60, 0x01, 0x33, 0x00, 0x33, 0x1C, 0x0E, 0x30, 0xFF,
  0x83, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x08, 0x10, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x04, 0x02, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x60, 0x00, 0x61, 0x80, 0x01, 0x84,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x60, 0x00, 0x05, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0B, 0x00,
  0x03, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x66, 0x00, 0x0B, 0x00, 0x0C,
  0xC0, 0x03, 0x60, 0x01, 0x98, 0x00, 0x64, 0x00, 0x21, 0x00, 0x0C, 0x80,
  0x0C, 0x30, 0x01, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C,
  0x20, 0x04, 0x08, 0x01, 0x84, 0x00, 0x81, 0x80, 0x20, 0xC0, 0x30, 0x30,
  0x0C, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x80, 0x40, 0x30, 0x20, 0x10,
  0x0C, 0x04, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x18,
  0x18, 0x02, 0x06, 0x01, 0x02, 0x00, 0x60, 0x80, 0x30, 0xC0, 0x0C, 0x30,
  0x06, 0x18, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x10, 0xC0, 0x08, 0x40, 0x02,
  0x10, 0x01, 0x98, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x60,
  0x00, 0x98, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x39, 0x80, 0x01,
  0x8C, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x10,
  0x06, 0x00, 0xC0, 0x30, 0x02, 0x03, 0x00, 0x18, 0x18, 0x00, 0x41, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0x98, 0x00,
  0x08, 0xC0, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x06, 0x03,
  0x00, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x60, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06,
  0x30, 0x00, 0x18, 0x40, 0x00, 0x61, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x08,
  0x00, 0x30, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x04, 0x00,
  0x60, 0x18, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x30, 0x03, 0x00, 0x80,
  0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x60, 0x01, 0x81, 0x00, 0x06,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x04, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x21, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x5C, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0xE8, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_Thin65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 46, 13, 5, -46 },
  { 19, 11, 16, 20, 4, -46 },
  { 41, 29, 46, 32, 1, -46 },
  { 208, 23, 53, 29, 3, -49 },
  { 361, 35, 48, 41, 3, -47 },
  { 571, 28, 48, 31, 3, -47 },
  { 739, 2, 16, 11, 4, -46 },
  { 743, 11, 56, 17, 3, -46 },
  { 820, 11, 56, 17, 3, -46 },
  { 897, 20, 19, 26, 3, -49 },
  { 945, 25, 30, 29, 2, -38 },
  { 1039, 6, 15, 12, 2, -7 },
  { 1051, 14, 2, 18, 2, -19 },
  { 1055, 3, 4, 12, 5, -4 },
  { 1057, 19, 46, 21, 1, -46 },
  { 1167, 23, 47, 29, 3, -47 },
  { 1303, 12, 46, 29, 5, -46 },
  { 1372, 22, 47, 29, 3, -47 },
  { 1502, 22, 48, 29, 3, -47 },
  { 1634, 27, 47, 29, 1, -47 },
  { 1793, 22, 47, 29, 4, -46 },
  { 1923, 22, 48, 29, 4, -47 },
  { 2055, 22, 46, 29, 3, -46 },
  { 2182, 23, 48, 29, 3, -47 },
  { 2320, 22, 48, 29, 3, -47 },
  { 2452, 3, 35, 12, 5, -35 },
  { 2466, 6, 43, 12, 2, -35 },
  { 2499, 25, 28, 29, 2, -37 },
  { 2587, 25, 16, 29, 2, -31 },
  { 2637, 25, 28, 29, 2, -37 },
  { 2725, 17, 47, 20, 1, -47 },
  { 2825, 38, 52, 45, 3, -46 },
  { 3072, 28, 46, 28, 0, -46 },
  { 3233, 23, 46, 32, 6, -46 },
  { 3366, 25, 48, 31, 4, -47 },
  { 3516, 25, 46, 35, 6, -46 },
  { 3660, 19, 46, 28, 6, -46 },
  { 3770, 19, 46, 26, 6, -46 },
  { 3880, 30, 48, 38, 4, -47 },
  { 4060, 24, 46, 36, 6, -46 },
  { 4198, 10, 46, 15, 3, -46 },
  { 4256, 12, 57, 13, -4, -46 },
  { 4342, 22, 46, 28, 6, -46 },
  { 4469, 18, 46, 25, 6, -46 },
  { 4573, 34, 46, 46, 6, -46 },
  { 4769, 25, 46, 37, 6, -46 },
  { 4913, 30, 48, 38, 4, -47 },
  { 5093, 21, 46, 29, 6, -46 },
  { 5214, 30, 58, 38, 4, -47 },
  { 5432, 22, 46, 30, 6, -46 },
  { 5559, 22, 48, 28, 3, -47 },
  { 5691, 25, 46, 25, 0, -46 },
  { 5835, 26, 47, 36, 5, -46 },
  { 5988, 28, 46, 28, 0, -46 },
  { 6149, 45, 46, 46, 1, -46 },
  { 6408, 25, 46, 25, 0, -46 },
  { 6552, 24, 46, 24, 0, -46 },
  { 6690, 22, 46, 26, 2, -46 },
  { 6817, 12, 56, 20, 6, -46 },
  { 6901, 19, 46, 21, 1, -46 },
  { 7011, 13, 56, 20, 2, -46 },
  { 7102, 25, 24, 29, 2, -46 },
  { 7177, 26, 2, 25, 0, 6 },
  { 7184, 9, 11, 15, 3, -50 },
  { 7197, 19, 36, 27, 3, -35 },
  { 7283, 22, 50, 31, 5, -49 },
  { 7421, 19, 36, 23, 3, -35 },
  { 7507, 23, 50, 31, 3, -49 },
  { 7651, 22, 36, 28, 3, -35 },
  { 7750, 16, 50, 15, 1, -50 },
  { 7850, 23, 51, 31, 3, -35 },
  { 7997, 20, 49, 30, 5, -49 },
  { 8120, 4, 47, 12, 4, -47 },
  { 8144, 9, 63, 12, -1, -47 },
  { 8215, 18, 49, 24, 5, -49 },
  { 8326, 2, 49, 12, 5, -49 },
  { 8339, 35, 35, 44, 5, -35 },
  { 8493, 20, 35, 30, 5, -35 },
  { 8581, 23, 36, 30, 3, -35 },
  { 8685, 22, 50, 31, 5, -35 },
  { 8823, 23, 50, 31, 3, -35 },
  { 8967, 14, 35, 19, 5, -35 },
  { 9029, 19, 36, 23, 2, -35 },
  { 9115, 14, 44, 16, 1, -43 },
  { 9192, 20, 35, 30, 5, -34 },
  { 9280, 22, 34, 22, 0, -34 },
  { 9374, 35, 34, 37, 1, -34 },
  { 9523, 21, 34, 24, 1, -34 },
  { 9613, 22, 50, 23, 0, -34 },
  { 9751, 17, 34, 21, 2, -34 },
  { 9824, 16, 56, 22, 3, -46 },
  { 9936, 2, 66, 28, 13, -50 },
  { 9953, 16, 56, 22, 3, -46 },
  { 10065, 25, 6, 29, 2, -26 },
};

const GFXfont NotoSans_Condensed_Thin65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_THIN65PT7B_H_
