#ifndef _NOTOSANS_CONDENSED_THIN68PT7B_H_
#define _NOTOSANS_CONDENSED_THIN68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x0E,
  0xFF, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x40, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x80, 0x08, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x40, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x01, 0x00, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x00, 0x10, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0E, 0x10, 0x7C, 0x18, 0x10,
  0x08, 0x30, 0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0x60, 0x10, 0x00, 0x70, 0x10, 0x00, 0x38, 0x10, 0x00, 0x1C, 0x10,
  0x00, 0x0F, 0x10, 0x00, 0x03, 0xD0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x13, 0xC0, 0x00, 0x10, 0xE0, 0x00, 0x10,
  0x70, 0x00, 0x10, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x10,
  0x06, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10,
  0x06, 0x00, 0x10, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x1C, 0xC0, 0x10,
  0x38, 0xFC, 0x11, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x63, 0x80, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x04, 0x00, 0x60, 0x30, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x01, 0x80, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x06, 0x00, 0x10,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x10,
  0x00, 0x60, 0x03, 0x01, 0x80, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x06, 0x00, 0x30, 0x20, 0x00,
  0x10, 0x01, 0x83, 0x00, 0x00, 0x80, 0x0C, 0x18, 0x1E, 0x04, 0x00, 0x61,
  0x83, 0xF8, 0x30, 0x03, 0x0C, 0x30, 0x61, 0x80, 0x10, 0x43, 0x01, 0x8C,
  0x00, 0x86, 0x18, 0x04, 0x20, 0x0C, 0x30, 0x80, 0x31, 0x80, 0x63, 0x0C,
  0x01, 0x8C, 0x06, 0x18, 0x60, 0x04, 0x30, 0x70, 0x83, 0x00, 0x30, 0xEF,
  0x0C, 0x10, 0x01, 0x83, 0xF0, 0x60, 0x80, 0x0C, 0x00, 0x02, 0x0C, 0x00,
  0x60, 0x00, 0x30, 0x60, 0x03, 0x00, 0x01, 0x83, 0x00, 0x18, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x04, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x20, 0x03, 0x00, 0x08, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x03, 0x00, 0x10, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x01, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x03, 0x18, 0x01, 0x80, 0x11, 0x80, 0x0C, 0x00, 0x8C, 0x00, 0x30,
  0x0C, 0xC0, 0x00, 0xC0, 0x66, 0x00, 0x06, 0x03, 0x30, 0x00, 0x18, 0x11,
  0x80, 0x00, 0x61, 0x8C, 0x00, 0x03, 0x0C, 0x60, 0x00, 0x0C, 0xC3, 0x00,
  0x00, 0x36, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x38, 0x10, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x1B, 0x07, 0x00, 0x01, 0x8C,
  0x18, 0x00, 0x18, 0x30, 0x70, 0x03, 0x81, 0x81, 0xE0, 0x78, 0x06, 0x07,
  0xFF, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xAA, 0xA0,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x08,
  0x04, 0x02, 0xF8, 0x20, 0x78, 0xF1, 0x1E, 0x00, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x64, 0x00, 0x02, 0x30, 0x00, 0x20, 0xC0, 0x03,
  0x02, 0x00, 0x30, 0x08, 0x03, 0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x33, 0x18,
  0xC4, 0x63, 0x10, 0xFF, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xF7, 0xC0, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x70, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x60, 0x01, 0xC3, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x1B, 0x03, 0x30, 0xE3, 0x1C, 0x33,
  0x83, 0x60, 0x3C, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x00, 0xE0,
  0x70, 0x00, 0x60, 0x20, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0xF0, 0x03, 0x83, 0x80, 0x03, 0x8C, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x30, 0x00, 0x3C, 0x7E, 0x01, 0xE0,
  0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x7C, 0x07, 0xC0, 0x3F, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0x80,
  0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x01,
  0xE0, 0x0C, 0x1F, 0xF8, 0x18, 0xF0, 0x3C, 0x33, 0x00, 0x1C, 0x6C, 0x00,
  0x18, 0xD0, 0x00, 0x19, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x80, 0x06, 0x03, 0x80, 0x18, 0x03, 0x80, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xE3,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x01, 0x81,
  0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x38, 0x03, 0x00, 0xE0, 0x03,
  0x01, 0x80, 0x03, 0x06, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x68, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x05, 0x30, 0x00,
  0x1A, 0x60, 0x00, 0x24, 0x60, 0x00, 0xC8, 0x60, 0x07, 0x30, 0x78, 0x78,
  0x60, 0x3F, 0xE0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x18, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x30,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x7C, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x03, 0xC0, 0x03, 0x18, 0x00, 0x3F,
  0xF0, 0x06, 0x60, 0x01, 0xC0, 0x60, 0x0C, 0xC0, 0x07, 0x00, 0xC0, 0x09,
  0x80, 0x1C, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x00, 0xC0,
  0x06, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x02, 0x00, 0x18, 0x01,
  0xE0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x07, 0x80, 0x30,
  0x00, 0xC0, 0x0F, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x02, 0x00,
  0x38, 0x01, 0x00, 0x04, 0x00, 0x70, 0x02, 0x00, 0x18, 0x00, 0xE0, 0x04,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0xC0,
  0x07, 0x80, 0x30, 0x01, 0x80, 0x0B, 0x00, 0x60, 0x07, 0x00, 0x36, 0x00,
  0xC0, 0x0F, 0x00, 0x6C, 0x00, 0xC0, 0x16, 0x01, 0x98, 0x01, 0x80, 0x64,
  0x03, 0x30, 0x01, 0x81, 0x8C, 0x0C, 0x30, 0x03, 0x8E, 0x0E, 0x70, 0x60,
  0x01, 0xF8, 0x1F, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0xC0,
  0x03, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xC0,
  0x0F, 0xC0, 0xFF, 0xFE, 0x00, 0xC0, 0x07, 0xC0, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x10, 0x03,
  0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0x00, 0x3F, 0x00, 0x60, 0x00, 0x70, 0x0C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x01, 0xE0, 0x30, 0x00, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0,
  0x3C, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E,
  0x81, 0xCF, 0xF8, 0x7E, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x66, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x38, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x1C,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x0E, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x31, 0xE0, 0x00, 0x66,
  0xC0, 0x00, 0xD8, 0xC0, 0x01, 0xB1, 0x80, 0x03, 0xC1, 0x80, 0x07, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x70, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7B, 0x00, 0x00, 0x00, 0x05, 0xF0, 0x00, 0x00, 0x00, 0xDF, 0x00, 0x00,
  0x00, 0x0D, 0xD8, 0x00, 0x00, 0x00, 0x9D, 0x80, 0x00, 0x00, 0x19, 0xD8,
  0x00, 0x00, 0x01, 0x9C, 0xC0, 0x00, 0x00, 0x11, 0xCC, 0x00, 0x00, 0x03,
  0x1C, 0xC0, 0x00, 0x00, 0x31, 0xC6, 0x00, 0x00, 0x02, 0x1C, 0x60, 0x00,
  0x00, 0x61, 0xC6, 0x00, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x00, 0x41, 0xC3,
  0x00, 0x00, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0xC1, 0xC1, 0x80, 0x00, 0x08,
  0x1C, 0x18, 0x00, 0x01, 0x81, 0xC1, 0x80, 0x00, 0x18, 0x1C, 0x0C, 0x00,
  0x01, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0xC0,
  0x60, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x60, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x1C, 0x03, 0x00,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x0C, 0x03, 0x00,
  0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x06, 0x06, 0x00, 0x1C, 0x00, 0x60,
  0x60, 0x01, 0xC0, 0x06, 0x06, 0x00, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0xC0,
  0x03, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0xC0, 0x01, 0x98, 0x00,
  0x1C, 0x00, 0x19, 0x80, 0x01, 0xC0, 0x01, 0x98, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x04, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x20, 0x01, 0xC0, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x01, 0xC0,
  0x03, 0x00, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x40, 0x03, 0xFF, 0xF8, 0x0C, 0x01, 0xF8,
  0x30, 0x00, 0x70, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0xC3, 0x00, 0x0E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x0F, 0x80, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0,
  0x03, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0x00, 0xFF, 0xE0, 0x07, 0xF7, 0xFC, 0x1C, 0x00, 0x30, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x3C, 0x7E, 0x01, 0xE0, 0x3F, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x38, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x01, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x78, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x18, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x10, 0x00,
  0x03, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x62, 0x00, 0x01, 0x81, 0x80, 0x00, 0x86, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x08, 0x00, 0x18, 0x30, 0x00, 0x60, 0x18, 0x00, 0x20,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x00, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x00, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x0C, 0x01, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00, 0x80,
  0x60, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x01, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x98, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x04, 0x80, 0x00,
  0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x10, 0x18, 0x00,
  0x0C, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x30, 0x00, 0x7F, 0xF0, 0x3F, 0x07, 0x81, 0x80, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x07, 0xFF, 0x03, 0xF8, 0x30,
  0xF0, 0x03, 0x1C, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x40, 0x00, 0xB6, 0x00,
  0x1B, 0x30, 0x03, 0x31, 0xC0, 0xE3, 0x0F, 0xFC, 0x30, 0x1E, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0xC1,
  0xFF, 0x80, 0xC3, 0xC1, 0xE0, 0xC6, 0x00, 0x70, 0xCC, 0x00, 0x30, 0xD8,
  0x00, 0x18, 0xD0, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x04, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xD0, 0x00, 0x18, 0xD8, 0x00, 0x18, 0xCC,
  0x00, 0x30, 0xCE, 0x00, 0x60, 0xC7, 0x83, 0xC0, 0xC1, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x01, 0xE0, 0x70, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x08,
  0x03, 0x00, 0xFF, 0x83, 0x03, 0xC1, 0xE3, 0x07, 0x00, 0x73, 0x0C, 0x00,
  0x33, 0x1C, 0x00, 0x1B, 0x18, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x30, 0x00,
  0x07, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x30, 0x00, 0x0B, 0x18, 0x00,
  0x1B, 0x0C, 0x00, 0x33, 0x0E, 0x00, 0x73, 0x07, 0x81, 0xE3, 0x01, 0xFF,
  0x83, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x0F,
  0x00, 0x38, 0x07, 0x00, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x06, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x98, 0x00, 0x01, 0xA0,
  0x00, 0x03, 0x40, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x1E, 0x03, 0xC0,
  0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0x83, 0x03, 0xC1, 0xE3, 0x07, 0x00, 0x73, 0x0C, 0x00, 0x1B,
  0x18, 0x00, 0x0B, 0x18, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07,
  0x20, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x30, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x30, 0x00, 0x0B, 0x18, 0x00, 0x1B,
  0x0C, 0x00, 0x33, 0x0E, 0x00, 0x63, 0x07, 0x81, 0xC3, 0x01, 0xFF, 0x83,
  0x00, 0x3C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x40, 0x00, 0x38, 0x30, 0x00, 0x70, 0x3F, 0x03, 0xE0, 0x07, 0xFF, 0x80,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0xC1, 0xFF, 0x06, 0x1E, 0x1E, 0x31,
  0x80, 0x39, 0x98, 0x00, 0xCD, 0x80, 0x03, 0x68, 0x00, 0x1B, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x19, 0x3C,
  0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83,
  0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0xC6, 0xC0, 0x19, 0x98, 0x03, 0x61,
  0x80, 0x6C, 0x30, 0x0F, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x01, 0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x18, 0x0C,
  0x3F, 0xE0, 0x1F, 0xF0, 0xC7, 0x07, 0x03, 0x83, 0x8C, 0xC0, 0x18, 0x60,
  0x0C, 0xD8, 0x00, 0x8C, 0x00, 0x6D, 0x80, 0x0C, 0x80, 0x06, 0xF0, 0x00,
  0x58, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x06, 0x0F, 0xFC, 0x30,
  0xE0, 0xF1, 0x8C, 0x01, 0xCC, 0xC0, 0x07, 0x6C, 0x00, 0x1B, 0x40, 0x00,
  0xDE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x08, 0x00, 0xC0, 0xFF, 0x80, 0xC3, 0xC1, 0xE0, 0xC7,
  0x00, 0x70, 0xCC, 0x00, 0x30, 0xD8, 0x00, 0x18, 0xD8, 0x00, 0x0C, 0xD0,
  0x00, 0x0C, 0xF0, 0x00, 0x04, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xD0,
  0x00, 0x18, 0xD8, 0x00, 0x18, 0xCC, 0x00, 0x30, 0xC6, 0x00, 0x60, 0xC7,
  0x81, 0xC0, 0xC1, 0xFF, 0x80, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x83, 0x03,
  0xC1, 0xE3, 0x07, 0x00, 0x73, 0x0C, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x18,
  0x00, 0x0F, 0x30, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x20, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30,
  0x00, 0x0F, 0x38, 0x00, 0x0B, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x33, 0x0E,
  0x00, 0x63, 0x07, 0x81, 0xC3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC1, 0xFF, 0x0E, 0x3C,
  0x60, 0x33, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xE0, 0x7C, 0x1F, 0x1C, 0x00, 0x66, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x0E, 0x7C, 0x07,
  0x83, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0xFF,
  0xFF, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC1, 0x03,
  0xFC, 0x01, 0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3D, 0x80, 0x01,
  0x6C, 0x00, 0x1B, 0x70, 0x01, 0x99, 0xC0, 0x1C, 0xC7, 0x03, 0xC6, 0x1F,
  0xF8, 0x30, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x10,
  0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x10, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20, 0x00, 0x40, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x40, 0x00, 0x09, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xB0, 0x00,
  0x1C, 0x00, 0x0C, 0x80, 0x00, 0xA0, 0x00, 0x66, 0x00, 0x05, 0x00, 0x03,
  0x30, 0x00, 0x6C, 0x00, 0x11, 0x80, 0x03, 0x60, 0x01, 0x84, 0x00, 0x1B,
  0x00, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x02, 0x0C,
  0x00, 0x63, 0x00, 0x30, 0x20, 0x03, 0x18, 0x01, 0x81, 0x80, 0x30, 0x40,
  0x0C, 0x0C, 0x01, 0x83, 0x00, 0x40, 0x60, 0x0C, 0x18, 0x06, 0x01, 0x00,
  0x60, 0xC0, 0x30, 0x0C, 0x06, 0x02, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x08, 0x0C, 0x06, 0x06, 0x00, 0x60, 0xC0,
  0x10, 0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x06, 0x08, 0x00,
  0xC1, 0x80, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x86, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x06, 0x30, 0x01, 0x98, 0x00, 0x13,
  0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xA0,
  0x00, 0x36, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x10, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x23, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x40, 0x60,
  0x01, 0x80, 0x40, 0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x08, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x20, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x10, 0x00,
  0x06, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x03, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x0F,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x78, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0xE8, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 49, 14, 5, -49 },
  { 26, 11, 18, 20, 5, -49 },
  { 51, 31, 49, 33, 1, -49 },
  { 241, 24, 56, 30, 3, -52 },
  { 409, 37, 50, 43, 3, -49 },
  { 641, 29, 50, 33, 3, -49 },
  { 823, 2, 18, 11, 5, -49 },
  { 828, 12, 60, 18, 3, -49 },
  { 918, 11, 60, 18, 3, -49 },
  { 1001, 21, 21, 27, 3, -52 },
  { 1057, 25, 32, 31, 3, -40 },
  { 1157, 5, 16, 12, 3, -7 },
  { 1167, 15, 1, 19, 2, -19 },
  { 1169, 3, 4, 13, 5, -4 },
  { 1171, 20, 49, 22, 1, -49 },
  { 1294, 24, 49, 30, 3, -49 },
  { 1441, 12, 49, 30, 6, -49 },
  { 1515, 24, 49, 30, 3, -49 },
  { 1662, 23, 50, 30, 3, -49 },
  { 1806, 29, 49, 30, 1, -49 },
  { 1984, 23, 50, 30, 4, -49 },
  { 2128, 23, 50, 30, 4, -49 },
  { 2272, 24, 49, 30, 3, -49 },
  { 2419, 24, 50, 30, 3, -49 },
  { 2569, 23, 50, 30, 3, -49 },
  { 2713, 3, 36, 13, 5, -36 },
  { 2727, 6, 45, 13, 3, -36 },
  { 2761, 25, 28, 31, 3, -38 },
  { 2849, 25, 16, 31, 3, -32 },
  { 2899, 25, 28, 31, 3, -38 },
  { 2987, 17, 49, 21, 2, -49 },
  { 3092, 39, 55, 47, 4, -49 },
  { 3361, 30, 49, 30, 0, -49 },
  { 3545, 24, 49, 33, 6, -49 },
  { 3692, 27, 50, 32, 4, -49 },
  { 3861, 27, 49, 37, 6, -49 },
  { 4027, 20, 49, 29, 6, -49 },
  { 4150, 20, 49, 27, 6, -49 },
  { 4273, 31, 50, 39, 4, -49 },
  { 4467, 26, 49, 38, 6, -49 },
  { 4627, 10, 49, 16, 3, -49 },
  { 4689, 12, 61, 14, -4, -49 },
  { 4781, 23, 49, 29, 6, -49 },
  { 4922, 19, 49, 27, 6, -49 },
  { 5039, 36, 49, 48, 6, -49 },
  { 5260, 26, 49, 38, 6, -49 },
  { 5420, 32, 50, 40, 4, -49 },
  { 5620, 22, 49, 30, 6, -49 },
  { 5755, 32, 61, 40, 4, -49 },
  { 5999, 24, 49, 31, 6, -49 },
  { 6146, 23, 50, 30, 3, -49 },
  { 6290, 26, 49, 26, 0, -49 },
  { 6450, 27, 50, 38, 5, -49 },
  { 6619, 29, 49, 29, 0, -49 },
  { 6797, 47, 49, 49, 1, -49 },
  { 7085, 26, 49, 26, 0, -49 },
  { 7245, 25, 49, 25, 0, -49 },
  { 7399, 23, 49, 27, 2, -49 },
  { 7540, 13, 60, 21, 6, -49 },
  { 7638, 20, 49, 22, 1, -49 },
  { 7761, 13, 60, 21, 2, -49 },
  { 7859, 27, 26, 30, 2, -49 },
  { 7947, 27, 2, 27, 0, 6 },
  { 7954, 10, 11, 16, 3, -52 },
  { 7968, 20, 38, 28, 3, -37 },
  { 8063, 24, 53, 32, 5, -52 },
  { 8222, 20, 38, 25, 3, -37 },
  { 8317, 24, 53, 32, 3, -52 },
  { 8476, 23, 38, 29, 3, -37 },
  { 8586, 17, 52, 16, 1, -52 },
  { 8697, 24, 53, 32, 3, -37 },
  { 8856, 21, 52, 31, 5, -52 },
  { 8993, 3, 49, 13, 5, -49 },
  { 9012, 9, 65, 13, -1, -49 },
  { 9086, 19, 52, 25, 5, -52 },
  { 9210, 2, 52, 12, 5, -52 },
  { 9223, 36, 37, 46, 5, -37 },
  { 9390, 21, 37, 31, 5, -37 },
  { 9488, 24, 38, 31, 3, -37 },
  { 9602, 24, 53, 32, 5, -37 },
  { 9761, 24, 53, 32, 3, -37 },
  { 9920, 14, 36, 20, 5, -36 },
  { 9983, 19, 38, 24, 3, -37 },
  { 10074, 14, 46, 16, 1, -45 },
  { 10155, 21, 37, 31, 5, -36 },
  { 10253, 23, 36, 23, 0, -36 },
  { 10357, 37, 36, 38, 1, -36 },
  { 10524, 22, 36, 25, 1, -36 },
  { 10623, 23, 52, 24, 0, -36 },
  { 10773, 18, 36, 22, 2, -36 },
  { 10854, 17, 60, 23, 3, -49 },
  { 10982, 1, 69, 29, 14, -52 },
  { 10991, 17, 60, 23, 3, -49 },
  { 11119, 25, 6, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_Thin68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_THIN68PT7B_H_
