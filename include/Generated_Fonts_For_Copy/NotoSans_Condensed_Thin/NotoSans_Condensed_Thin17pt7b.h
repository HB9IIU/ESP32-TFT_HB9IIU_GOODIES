#ifndef _NOTOSANS_CONDENSED_THIN17PT7B_H_
#define _NOTOSANS_CONDENSED_THIN17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x7F, 0x24, 0x24, 0x24,
  0xFE, 0x24, 0x24, 0x24, 0x48, 0x21, 0xEA, 0x28, 0xA2, 0x86, 0x0E, 0x24,
  0x92, 0x4A, 0xF0, 0x80, 0xE2, 0x49, 0x25, 0x12, 0x89, 0x94, 0xD6, 0xB2,
  0xA9, 0x14, 0x8A, 0x49, 0x24, 0x70, 0x71, 0x12, 0x22, 0x45, 0x0C, 0x28,
  0x49, 0x8B, 0x0A, 0x17, 0xD0, 0xF0, 0x2A, 0x49, 0x24, 0x92, 0x44, 0x88,
  0x91, 0x22, 0x49, 0x25, 0x25, 0x20, 0x21, 0x3E, 0xC5, 0x00, 0x20, 0x82,
  0x08, 0xFC, 0x82, 0x08, 0xF0, 0xE0, 0x80, 0x08, 0x42, 0x21, 0x10, 0x84,
  0x42, 0x11, 0x00, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x9E,
  0x2E, 0x92, 0x49, 0x24, 0x90, 0xF8, 0x20, 0x42, 0x08, 0x21, 0x04, 0x21,
  0x08, 0x3F, 0xF8, 0x20, 0x41, 0x09, 0xC0, 0x81, 0x04, 0x10, 0xBE, 0x04,
  0x18, 0x50, 0xA2, 0x44, 0x91, 0x22, 0xFE, 0x08, 0x10, 0x20, 0xFA, 0x08,
  0x20, 0x83, 0xE0, 0x41, 0x04, 0x10, 0xBC, 0x39, 0x08, 0x20, 0xB3, 0x28,
  0x61, 0x86, 0x18, 0x5E, 0xFC, 0x20, 0x82, 0x10, 0x41, 0x08, 0x20, 0x84,
  0x10, 0x7A, 0x18, 0x61, 0x48, 0xC4, 0xA1, 0x86, 0x18, 0x5E, 0xFA, 0x28,
  0x61, 0x86, 0x1D, 0xC9, 0x04, 0x20, 0xBC, 0x80, 0x80, 0x81, 0xE0, 0x04,
  0x66, 0x20, 0xC0, 0xC0, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0x03, 0x03, 0x08,
  0xC4, 0x20, 0xF0, 0x42, 0x11, 0x08, 0x84, 0x40, 0x00, 0x80, 0x3F, 0x10,
  0x24, 0x0A, 0x39, 0x92, 0x64, 0x9A, 0x26, 0x89, 0x92, 0x67, 0xE8, 0x01,
  0x00, 0x20, 0x07, 0x80, 0x10, 0x30, 0xA1, 0x42, 0x44, 0x91, 0x3E, 0x43,
  0x06, 0x0C, 0x10, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x06,
  0x17, 0xC0, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x01,
  0xF0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0,
  0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x21, 0xF0, 0xFC, 0x21, 0x08, 0x43,
  0xF0, 0x84, 0x21, 0x00, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x80, 0x8F, 0x81,
  0x81, 0x81, 0x41, 0x3F, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0xD5, 0x55, 0x57, 0x24, 0x92, 0x49, 0x24, 0x92, 0x70,
  0x86, 0x28, 0xA4, 0xA3, 0x8A, 0x24, 0x8A, 0x28, 0x61, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0xF0, 0x80, 0x70, 0x3C, 0x0E, 0x85, 0xA1, 0x68,
  0x59, 0x26, 0x49, 0x92, 0x63, 0x18, 0xC6, 0x11, 0x83, 0x86, 0x8D, 0x19,
  0x32, 0x62, 0xC5, 0x87, 0x0E, 0x0C, 0x10, 0x3C, 0x42, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFA, 0x18, 0x61, 0x86, 0x1F,
  0xA0, 0x82, 0x08, 0x20, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x34, 0x08, 0x04, 0x02, 0xFA, 0x18, 0x61, 0x86, 0x2F,
  0x24, 0x8A, 0x28, 0x61, 0x7E, 0x08, 0x20, 0x81, 0x81, 0x81, 0x04, 0x10,
  0x7E, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x0B, 0xE0, 0x83, 0x06, 0x0A,
  0x24, 0x48, 0x89, 0x14, 0x28, 0x50, 0x40, 0x80, 0x82, 0x18, 0x61, 0x46,
  0x14, 0x62, 0x45, 0x24, 0x92, 0x49, 0x22, 0x94, 0x29, 0x43, 0x0C, 0x10,
  0x81, 0x08, 0x45, 0x14, 0x8A, 0x30, 0x43, 0x0A, 0x29, 0x14, 0x61, 0x86,
  0x14, 0x52, 0x28, 0xC1, 0x04, 0x10, 0x41, 0x04, 0xF8, 0x44, 0x21, 0x10,
  0x88, 0x44, 0x21, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0x82, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0x10, 0xE4, 0x92, 0x49, 0x24,
  0x92, 0x78, 0x10, 0x30, 0x91, 0x24, 0x38, 0x40, 0xFE, 0x94, 0xF0, 0x42,
  0x17, 0xC6, 0x31, 0xF8, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x18,
  0x61, 0xF8, 0x7C, 0x21, 0x08, 0x42, 0x10, 0x78, 0x04, 0x10, 0x41, 0x7E,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x7C, 0x63, 0x1F, 0x42, 0x10, 0x78,
  0x3A, 0x10, 0x8E, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7E, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x7C, 0x10, 0x41, 0xF8, 0x82, 0x08, 0x20, 0xFA, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x9F, 0xF0, 0x41, 0x55, 0x55, 0x57, 0x84,
  0x21, 0x08, 0xCA, 0x94, 0xE4, 0xA5, 0x18, 0x80, 0xFF, 0xF8, 0xFF, 0xC4,
  0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x7E, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x7C, 0x10, 0x41, 0x04, 0xF8, 0x88, 0x88, 0x88, 0x80,
  0xF8, 0x88, 0x61, 0x11, 0xF0, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x70, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x78, 0x86, 0x28, 0x92, 0x49, 0x43, 0x08, 0x20,
  0x88, 0xC4, 0x53, 0x2A, 0x95, 0x4A, 0x99, 0x4C, 0x42, 0x21, 0x00, 0x85,
  0x22, 0x8C, 0x10, 0xC4, 0x92, 0x84, 0x86, 0x14, 0x92, 0x48, 0xA3, 0x0C,
  0x10, 0x82, 0x08, 0xC0, 0xF1, 0x22, 0x44, 0x88, 0xF0, 0x34, 0x44, 0x44,
  0x48, 0x44, 0x44, 0x44, 0x30, 0xFF, 0xFF, 0x80, 0xC2, 0x22, 0x22, 0x21,
  0x22, 0x22, 0x24, 0x80, 0xE6, 0x60,
};

const GFXglyph NotoSans_Condensed_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 3, 4, 5, 1, -12 },
  { 5, 8, 12, 8, 0, -12 },
  { 17, 6, 14, 8, 1, -13 },
  { 28, 9, 12, 11, 1, -12 },
  { 42, 7, 12, 8, 1, -12 },
  { 53, 1, 4, 3, 1, -12 },
  { 54, 3, 15, 4, 1, -12 },
  { 60, 3, 15, 4, 1, -12 },
  { 66, 5, 5, 7, 1, -13 },
  { 70, 6, 8, 8, 1, -10 },
  { 76, 1, 4, 3, 1, -2 },
  { 77, 3, 1, 5, 1, -5 },
  { 78, 1, 1, 3, 1, -1 },
  { 79, 5, 12, 6, 0, -12 },
  { 87, 6, 12, 8, 1, -12 },
  { 96, 3, 12, 8, 1, -12 },
  { 101, 6, 12, 8, 1, -12 },
  { 110, 6, 12, 8, 1, -12 },
  { 119, 7, 12, 8, 0, -12 },
  { 130, 6, 12, 8, 1, -12 },
  { 139, 6, 12, 8, 1, -12 },
  { 148, 6, 12, 8, 1, -12 },
  { 157, 6, 12, 8, 1, -12 },
  { 166, 6, 12, 8, 1, -12 },
  { 175, 1, 9, 3, 1, -9 },
  { 177, 1, 11, 3, 1, -9 },
  { 179, 6, 8, 8, 1, -10 },
  { 185, 6, 4, 8, 1, -8 },
  { 188, 6, 8, 8, 1, -10 },
  { 194, 5, 12, 5, 0, -12 },
  { 202, 10, 14, 12, 1, -12 },
  { 220, 7, 12, 7, 0, -12 },
  { 231, 7, 12, 8, 1, -12 },
  { 242, 7, 12, 8, 1, -12 },
  { 253, 7, 12, 9, 1, -12 },
  { 264, 5, 12, 7, 1, -12 },
  { 272, 5, 12, 7, 1, -12 },
  { 280, 8, 12, 10, 1, -12 },
  { 292, 7, 12, 9, 1, -12 },
  { 303, 2, 12, 4, 1, -12 },
  { 306, 3, 15, 3, -1, -12 },
  { 312, 6, 12, 7, 1, -12 },
  { 321, 5, 12, 7, 1, -12 },
  { 329, 10, 12, 12, 1, -12 },
  { 344, 7, 12, 10, 1, -12 },
  { 355, 8, 12, 10, 1, -12 },
  { 367, 6, 12, 8, 1, -12 },
  { 376, 8, 15, 10, 1, -12 },
  { 391, 6, 12, 8, 1, -12 },
  { 400, 6, 12, 7, 1, -12 },
  { 409, 6, 12, 7, 0, -12 },
  { 418, 7, 12, 9, 1, -12 },
  { 429, 7, 12, 7, 0, -12 },
  { 440, 12, 12, 12, 0, -12 },
  { 458, 6, 12, 7, 0, -12 },
  { 467, 6, 12, 6, 0, -12 },
  { 476, 5, 12, 7, 1, -12 },
  { 484, 4, 15, 5, 1, -12 },
  { 492, 5, 12, 6, 0, -12 },
  { 500, 3, 15, 5, 1, -12 },
  { 506, 7, 6, 8, 0, -12 },
  { 512, 7, 1, 7, 0, 1 },
  { 513, 2, 3, 4, 1, -13 },
  { 514, 5, 9, 7, 1, -9 },
  { 520, 6, 13, 8, 1, -13 },
  { 530, 5, 9, 6, 1, -9 },
  { 536, 6, 13, 8, 1, -13 },
  { 546, 5, 9, 7, 1, -9 },
  { 552, 5, 13, 4, 0, -13 },
  { 561, 6, 13, 8, 1, -9 },
  { 571, 6, 13, 8, 1, -13 },
  { 581, 1, 12, 3, 1, -12 },
  { 583, 2, 16, 3, 0, -12 },
  { 587, 5, 13, 6, 1, -13 },
  { 596, 1, 13, 3, 1, -13 },
  { 598, 9, 9, 12, 1, -9 },
  { 609, 6, 9, 8, 1, -9 },
  { 616, 6, 9, 8, 1, -9 },
  { 623, 6, 13, 8, 1, -9 },
  { 633, 6, 13, 8, 1, -9 },
  { 643, 4, 9, 5, 1, -9 },
  { 648, 4, 9, 6, 1, -9 },
  { 653, 4, 11, 4, 0, -11 },
  { 659, 5, 9, 8, 1, -9 },
  { 665, 6, 9, 6, 0, -9 },
  { 672, 9, 9, 10, 0, -9 },
  { 683, 6, 9, 6, 0, -9 },
  { 690, 6, 13, 6, 0, -9 },
  { 700, 4, 9, 5, 1, -9 },
  { 705, 4, 15, 6, 1, -12 },
  { 713, 1, 17, 7, 3, -13 },
  { 716, 4, 15, 6, 1, -12 },
  { 724, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Thin17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_THIN17PT7B_H_
