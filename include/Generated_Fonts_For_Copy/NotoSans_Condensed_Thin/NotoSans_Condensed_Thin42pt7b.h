#ifndef _NOTOSANS_CONDENSED_THIN42PT7B_H_
#define _NOTOSANS_CONDENSED_THIN42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x54, 0x01, 0xF0, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x01, 0x02, 0x00, 0x20, 0x40,
  0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80,
  0x10, 0x20, 0x02, 0x04, 0x0F, 0xFF, 0xFC, 0x08, 0x10, 0x03, 0x02, 0x00,
  0x40, 0x40, 0x08, 0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x10, 0x20, 0x7F, 0xFF, 0xC0, 0x80, 0x80, 0x10, 0x10, 0x02,
  0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0x40, 0x08,
  0x08, 0x01, 0x01, 0x00, 0x20, 0x40, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0E,
  0x00, 0xF7, 0xC2, 0x20, 0x88, 0x40, 0x30, 0x80, 0x41, 0x00, 0x82, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x10, 0x0C, 0x20, 0x08, 0x40, 0x0C, 0x80, 0x0D,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x09, 0x80, 0x10, 0xC0, 0x20, 0xC0, 0x40,
  0x80, 0x81, 0x01, 0x03, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x98, 0x46, 0x1F, 0xF8, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x3E,
  0x00, 0x40, 0xC2, 0x01, 0x01, 0x04, 0x02, 0x02, 0x04, 0x0C, 0x0C, 0x08,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x80, 0x40, 0x41, 0x00, 0x80, 0x86,
  0x01, 0x01, 0x08, 0x02, 0x02, 0x10, 0x04, 0x04, 0x40, 0x08, 0x08, 0x8F,
  0x98, 0x13, 0x21, 0x10, 0x64, 0x41, 0x20, 0x89, 0x02, 0x63, 0x22, 0x04,
  0x7C, 0x44, 0x0C, 0x01, 0x88, 0x08, 0x02, 0x10, 0x10, 0x04, 0x20, 0x20,
  0x10, 0x40, 0x40, 0x20, 0x80, 0x80, 0xC1, 0x01, 0x01, 0x02, 0x06, 0x02,
  0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x08, 0x20, 0x20, 0x10, 0x80, 0x80,
  0x1E, 0x00, 0x0F, 0xC0, 0x06, 0x18, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x04, 0x08,
  0x00, 0x84, 0x00, 0x23, 0x00, 0x05, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x44, 0x00, 0x21, 0x80, 0x10, 0x20, 0x24, 0x04, 0x0A, 0x01, 0x82, 0x80,
  0x21, 0x20, 0x04, 0x48, 0x01, 0x92, 0x00, 0x28, 0x80, 0x06, 0x20, 0x01,
  0x8C, 0x00, 0xA1, 0x00, 0x64, 0x20, 0x30, 0x87, 0xF0, 0x30, 0xFF, 0xE0,
  0x02, 0x08, 0x30, 0x41, 0x02, 0x08, 0x10, 0x60, 0x81, 0x02, 0x0C, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02,
  0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x80, 0x81, 0x81,
  0x03, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0x81, 0x06,
  0x08, 0x30, 0x41, 0x02, 0x08, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x08, 0x20, 0xB9, 0x38, 0x3E, 0x00, 0x40, 0x05, 0x00, 0x44, 0x04, 0x10,
  0x60, 0xC2, 0x02, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x2D, 0xA4, 0xB4, 0x80, 0xFF, 0xC0, 0x7C, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x0F, 0xE0, 0x30, 0x60,
  0x40, 0x41, 0x00, 0x42, 0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x05, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x2C, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x40, 0x10, 0x80, 0x20, 0x80,
  0x81, 0x83, 0x00, 0xF8, 0x00, 0x02, 0x1C, 0x69, 0x94, 0x30, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1F, 0xC1, 0x80, 0xC4,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFF,
  0xF0, 0x3F, 0xC1, 0x80, 0xC8, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x03, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x80, 0x31, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x30, 0x08, 0x10, 0x04, 0x18, 0x02, 0x08, 0x01,
  0x08, 0x00, 0x87, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xF8,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0xF8, 0x0E, 0x0E,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xCC, 0x03, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0xFE, 0x1B, 0x03, 0x28, 0x02, 0x50,
  0x02, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x03, 0x40, 0x04, 0xC0, 0x08, 0x80, 0x11, 0x80, 0x41,
  0x81, 0x01, 0xFC, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0F,
  0xE0, 0x20, 0x20, 0x80, 0x22, 0x00, 0x64, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x04, 0xC0, 0x10, 0x80, 0x60, 0x81, 0x80, 0xC6, 0x00,
  0xF0, 0x01, 0xE0, 0x06, 0x30, 0x10, 0x30, 0x40, 0x31, 0x00, 0x36, 0x00,
  0x28, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x09,
  0x00, 0x13, 0x00, 0x43, 0x01, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xC0, 0x86,
  0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x34, 0x00, 0xD0, 0x05,
  0x20, 0x34, 0x7F, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC1, 0xFE,
  0x00, 0xF4, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x6C, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xB6, 0x92, 0xD2, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x04, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x7F, 0x10, 0x10,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x01, 0x00, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x01, 0x30, 0x1F, 0xC0, 0x90, 0x18,
  0x20, 0x48, 0x08, 0x10, 0x24, 0x08, 0x08, 0x16, 0x04, 0x04, 0x0F, 0x06,
  0x02, 0x07, 0x02, 0x01, 0x01, 0x81, 0x00, 0x81, 0xC0, 0x80, 0x40, 0xE0,
  0x40, 0x60, 0x50, 0x20, 0x30, 0x28, 0x10, 0x18, 0x16, 0x0C, 0x0C, 0x09,
  0x02, 0x0A, 0x08, 0x81, 0x85, 0x8C, 0x40, 0x7C, 0x7C, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01,
  0x20, 0x00, 0x4C, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x82,
  0x00, 0x20, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x01, 0x00, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x06, 0x03, 0xFF, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x06, 0x20, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xC1,
  0x00, 0xE2, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x03, 0x10, 0x3C,
  0x3F, 0xF0, 0x40, 0x18, 0x80, 0x09, 0x00, 0x1A, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xE0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x24, 0x00, 0xC8, 0x07, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0x80, 0x43,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x08, 0x0F, 0xF8, 0xFF,
  0x80, 0x80, 0xE0, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x30, 0x80, 0xE0, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x06, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01,
  0x60, 0x00, 0x12, 0x00, 0x01, 0x30, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00,
  0x10, 0xC0, 0x01, 0x03, 0x00, 0x30, 0x1F, 0xFC, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x06, 0xFC, 0x80, 0x0E, 0x00, 0x68,
  0x01, 0x20, 0x08, 0x80, 0x62, 0x03, 0x08, 0x08, 0x20, 0x40, 0x83, 0x02,
  0x08, 0x08, 0x40, 0x23, 0x00, 0x98, 0x02, 0x60, 0x0A, 0x80, 0x39, 0x00,
  0xC6, 0x02, 0x08, 0x08, 0x30, 0x20, 0x40, 0x80, 0x82, 0x02, 0x08, 0x04,
  0x20, 0x18, 0x80, 0x22, 0x00, 0xC8, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00,
  0x10, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x05, 0xA0, 0x00, 0x16,
  0x80, 0x00, 0x5A, 0x00, 0x02, 0x64, 0x00, 0x09, 0x90, 0x00, 0x26, 0x40,
  0x01, 0x18, 0x80, 0x04, 0x62, 0x00, 0x11, 0x88, 0x00, 0x86, 0x10, 0x02,
  0x18, 0x40, 0x08, 0x61, 0x00, 0x41, 0x82, 0x01, 0x06, 0x08, 0x04, 0x18,
  0x20, 0x20, 0x60, 0x40, 0x81, 0x81, 0x02, 0x06, 0x04, 0x10, 0x18, 0x08,
  0x40, 0x60, 0x21, 0x01, 0x80, 0x88, 0x06, 0x01, 0x20, 0x18, 0x04, 0x80,
  0x60, 0x14, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xA0, 0x01, 0xB0, 0x01, 0x90, 0x01, 0x98,
  0x01, 0x88, 0x01, 0x8C, 0x01, 0x84, 0x01, 0x86, 0x01, 0x82, 0x01, 0x83,
  0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0x81, 0x80, 0x41, 0x80, 0x41, 0x80,
  0x21, 0x80, 0x21, 0x80, 0x11, 0x80, 0x11, 0x80, 0x09, 0x80, 0x09, 0x80,
  0x05, 0x80, 0x05, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x03, 0xFC, 0x00,
  0x60, 0x30, 0x08, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x06,
  0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x63,
  0x00, 0x04, 0x10, 0x00, 0xC0, 0x80, 0x18, 0x06, 0x03, 0x00, 0x3F, 0xC0,
  0xFF, 0x04, 0x06, 0x20, 0x0D, 0x00, 0x28, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0A, 0x00,
  0x90, 0x18, 0xFF, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x03, 0xFC, 0x00, 0x60, 0x30, 0x08, 0x01, 0x81, 0x00, 0x0C, 0x30,
  0x00, 0x42, 0x00, 0x06, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x34,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x10, 0x00, 0xC0, 0x80, 0x18, 0x06,
  0x03, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0xFF, 0x02,
  0x03, 0x88, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0xC8, 0x06,
  0x3F, 0xE0, 0xFE, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x80, 0x82, 0x01,
  0x08, 0x04, 0x20, 0x08, 0x80, 0x22, 0x00, 0x48, 0x01, 0x20, 0x02, 0x80,
  0x0A, 0x00, 0x10, 0x0F, 0xF8, 0xC0, 0x16, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x80, 0x33, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40,
  0x01, 0xA0, 0x00, 0x98, 0x00, 0xC6, 0x00, 0x41, 0x80, 0xC0, 0x7F, 0xC0,
  0x80, 0x00, 0x70, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x88,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03, 0x04, 0x00, 0x81, 0x00,
  0x20, 0x40, 0x08, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30,
  0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x40, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x23, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x16,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x40, 0x0E,
  0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x06,
  0x20, 0x19, 0x00, 0x42, 0x01, 0x18, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01,
  0x08, 0x04, 0x30, 0x10, 0x80, 0xC1, 0x03, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x18, 0x20, 0x41, 0x80, 0x82, 0x04, 0x10, 0x08,
  0x40, 0x61, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x23, 0x00, 0x44, 0x02,
  0x20, 0x04, 0xC0, 0x22, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x68, 0x01, 0x40, 0x02, 0x80, 0x14, 0x00, 0x30, 0x01, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x60, 0x03, 0x20, 0x02, 0x30, 0x06, 0x10,
  0x04, 0x10, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x04, 0x10, 0x04, 0x10, 0x02,
  0x20, 0x02, 0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80, 0x01,
  0xC0, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x0C,
  0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x08, 0x30, 0x04, 0x20, 0x04, 0x60,
  0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x40, 0x02, 0x40, 0x06, 0x60,
  0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x18, 0x10, 0x08,
  0x10, 0x08, 0x30, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0xC0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xFF, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x64, 0x00, 0x22, 0x00,
  0x30, 0x80, 0x10, 0x40, 0x18, 0x10, 0x08, 0x08, 0x08, 0x02, 0x04, 0x01,
  0x04, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x02, 0x03, 0xFC, 0x60,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x70, 0xF9, 0x30, 0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0xC0, 0x54, 0x0D, 0x3F, 0x90, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x07, 0x02, 0x3B, 0x84, 0x80, 0x8A, 0x00, 0x94, 0x01, 0xB0, 0x01, 0x60,
  0x02, 0xC0, 0x05, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x2A,
  0x00, 0x94, 0x03, 0x24, 0x0C, 0x47, 0xF0, 0x00, 0x80, 0x7F, 0x18, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0F, 0xF0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x02,
  0x04, 0x3F, 0x88, 0x80, 0x92, 0x00, 0xAC, 0x01, 0x50, 0x01, 0xA0, 0x03,
  0x40, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x36, 0x00,
  0xA4, 0x01, 0x44, 0x0C, 0x87, 0xF1, 0x01, 0x00, 0x3F, 0x81, 0x03, 0x08,
  0x04, 0x60, 0x09, 0x00, 0x24, 0x00, 0x90, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x20, 0xFF, 0x00, 0x03,
  0xE0, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x03, 0xFE, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x01, 0x00, 0x1F, 0xC4, 0x40,
  0x49, 0x00, 0x56, 0x00, 0xA8, 0x00, 0xD0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x2B, 0x00, 0x72, 0x01, 0xE2, 0x06,
  0xC3, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x30, 0x18, 0x1F, 0xC0, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x08, 0x23, 0xF9, 0x20, 0x6A, 0x01, 0x50, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x21, 0xBC, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x04, 0x80, 0xC8, 0x08,
  0x81, 0x08, 0x20, 0x82, 0x08, 0x40, 0x88, 0x09, 0xC0, 0x94, 0x0A, 0x20,
  0xC2, 0x0C, 0x10, 0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02,
  0x80, 0x28, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x41, 0x3B, 0x87,
  0x62, 0x41, 0x90, 0x25, 0x01, 0x40, 0x2C, 0x02, 0x80, 0x58, 0x02, 0x00,
  0xB0, 0x04, 0x01, 0x40, 0x08, 0x03, 0x80, 0x10, 0x07, 0x00, 0x20, 0x0E,
  0x00, 0x40, 0x1C, 0x00, 0x80, 0x38, 0x01, 0x00, 0x70, 0x02, 0x00, 0xE0,
  0x04, 0x01, 0xC0, 0x08, 0x03, 0x80, 0x10, 0x07, 0x00, 0x20, 0x0E, 0x00,
  0x40, 0x1C, 0x00, 0x80, 0x38, 0x01, 0x00, 0x70, 0x02, 0x00, 0xE0, 0x04,
  0x01, 0x80, 0x01, 0x04, 0x77, 0x24, 0x0D, 0x40, 0x2A, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x80, 0x1F, 0xC0, 0x40, 0x61, 0x00, 0x46,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x60, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x06,
  0x80, 0x09, 0x00, 0x13, 0x00, 0x62, 0x00, 0x82, 0x02, 0x03, 0xF8, 0x00,
  0x01, 0x81, 0x1F, 0xC2, 0x40, 0x45, 0x00, 0x4A, 0x00, 0xD8, 0x00, 0xB0,
  0x01, 0x60, 0x02, 0xC0, 0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x02, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x15,
  0x00, 0x4A, 0x01, 0x93, 0x06, 0x23, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x1F, 0xC4, 0x40, 0x49, 0x00, 0x56, 0x00, 0xA8,
  0x00, 0xD0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x80, 0x0D,
  0x00, 0x2B, 0x00, 0x72, 0x01, 0x62, 0x06, 0xC3, 0xF9, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x8F, 0xC8, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x02, 0x07, 0xFD, 0x80, 0xE0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x07, 0x01, 0xBF,
  0xE0, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x30, 0x10, 0x1F, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xF0, 0x06,
  0x80, 0x56, 0x04, 0x9F, 0xC4, 0x80, 0x05, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x60, 0x18, 0x80, 0x42, 0x01, 0x08, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x06, 0x18, 0x08, 0x40, 0x21, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x80,
  0x30, 0x05, 0x00, 0x60, 0x0A, 0x00, 0xC0, 0x22, 0x02, 0x40, 0x44, 0x04,
  0x80, 0x88, 0x09, 0x01, 0x10, 0x12, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x80, 0x88, 0x11, 0x01, 0x10, 0x22,
  0x02, 0x20, 0x44, 0x04, 0x40, 0x88, 0x05, 0x00, 0xA0, 0x0A, 0x01, 0x40,
  0x14, 0x02, 0x80, 0x28, 0x05, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0xC0, 0x1A, 0x00, 0x88, 0x0C, 0x40, 0x41, 0x06, 0x08, 0x20, 0x23, 0x01,
  0x90, 0x05, 0x80, 0x38, 0x00, 0x80, 0x0E, 0x00, 0x50, 0x06, 0x40, 0x22,
  0x03, 0x08, 0x10, 0x41, 0x01, 0x08, 0x0C, 0x80, 0x24, 0x01, 0xC0, 0x04,
  0x40, 0x05, 0x00, 0x16, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x21, 0x01,
  0x04, 0x04, 0x10, 0x10, 0x60, 0xC0, 0x82, 0x02, 0x08, 0x08, 0x20, 0x11,
  0x00, 0x44, 0x01, 0x10, 0x06, 0xC0, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x3C, 0x00, 0x7F, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0xFF, 0xC0, 0x01, 0xC0, 0xC0, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x0C, 0x0E, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x60, 0x0F,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x70, 0x03, 0x81, 0x80,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x38, 0x0C, 0x00, 0x18,
  0x01, 0xDE, 0x06, 0x06, 0x1C, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 30, 9, 3, -30 },
  { 9, 7, 11, 13, 3, -30 },
  { 19, 19, 30, 21, 1, -30 },
  { 91, 15, 34, 19, 2, -32 },
  { 155, 23, 30, 27, 2, -30 },
  { 242, 18, 30, 20, 2, -30 },
  { 310, 1, 11, 7, 3, -30 },
  { 312, 7, 37, 11, 2, -30 },
  { 345, 7, 37, 11, 2, -30 },
  { 378, 13, 13, 17, 2, -32 },
  { 400, 15, 19, 19, 2, -24 },
  { 436, 3, 9, 7, 2, -4 },
  { 440, 10, 1, 12, 1, -12 },
  { 442, 2, 3, 8, 3, -3 },
  { 443, 12, 30, 14, 1, -30 },
  { 488, 15, 30, 19, 2, -30 },
  { 545, 7, 30, 19, 4, -30 },
  { 572, 14, 30, 19, 2, -30 },
  { 625, 14, 30, 19, 2, -30 },
  { 678, 17, 30, 19, 1, -30 },
  { 742, 15, 30, 19, 2, -30 },
  { 799, 15, 31, 19, 2, -30 },
  { 858, 14, 30, 19, 2, -30 },
  { 911, 15, 30, 19, 2, -30 },
  { 968, 14, 30, 19, 2, -30 },
  { 1021, 2, 22, 8, 3, -22 },
  { 1027, 3, 27, 8, 2, -22 },
  { 1038, 15, 18, 19, 2, -24 },
  { 1072, 15, 10, 19, 2, -20 },
  { 1091, 15, 18, 19, 2, -24 },
  { 1125, 11, 30, 13, 1, -30 },
  { 1167, 25, 34, 29, 2, -30 },
  { 1274, 18, 30, 18, 0, -30 },
  { 1342, 15, 30, 20, 4, -30 },
  { 1399, 17, 30, 20, 2, -30 },
  { 1463, 16, 30, 23, 4, -30 },
  { 1523, 12, 30, 18, 4, -30 },
  { 1568, 12, 30, 17, 4, -30 },
  { 1613, 20, 30, 24, 2, -30 },
  { 1688, 16, 30, 23, 4, -30 },
  { 1748, 6, 30, 10, 2, -30 },
  { 1771, 8, 37, 8, -3, -30 },
  { 1808, 14, 30, 18, 4, -30 },
  { 1861, 12, 30, 16, 4, -30 },
  { 1906, 22, 30, 30, 4, -30 },
  { 1989, 16, 30, 24, 4, -30 },
  { 2049, 20, 30, 25, 2, -30 },
  { 2124, 13, 30, 19, 4, -30 },
  { 2173, 20, 37, 25, 2, -30 },
  { 2266, 14, 30, 19, 4, -30 },
  { 2319, 14, 30, 18, 2, -30 },
  { 2372, 16, 30, 16, 0, -30 },
  { 2432, 17, 30, 23, 3, -30 },
  { 2496, 18, 30, 18, 0, -30 },
  { 2564, 28, 30, 30, 1, -30 },
  { 2669, 16, 30, 16, 0, -30 },
  { 2729, 16, 30, 16, 0, -30 },
  { 2789, 15, 30, 17, 1, -30 },
  { 2846, 8, 37, 13, 4, -30 },
  { 2883, 12, 30, 14, 1, -30 },
  { 2928, 8, 37, 13, 1, -30 },
  { 2965, 17, 16, 19, 1, -30 },
  { 2999, 17, 1, 16, 0, 4 },
  { 3002, 6, 7, 10, 2, -32 },
  { 3008, 12, 23, 17, 2, -23 },
  { 3043, 15, 32, 20, 3, -32 },
  { 3103, 12, 23, 15, 2, -23 },
  { 3138, 15, 32, 20, 2, -32 },
  { 3198, 14, 23, 18, 2, -23 },
  { 3239, 11, 32, 10, 0, -32 },
  { 3283, 15, 33, 20, 2, -23 },
  { 3345, 13, 32, 19, 3, -32 },
  { 3397, 2, 30, 8, 3, -30 },
  { 3405, 6, 40, 8, -1, -30 },
  { 3435, 12, 32, 15, 3, -32 },
  { 3483, 1, 32, 8, 3, -32 },
  { 3487, 23, 23, 29, 3, -23 },
  { 3554, 13, 23, 19, 3, -23 },
  { 3592, 15, 23, 19, 2, -23 },
  { 3636, 15, 33, 20, 3, -23 },
  { 3698, 15, 33, 20, 2, -23 },
  { 3760, 9, 22, 12, 3, -22 },
  { 3785, 11, 23, 15, 2, -23 },
  { 3817, 8, 28, 10, 1, -28 },
  { 3845, 13, 22, 19, 3, -22 },
  { 3881, 14, 22, 14, 0, -22 },
  { 3920, 23, 22, 24, 0, -22 },
  { 3984, 13, 22, 15, 1, -22 },
  { 4020, 14, 32, 15, 0, -22 },
  { 4076, 11, 22, 13, 1, -22 },
  { 4107, 10, 37, 14, 2, -30 },
  { 4154, 1, 42, 18, 8, -32 },
  { 4160, 11, 37, 14, 2, -30 },
  { 4211, 15, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_Thin42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_THIN42PT7B_H_
