#ifndef _NOTOSANS_CONDENSED_THIN54PT7B_H_
#define _NOTOSANS_CONDENSED_THIN54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x0F, 0xF8, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x08, 0x00, 0x60, 0x10, 0x00,
  0x60, 0x10, 0x00, 0x40, 0x10, 0x00, 0x40, 0x30, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x00,
  0x80, 0x20, 0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x3F, 0xFF, 0xFF, 0x00,
  0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01,
  0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x03,
  0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00, 0x80, 0xFF,
  0xFF, 0xFE, 0x02, 0x01, 0x80, 0x02, 0x01, 0x80, 0x02, 0x01, 0x00, 0x06,
  0x01, 0x00, 0x06, 0x01, 0x00, 0x06, 0x01, 0x00, 0x04, 0x03, 0x00, 0x04,
  0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C,
  0x02, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x01, 0xFE, 0x00, 0xF4, 0xFC, 0x30, 0x81, 0x0C, 0x10, 0x03, 0x02, 0x00,
  0x40, 0x40, 0x18, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x04, 0x01,
  0x80, 0x80, 0x30, 0x10, 0x02, 0x02, 0x00, 0x60, 0x40, 0x06, 0x08, 0x00,
  0x61, 0x00, 0x07, 0x20, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x02, 0x70, 0x00, 0x43, 0x00, 0x08, 0x30, 0x01, 0x03, 0x00, 0x20, 0x30,
  0x04, 0x06, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x01, 0x80, 0x20, 0x20, 0x04, 0x0D, 0x80, 0x87, 0x1F,
  0x97, 0x80, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0x00, 0x06, 0x01, 0x8C, 0x00, 0x20, 0x18, 0x30, 0x03,
  0x00, 0x80, 0x80, 0x10, 0x04, 0x06, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x06, 0x00, 0x80, 0x20, 0x20, 0x04, 0x01,
  0x01, 0x00, 0x20, 0x08, 0x18, 0x01, 0x00, 0x40, 0x80, 0x08, 0x02, 0x0C,
  0x00, 0x40, 0x10, 0x40, 0x02, 0x00, 0x82, 0x00, 0x10, 0x04, 0x30, 0x60,
  0x80, 0x21, 0x0F, 0xC4, 0x01, 0x18, 0xC3, 0x30, 0x18, 0x84, 0x08, 0x80,
  0xC4, 0x60, 0x64, 0x04, 0x62, 0x01, 0x30, 0x62, 0x10, 0x08, 0xC6, 0x31,
  0x80, 0x43, 0xE1, 0x0C, 0x03, 0x00, 0x08, 0x60, 0x18, 0x00, 0xC2, 0x00,
  0xC0, 0x04, 0x10, 0x06, 0x00, 0x60, 0x80, 0x30, 0x02, 0x04, 0x01, 0x80,
  0x10, 0x20, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x08, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x03, 0x00, 0x60,
  0x60, 0x10, 0x01, 0x02, 0x01, 0x80, 0x0C, 0x30, 0x0C, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0x38, 0x00, 0x10, 0x10, 0x00, 0x60, 0x30, 0x00,
  0x80, 0x20, 0x01, 0x00, 0x40, 0x02, 0x00, 0x80, 0x04, 0x01, 0x80, 0x08,
  0x03, 0x00, 0x10, 0x04, 0x00, 0x20, 0x08, 0x00, 0x60, 0x10, 0x00, 0xC0,
  0x60, 0x00, 0x80, 0x80, 0x01, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x04, 0x00, 0x0C, 0x04, 0x01, 0x10, 0x0C, 0x02, 0x60, 0x08, 0x04,
  0x80, 0x08, 0x09, 0x00, 0x18, 0x36, 0x00, 0x18, 0x4C, 0x00, 0x10, 0x98,
  0x00, 0x33, 0x30, 0x00, 0x34, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x60, 0x80,
  0x00, 0xE1, 0x80, 0x03, 0x41, 0x00, 0x0C, 0xC3, 0x00, 0x30, 0xC3, 0x81,
  0xC0, 0x81, 0xFE, 0x00, 0x80, 0x40, 0x00, 0xFF, 0xFC, 0x01, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10,
  0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x03, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08,
  0x06, 0x03, 0x00, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x81, 0x01, 0xE1, 0x0F, 0x1D, 0x38, 0x03, 0xC0, 0x01, 0x80, 0x02,
  0x40, 0x04, 0x60, 0x0C, 0x20, 0x08, 0x10, 0x10, 0x08, 0x20, 0x0C, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x10,
  0xC4, 0x63, 0x18, 0x84, 0x63, 0x11, 0x88, 0x00, 0xFF, 0xF0, 0xDF, 0x00,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xC7, 0x00, 0xC0,
  0x60, 0x60, 0x08, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x19, 0x80, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xD0,
  0x00, 0x34, 0x00, 0x09, 0x80, 0x02, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00,
  0x10, 0x60, 0x08, 0x18, 0x06, 0x03, 0x83, 0x00, 0x3F, 0x80, 0x00, 0x80,
  0xC0, 0xE1, 0x91, 0x89, 0x85, 0x83, 0x81, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0xF8, 0x03, 0xC3, 0x81, 0xC0,
  0x1C, 0x10, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xC3, 0xC1, 0xC0, 0x0C, 0x60, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC8, 0x00, 0x31, 0xE0, 0x1C, 0x0F, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00, 0x0C,
  0x40, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04,
  0x00, 0x04, 0x08, 0x00, 0x18, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40,
  0x03, 0x00, 0x80, 0x04, 0x01, 0x00, 0x18, 0x02, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x10, 0x06, 0x00, 0x20, 0x18, 0x00, 0x40, 0x20,
  0x00, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x06, 0x00, 0x04, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC2,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x4F, 0xF0, 0x1F, 0x9F, 0x04,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x80, 0x06, 0x38, 0x07, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x3C, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x02,
  0x00, 0xC7, 0xFC, 0x19, 0x80, 0xC2, 0x60, 0x04, 0x58, 0x00, 0xCA, 0x00,
  0x09, 0x80, 0x01, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00,
  0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x02, 0x18, 0x00,
  0xC1, 0x80, 0x30, 0x18, 0x0C, 0x01, 0xFF, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x79, 0xE0, 0x0C, 0x03, 0x81, 0x80, 0x08,
  0x30, 0x00, 0xC2, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80,
  0x08, 0x08, 0x01, 0x80, 0xE0, 0x30, 0x03, 0x0C, 0x00, 0x1D, 0x80, 0x00,
  0x60, 0x00, 0x1B, 0x80, 0x07, 0x0E, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x83,
  0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00,
  0x24, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0,
  0x30, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x03, 0xF8, 0x01, 0xC3, 0x80, 0x60,
  0x18, 0x08, 0x01, 0x83, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00, 0x32, 0x00,
  0x06, 0x40, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00,
  0x0D, 0x80, 0x02, 0x90, 0x00, 0x73, 0x00, 0x16, 0x30, 0x06, 0xC3, 0x83,
  0x98, 0x1F, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x70,
  0x0F, 0xF8, 0x00, 0x38, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x7C, 0x11, 0xCE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x18, 0x8C, 0x63, 0x10, 0x8C,
  0x42, 0x31, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xC3, 0xE3, 0x84, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x07, 0x00,
  0x26, 0x00, 0x7F, 0xC0, 0x4C, 0x01, 0x81, 0x80, 0xD0, 0x06, 0x03, 0x01,
  0xA0, 0x18, 0x04, 0x03, 0xC0, 0x20, 0x08, 0x03, 0x80, 0xC0, 0x10, 0x07,
  0x01, 0x80, 0x20, 0x0C, 0x02, 0x00, 0x40, 0x18, 0x04, 0x00, 0x80, 0x30,
  0x08, 0x01, 0x00, 0x60, 0x10, 0x02, 0x00, 0xC0, 0x20, 0x04, 0x01, 0x80,
  0x40, 0x18, 0x03, 0x00, 0x80, 0x30, 0x0E, 0x01, 0x00, 0x60, 0x1E, 0x02,
  0x00, 0xC0, 0x2C, 0x06, 0x03, 0x80, 0x58, 0x04, 0x05, 0x81, 0xB0, 0x0C,
  0x19, 0x06, 0x20, 0x0C, 0x63, 0xB8, 0x40, 0x0F, 0x83, 0xE0, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x08, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x46, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x01, 0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x02,
  0x00, 0xC0, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0x60, 0x04,
  0x00, 0x20, 0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x30, 0x08,
  0x00, 0x10, 0x18, 0x00, 0x10, 0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60,
  0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x82, 0x00, 0x38, 0x40, 0x01, 0x88,
  0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD0,
  0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0x20,
  0x00, 0x64, 0x00, 0x08, 0x80, 0x03, 0x10, 0x01, 0xC3, 0xFF, 0xC0, 0x40,
  0x3E, 0x08, 0x00, 0x71, 0x00, 0x03, 0x20, 0x00, 0x24, 0x00, 0x06, 0x80,
  0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00,
  0x02, 0x40, 0x00, 0xC8, 0x00, 0x71, 0x00, 0x78, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0x83, 0xC0, 0xE0, 0x02, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x0C, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x20, 0x07, 0x81, 0x00, 0x06, 0x08, 0x00, 0x18, 0x40, 0x00, 0x62,
  0x00, 0x01, 0x10, 0x00, 0x0C, 0x80, 0x00, 0x24, 0x00, 0x01, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x03,
  0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00,
  0x06, 0x20, 0x00, 0x61, 0x00, 0x06, 0x08, 0x00, 0xE0, 0x40, 0x7C, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x70, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02,
  0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x08, 0x0F, 0x00, 0x3C, 0x01, 0xFF,
  0xF0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0xFF, 0x7F, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0A, 0x0D, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x0C,
  0x80, 0x06, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x20,
  0x08, 0x08, 0x06, 0x02, 0x03, 0x00, 0x81, 0x80, 0x20, 0x60, 0x08, 0x30,
  0x02, 0x18, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x09, 0xE0, 0x02, 0xC8, 0x00,
  0xA3, 0x00, 0x38, 0x60, 0x0C, 0x18, 0x02, 0x03, 0x00, 0x80, 0x40, 0x20,
  0x18, 0x08, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x06, 0x08, 0x00,
  0xC2, 0x00, 0x10, 0x80, 0x06, 0x20, 0x00, 0x88, 0x00, 0x32, 0x00, 0x04,
  0x80, 0x01, 0xA0, 0x00, 0x38, 0x00, 0x04, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFA,
  0x00, 0x00, 0x07, 0xD0, 0x00, 0x00, 0x2E, 0xC0, 0x00, 0x03, 0x72, 0x00,
  0x00, 0x1B, 0x90, 0x00, 0x00, 0x9C, 0xC0, 0x00, 0x0C, 0xE2, 0x00, 0x00,
  0x67, 0x10, 0x00, 0x02, 0x38, 0xC0, 0x00, 0x31, 0xC2, 0x00, 0x01, 0x8E,
  0x10, 0x00, 0x08, 0x70, 0xC0, 0x00, 0xC3, 0x82, 0x00, 0x06, 0x1C, 0x10,
  0x00, 0x20, 0xE0, 0xC0, 0x03, 0x07, 0x02, 0x00, 0x18, 0x38, 0x10, 0x00,
  0x81, 0xC0, 0xC0, 0x0C, 0x0E, 0x02, 0x00, 0x60, 0x70, 0x10, 0x02, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x02, 0x01, 0x80, 0xE0, 0x10, 0x08, 0x07, 0x00,
  0xC0, 0xC0, 0x38, 0x02, 0x06, 0x01, 0xC0, 0x10, 0x20, 0x0E, 0x00, 0xC3,
  0x00, 0x70, 0x02, 0x18, 0x03, 0x80, 0x18, 0x80, 0x1C, 0x00, 0xCC, 0x00,
  0xE0, 0x02, 0x60, 0x07, 0x00, 0x1A, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3A, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0x40,
  0x00, 0x73, 0x00, 0x03, 0x88, 0x00, 0x1C, 0x60, 0x00, 0xE1, 0x00, 0x07,
  0x0C, 0x00, 0x38, 0x20, 0x01, 0xC1, 0x80, 0x0E, 0x04, 0x00, 0x70, 0x30,
  0x03, 0x80, 0x80, 0x1C, 0x06, 0x00, 0xE0, 0x10, 0x07, 0x00, 0xC0, 0x38,
  0x02, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x40, 0x70, 0x03, 0x03, 0x80, 0x08,
  0x1C, 0x00, 0x60, 0xE0, 0x01, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x21, 0xC0,
  0x01, 0x8E, 0x00, 0x06, 0x70, 0x00, 0x33, 0x80, 0x00, 0xDC, 0x00, 0x06,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x18,
  0x60, 0x00, 0x04, 0x20, 0x00, 0x03, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x04, 0x40, 0x00, 0x06, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x01, 0x80, 0x01, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x03,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x20,
  0x07, 0x10, 0x00, 0xC8, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x01, 0x90,
  0x01, 0x88, 0x03, 0x87, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x40, 0x00, 0x18, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x48, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x06, 0x30, 0x00,
  0x02, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x01, 0x80, 0x01, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x03, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3A, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0xFF, 0x00, 0x3F, 0xFC, 0x08, 0x01, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20,
  0x00, 0x48, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x04,
  0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x60, 0xFF, 0xF0, 0x3F,
  0xF0, 0x08, 0x04, 0x02, 0x01, 0x80, 0x80, 0x20, 0x20, 0x0C, 0x08, 0x01,
  0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x42, 0x00, 0x18,
  0x80, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x12, 0x00, 0x06, 0x80, 0x00, 0xA0,
  0x00, 0x38, 0x00, 0x04, 0x01, 0xFE, 0x00, 0xE0, 0x78, 0x30, 0x01, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x39, 0xC0, 0x1C, 0x1F, 0xFF,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90,
  0x00, 0x02, 0x40, 0x00, 0x19, 0x80, 0x00, 0x62, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x38, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x08,
  0x00, 0x40, 0x10, 0x00, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x00,
  0x02, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x24,
  0x00, 0x07, 0x00, 0x03, 0x20, 0x00, 0x68, 0x00, 0x19, 0x80, 0x03, 0x40,
  0x00, 0x8C, 0x00, 0x12, 0x00, 0x04, 0x20, 0x00, 0x98, 0x00, 0x61, 0x00,
  0x0C, 0xC0, 0x03, 0x08, 0x00, 0x62, 0x00, 0x10, 0x60, 0x03, 0x10, 0x00,
  0x83, 0x00, 0x10, 0xC0, 0x0C, 0x08, 0x00, 0x86, 0x00, 0x60, 0x40, 0x0C,
  0x30, 0x03, 0x03, 0x00, 0x60, 0x80, 0x10, 0x18, 0x02, 0x04, 0x00, 0x80,
  0x40, 0x10, 0x30, 0x0C, 0x02, 0x01, 0x81, 0x80, 0x60, 0x18, 0x0C, 0x04,
  0x02, 0x00, 0xC0, 0x60, 0x20, 0x10, 0x02, 0x02, 0x01, 0x81, 0x80, 0x10,
  0x10, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x20, 0x40, 0x06, 0x0C, 0x01, 0x02,
  0x00, 0x30, 0x40, 0x08, 0x30, 0x00, 0x82, 0x00, 0x61, 0x80, 0x04, 0x10,
  0x03, 0x08, 0x00, 0x31, 0x80, 0x08, 0x40, 0x01, 0x8C, 0x00, 0x42, 0x00,
  0x04, 0x40, 0x03, 0x30, 0x00, 0x22, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00,
  0x48, 0x00, 0x0D, 0x80, 0x02, 0x40, 0x00, 0x28, 0x00, 0x16, 0x00, 0x01,
  0x40, 0x00, 0xF0, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x13, 0x00, 0x03, 0x10,
  0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x40, 0x80, 0x0C, 0x0C, 0x00, 0x80,
  0x40, 0x18, 0x06, 0x01, 0x00, 0x20, 0x30, 0x03, 0x03, 0x00, 0x10, 0x20,
  0x01, 0x86, 0x00, 0x18, 0x40, 0x00, 0x8C, 0x00, 0x0C, 0x80, 0x00, 0x58,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x05,
  0x80, 0x00, 0xC8, 0x00, 0x08, 0xC0, 0x01, 0x84, 0x00, 0x10, 0x60, 0x03,
  0x06, 0x00, 0x20, 0x20, 0x06, 0x03, 0x00, 0x40, 0x10, 0x0C, 0x01, 0x80,
  0x80, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0x43, 0x00, 0x06,
  0x60, 0x00, 0x26, 0x00, 0x03, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x63, 0x00, 0x04, 0x30,
  0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00,
  0xC0, 0x30, 0x04, 0x02, 0x00, 0x60, 0x60, 0x02, 0x06, 0x00, 0x20, 0x40,
  0x03, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00, 0x90,
  0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0xFF, 0xFF, 0xF0, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x44, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x20, 0x18, 0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x30, 0x01, 0x01, 0x80,
  0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01,
  0xB8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x07, 0xF0, 0x1F, 0x3C, 0x30, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x07, 0x81, 0x1C, 0x01, 0x30, 0x01,
  0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x07, 0x40, 0x05, 0x60, 0x0D, 0x30, 0x19, 0x1F, 0xE1,
  0x01, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x1F, 0x81, 0x8E, 0x3C, 0x33,
  0x00, 0xC6, 0x80, 0x08, 0xF0, 0x01, 0x9C, 0x00, 0x12, 0x80, 0x03, 0x60,
  0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00,
  0x03, 0x70, 0x00, 0x4A, 0x00, 0x19, 0x60, 0x03, 0x26, 0x00, 0xC4, 0x60,
  0x70, 0x87, 0xFC, 0x00, 0x08, 0x00, 0x01, 0xFC, 0x0F, 0x9C, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x10, 0x7F,
  0xE0, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x03, 0xF0, 0x43, 0xCF, 0x11, 0x80,
  0x64, 0xC0, 0x0D, 0x20, 0x01, 0x58, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03,
  0x60, 0x01, 0xC8, 0x00, 0x53, 0x00, 0x24, 0x70, 0x31, 0x07, 0xF8, 0x40,
  0x20, 0x00, 0x03, 0xF0, 0x07, 0x9E, 0x06, 0x01, 0x86, 0x00, 0x42, 0x00,
  0x33, 0x00, 0x09, 0x00, 0x06, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x21,
  0xC0, 0x60, 0x7F, 0xE0, 0x02, 0x00, 0x01, 0xF8, 0x38, 0x41, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x7F, 0xE0, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x03, 0xF8, 0x03, 0xCF, 0x11, 0x80, 0x64, 0xC0, 0x0D, 0x20, 0x01,
  0x58, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x01, 0x48, 0x00, 0xD3,
  0x00, 0x24, 0x70, 0x31, 0x07, 0xF8, 0x40, 0x20, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x31, 0x00, 0x18, 0x7C, 0x3C, 0x03, 0xFC, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x3F, 0x06, 0x39, 0xE3, 0x30, 0x19, 0xA0, 0x06, 0xF0, 0x03,
  0x70, 0x00, 0xB8, 0x00, 0x58, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0xFD, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x06, 0x0C, 0x18, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x1A, 0x67, 0x80,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x01, 0xB0, 0x02, 0x60, 0x0C, 0xC0, 0x31, 0x80, 0x43, 0x01, 0x06,
  0x06, 0x0C, 0x18, 0x18, 0x20, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x96,
  0x03, 0x64, 0x07, 0x8C, 0x0E, 0x08, 0x18, 0x18, 0x30, 0x10, 0x60, 0x30,
  0xC0, 0x21, 0x80, 0x63, 0x00, 0x46, 0x00, 0xCC, 0x00, 0x98, 0x01, 0xB0,
  0x01, 0x60, 0x03, 0xC0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0x84, 0x71, 0xC1, 0xCE, 0x26,
  0x02, 0x10, 0x19, 0x20, 0x09, 0x00, 0x6A, 0x00, 0x58, 0x01, 0x50, 0x03,
  0x80, 0x0B, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x03, 0xC0, 0x02, 0x00,
  0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C,
  0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x78, 0x00,
  0x40, 0x03, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x80,
  0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0F,
  0x00, 0x08, 0x00, 0x78, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x00, 0x1E, 0x00,
  0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20,
  0x01, 0x80, 0x03, 0xF0, 0x43, 0x8E, 0x23, 0x01, 0x92, 0x00, 0x6B, 0x00,
  0x35, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x18, 0x03, 0xF8, 0x01, 0xE7, 0x80, 0x60, 0x1C, 0x18,
  0x00, 0x82, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00, 0x32, 0x00, 0x02, 0xC0,
  0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x00, 0x90, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x00, 0x86, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x03, 0x00, 0x7F,
  0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x10, 0xF3, 0xC2, 0x30, 0x0C, 0x4C,
  0x00, 0x8B, 0x00, 0x19, 0x40, 0x01, 0x28, 0x00, 0x36, 0x00, 0x02, 0xC0,
  0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x35, 0x00,
  0x04, 0xE0, 0x01, 0x9A, 0x00, 0x23, 0x60, 0x0C, 0x67, 0x07, 0x0C, 0x7F,
  0x81, 0x80, 0x80, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xC7,
  0x11, 0x80, 0x64, 0xC0, 0x0D, 0x20, 0x01, 0x58, 0x00, 0x34, 0x00, 0x0D,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D,
  0x00, 0x03, 0x60, 0x01, 0x4C, 0x00, 0xD3, 0x00, 0x64, 0x70, 0x31, 0x07,
  0xF8, 0x40, 0x20, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x03, 0xF0, 0xEE, 0x20, 0x48,
  0x0B, 0x01, 0x40, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x07,
  0xF0, 0x3C, 0x7C, 0xC0, 0x13, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x37, 0x00, 0xC7, 0xFF, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x07, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x1F, 0x80, 0x80, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x40, 0x05, 0xB0, 0x06, 0xCC, 0x0E, 0x63, 0xFC, 0x30, 0x10, 0x00,
  0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x08,
  0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x81, 0x80,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x20,
  0x04, 0x08, 0x01, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x80, 0x02, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xB0, 0x01,
  0x40, 0x04, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x50, 0x03, 0x30, 0x06, 0xC0,
  0x11, 0x80, 0x22, 0x00, 0x84, 0x01, 0x10, 0x04, 0x20, 0x08, 0x80, 0x61,
  0x00, 0xC6, 0x03, 0x0C, 0x04, 0x10, 0x10, 0x20, 0x20, 0x80, 0x81, 0x03,
  0x04, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x60, 0x80, 0x82, 0x01, 0x04, 0x04,
  0x10, 0x08, 0x60, 0x20, 0x80, 0x43, 0x01, 0x8C, 0x03, 0x10, 0x0C, 0x40,
  0x18, 0x80, 0x22, 0x00, 0x4C, 0x01, 0x10, 0x02, 0x60, 0x0D, 0x80, 0x1A,
  0x00, 0x68, 0x00, 0xD0, 0x01, 0x40, 0x02, 0x80, 0x0A, 0x00, 0x1C, 0x00,
  0x50, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x08, 0x00, 0x60, 0x01, 0x88,
  0x00, 0xC3, 0x00, 0x30, 0x40, 0x18, 0x18, 0x06, 0x02, 0x03, 0x00, 0xC0,
  0x80, 0x10, 0x60, 0x06, 0x10, 0x00, 0x8C, 0x00, 0x32, 0x00, 0x05, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00,
  0x8C, 0x00, 0x61, 0x00, 0x10, 0x60, 0x0C, 0x0C, 0x02, 0x03, 0x01, 0x80,
  0x60, 0xC0, 0x08, 0x30, 0x03, 0x18, 0x00, 0x44, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x43, 0x00, 0x08,
  0x20, 0x03, 0x04, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x01, 0x00, 0x60,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x81, 0x00,
  0x30, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x20, 0x00, 0x8C, 0x00,
  0x11, 0x00, 0x03, 0x20, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x04, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0x00, 0x04, 0x01, 0xF0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03,
  0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x0F, 0xC0, 0x20, 0x00, 0x3F, 0x80,
  0x16, 0x0E, 0x01, 0x80, 0x38, 0x78, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 39, 11, 4, -39 },
  { 16, 9, 14, 16, 4, -39 },
  { 32, 24, 39, 27, 1, -39 },
  { 149, 19, 44, 24, 2, -41 },
  { 254, 29, 39, 34, 3, -39 },
  { 396, 23, 40, 26, 2, -39 },
  { 511, 1, 14, 9, 4, -39 },
  { 513, 9, 48, 14, 3, -39 },
  { 567, 10, 48, 14, 2, -39 },
  { 627, 16, 16, 22, 3, -41 },
  { 659, 20, 24, 24, 2, -31 },
  { 719, 5, 13, 10, 2, -6 },
  { 728, 12, 1, 15, 2, -15 },
  { 730, 3, 3, 10, 4, -3 },
  { 732, 16, 39, 18, 1, -39 },
  { 810, 18, 39, 24, 3, -39 },
  { 898, 9, 39, 24, 5, -39 },
  { 942, 19, 39, 24, 2, -39 },
  { 1035, 19, 40, 24, 2, -39 },
  { 1130, 23, 39, 24, 1, -39 },
  { 1243, 18, 39, 24, 3, -39 },
  { 1331, 19, 40, 24, 3, -39 },
  { 1426, 18, 39, 24, 3, -39 },
  { 1514, 20, 40, 24, 2, -39 },
  { 1614, 19, 40, 24, 2, -39 },
  { 1709, 3, 29, 10, 4, -29 },
  { 1720, 5, 36, 10, 2, -29 },
  { 1743, 20, 23, 24, 2, -31 },
  { 1801, 20, 12, 24, 2, -25 },
  { 1831, 20, 23, 24, 2, -31 },
  { 1889, 14, 39, 17, 1, -39 },
  { 1958, 31, 44, 37, 3, -39 },
  { 2129, 24, 39, 24, 0, -39 },
  { 2246, 19, 39, 26, 5, -39 },
  { 2339, 21, 40, 26, 3, -39 },
  { 2444, 21, 39, 29, 5, -39 },
  { 2547, 15, 39, 23, 5, -39 },
  { 2621, 16, 39, 21, 5, -39 },
  { 2699, 25, 40, 31, 3, -39 },
  { 2824, 20, 39, 30, 5, -39 },
  { 2922, 8, 39, 13, 2, -39 },
  { 2961, 9, 48, 11, -3, -39 },
  { 3015, 18, 39, 23, 5, -39 },
  { 3103, 15, 39, 21, 5, -39 },
  { 3177, 29, 39, 38, 5, -39 },
  { 3319, 21, 39, 30, 5, -39 },
  { 3422, 25, 40, 32, 3, -39 },
  { 3547, 17, 39, 24, 5, -39 },
  { 3630, 25, 48, 32, 3, -39 },
  { 3780, 18, 39, 25, 5, -39 },
  { 3868, 19, 40, 23, 2, -39 },
  { 3963, 21, 39, 21, 0, -39 },
  { 4066, 22, 40, 30, 4, -39 },
  { 4176, 23, 39, 23, 0, -39 },
  { 4289, 37, 39, 39, 1, -39 },
  { 4470, 20, 39, 21, 0, -39 },
  { 4568, 20, 39, 20, 0, -39 },
  { 4666, 18, 39, 22, 2, -39 },
  { 4754, 10, 48, 17, 5, -39 },
  { 4814, 16, 39, 18, 1, -39 },
  { 4892, 10, 48, 17, 2, -39 },
  { 4952, 22, 20, 24, 1, -39 },
  { 5007, 21, 1, 21, 0, 5 },
  { 5010, 8, 8, 13, 2, -41 },
  { 5018, 16, 30, 22, 2, -29 },
  { 5078, 19, 42, 25, 4, -41 },
  { 5178, 15, 30, 20, 3, -29 },
  { 5235, 18, 42, 25, 3, -41 },
  { 5330, 17, 30, 23, 3, -29 },
  { 5394, 13, 41, 12, 1, -41 },
  { 5461, 18, 42, 25, 3, -29 },
  { 5556, 17, 41, 25, 4, -41 },
  { 5644, 2, 39, 10, 4, -39 },
  { 5654, 7, 52, 10, -1, -39 },
  { 5700, 15, 41, 20, 4, -41 },
  { 5777, 2, 41, 10, 4, -41 },
  { 5788, 29, 29, 37, 4, -29 },
  { 5894, 17, 29, 25, 4, -29 },
  { 5956, 19, 30, 25, 3, -29 },
  { 6028, 19, 42, 25, 4, -29 },
  { 6128, 18, 42, 25, 3, -29 },
  { 6223, 11, 29, 16, 4, -29 },
  { 6263, 15, 30, 19, 2, -29 },
  { 6320, 11, 36, 13, 1, -35 },
  { 6370, 17, 29, 25, 4, -28 },
  { 6432, 18, 28, 18, 0, -28 },
  { 6495, 29, 28, 30, 1, -28 },
  { 6597, 18, 28, 20, 1, -28 },
  { 6660, 19, 41, 19, 0, -28 },
  { 6758, 14, 28, 17, 2, -28 },
  { 6807, 14, 48, 19, 2, -39 },
  { 6891, 1, 54, 23, 11, -41 },
  { 6898, 14, 48, 19, 2, -39 },
  { 6982, 20, 4, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Thin54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_THIN54PT7B_H_
