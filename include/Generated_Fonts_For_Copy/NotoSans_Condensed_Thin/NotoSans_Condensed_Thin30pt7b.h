#ifndef _NOTOSANS_CONDENSED_THIN30PT7B_H_
#define _NOTOSANS_CONDENSED_THIN30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x03, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x20,
  0x04, 0x20, 0x41, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x23, 0xFF, 0xE1,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x20, 0x21, 0x01, 0x08, 0x7F, 0xF8, 0x42,
  0x04, 0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x00, 0x04,
  0x00, 0x80, 0x7E, 0x32, 0x24, 0x41, 0x08, 0x21, 0x04, 0x20, 0x84, 0x08,
  0x80, 0x90, 0x0E, 0x00, 0x60, 0x0B, 0x01, 0x10, 0x21, 0x04, 0x20, 0x84,
  0x10, 0x82, 0x10, 0x45, 0xEF, 0x03, 0x00, 0x20, 0x04, 0x00, 0x18, 0x00,
  0x12, 0x04, 0x10, 0x82, 0x08, 0x42, 0x08, 0x21, 0x04, 0x11, 0x02, 0x08,
  0x81, 0x04, 0x40, 0x82, 0x40, 0x21, 0x27, 0x10, 0xA4, 0x48, 0x94, 0x22,
  0x4A, 0x08, 0x89, 0x04, 0x04, 0x82, 0x04, 0x41, 0x02, 0x20, 0x81, 0x10,
  0x41, 0x08, 0x20, 0x84, 0x20, 0x81, 0x10, 0x40, 0x70, 0x0C, 0x00, 0x88,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x02, 0x20, 0x11, 0x00,
  0x70, 0x02, 0x00, 0x28, 0x02, 0x20, 0x21, 0x06, 0x04, 0x50, 0x12, 0x80,
  0x94, 0x03, 0x20, 0x08, 0x80, 0xC4, 0x09, 0x1F, 0x84, 0xFE, 0x0C, 0x41,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0x04,
  0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0xC2, 0x08, 0x21, 0x08, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x08, 0x84, 0x44, 0x00, 0x04,
  0x01, 0x00, 0x43, 0x13, 0x37, 0x03, 0x01, 0x20, 0x48, 0x21, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x29, 0x25, 0x20, 0xFE, 0xF0, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x1C, 0x08, 0xC4, 0x11, 0x02,
  0x80, 0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x09, 0x02, 0x21, 0x0F, 0x80, 0x19,
  0x53, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x80, 0x1E, 0x0C, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFF, 0xC0, 0x1E, 0x0C, 0x32, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x30, 0x78, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x28,
  0x08, 0xFE, 0x00, 0x00, 0x80, 0x08, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48,
  0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x20, 0x82, 0x08, 0x40, 0x84, 0x08,
  0x80, 0x88, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x7F, 0x90, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xBC, 0x30,
  0xC0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x0A,
  0x04, 0xFE, 0x00, 0x03, 0x06, 0x22, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x2F, 0xCC, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x02, 0x40, 0x8F, 0xC0, 0xFF, 0xE0, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x0F, 0x06, 0x11, 0x01, 0x20, 0x24, 0x02, 0x80, 0x50, 0x12, 0x02, 0x20,
  0x83, 0x20, 0x18, 0x0C, 0x82, 0x08, 0x80, 0x90, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xA0, 0x22, 0x04, 0x3F, 0x00, 0x0E, 0x06, 0x21, 0x02, 0x20,
  0x24, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01, 0xA0, 0x52,
  0x1A, 0x3C, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0xFC, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x52,
  0x4A, 0x40, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x08, 0x00,
  0x71, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x20, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x00, 0x00, 0x02, 0x04, 0x00, 0x07, 0xF8, 0x0C, 0x02,
  0x0C, 0x00, 0x84, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x07, 0xC3, 0x04,
  0x21, 0x84, 0x10, 0xC2, 0x08, 0x62, 0x04, 0x31, 0x02, 0x18, 0x82, 0x0C,
  0x41, 0x06, 0x10, 0xC3, 0x08, 0x62, 0x86, 0x51, 0x40, 0xC7, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x40, 0x07, 0xC0, 0x02,
  0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x43, 0xFE, 0x10, 0x10, 0x80, 0x88,
  0x02, 0x40, 0x12, 0x00, 0x90, 0x03, 0x00, 0x18, 0x00, 0x80, 0xFF, 0x20,
  0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x81, 0x3F, 0x88, 0x12,
  0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x06, 0xFE,
  0x00, 0x07, 0x81, 0x04, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xC0, 0xFF, 0x10, 0x12, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x8F,
  0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x01, 0xC0, 0x60, 0xC4, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x01, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00,
  0x50, 0x02, 0x40, 0x11, 0x00, 0x87, 0xFC, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x4F, 0x80, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x0B, 0xC0, 0x80, 0xE0,
  0x48, 0x12, 0x08, 0x84, 0x23, 0x08, 0x82, 0x40, 0xA0, 0x2C, 0x0D, 0x02,
  0x20, 0x88, 0x21, 0x08, 0x42, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x02, 0x80,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x05, 0xC0, 0x05, 0xC0, 0x05, 0xA0, 0x09, 0xA0, 0x09,
  0xA0, 0x09, 0x90, 0x11, 0x90, 0x11, 0x90, 0x11, 0x88, 0x21, 0x88, 0x21,
  0x84, 0x21, 0x84, 0x41, 0x84, 0x41, 0x82, 0x41, 0x82, 0x81, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1A, 0x03, 0x40,
  0x64, 0x0C, 0x41, 0x88, 0x30, 0x86, 0x10, 0xC1, 0x18, 0x23, 0x02, 0x60,
  0x4C, 0x05, 0x80, 0xB0, 0x0E, 0x01, 0xC0, 0x18, 0x02, 0x07, 0x00, 0x61,
  0x82, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x09, 0x00, 0x24, 0x00, 0x88, 0x04, 0x30, 0x20, 0x3F, 0x00,
  0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0,
  0x9F, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00,
  0x07, 0x00, 0x61, 0x82, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x09, 0x00, 0x24, 0x00, 0x88, 0x04, 0x30,
  0x20, 0x3F, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x4F, 0xE2, 0x20, 0x84, 0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x48, 0x0A,
  0x02, 0x80, 0x40, 0x0F, 0x86, 0x09, 0x00, 0x20, 0x04, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x09, 0xFE, 0x00, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x22, 0x02, 0x1F, 0xC0, 0x80,
  0x0C, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04,
  0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x08, 0x04, 0x40, 0x22, 0x01,
  0x20, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x20,
  0x0A, 0x01, 0x00, 0x50, 0x0C, 0x04, 0x80, 0xA0, 0x24, 0x05, 0x01, 0x10,
  0x28, 0x08, 0x81, 0x20, 0x84, 0x11, 0x04, 0x20, 0x88, 0x20, 0x84, 0x41,
  0x04, 0x21, 0x08, 0x21, 0x08, 0x81, 0x10, 0x44, 0x04, 0x82, 0x20, 0x24,
  0x11, 0x01, 0x20, 0x50, 0x0A, 0x02, 0x80, 0x50, 0x14, 0x01, 0x80, 0xA0,
  0x0C, 0x02, 0x00, 0x40, 0x10, 0x00, 0x40, 0x24, 0x08, 0x81, 0x08, 0x41,
  0x08, 0x21, 0x02, 0x40, 0x48, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x90,
  0x12, 0x04, 0x20, 0x84, 0x20, 0x84, 0x09, 0x01, 0x20, 0x18, 0x02, 0x80,
  0x28, 0x09, 0x01, 0x20, 0x22, 0x08, 0x41, 0x04, 0x20, 0x88, 0x11, 0x01,
  0x40, 0x28, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0xFF, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x07, 0xF0, 0x06, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x10,
  0x82, 0x08, 0x20, 0x44, 0x04, 0x40, 0x28, 0x02, 0x80, 0x10, 0xFF, 0xF0,
  0x82, 0x08, 0x20, 0x80, 0x3E, 0x20, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x1F, 0x30, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x06, 0x7D, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xF8, 0xA0, 0x98, 0x0B,
  0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x60, 0x2C, 0x05, 0x41, 0x27, 0xC0, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3F, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0xF9, 0x20, 0xA4, 0x0D,
  0x00, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x06, 0x41, 0x47, 0xC8, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x02, 0x7F,
  0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F,
  0x24, 0x15, 0x01, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xA0, 0x14, 0x06, 0x80, 0xC8, 0x28, 0xF9, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x81, 0x8F, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x7C, 0xA0, 0xB0, 0x2C, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04,
  0xB0, 0x0A, 0xAA, 0xAA, 0xAA, 0xA0, 0x23, 0x00, 0x00, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xC0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x02, 0x82, 0x41, 0x21, 0x11, 0x08, 0x84,
  0x82, 0xA1, 0x50, 0xC4, 0x42, 0x20, 0x90, 0x48, 0x14, 0x0A, 0x02, 0xFF,
  0xFF, 0xFE, 0x9E, 0x3E, 0xA1, 0x43, 0xC1, 0x41, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x9F, 0x28,
  0x2C, 0x0B, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x14,
  0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x88, 0x10, 0xFC, 0x9F, 0x14, 0x13, 0x01, 0x60, 0x28, 0x05, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x2C, 0x05, 0x80, 0xA8,
  0x24, 0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x1F, 0x24, 0x14, 0x81, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xC8, 0x28, 0xF9, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x9F, 0x43, 0x06, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x3F, 0x20,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x40, 0x10,
  0x08, 0x0A, 0x05, 0xFC, 0x41, 0x04, 0x10, 0xFD, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x0F, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x06,
  0x7D, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x88, 0x22, 0x10, 0x84, 0x21,
  0x04, 0x81, 0x20, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x30, 0x80, 0x80, 0xA0,
  0x40, 0x90, 0x50, 0x48, 0x28, 0x24, 0x14, 0x11, 0x0A, 0x10, 0x84, 0x88,
  0x44, 0x44, 0x22, 0x22, 0x09, 0x11, 0x04, 0x85, 0x02, 0x82, 0x81, 0x41,
  0x40, 0xA0, 0xA0, 0x20, 0x20, 0x10, 0x10, 0x80, 0xA0, 0x90, 0x44, 0x42,
  0x20, 0xA0, 0x50, 0x10, 0x08, 0x0A, 0x09, 0x04, 0x44, 0x22, 0x0A, 0x03,
  0x01, 0x80, 0x50, 0x14, 0x05, 0x02, 0x20, 0x88, 0x22, 0x08, 0x84, 0x11,
  0x04, 0x41, 0x20, 0x28, 0x0A, 0x02, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x0E, 0x00, 0xFF, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0xFF, 0x07, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xC0, 0x30,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x0C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0xE0, 0x78, 0x30, 0xC4, 0x03, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 7, 9, 2, -21 },
  { 12, 13, 21, 15, 1, -21 },
  { 47, 11, 25, 13, 1, -23 },
  { 82, 17, 22, 19, 1, -22 },
  { 129, 13, 22, 14, 1, -22 },
  { 165, 1, 7, 5, 2, -21 },
  { 166, 6, 26, 8, 1, -21 },
  { 186, 5, 26, 8, 1, -21 },
  { 203, 10, 9, 12, 1, -23 },
  { 215, 11, 13, 14, 1, -17 },
  { 233, 3, 7, 5, 1, -3 },
  { 236, 7, 1, 8, 1, -9 },
  { 237, 2, 2, 6, 2, -2 },
  { 238, 8, 21, 10, 1, -21 },
  { 259, 10, 22, 13, 2, -22 },
  { 287, 5, 21, 13, 3, -21 },
  { 301, 11, 22, 13, 1, -22 },
  { 332, 11, 22, 13, 1, -22 },
  { 363, 12, 22, 13, 1, -22 },
  { 396, 10, 21, 13, 2, -21 },
  { 423, 10, 22, 13, 2, -22 },
  { 451, 11, 21, 13, 1, -21 },
  { 480, 11, 22, 13, 1, -22 },
  { 511, 11, 22, 13, 1, -22 },
  { 542, 2, 16, 6, 2, -16 },
  { 546, 3, 20, 6, 1, -16 },
  { 554, 11, 13, 14, 1, -17 },
  { 572, 11, 7, 14, 1, -14 },
  { 582, 11, 13, 14, 1, -17 },
  { 600, 7, 22, 9, 1, -22 },
  { 620, 17, 24, 21, 2, -21 },
  { 671, 13, 21, 13, 0, -21 },
  { 706, 10, 21, 15, 3, -21 },
  { 733, 11, 22, 14, 2, -22 },
  { 764, 11, 21, 16, 3, -21 },
  { 793, 8, 21, 13, 3, -21 },
  { 814, 8, 21, 12, 3, -21 },
  { 835, 13, 22, 17, 2, -22 },
  { 871, 11, 21, 17, 3, -21 },
  { 900, 5, 21, 7, 1, -21 },
  { 914, 6, 26, 6, -2, -21 },
  { 934, 10, 21, 13, 3, -21 },
  { 961, 8, 21, 12, 3, -21 },
  { 982, 16, 21, 21, 3, -21 },
  { 1024, 11, 21, 17, 3, -21 },
  { 1053, 14, 22, 18, 2, -22 },
  { 1092, 9, 21, 13, 3, -21 },
  { 1116, 14, 27, 18, 2, -22 },
  { 1164, 10, 21, 14, 3, -21 },
  { 1191, 11, 22, 13, 1, -22 },
  { 1222, 11, 21, 12, 0, -21 },
  { 1251, 12, 21, 17, 2, -21 },
  { 1283, 13, 21, 13, 0, -21 },
  { 1318, 21, 21, 21, 0, -21 },
  { 1374, 11, 21, 12, 0, -21 },
  { 1403, 11, 21, 11, 0, -21 },
  { 1432, 10, 21, 12, 1, -21 },
  { 1459, 5, 26, 9, 3, -21 },
  { 1476, 8, 21, 10, 1, -21 },
  { 1497, 6, 26, 9, 1, -21 },
  { 1517, 12, 11, 13, 1, -21 },
  { 1534, 12, 1, 12, 0, 3 },
  { 1536, 5, 5, 7, 1, -23 },
  { 1540, 9, 16, 12, 1, -16 },
  { 1558, 11, 23, 14, 2, -23 },
  { 1590, 8, 16, 11, 2, -16 },
  { 1606, 11, 23, 14, 1, -23 },
  { 1638, 9, 16, 13, 2, -16 },
  { 1656, 8, 23, 7, 0, -23 },
  { 1679, 11, 23, 14, 1, -16 },
  { 1711, 10, 23, 14, 2, -23 },
  { 1740, 2, 22, 6, 2, -22 },
  { 1746, 4, 29, 6, 0, -22 },
  { 1761, 9, 23, 11, 2, -23 },
  { 1787, 1, 23, 5, 2, -23 },
  { 1790, 16, 16, 20, 2, -16 },
  { 1822, 10, 16, 14, 2, -16 },
  { 1842, 11, 16, 14, 1, -16 },
  { 1864, 11, 23, 14, 2, -16 },
  { 1896, 11, 23, 14, 1, -16 },
  { 1928, 7, 16, 9, 2, -16 },
  { 1942, 9, 16, 11, 1, -16 },
  { 1960, 6, 20, 7, 1, -20 },
  { 1975, 9, 16, 14, 2, -16 },
  { 1993, 10, 16, 10, 0, -16 },
  { 2013, 17, 16, 17, 0, -16 },
  { 2047, 9, 16, 11, 1, -16 },
  { 2065, 10, 23, 11, 0, -16 },
  { 2094, 8, 16, 10, 1, -16 },
  { 2110, 8, 26, 10, 1, -21 },
  { 2136, 1, 30, 13, 6, -23 },
  { 2140, 8, 26, 10, 1, -21 },
  { 2166, 11, 3, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Thin30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_THIN30PT7B_H_
