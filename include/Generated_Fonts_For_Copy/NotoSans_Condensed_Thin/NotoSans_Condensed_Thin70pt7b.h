#ifndef _NOTOSANS_CONDENSED_THIN70PT7B_H_
#define _NOTOSANS_CONDENSED_THIN70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF7, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xC0, 0x38, 0x04, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x30, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x08, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x3E, 0xDF, 0xC0, 0x38, 0x60, 0x70, 0x30, 0x30, 0x08,
  0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x30, 0x00, 0x0F, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x30, 0xF0, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x19, 0x00, 0x30, 0x38, 0xE0, 0x18, 0x38, 0x7F, 0x0C, 0xF8, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x01, 0xC3, 0x80, 0x00, 0xC0,
  0x06, 0x06, 0x00, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x30,
  0x00, 0x40, 0x02, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x01, 0x80, 0x06, 0x00, 0x20,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x30, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x40, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x04,
  0x00, 0x30, 0x60, 0x00, 0x10, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x02, 0x04,
  0x07, 0x01, 0x80, 0x08, 0x30, 0x7F, 0x06, 0x00, 0x60, 0xC3, 0x06, 0x18,
  0x01, 0x86, 0x18, 0x0C, 0x60, 0x06, 0x18, 0x60, 0x10, 0x80, 0x18, 0x43,
  0x00, 0x63, 0x00, 0xC3, 0x0C, 0x01, 0x8C, 0x03, 0x0C, 0x30, 0x02, 0x18,
  0x18, 0x60, 0x80, 0x0C, 0x70, 0xE1, 0x86, 0x00, 0x30, 0xFF, 0x04, 0x18,
  0x00, 0xC0, 0xE0, 0x30, 0x60, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x30, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x60,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x20,
  0x00, 0x70, 0x30, 0x01, 0x80, 0x00, 0xE1, 0x80, 0x06, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x40, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x00, 0x40, 0x06,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x18, 0x00, 0x63, 0x00, 0x30,
  0x01, 0x18, 0x00, 0x60, 0x04, 0x60, 0x01, 0x80, 0x31, 0x80, 0x03, 0x00,
  0xCC, 0x00, 0x06, 0x03, 0x30, 0x00, 0x18, 0x08, 0xC0, 0x00, 0x30, 0x63,
  0x00, 0x00, 0x61, 0x8C, 0x00, 0x01, 0x84, 0x30, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x06, 0x83, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x06, 0xC1, 0x80, 0x00, 0x33, 0x03, 0x00, 0x01,
  0xC6, 0x0E, 0x00, 0x0E, 0x0C, 0x1C, 0x00, 0x70, 0x30, 0x3C, 0x0F, 0x00,
  0x60, 0x3F, 0xF8, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x0C, 0x06, 0xFC,
  0x10, 0xFC, 0x3C, 0x4F, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0x30, 0x00, 0x08, 0x40, 0x00, 0x60, 0x80, 0x03, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x40, 0x0C, 0x07, 0x00, 0x38, 0x08, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x18, 0xC6, 0x31, 0x98, 0xC6,
  0x33, 0x18, 0xC6, 0x63, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x83, 0xC0, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x07, 0x00,
  0xD0, 0x19, 0x07, 0x10, 0xE1, 0x1C, 0x13, 0x81, 0x60, 0x1C, 0x01, 0x40,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0x01, 0xE0, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x40,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xFC,
  0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x60,
  0x01, 0x00, 0x03, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x40, 0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x40, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x01,
  0xE0, 0x20, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x80, 0x00,
  0x70, 0xC0, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x18, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0xC1, 0xFF, 0xC0, 0xC3, 0xC1, 0xE0, 0xC6, 0x00,
  0x30, 0xCC, 0x00, 0x18, 0xD8, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x0E, 0x00, 0x30, 0x07, 0x80, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x10,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x07, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x81, 0xC0, 0x0E,
  0x00, 0x60, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x30, 0x00, 0x1B, 0x18,
  0x00, 0x1B, 0x0C, 0x00, 0x73, 0x07, 0x01, 0xE3, 0x03, 0xFF, 0x83, 0x00,
  0xFE, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0xEF, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x18, 0xF3, 0xCF,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC6, 0x18, 0x61, 0x8E,
  0x30, 0xC3, 0x18, 0x61, 0x84, 0x30, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFE,
  0x0F, 0x03, 0xC3, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0x7F, 0xF0, 0x06, 0x60,
  0x00, 0xE0, 0x30, 0x02, 0x60, 0x01, 0x80, 0x30, 0x03, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x60, 0x07, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0xC0, 0x08, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x00, 0x20,
  0x01, 0xC0, 0x18, 0x00, 0x20, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00,
  0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03,
  0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0xC0, 0x0C, 0x01, 0xB0,
  0x0C, 0xC0, 0x06, 0x01, 0x30, 0x0C, 0x60, 0x07, 0x03, 0x18, 0x18, 0x60,
  0x03, 0xFE, 0x0F, 0xF0, 0x60, 0x00, 0xFC, 0x07, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x30, 0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0x3C, 0x18,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x03, 0x83, 0x00,
  0x0F, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x38, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x63, 0x00, 0x00, 0xE1, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x20, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x01, 0xE0, 0x0C, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE6,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x03, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0xFF,
  0xE7, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x1F, 0xFC, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0xFF, 0xCF, 0xF0, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7,
  0x80, 0x00, 0xCF, 0x80, 0x00, 0xCC, 0xC0, 0x00, 0xD8, 0xE0, 0x00, 0xF8,
  0x60, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00,
  0x06, 0xF6, 0x00, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x00, 0xCF, 0x30,
  0x00, 0x00, 0x03, 0x3C, 0xC0, 0x00, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x00,
  0x63, 0xC6, 0x00, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00, 0x0C, 0x3C, 0x30,
  0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x06,
  0x0F, 0x06, 0x00, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x00, 0x40, 0xF0, 0x60,
  0x00, 0x03, 0x03, 0xC0, 0xC0, 0x00, 0x0C, 0x0F, 0x03, 0x00, 0x00, 0x20,
  0x3C, 0x0C, 0x00, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x06, 0x03, 0xC0, 0x60,
  0x00, 0x10, 0x0F, 0x01, 0x80, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x03, 0x00,
  0xF0, 0x0C, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x00, 0x60, 0x0F, 0x00, 0x60,
  0x01, 0x80, 0x3C, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x06, 0x00, 0x3C, 0x00, 0xC0,
  0x18, 0x00, 0xF0, 0x01, 0x80, 0x60, 0x03, 0xC0, 0x06, 0x03, 0x00, 0x0F,
  0x00, 0x18, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x30, 0x00, 0xF0, 0x00, 0xC1,
  0x80, 0x03, 0xC0, 0x03, 0x06, 0x00, 0x0F, 0x00, 0x06, 0x18, 0x00, 0x3C,
  0x00, 0x18, 0xC0, 0x00, 0xF0, 0x00, 0x63, 0x00, 0x03, 0xC0, 0x00, 0xCC,
  0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07,
  0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0,
  0x0C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0x30, 0x0E, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x0F, 0x06, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x61, 0x80, 0x03, 0x83, 0x00, 0x3E, 0x07, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x03, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01,
  0xC0, 0xC0, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xC0,
  0x3E, 0x0F, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xFC, 0x03, 0xE0, 0x3F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07,
  0xC0, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00,
  0xC0, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00,
  0x00, 0x41, 0x80, 0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x68, 0x00, 0x00, 0x16, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x10, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x30, 0x00,
  0x3F, 0xF8, 0x07, 0xC0, 0xF0, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF6, 0x0F,
  0x80, 0x30, 0xE0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03,
  0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x5B,
  0x00, 0x06, 0xD8, 0x00, 0x66, 0x60, 0x07, 0x31, 0xC0, 0x71, 0x87, 0xFE,
  0x0C, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0xC0, 0xFF, 0xC0, 0x61, 0xE0, 0x70,
  0x31, 0xC0, 0x0C, 0x19, 0x80, 0x03, 0x0D, 0x80, 0x00, 0xC6, 0xC0, 0x00,
  0x63, 0x40, 0x00, 0x19, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x02, 0x70, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x67, 0x80, 0x00, 0x33, 0xC0, 0x00, 0x19, 0xA0, 0x00, 0x18, 0xD8, 0x00,
  0x1C, 0x66, 0x00, 0x1C, 0x31, 0x80, 0x1C, 0x18, 0x78, 0x3C, 0x0C, 0x1F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x03, 0xE0,
  0x60, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x70, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x38, 0x03, 0x00, 0xFF, 0xC1,
  0x81, 0xE0, 0xF0, 0xC1, 0xC0, 0x0C, 0x61, 0xC0, 0x03, 0x30, 0xC0, 0x00,
  0xD8, 0xC0, 0x00, 0x2C, 0x60, 0x00, 0x1E, 0x60, 0x00, 0x0F, 0x30, 0x00,
  0x03, 0x90, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x1E, 0x30, 0x00,
  0x0B, 0x18, 0x00, 0x0D, 0x86, 0x00, 0x0C, 0xC1, 0x80, 0x0C, 0x60, 0x78,
  0x1C, 0x30, 0x1F, 0xFC, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFC, 0x00, 0x78, 0x3C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60, 0x60, 0x00,
  0xC3, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x24,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x43, 0x80, 0x06, 0x07,
  0xC0, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xF0, 0x0E, 0x08, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0x80, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xE0, 0xC0, 0xF0, 0x78, 0x60, 0xE0, 0x06, 0x30, 0xE0,
  0x01, 0x98, 0x60, 0x00, 0x6C, 0x60, 0x00, 0x16, 0x20, 0x00, 0x0F, 0x30,
  0x00, 0x03, 0x98, 0x00, 0x01, 0xC8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x39, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x1E, 0x60,
  0x00, 0x0B, 0x18, 0x00, 0x0D, 0x8C, 0x00, 0x04, 0xC3, 0x00, 0x06, 0x60,
  0xC0, 0x0E, 0x30, 0x38, 0x1E, 0x18, 0x0F, 0xFC, 0x0C, 0x00, 0xF8, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0xC0, 0xFF,
  0x83, 0x0F, 0x07, 0x0C, 0x70, 0x06, 0x33, 0x00, 0x0C, 0xC8, 0x00, 0x1B,
  0x60, 0x00, 0x6D, 0x00, 0x01, 0xBC, 0x00, 0x02, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x5F, 0xFE, 0x00, 0x00, 0x00, 0x12, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x01, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x3F, 0x1F, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x6C,
  0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x38,
  0x00, 0xC2, 0xC0, 0x0C, 0x6C, 0x00, 0xCC, 0x60, 0x0D, 0x86, 0x00, 0xD8,
  0x30, 0x0F, 0x03, 0x00, 0xE0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0x07, 0xFC, 0x03, 0xFE, 0x0C, 0x78, 0x38, 0x1C, 0x1E, 0x33, 0x80,
  0x70, 0xC0, 0x18, 0xCC, 0x00, 0xC6, 0x00, 0x33, 0x60, 0x01, 0x90, 0x00,
  0xED, 0x00, 0x06, 0xC0, 0x01, 0xBC, 0x00, 0x1A, 0x00, 0x06, 0xE0, 0x00,
  0x38, 0x00, 0x1B, 0x80, 0x00, 0xE0, 0x00, 0x2E, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03,
  0x07, 0xFE, 0x0C, 0x3C, 0x1E, 0x31, 0xC0, 0x1C, 0xCC, 0x00, 0x33, 0x60,
  0x00, 0x6D, 0x80, 0x01, 0xBC, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x7F, 0xE0, 0x30, 0xF0, 0x78, 0x18, 0xE0, 0x06, 0x0C, 0xE0, 0x01, 0x86,
  0x60, 0x00, 0x63, 0x60, 0x00, 0x31, 0xA0, 0x00, 0x0C, 0xF0, 0x00, 0x06,
  0x78, 0x00, 0x01, 0x38, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x19, 0xA0, 0x00, 0x0C,
  0xD8, 0x00, 0x0C, 0x66, 0x00, 0x0E, 0x33, 0x00, 0x0E, 0x18, 0xE0, 0x0E,
  0x0C, 0x3C, 0x1E, 0x06, 0x0F, 0xFC, 0x03, 0x00, 0xF0, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xE0, 0xC0, 0xF0, 0x78, 0x60, 0xE0, 0x06, 0x30, 0xE0, 0x01,
  0x98, 0x60, 0x00, 0x6C, 0x60, 0x00, 0x16, 0x30, 0x00, 0x0F, 0x30, 0x00,
  0x07, 0x98, 0x00, 0x01, 0xC8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x39, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x1E, 0x60, 0x00,
  0x0B, 0x18, 0x00, 0x0D, 0x8E, 0x00, 0x04, 0xC3, 0x00, 0x06, 0x60, 0xE0,
  0x0E, 0x30, 0x3C, 0x1E, 0x18, 0x0F, 0xFC, 0x0C, 0x00, 0xF8, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0xC1, 0xFF,
  0x87, 0x8F, 0x18, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x00, 0x34, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0x7C, 0x0F, 0x9C, 0x00, 0x27, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x01, 0xCF, 0x80, 0xF0,
  0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x20, 0x3F, 0xC0, 0x1E, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF6, 0x00, 0x02, 0xD8,
  0x00, 0x0B, 0x60, 0x00, 0x6C, 0xC0, 0x03, 0x33, 0x80, 0x18, 0xC7, 0x81,
  0xC3, 0x0F, 0xFE, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x30, 0x00, 0x20,
  0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x18, 0x02, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0x40,
  0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x02, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0x80, 0x01, 0x90, 0x00, 0x1E, 0x00,
  0x06, 0x60, 0x00, 0x78, 0x00, 0x19, 0x80, 0x01, 0xA0, 0x00, 0x46, 0x00,
  0x04, 0xC0, 0x03, 0x08, 0x00, 0x33, 0x00, 0x0C, 0x30, 0x00, 0xCC, 0x00,
  0x30, 0xC0, 0x03, 0x10, 0x00, 0x83, 0x00, 0x08, 0x60, 0x06, 0x04, 0x00,
  0x61, 0x80, 0x18, 0x18, 0x01, 0x86, 0x00, 0x60, 0x60, 0x06, 0x08, 0x01,
  0x81, 0x80, 0x10, 0x30, 0x04, 0x02, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x04, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x08,
  0x01, 0x01, 0x80, 0x60, 0x60, 0x06, 0x06, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x00, 0x83, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x31, 0x80,
  0x04, 0x20, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00,
  0x0D, 0x00, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xC1, 0x80, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x70, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x61, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x06, 0x00, 0x60,
  0x0E, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x20, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x10, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x10, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80,
  0x40, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0xC1,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x63, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x22, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x87, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x17, 0x07, 0x80, 0x0F, 0x00,
  0x38, 0x07, 0x80, 0x07, 0xFF, 0x20, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 50, 14, 5, -50 },
  { 26, 11, 18, 21, 5, -50 },
  { 51, 32, 50, 34, 1, -50 },
  { 251, 25, 57, 31, 3, -53 },
  { 430, 38, 52, 45, 3, -51 },
  { 677, 30, 52, 34, 3, -51 },
  { 872, 2, 18, 11, 5, -50 },
  { 877, 13, 61, 18, 3, -50 },
  { 977, 12, 61, 18, 3, -50 },
  { 1069, 22, 21, 28, 3, -53 },
  { 1127, 26, 32, 32, 3, -41 },
  { 1231, 5, 16, 12, 3, -7 },
  { 1241, 16, 2, 20, 2, -20 },
  { 1245, 4, 4, 13, 5, -4 },
  { 1247, 21, 50, 23, 1, -50 },
  { 1379, 24, 51, 31, 4, -51 },
  { 1532, 12, 50, 31, 6, -50 },
  { 1607, 24, 51, 31, 3, -51 },
  { 1760, 24, 52, 31, 3, -51 },
  { 1916, 30, 50, 31, 1, -50 },
  { 2104, 24, 51, 31, 4, -50 },
  { 2257, 24, 52, 31, 4, -51 },
  { 2413, 24, 50, 31, 3, -50 },
  { 2563, 25, 52, 31, 3, -51 },
  { 2726, 24, 52, 31, 3, -51 },
  { 2882, 4, 37, 13, 5, -37 },
  { 2901, 6, 46, 13, 3, -37 },
  { 2936, 26, 30, 32, 3, -40 },
  { 3034, 26, 17, 32, 3, -33 },
  { 3090, 26, 30, 32, 3, -40 },
  { 3188, 18, 51, 22, 2, -51 },
  { 3303, 40, 57, 48, 4, -50 },
  { 3588, 31, 50, 31, 0, -50 },
  { 3782, 25, 50, 34, 6, -50 },
  { 3939, 27, 52, 33, 4, -51 },
  { 4115, 28, 50, 38, 6, -50 },
  { 4290, 21, 50, 30, 6, -50 },
  { 4422, 21, 50, 28, 6, -50 },
  { 4554, 32, 52, 41, 4, -51 },
  { 4762, 27, 50, 39, 6, -50 },
  { 4931, 11, 50, 17, 3, -50 },
  { 5000, 12, 62, 14, -4, -50 },
  { 5093, 24, 50, 30, 6, -50 },
  { 5243, 20, 50, 27, 6, -50 },
  { 5368, 38, 50, 49, 6, -50 },
  { 5606, 27, 50, 39, 6, -50 },
  { 5775, 33, 52, 41, 4, -51 },
  { 5990, 23, 50, 31, 6, -50 },
  { 6134, 33, 63, 41, 4, -51 },
  { 6394, 24, 50, 32, 6, -50 },
  { 6544, 24, 52, 30, 3, -51 },
  { 6700, 27, 50, 27, 0, -50 },
  { 6869, 27, 51, 39, 6, -50 },
  { 7042, 30, 50, 30, 0, -50 },
  { 7230, 48, 50, 50, 1, -50 },
  { 7530, 26, 50, 27, 0, -50 },
  { 7693, 26, 50, 26, 0, -50 },
  { 7856, 24, 50, 28, 2, -50 },
  { 8006, 13, 61, 22, 6, -50 },
  { 8106, 21, 50, 23, 1, -50 },
  { 8238, 14, 61, 22, 2, -50 },
  { 8345, 28, 26, 31, 2, -50 },
  { 8436, 28, 2, 27, 0, 6 },
  { 8443, 10, 11, 16, 3, -53 },
  { 8457, 21, 39, 29, 3, -38 },
  { 8560, 25, 54, 33, 5, -53 },
  { 8729, 20, 39, 25, 4, -38 },
  { 8827, 25, 54, 33, 3, -53 },
  { 8996, 22, 39, 30, 4, -38 },
  { 9104, 18, 54, 16, 1, -54 },
  { 9226, 25, 55, 33, 3, -38 },
  { 9398, 22, 53, 32, 5, -53 },
  { 9544, 3, 51, 13, 5, -51 },
  { 9564, 9, 68, 13, -1, -51 },
  { 9641, 20, 53, 25, 5, -53 },
  { 9774, 2, 53, 13, 5, -53 },
  { 9788, 38, 38, 48, 5, -38 },
  { 9969, 22, 38, 32, 5, -38 },
  { 10074, 25, 39, 32, 3, -38 },
  { 10196, 25, 54, 33, 5, -38 },
  { 10365, 25, 54, 33, 3, -38 },
  { 10534, 15, 37, 21, 5, -37 },
  { 10604, 19, 39, 25, 3, -38 },
  { 10697, 15, 47, 17, 1, -46 },
  { 10786, 22, 38, 32, 5, -37 },
  { 10891, 23, 37, 23, 0, -37 },
  { 10998, 38, 37, 39, 1, -37 },
  { 11174, 23, 37, 25, 1, -37 },
  { 11281, 24, 54, 25, 0, -37 },
  { 11443, 18, 37, 22, 2, -37 },
  { 11527, 18, 61, 24, 3, -50 },
  { 11665, 2, 70, 30, 14, -53 },
  { 11683, 18, 61, 24, 3, -50 },
  { 11821, 26, 6, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_Thin70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_THIN70PT7B_H_
