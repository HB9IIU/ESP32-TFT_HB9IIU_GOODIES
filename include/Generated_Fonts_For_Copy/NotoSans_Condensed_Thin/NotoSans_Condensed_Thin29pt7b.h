#ifndef _NOTOSANS_CONDENSED_THIN29PT7B_H_
#define _NOTOSANS_CONDENSED_THIN29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x03, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x08, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x23, 0xBF, 0xE2,
  0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x7F, 0xF8, 0x42,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x00, 0x04,
  0x03, 0x83, 0x5D, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x44, 0x11, 0x03,
  0x40, 0x30, 0x07, 0x01, 0x20, 0x44, 0x11, 0x04, 0x41, 0x10, 0x44, 0x11,
  0xE7, 0x87, 0x00, 0x40, 0x10, 0x38, 0x08, 0x44, 0x10, 0x44, 0x10, 0x42,
  0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x40, 0x82, 0x4C, 0x42,
  0x92, 0x44, 0xA1, 0x45, 0x21, 0x39, 0x21, 0x01, 0x21, 0x02, 0x21, 0x02,
  0x21, 0x04, 0x21, 0x04, 0x21, 0x04, 0x21, 0x08, 0x22, 0x08, 0x1E, 0x1E,
  0x00, 0x88, 0x08, 0x40, 0x41, 0x02, 0x08, 0x10, 0x80, 0x84, 0x02, 0x20,
  0x12, 0x00, 0x60, 0x05, 0x00, 0x48, 0x04, 0x21, 0x40, 0x8A, 0x04, 0x50,
  0x14, 0x80, 0x64, 0x02, 0x10, 0x18, 0x81, 0x23, 0xF1, 0x80, 0xFF, 0x08,
  0x44, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x82,
  0x10, 0x82, 0x08, 0x40, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x21, 0x08, 0x88, 0x44, 0x00, 0x08, 0x04, 0x02,
  0x1D, 0x31, 0xE0, 0x60, 0x48, 0x44, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x69, 0x25, 0x20, 0xFC, 0xB0, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x0F, 0x08, 0x22, 0x09, 0x01, 0x40, 0x50, 0x14,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x01,
  0x40, 0x50, 0x12, 0x08, 0x82, 0x1F, 0x00, 0x04, 0x33, 0x51, 0x84, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x3E,
  0x10, 0x60, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0xC0, 0x3E, 0x30, 0x60, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0xC1, 0xE0, 0x06, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0xFF, 0x00, 0x00, 0x40, 0x06, 0x00, 0x50, 0x02, 0x80,
  0x24, 0x01, 0x20, 0x11, 0x00, 0x88, 0x08, 0x40, 0x42, 0x04, 0x10, 0x40,
  0x82, 0x04, 0x20, 0x21, 0x01, 0x1F, 0xFF, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x7F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x7F, 0x00, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x30, 0x2F, 0xE0, 0x0F, 0x8C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x9E, 0x28, 0x4C, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x28, 0x09, 0x04, 0x3E, 0x00, 0xFF, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x00, 0x1F, 0x04,
  0x11, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x11, 0x04, 0x11, 0x01, 0x40,
  0x38, 0x18, 0x84, 0x08, 0x80, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01,
  0x20, 0x43, 0xF0, 0x1E, 0x08, 0x44, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x14, 0x04, 0x83, 0x1F, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x7E, 0x00, 0xE0, 0x00, 0x00, 0x2C, 0x68, 0x00,
  0x00, 0x00, 0x02, 0x92, 0x52, 0x00, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x00, 0x79, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x10, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x00, 0x00, 0x01, 0x02, 0x00, 0x03, 0xE0, 0x0C,
  0x18, 0x10, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x81, 0xE1, 0x82,
  0x21, 0x84, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88,
  0x21, 0x88, 0x21, 0x84, 0x61, 0x84, 0x52, 0x83, 0x8C, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x30, 0x07, 0xC0, 0x02, 0x00, 0x30,
  0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x22, 0x01, 0x10, 0x10, 0x80,
  0x82, 0x04, 0x10, 0x20, 0x83, 0xFC, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40,
  0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x00, 0x80, 0xFE, 0x10, 0x32, 0x01,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x23, 0xFC, 0x40,
  0x68, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x4F,
  0xF0, 0x0F, 0xC2, 0x04, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFE, 0xFE, 0x08, 0x18, 0x80, 0x48, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x18,
  0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x3F, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0F, 0xF8, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x1F, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x07, 0xE0, 0xC0, 0xC8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x02, 0x20, 0x10, 0xFF,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F, 0x80, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x0F, 0x80, 0x80, 0x50, 0x12, 0x02, 0x40, 0x88, 0x21, 0x04,
  0x21, 0x04, 0x40, 0x90, 0x12, 0x02, 0xA0, 0x64, 0x08, 0x41, 0x08, 0x20,
  0x84, 0x08, 0x81, 0x10, 0x12, 0x02, 0x40, 0x28, 0x06, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xF8, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xA0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0x90, 0x05, 0x90,
  0x09, 0x90, 0x09, 0x88, 0x09, 0x88, 0x11, 0x88, 0x11, 0x84, 0x11, 0x84,
  0x21, 0x84, 0x21, 0x82, 0x21, 0x82, 0x41, 0x82, 0x41, 0x81, 0x41, 0x81,
  0x81, 0x80, 0x81, 0x80, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19, 0x01,
  0x88, 0x18, 0x81, 0x84, 0x18, 0x41, 0x82, 0x18, 0x21, 0x81, 0x18, 0x11,
  0x80, 0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x03, 0x80, 0x10, 0x0F,
  0x81, 0x83, 0x08, 0x08, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x41, 0xFC, 0x00, 0xFC, 0x20,
  0xC8, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x13,
  0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x00, 0x0F, 0x81, 0x83, 0x08, 0x08, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x41, 0xF8, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0xFC, 0x10, 0x62, 0x02,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x0C, 0x7E,
  0x08, 0x41, 0x04, 0x20, 0x84, 0x08, 0x81, 0x10, 0x12, 0x02, 0x40, 0x28,
  0x06, 0x1F, 0x88, 0x14, 0x01, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0xFF, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02,
  0x40, 0x22, 0x04, 0x1F, 0x80, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40,
  0x24, 0x02, 0x20, 0x22, 0x04, 0x20, 0x42, 0x04, 0x10, 0x41, 0x08, 0x10,
  0x81, 0x08, 0x08, 0x80, 0x90, 0x09, 0x00, 0x50, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x80, 0x20, 0x14, 0x02, 0x01, 0x40, 0x60, 0x14, 0x06, 0x01, 0x40,
  0x50, 0x24, 0x05, 0x02, 0x20, 0x90, 0x22, 0x09, 0x02, 0x20, 0x88, 0x42,
  0x08, 0x84, 0x10, 0x88, 0x41, 0x10, 0x84, 0x11, 0x08, 0x41, 0x10, 0x48,
  0x09, 0x04, 0x80, 0xA0, 0x48, 0x0A, 0x04, 0x80, 0xA0, 0x30, 0x0A, 0x03,
  0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x40, 0x28, 0x08, 0x81, 0x10, 0x41,
  0x08, 0x21, 0x02, 0x40, 0x48, 0x0A, 0x00, 0xC0, 0x10, 0x03, 0x00, 0xA0,
  0x12, 0x04, 0x40, 0x84, 0x20, 0x84, 0x09, 0x01, 0x20, 0x28, 0x02, 0x80,
  0x30, 0x09, 0x01, 0x20, 0x22, 0x08, 0x41, 0x08, 0x40, 0x88, 0x11, 0x01,
  0x40, 0x28, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0xFF, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x83, 0xF0, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x0F, 0xC0, 0x04, 0x00, 0xC0, 0x28, 0x04, 0x81, 0x10,
  0x21, 0x08, 0x21, 0x02, 0x40, 0x50, 0x06, 0x00, 0x80, 0xFF, 0xE0, 0xC2,
  0x08, 0x30, 0x18, 0x31, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x1F, 0x30,
  0xA0, 0x60, 0x30, 0x18, 0x0C, 0x0D, 0x06, 0xFD, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x62, 0xC4, 0xC0, 0xB0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x02, 0xA0, 0xA7, 0xC0,
  0x03, 0x0C, 0x48, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x3F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0xE4, 0x45, 0x20, 0xD0, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x50, 0x14, 0x05, 0x01, 0x20, 0xC7, 0xD0, 0x0E, 0x04,
  0x42, 0x09, 0x02, 0x40, 0x50, 0x18, 0x07, 0xFF, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x7E, 0x0F, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0xFC, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x0C, 0x04, 0x72, 0x0D, 0x01, 0x40, 0x50, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x50, 0x12, 0x0C, 0x7D,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x50, 0x23, 0xF0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x31, 0x66, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0xC3, 0xFF,
  0xF8, 0x24, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x83, 0x82, 0x84, 0x88, 0x88,
  0x90, 0xB0, 0xA8, 0xC8, 0x84, 0x84, 0x82, 0x82, 0x81, 0x81, 0xFF, 0xFF,
  0xFC, 0x18, 0x10, 0xA2, 0x66, 0xC1, 0x82, 0xC1, 0x81, 0x81, 0x01, 0x81,
  0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81,
  0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x0E, 0x58, 0xB0,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x0C, 0x02, 0x30, 0x81, 0x20, 0x24, 0x04, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x20,
  0xF8, 0x0E, 0x2C, 0x4A, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x2A, 0x0A, 0x7C, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0E, 0x04, 0x52, 0x0D, 0x01, 0x40,
  0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x50, 0x12,
  0x0C, 0x7D, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0A,
  0xDC, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x18,
  0x63, 0x40, 0x80, 0x80, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x81, 0xFE, 0x41, 0x04, 0x10, 0xFD, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x03, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1A, 0x0C, 0xFA, 0x80,
  0xD0, 0x24, 0x09, 0x02, 0x41, 0x08, 0x42, 0x10, 0x88, 0x22, 0x04, 0x81,
  0x20, 0x50, 0x0C, 0x03, 0x00, 0x80, 0x80, 0x81, 0x41, 0x81, 0x41, 0x42,
  0x41, 0x42, 0x41, 0x42, 0x22, 0x42, 0x22, 0x22, 0x22, 0x24, 0x22, 0x24,
  0x14, 0x24, 0x14, 0x24, 0x14, 0x18, 0x14, 0x18, 0x08, 0x18, 0x08, 0x08,
  0x81, 0xA0, 0x90, 0x84, 0x42, 0x40, 0xA0, 0x60, 0x10, 0x14, 0x12, 0x08,
  0x88, 0x44, 0x14, 0x0A, 0x02, 0xC0, 0x50, 0x14, 0x09, 0x02, 0x20, 0x88,
  0x42, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x28, 0x0C, 0x03, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x38, 0x00, 0xFE, 0x04, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x3F, 0x80, 0x07,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xE0,
  0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0C,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x30, 0x10, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x30, 0xC0, 0xFC, 0x30, 0x78,
};

const GFXglyph NotoSans_Condensed_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 8, 9, 2, -21 },
  { 12, 13, 21, 14, 1, -21 },
  { 47, 10, 24, 13, 1, -22 },
  { 77, 16, 21, 19, 1, -21 },
  { 119, 13, 21, 14, 1, -21 },
  { 154, 1, 8, 5, 2, -21 },
  { 155, 5, 26, 8, 1, -21 },
  { 172, 5, 26, 8, 1, -21 },
  { 189, 9, 9, 12, 1, -22 },
  { 200, 11, 13, 13, 1, -17 },
  { 218, 3, 7, 5, 1, -3 },
  { 221, 6, 1, 8, 1, -8 },
  { 222, 2, 2, 6, 2, -2 },
  { 223, 8, 21, 9, 1, -21 },
  { 244, 10, 21, 13, 1, -21 },
  { 271, 6, 21, 13, 2, -21 },
  { 287, 10, 21, 13, 1, -21 },
  { 314, 10, 21, 13, 1, -21 },
  { 341, 13, 21, 13, 0, -21 },
  { 376, 9, 21, 13, 2, -21 },
  { 400, 10, 21, 13, 2, -21 },
  { 427, 10, 21, 13, 1, -21 },
  { 454, 11, 21, 13, 1, -21 },
  { 483, 10, 21, 13, 1, -21 },
  { 510, 2, 15, 6, 2, -15 },
  { 514, 3, 19, 6, 1, -15 },
  { 522, 11, 12, 13, 1, -16 },
  { 539, 11, 7, 13, 1, -14 },
  { 549, 11, 12, 13, 1, -16 },
  { 566, 7, 21, 9, 1, -21 },
  { 585, 16, 24, 20, 2, -21 },
  { 633, 13, 21, 13, 0, -21 },
  { 668, 11, 21, 14, 2, -21 },
  { 697, 11, 21, 14, 2, -21 },
  { 726, 12, 21, 16, 2, -21 },
  { 758, 9, 21, 13, 2, -21 },
  { 782, 9, 21, 11, 2, -21 },
  { 806, 13, 21, 17, 2, -21 },
  { 841, 12, 21, 16, 2, -21 },
  { 873, 5, 21, 7, 1, -21 },
  { 887, 5, 26, 6, -2, -21 },
  { 904, 11, 21, 13, 2, -21 },
  { 933, 9, 21, 11, 2, -21 },
  { 957, 16, 21, 21, 2, -21 },
  { 999, 12, 21, 16, 2, -21 },
  { 1031, 13, 21, 17, 2, -21 },
  { 1066, 10, 21, 13, 2, -21 },
  { 1093, 13, 26, 17, 2, -21 },
  { 1136, 11, 21, 13, 2, -21 },
  { 1165, 10, 21, 13, 1, -21 },
  { 1192, 11, 21, 11, 0, -21 },
  { 1221, 12, 21, 16, 2, -21 },
  { 1253, 12, 21, 12, 0, -21 },
  { 1285, 20, 21, 21, 0, -21 },
  { 1338, 11, 21, 11, 0, -21 },
  { 1367, 11, 21, 11, 0, -21 },
  { 1396, 10, 21, 12, 1, -21 },
  { 1423, 6, 26, 9, 2, -21 },
  { 1443, 8, 21, 9, 1, -21 },
  { 1464, 5, 26, 9, 1, -21 },
  { 1481, 11, 11, 13, 1, -21 },
  { 1497, 11, 1, 11, 0, 3 },
  { 1499, 5, 4, 7, 1, -22 },
  { 1502, 9, 16, 12, 1, -16 },
  { 1520, 10, 22, 14, 2, -22 },
  { 1548, 9, 16, 10, 1, -16 },
  { 1566, 10, 22, 14, 1, -22 },
  { 1594, 10, 16, 12, 1, -16 },
  { 1614, 8, 22, 7, 0, -22 },
  { 1636, 10, 23, 14, 1, -16 },
  { 1665, 9, 22, 13, 2, -22 },
  { 1690, 1, 21, 5, 2, -21 },
  { 1693, 3, 28, 5, 0, -21 },
  { 1704, 8, 22, 11, 2, -22 },
  { 1726, 1, 22, 5, 2, -22 },
  { 1729, 16, 16, 20, 2, -16 },
  { 1761, 9, 16, 13, 2, -16 },
  { 1779, 11, 16, 13, 1, -16 },
  { 1801, 10, 23, 14, 2, -16 },
  { 1830, 10, 23, 14, 1, -16 },
  { 1859, 6, 16, 9, 2, -16 },
  { 1871, 8, 16, 10, 1, -16 },
  { 1887, 6, 19, 7, 1, -19 },
  { 1902, 9, 15, 13, 2, -15 },
  { 1919, 10, 15, 10, 0, -15 },
  { 1938, 16, 15, 16, 0, -15 },
  { 1968, 9, 15, 11, 1, -15 },
  { 1985, 10, 22, 10, 0, -15 },
  { 2013, 7, 15, 9, 1, -15 },
  { 2027, 8, 26, 10, 1, -21 },
  { 2053, 1, 29, 12, 6, -22 },
  { 2057, 8, 26, 10, 1, -21 },
  { 2083, 11, 2, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Thin29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_THIN29PT7B_H_
