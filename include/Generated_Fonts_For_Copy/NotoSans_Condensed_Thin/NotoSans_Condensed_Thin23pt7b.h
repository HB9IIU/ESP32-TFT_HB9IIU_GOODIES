#ifndef _NOTOSANS_CONDENSED_THIN23PT7B_H_
#define _NOTOSANS_CONDENSED_THIN23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0xB6, 0xDB, 0x40, 0x08, 0x81, 0x10, 0x22, 0x04, 0x46,
  0xEE, 0x22, 0x04, 0x40, 0x88, 0x11, 0x02, 0x23, 0xFF, 0x08, 0x82, 0x20,
  0x44, 0x08, 0x81, 0x10, 0x10, 0x7E, 0x90, 0x90, 0x90, 0x90, 0x90, 0x70,
  0x18, 0x14, 0x12, 0x11, 0x11, 0x11, 0x11, 0x92, 0x7C, 0x10, 0x30, 0x02,
  0x42, 0x22, 0x21, 0x11, 0x08, 0x88, 0x44, 0x82, 0x24, 0x11, 0x4C, 0x8A,
  0x92, 0x54, 0x4D, 0x42, 0x0A, 0x10, 0x90, 0x84, 0x84, 0x22, 0x22, 0x12,
  0x10, 0xF0, 0x18, 0x09, 0x04, 0x21, 0x08, 0x42, 0x11, 0x02, 0x40, 0x60,
  0x30, 0x12, 0x08, 0x46, 0x12, 0x82, 0xA0, 0x48, 0x12, 0x0A, 0x7C, 0x40,
  0xFC, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x21, 0x84,
  0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x10, 0x23, 0xF8,
  0x82, 0x88, 0x80, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x5A, 0x80, 0xF8, 0x80, 0x02, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x1C, 0x22, 0x42,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x42, 0x3C, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x38, 0xC6,
  0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x40, 0xFF, 0x38, 0xC6, 0x02, 0x01, 0x01, 0x01, 0x02, 0x04, 0x3C,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x01, 0x00, 0xC0, 0x30,
  0x14, 0x05, 0x02, 0x41, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x04, 0xFF,
  0xC0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x80,
  0xFC, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x0E, 0x10,
  0x20, 0x40, 0x40, 0x80, 0x80, 0xBE, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x41, 0x3E, 0xFF, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x1C, 0x62, 0x41, 0x81, 0x81,
  0x41, 0x42, 0x24, 0x18, 0x26, 0x41, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E,
  0x38, 0x46, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01,
  0x01, 0x02, 0x02, 0x04, 0x78, 0x80, 0x10, 0x40, 0x00, 0x05, 0xA8, 0x01,
  0x06, 0x18, 0x60, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x80, 0x60, 0x18, 0x06, 0x01, 0x02, 0x0C, 0x30,
  0x40, 0x80, 0x74, 0x42, 0x10, 0x84, 0x22, 0x11, 0x10, 0x84, 0x00, 0x00,
  0x40, 0x0F, 0xE0, 0x40, 0x42, 0x01, 0x10, 0x02, 0x43, 0x8A, 0x11, 0x18,
  0x84, 0x62, 0x11, 0x88, 0x86, 0x22, 0x18, 0x88, 0x62, 0x22, 0x85, 0x49,
  0x08, 0xC4, 0x00, 0x08, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0x48, 0x12, 0x04, 0x82, 0x10, 0x84, 0x21, 0x0F, 0xC4, 0x09, 0x02,
  0x40, 0x90, 0x18, 0x06, 0x01, 0xFE, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x0F, 0x08, 0x48,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x1F, 0x80, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x14, 0x0A, 0x09, 0xF8, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x7F, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFD, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x07, 0x83, 0x0C, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x7E, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x50, 0x09,
  0x01, 0x1F, 0xE0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xE9, 0x24, 0x92,
  0x49, 0x24, 0x97, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1E, 0x83, 0x84, 0x84, 0x88, 0x90, 0x90, 0xA0, 0xE0, 0x90, 0x90, 0x88,
  0x84, 0x84, 0x82, 0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xA0, 0x3A, 0x05, 0xA0, 0x59, 0x05, 0x90, 0x99, 0x09, 0x88, 0x98,
  0x91, 0x89, 0x18, 0x51, 0x86, 0x18, 0x21, 0x80, 0xE0, 0x70, 0x34, 0x1A,
  0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x2C, 0x0E, 0x03,
  0x01, 0x0F, 0x02, 0x10, 0x81, 0x20, 0x24, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x50, 0x11, 0x02, 0x1F,
  0x80, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xF9, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x0F, 0x02, 0x10, 0x81, 0x20, 0x24, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x50, 0x11,
  0x02, 0x1D, 0x80, 0x40, 0x04, 0x00, 0x40, 0x08, 0xFC, 0x82, 0x82, 0x81,
  0x81, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81,
  0x1E, 0x61, 0x80, 0x80, 0x80, 0x80, 0x40, 0x60, 0x18, 0x04, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x05, 0x04, 0x7C, 0x80, 0x60, 0x24, 0x09, 0x02, 0x40, 0x90,
  0x42, 0x10, 0x84, 0x22, 0x04, 0x81, 0x20, 0x48, 0x14, 0x03, 0x00, 0xC0,
  0x20, 0x80, 0x81, 0x41, 0x81, 0x41, 0x81, 0x41, 0x42, 0x41, 0x42, 0x42,
  0x42, 0x22, 0x42, 0x22, 0x44, 0x22, 0x24, 0x24, 0x24, 0x14, 0x24, 0x14,
  0x28, 0x14, 0x18, 0x14, 0x18, 0x08, 0x18, 0x08, 0x10, 0x41, 0xA0, 0x88,
  0x84, 0x41, 0x40, 0xA0, 0x20, 0x10, 0x08, 0x0A, 0x05, 0x04, 0x42, 0x22,
  0x09, 0x05, 0x01, 0x81, 0xA0, 0x90, 0x48, 0x42, 0x21, 0x20, 0x50, 0x28,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFE, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80,
  0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0,
  0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80,
  0x81, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08,
  0x0A, 0x09, 0x04, 0x44, 0x22, 0x0A, 0x05, 0x01, 0xFF, 0x80, 0x91, 0x10,
  0x7C, 0x04, 0x08, 0x10, 0x27, 0xD0, 0xC1, 0x83, 0x06, 0x1B, 0xD0, 0x80,
  0x80, 0x80, 0x80, 0x98, 0xE4, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x82, 0xFC, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x81, 0x01, 0xF0, 0x01, 0x01, 0x01, 0x01, 0x09, 0x37, 0x43, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x42, 0x81, 0x81,
  0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3E, 0x1C, 0x82, 0x08, 0x20,
  0x8F, 0x88, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3F, 0x43,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01,
  0x01, 0x01, 0xC6, 0x38, 0x81, 0x02, 0x04, 0x09, 0x1D, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xC7, 0xFF, 0x80, 0x24, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0xA0, 0x82, 0x08, 0x20, 0x82, 0x18,
  0xA4, 0x92, 0x8E, 0x24, 0x92, 0x28, 0xA1, 0x84, 0xFF, 0xFF, 0x80, 0xF9,
  0xE8, 0x61, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84,
  0x18, 0x41, 0x84, 0x18, 0x41, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x3E, 0xFC, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x7E, 0x08,
  0x20, 0x40, 0xC0, 0x81, 0x04, 0x10, 0x7E, 0x21, 0x09, 0xF2, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xE0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x1B, 0xD0, 0x81, 0x82, 0x42, 0x42, 0x44, 0x44, 0x24, 0x24,
  0x28, 0x18, 0x18, 0x10, 0x82, 0x0C, 0x10, 0x51, 0x44, 0x8A, 0x24, 0x51,
  0x22, 0x88, 0xA2, 0x85, 0x14, 0x28, 0xA1, 0x45, 0x04, 0x10, 0x20, 0x80,
  0x41, 0x42, 0x24, 0x24, 0x18, 0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0xC1,
  0x81, 0x41, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x14, 0x18, 0x18, 0x08,
  0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0xFC, 0x20, 0x84, 0x10, 0x82, 0x10,
  0x42, 0x08, 0x3F, 0x1C, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0x02, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x81, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x31, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x30,
  0xF1, 0x8F,
};

const GFXglyph NotoSans_Condensed_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 3, 6, 7, 2, -16 },
  { 6, 11, 16, 11, 0, -16 },
  { 28, 8, 18, 10, 1, -17 },
  { 46, 13, 17, 15, 1, -17 },
  { 74, 10, 17, 11, 1, -17 },
  { 96, 1, 6, 4, 1, -16 },
  { 97, 4, 20, 6, 1, -16 },
  { 107, 4, 20, 6, 1, -16 },
  { 117, 7, 6, 9, 1, -17 },
  { 123, 9, 10, 10, 1, -13 },
  { 135, 2, 5, 4, 1, -2 },
  { 137, 5, 1, 6, 1, -7 },
  { 138, 1, 1, 4, 2, -1 },
  { 139, 7, 16, 8, 0, -16 },
  { 153, 8, 17, 10, 1, -17 },
  { 170, 4, 16, 10, 2, -16 },
  { 178, 8, 17, 10, 1, -17 },
  { 195, 8, 17, 10, 1, -17 },
  { 212, 10, 17, 10, 0, -17 },
  { 234, 8, 16, 10, 1, -16 },
  { 250, 8, 17, 10, 1, -17 },
  { 267, 8, 16, 10, 1, -16 },
  { 283, 8, 17, 10, 1, -17 },
  { 300, 8, 17, 10, 1, -17 },
  { 317, 1, 12, 4, 2, -12 },
  { 319, 2, 15, 4, 1, -12 },
  { 323, 8, 10, 10, 1, -13 },
  { 333, 9, 6, 10, 1, -11 },
  { 340, 8, 10, 10, 1, -13 },
  { 350, 5, 17, 7, 1, -17 },
  { 361, 14, 18, 16, 1, -16 },
  { 393, 10, 16, 10, 0, -16 },
  { 413, 8, 16, 11, 2, -16 },
  { 429, 9, 17, 11, 1, -17 },
  { 449, 9, 16, 12, 2, -16 },
  { 467, 7, 16, 10, 2, -16 },
  { 481, 7, 16, 9, 2, -16 },
  { 495, 11, 17, 13, 1, -17 },
  { 519, 9, 16, 13, 2, -16 },
  { 537, 3, 16, 5, 1, -16 },
  { 543, 4, 20, 5, -1, -16 },
  { 553, 8, 16, 10, 2, -16 },
  { 569, 7, 16, 9, 2, -16 },
  { 583, 12, 16, 16, 2, -16 },
  { 607, 9, 16, 13, 2, -16 },
  { 625, 11, 17, 13, 1, -17 },
  { 649, 7, 16, 10, 2, -16 },
  { 663, 11, 21, 13, 1, -17 },
  { 692, 8, 16, 10, 2, -16 },
  { 708, 8, 17, 10, 1, -17 },
  { 725, 9, 16, 9, 0, -16 },
  { 743, 9, 16, 13, 2, -16 },
  { 761, 10, 16, 10, 0, -16 },
  { 781, 16, 16, 16, 0, -16 },
  { 813, 9, 16, 9, 0, -16 },
  { 831, 9, 16, 9, 0, -16 },
  { 849, 8, 16, 9, 1, -16 },
  { 865, 4, 20, 7, 2, -16 },
  { 875, 7, 16, 8, 0, -16 },
  { 889, 4, 20, 7, 1, -16 },
  { 899, 9, 8, 10, 1, -16 },
  { 908, 9, 1, 9, 0, 2 },
  { 910, 3, 4, 5, 1, -18 },
  { 912, 7, 12, 9, 1, -12 },
  { 923, 8, 17, 11, 2, -17 },
  { 940, 7, 12, 8, 1, -12 },
  { 951, 8, 17, 11, 1, -17 },
  { 968, 8, 12, 10, 1, -12 },
  { 980, 6, 18, 5, 0, -18 },
  { 994, 8, 18, 11, 1, -12 },
  { 1012, 7, 17, 11, 2, -17 },
  { 1027, 1, 17, 4, 2, -17 },
  { 1030, 3, 23, 4, 0, -17 },
  { 1039, 6, 17, 8, 2, -17 },
  { 1052, 1, 17, 4, 2, -17 },
  { 1055, 12, 12, 16, 2, -12 },
  { 1073, 7, 12, 11, 2, -12 },
  { 1084, 8, 12, 10, 1, -12 },
  { 1096, 8, 17, 11, 2, -12 },
  { 1113, 8, 17, 11, 1, -12 },
  { 1130, 5, 12, 7, 2, -12 },
  { 1138, 6, 12, 8, 1, -12 },
  { 1147, 5, 15, 6, 0, -15 },
  { 1157, 7, 12, 11, 2, -12 },
  { 1168, 8, 12, 8, 0, -12 },
  { 1180, 13, 12, 13, 0, -12 },
  { 1200, 8, 12, 8, 0, -12 },
  { 1212, 8, 18, 8, 0, -12 },
  { 1230, 6, 12, 7, 1, -12 },
  { 1239, 6, 20, 8, 1, -16 },
  { 1254, 1, 24, 10, 4, -18 },
  { 1257, 6, 20, 8, 1, -16 },
  { 1272, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Thin23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_THIN23PT7B_H_
