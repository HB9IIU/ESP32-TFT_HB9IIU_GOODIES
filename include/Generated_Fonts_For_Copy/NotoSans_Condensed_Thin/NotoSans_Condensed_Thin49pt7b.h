#ifndef _NOTOSANS_CONDENSED_THIN49PT7B_H_
#define _NOTOSANS_CONDENSED_THIN49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x41, 0x00,
  0xC0, 0x40, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80,
  0xC0, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x60, 0x20, 0x01, 0x00, 0x80,
  0x04, 0x02, 0x00, 0x10, 0x08, 0x1F, 0xFF, 0xFF, 0x01, 0x01, 0x80, 0x04,
  0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x00, 0x08, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0xC0, 0x02, 0x02, 0x00, 0x18, 0x08, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x04, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40,
  0x60, 0x01, 0x01, 0x80, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40,
  0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x70, 0x01, 0xFF, 0xC1, 0x88, 0x71, 0x04,
  0x01, 0x82, 0x00, 0x81, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x0C, 0x08, 0x06, 0x04, 0x01, 0x02, 0x00, 0x41, 0x00, 0x38, 0x80,
  0x06, 0x40, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0B, 0x00, 0x04, 0x60, 0x02,
  0x18, 0x01, 0x06, 0x00, 0x81, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x03, 0x00, 0x83, 0x40, 0x43,
  0x3E, 0x27, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x1F, 0x00, 0x08, 0x06, 0x10, 0x03, 0x00, 0x81, 0x00, 0x40, 0x30,
  0x20, 0x08, 0x04, 0x06, 0x02, 0x00, 0x80, 0xC0, 0x40, 0x10, 0x08, 0x18,
  0x02, 0x01, 0x02, 0x00, 0xC0, 0x20, 0x40, 0x18, 0x04, 0x10, 0x03, 0x00,
  0x82, 0x00, 0x60, 0x10, 0xC0, 0x0C, 0x02, 0x10, 0x00, 0x80, 0x42, 0x08,
  0x10, 0x08, 0x87, 0xC2, 0x03, 0x11, 0x04, 0x40, 0x46, 0x60, 0xCC, 0x08,
  0x88, 0x08, 0x83, 0x11, 0x01, 0x18, 0x44, 0x20, 0x21, 0xF0, 0x8C, 0x06,
  0x00, 0x31, 0x80, 0xC0, 0x04, 0x30, 0x08, 0x00, 0x84, 0x01, 0x00, 0x30,
  0x80, 0x20, 0x04, 0x10, 0x04, 0x01, 0x83, 0x00, 0x80, 0x20, 0x60, 0x30,
  0x04, 0x0C, 0x06, 0x01, 0x80, 0x80, 0x80, 0x20, 0x10, 0x10, 0x0C, 0x02,
  0x02, 0x01, 0x00, 0x60, 0xC0, 0x20, 0x06, 0x10, 0x0C, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x00, 0x60, 0xC0, 0x02, 0x02, 0x00, 0x30, 0x18, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0xC0, 0x60, 0x02, 0x02, 0x00, 0x10, 0x30, 0x00, 0x41, 0x00, 0x02, 0x18,
  0x00, 0x09, 0x80, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x64, 0x00, 0x06,
  0x30, 0x00, 0x60, 0x80, 0x02, 0x02, 0x01, 0x20, 0x18, 0x09, 0x00, 0x60,
  0xD8, 0x01, 0x04, 0x80, 0x0C, 0x24, 0x00, 0x31, 0x20, 0x00, 0x91, 0x00,
  0x02, 0x88, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x00, 0x05, 0x0C, 0x00, 0x4C,
  0x20, 0x06, 0x20, 0xC0, 0xE0, 0x83, 0xFC, 0x06, 0xFF, 0xFF, 0xD5, 0x40,
  0x01, 0x01, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06,
  0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x1C, 0x21, 0xC7, 0x4E, 0x01, 0xE0, 0x01,
  0x80, 0x04, 0x80, 0x11, 0x80, 0x61, 0x00, 0x81, 0x02, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x33, 0x32, 0x26, 0x64, 0x4C, 0x80, 0xFF, 0xE0, 0x7D,
  0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xF8, 0x06, 0x06, 0x02, 0x01, 0x82, 0x00, 0x43,
  0x00, 0x31, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x60, 0x01, 0xA0, 0x00,
  0xD0, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD8, 0x00,
  0x64, 0x00, 0x22, 0x00, 0x11, 0x80, 0x08, 0x40, 0x08, 0x30, 0x04, 0x08,
  0x04, 0x03, 0x06, 0x00, 0xFC, 0x00, 0x01, 0x81, 0xC1, 0xA1, 0x93, 0x0B,
  0x07, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xF0,
  0x18, 0x0E, 0x18, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x18, 0x06, 0x30, 0x01, 0x90, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x80, 0x06, 0x70,
  0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xA0, 0x00, 0x1A, 0x00, 0x01, 0x20, 0x00, 0x32, 0x00, 0x02, 0x20,
  0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x02,
  0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x02, 0x01, 0x00, 0x20, 0x30, 0x02, 0x02, 0x00, 0x20, 0x60,
  0x02, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xCF, 0xC0, 0xFC, 0xF8, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x80, 0x0C, 0xC0, 0x38, 0x7F, 0xE0, 0x01, 0xFE, 0x03, 0x81, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x1F, 0xC1, 0x30, 0x18, 0xB0, 0x06, 0x50, 0x01, 0x30, 0x00, 0xD8, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x58, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x80, 0x08,
  0x40, 0x04, 0x30, 0x04, 0x0C, 0x06, 0x03, 0xFC, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xF8, 0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x0C, 0x20,
  0x01, 0x18, 0x00, 0x64, 0x00, 0x19, 0x00, 0x06, 0x40, 0x01, 0x98, 0x00,
  0x62, 0x00, 0x10, 0xC0, 0x0C, 0x10, 0x02, 0x03, 0x03, 0x00, 0x61, 0x80,
  0x0D, 0xC0, 0x01, 0xC0, 0x00, 0xCC, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x30,
  0x03, 0x18, 0x00, 0x44, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x90, 0x00, 0x24, 0x00, 0x19,
  0x80, 0x04, 0x30, 0x03, 0x06, 0x03, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x0C,
  0x0C, 0x0C, 0x01, 0x04, 0x00, 0x46, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05,
  0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0xB0, 0x01, 0x4C,
  0x01, 0xA3, 0x01, 0x90, 0xFF, 0x08, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x0F, 0xF0, 0x01,
  0x80, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEC,
  0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33,
  0x22, 0x66, 0x44, 0xC8, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xC6, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x06, 0x60, 0x0F, 0xE0, 0x24, 0x01, 0x86, 0x02, 0x40, 0x30,
  0x20, 0x3C, 0x06, 0x02, 0x03, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0x80, 0x20, 0x18, 0x08, 0x02, 0x01, 0x80, 0x80, 0x20, 0x18, 0x08,
  0x02, 0x01, 0x80, 0x80, 0x20, 0x18, 0x08, 0x06, 0x01, 0x80, 0x80, 0x60,
  0x38, 0x08, 0x06, 0x03, 0x80, 0x80, 0x60, 0x28, 0x0C, 0x0E, 0x02, 0x80,
  0xC0, 0xA0, 0x6C, 0x06, 0x19, 0x0C, 0xC0, 0x3F, 0x1F, 0x84, 0x00, 0x80,
  0x20, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x04,
  0x80, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00,
  0x0C, 0x20, 0x00, 0x41, 0x80, 0x02, 0x04, 0x00, 0x30, 0x20, 0x01, 0x01,
  0x00, 0x08, 0x0C, 0x00, 0x40, 0x20, 0x06, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x18, 0x01, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x60, 0x20, 0x01,
  0x03, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x03, 0x0C, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x02, 0xFF, 0xF0, 0x20, 0x0F,
  0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x1A,
  0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x70, 0xFF, 0xE0, 0x20, 0x0F,
  0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x0C, 0x80, 0x06, 0x20, 0x0F,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x0C, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x0C,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x08, 0x07, 0x80, 0x80, 0x0E, 0x08, 0x00,
  0x30, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80,
  0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80,
  0x0C, 0x08, 0x07, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xFF, 0xFD, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF,
  0xF8, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF,
  0xF4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0xC0, 0x18, 0x01, 0xC1, 0x80, 0x01, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x60, 0x00, 0x04, 0x80, 0x00, 0x13, 0x00, 0x00, 0x46, 0x00, 0x01, 0x0C,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x38, 0x01, 0xC0, 0x3F, 0xFC, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0xBF, 0x86, 0x00, 0x80,
  0x01, 0xC0, 0x01, 0xA0, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC4, 0x00, 0xC2,
  0x00, 0xC1, 0x00, 0x40, 0x80, 0x60, 0x40, 0x60, 0x20, 0x20, 0x10, 0x30,
  0x08, 0x30, 0x04, 0x30, 0x02, 0x10, 0x01, 0x18, 0x00, 0x9E, 0x00, 0x49,
  0x00, 0x28, 0xC0, 0x1C, 0x20, 0x0C, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01,
  0x00, 0xC0, 0x80, 0x20, 0x40, 0x18, 0x20, 0x04, 0x10, 0x01, 0x08, 0x00,
  0xC4, 0x00, 0x22, 0x00, 0x19, 0x00, 0x04, 0x80, 0x03, 0x40, 0x00, 0xA0,
  0x00, 0x20, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x0F, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0x0E, 0x80, 0x00, 0x07, 0xB0, 0x00, 0x01, 0x64, 0x00, 0x00, 0x59,
  0x00, 0x00, 0x36, 0x60, 0x00, 0x09, 0x88, 0x00, 0x02, 0x62, 0x00, 0x01,
  0x98, 0xC0, 0x00, 0x46, 0x10, 0x00, 0x11, 0x84, 0x00, 0x0C, 0x61, 0x80,
  0x02, 0x18, 0x20, 0x00, 0x86, 0x08, 0x00, 0x61, 0x83, 0x00, 0x10, 0x60,
  0x40, 0x04, 0x18, 0x10, 0x03, 0x06, 0x06, 0x00, 0x81, 0x80, 0x80, 0x20,
  0x60, 0x20, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x01, 0x01, 0x01, 0x80, 0x40,
  0xC0, 0x60, 0x18, 0x20, 0x18, 0x02, 0x08, 0x06, 0x00, 0x86, 0x01, 0x80,
  0x31, 0x00, 0x60, 0x04, 0x40, 0x18, 0x01, 0x30, 0x06, 0x00, 0x68, 0x01,
  0x80, 0x0A, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x04, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x03, 0x20, 0x00,
  0x66, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00,
  0xC1, 0x00, 0x18, 0x10, 0x03, 0x02, 0x00, 0x60, 0x20, 0x0C, 0x04, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x18, 0x18, 0x01, 0x03,
  0x00, 0x30, 0x60, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x30, 0x00, 0xC6,
  0x00, 0x08, 0xC0, 0x01, 0x98, 0x00, 0x13, 0x00, 0x03, 0x60, 0x00, 0x2C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x01, 0xFF,
  0x00, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x01,
  0x04, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x04, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x33, 0x00, 0x00, 0x42, 0x00, 0x00, 0x86, 0x00, 0x03,
  0x04, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x0E, 0x03, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x80, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x1C, 0x80, 0x70, 0xFF, 0xC0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01,
  0x01, 0x00, 0x01, 0x04, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xC0, 0x00,
  0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x33, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x86, 0x00, 0x03, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x60,
  0x0E, 0x03, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x40, 0x3C, 0x20, 0x03, 0x10,
  0x00, 0xC8, 0x00, 0x24, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x34, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x18, 0x3F, 0xF8, 0x10, 0x18, 0x08,
  0x04, 0x04, 0x03, 0x02, 0x00, 0x81, 0x00, 0x60, 0x80, 0x10, 0x40, 0x0C,
  0x20, 0x02, 0x10, 0x01, 0x88, 0x00, 0x44, 0x00, 0x32, 0x00, 0x09, 0x00,
  0x06, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x07, 0xFE, 0x0E, 0x01,
  0x8C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x60, 0x0E, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x00, 0x98, 0x00,
  0x11, 0x00, 0x06, 0x30, 0x01, 0x83, 0x80, 0xE0, 0x1F, 0xF0, 0x00, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x03,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x80,
  0x02, 0x04, 0x00, 0x10, 0x20, 0x01, 0x81, 0x80, 0x08, 0x04, 0x00, 0x40,
  0x20, 0x06, 0x01, 0x80, 0x30, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0xC0, 0x0C, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x18, 0x00,
  0x60, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x03, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x50, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x28, 0x00, 0x34,
  0x00, 0x14, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x0D, 0x00, 0x0C,
  0xC0, 0x04, 0xC0, 0x06, 0x20, 0x02, 0x20, 0x02, 0x10, 0x01, 0x10, 0x01,
  0x08, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC6, 0x00, 0xC1, 0x00, 0x43, 0x00,
  0x40, 0x80, 0x20, 0x80, 0x20, 0x40, 0x10, 0x40, 0x10, 0x30, 0x18, 0x20,
  0x18, 0x18, 0x08, 0x18, 0x08, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x01, 0x03, 0x01, 0x03, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x20, 0x80,
  0x60, 0x80, 0x10, 0x40, 0x10, 0x40, 0x08, 0x20, 0x08, 0x60, 0x06, 0x30,
  0x04, 0x30, 0x01, 0x18, 0x03, 0x10, 0x00, 0x88, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x44, 0x00, 0x36, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x1A, 0x00, 0x05,
  0x00, 0x0D, 0x00, 0x02, 0x80, 0x02, 0x80, 0x01, 0x40, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x46, 0x00,
  0x18, 0x40, 0x02, 0x08, 0x00, 0xC1, 0x80, 0x10, 0x10, 0x06, 0x03, 0x00,
  0x80, 0x20, 0x30, 0x06, 0x04, 0x00, 0x40, 0x80, 0x0C, 0x20, 0x00, 0x84,
  0x00, 0x11, 0x80, 0x03, 0x20, 0x00, 0x2C, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x19, 0x00, 0x02, 0x30,
  0x00, 0xC2, 0x00, 0x10, 0x40, 0x06, 0x04, 0x00, 0x80, 0x80, 0x30, 0x18,
  0x04, 0x01, 0x01, 0x80, 0x30, 0x20, 0x02, 0x0C, 0x00, 0x61, 0x00, 0x04,
  0x60, 0x00, 0x88, 0x00, 0x1B, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x50, 0x00,
  0x34, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0x41, 0x00, 0x30,
  0x40, 0x08, 0x18, 0x02, 0x02, 0x01, 0x80, 0x80, 0x40, 0x10, 0x30, 0x04,
  0x08, 0x01, 0x82, 0x00, 0x21, 0x80, 0x08, 0x40, 0x01, 0x30, 0x00, 0x48,
  0x00, 0x1A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0xFF, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x09, 0x80, 0x01, 0x88, 0x00, 0x10,
  0xC0, 0x03, 0x04, 0x00, 0x20, 0x60, 0x06, 0x02, 0x00, 0x40, 0x20, 0x0C,
  0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC2,
  0x00, 0x04, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xE0, 0xE0, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x0F, 0x07, 0xE4, 0x70, 0x13, 0x00, 0x58, 0x01, 0x40,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xD0,
  0x05, 0x20, 0x24, 0x7F, 0x10, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0xFE, 0x09, 0x81, 0x85, 0x80, 0x22, 0x80,
  0x19, 0xC0, 0x04, 0xC0, 0x03, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0B, 0x00, 0x05, 0x80,
  0x06, 0xC0, 0x02, 0x50, 0x03, 0x2C, 0x03, 0x13, 0x03, 0x08, 0xFF, 0x00,
  0x03, 0xFE, 0x0C, 0x08, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x02, 0x0F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x7F, 0x10, 0xC0, 0xC8, 0xC0, 0x34, 0x40, 0x0A, 0x40, 0x03, 0x20,
  0x01, 0xB0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0xC0, 0x03, 0x20, 0x01, 0x98,
  0x01, 0x44, 0x01, 0xA1, 0x81, 0x90, 0x7F, 0x88, 0x07, 0xF0, 0x0C, 0x1C,
  0x18, 0x04, 0x10, 0x02, 0x20, 0x02, 0x20, 0x03, 0x60, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x01, 0x0C, 0x03, 0x07, 0xFE,
  0x01, 0xF8, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x07, 0xF8, 0x86, 0x06, 0x46, 0x00, 0xA6, 0x00, 0x72, 0x00, 0x19,
  0x00, 0x0D, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x19, 0x00, 0x0C,
  0xC0, 0x0A, 0x20, 0x0D, 0x0C, 0x0C, 0x83, 0xFC, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xCC, 0x00, 0xC3, 0xE7, 0xC0, 0x3F, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x3F, 0x89, 0x81, 0x96, 0x01,
  0xA8, 0x01, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0xFD, 0x00, 0x00, 0x09,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x0E, 0x1C,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0xD7, 0x3C, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x06, 0x80, 0x32, 0x00, 0x88, 0x06, 0x20, 0x30, 0x80, 0x82, 0x04, 0x08,
  0x30, 0x20, 0x80, 0x84, 0x02, 0x30, 0x09, 0xC0, 0x25, 0x80, 0xA2, 0x03,
  0x8C, 0x0C, 0x10, 0x20, 0x60, 0x80, 0x82, 0x03, 0x08, 0x04, 0x20, 0x08,
  0x80, 0x22, 0x00, 0xC8, 0x01, 0x20, 0x02, 0x80, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x8F, 0xC0, 0xFE, 0x26, 0x0C, 0x60, 0xCB, 0x01, 0x30, 0x1A,
  0x80, 0x68, 0x02, 0xC0, 0x0C, 0x00, 0xB0, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x80, 0x08, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00,
  0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x60, 0x02, 0x00, 0x18,
  0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x60, 0x02, 0x00,
  0x18, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x60, 0x02,
  0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x87, 0xF1, 0x30, 0x32, 0xC0, 0x35, 0x00, 0x2C, 0x00,
  0x58, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x07, 0xF8, 0x03, 0x03, 0x01, 0x80, 0x20, 0xC0,
  0x0C, 0x20, 0x01, 0x18, 0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x09, 0x00,
  0x02, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x10, 0x60, 0x08, 0x0C, 0x0E,
  0x01, 0xFE, 0x00, 0x87, 0xF0, 0x46, 0x0C, 0x24, 0x01, 0x14, 0x00, 0xCA,
  0x00, 0x26, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x36,
  0x00, 0x12, 0x80, 0x19, 0x60, 0x18, 0x98, 0x18, 0x47, 0xF8, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8,
  0x86, 0x06, 0x46, 0x01, 0xA6, 0x00, 0x52, 0x00, 0x19, 0x00, 0x0D, 0x80,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x19, 0x00, 0x0C, 0xC0, 0x0A, 0x30,
  0x0D, 0x0C, 0x0C, 0x83, 0xFC, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x8F, 0xE6, 0x19, 0x02, 0x80, 0xA0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x1F, 0xF0, 0xC0, 0x66, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xA0, 0x06, 0xC0, 0x31, 0xFF, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xFC, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0x70, 0x02, 0xA0,
  0x09, 0x60, 0x62, 0x7F, 0x84, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40,
  0x02, 0x60, 0x02, 0x20, 0x06, 0x20, 0x04, 0x30, 0x04, 0x10, 0x04, 0x10,
  0x0C, 0x10, 0x08, 0x18, 0x08, 0x08, 0x18, 0x08, 0x10, 0x08, 0x10, 0x04,
  0x10, 0x04, 0x30, 0x04, 0x20, 0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0x00, 0x38, 0x02, 0x40, 0x1A,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x19, 0x80, 0x4C, 0x04, 0x20,
  0x31, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x30, 0xC0, 0x84, 0x08,
  0x10, 0x61, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x60, 0x61, 0x02,
  0x10, 0x08, 0xC0, 0xC4, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x32,
  0x01, 0x30, 0x05, 0x80, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x07, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x02,
  0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10,
  0x0C, 0x30, 0x04, 0x20, 0x06, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x04, 0x60, 0x04, 0x20, 0x08, 0x30,
  0x18, 0x10, 0x10, 0x18, 0x30, 0x08, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x02,
  0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x98, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x31, 0x80, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x0C, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x80, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x60, 0x08, 0x20,
  0x06, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x64, 0x00, 0x12, 0x00, 0x0B,
  0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x09, 0x80, 0x07, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x0F, 0xFF, 0x00, 0x78, 0x0E, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x03, 0x80,
  0x70, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0F, 0x80, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xE0, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x03, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x07, 0xC0, 0x38, 0x00, 0x3F, 0x00, 0x70, 0x30, 0x18, 0x07, 0xF8,
  0x00, 0x38,
};

const GFXglyph NotoSans_Condensed_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 35, 10, 4, -35 },
  { 10, 8, 13, 15, 3, -35 },
  { 23, 22, 35, 24, 1, -35 },
  { 120, 17, 40, 22, 2, -37 },
  { 205, 27, 35, 31, 2, -35 },
  { 324, 21, 35, 24, 2, -35 },
  { 416, 2, 13, 8, 3, -35 },
  { 420, 9, 43, 13, 2, -35 },
  { 469, 8, 43, 13, 2, -35 },
  { 512, 15, 14, 20, 2, -37 },
  { 539, 18, 23, 22, 2, -29 },
  { 591, 4, 11, 9, 2, -5 },
  { 597, 11, 1, 14, 1, -14 },
  { 599, 3, 3, 9, 3, -3 },
  { 601, 14, 35, 16, 1, -35 },
  { 663, 17, 35, 22, 2, -35 },
  { 738, 9, 35, 22, 4, -35 },
  { 778, 17, 35, 22, 2, -35 },
  { 853, 17, 35, 22, 2, -35 },
  { 928, 20, 35, 22, 1, -35 },
  { 1016, 16, 35, 22, 3, -35 },
  { 1086, 17, 36, 22, 3, -35 },
  { 1163, 17, 35, 22, 2, -35 },
  { 1238, 18, 35, 22, 2, -35 },
  { 1317, 17, 36, 22, 2, -35 },
  { 1394, 3, 26, 9, 3, -26 },
  { 1404, 4, 32, 9, 2, -26 },
  { 1420, 18, 21, 22, 2, -28 },
  { 1468, 18, 12, 22, 2, -23 },
  { 1495, 18, 21, 22, 2, -28 },
  { 1543, 13, 35, 15, 1, -35 },
  { 1600, 28, 40, 34, 3, -35 },
  { 1740, 21, 35, 21, 0, -35 },
  { 1832, 18, 35, 24, 4, -35 },
  { 1911, 19, 35, 23, 3, -35 },
  { 1995, 20, 35, 26, 4, -35 },
  { 2083, 15, 35, 21, 4, -35 },
  { 2149, 15, 35, 19, 4, -35 },
  { 2215, 22, 36, 28, 3, -36 },
  { 2314, 19, 35, 27, 4, -35 },
  { 2398, 8, 35, 12, 2, -35 },
  { 2433, 9, 44, 10, -3, -35 },
  { 2483, 17, 35, 21, 4, -35 },
  { 2558, 14, 35, 19, 4, -35 },
  { 2620, 26, 35, 35, 4, -35 },
  { 2734, 19, 35, 28, 4, -35 },
  { 2818, 23, 35, 29, 3, -35 },
  { 2919, 16, 35, 22, 4, -35 },
  { 2989, 23, 43, 29, 3, -35 },
  { 3113, 17, 35, 22, 4, -35 },
  { 3188, 17, 35, 21, 2, -35 },
  { 3263, 19, 35, 19, 0, -35 },
  { 3347, 19, 35, 27, 4, -35 },
  { 3431, 21, 35, 21, 0, -35 },
  { 3523, 33, 35, 35, 1, -35 },
  { 3668, 19, 35, 19, 0, -35 },
  { 3752, 18, 35, 18, 0, -35 },
  { 3831, 17, 35, 20, 1, -35 },
  { 3906, 9, 43, 15, 4, -35 },
  { 3955, 14, 35, 16, 1, -35 },
  { 4017, 9, 43, 15, 2, -35 },
  { 4066, 20, 18, 22, 1, -35 },
  { 4111, 19, 2, 19, 0, 4 },
  { 4116, 7, 7, 11, 2, -37 },
  { 4123, 14, 26, 20, 2, -26 },
  { 4169, 17, 37, 23, 4, -37 },
  { 4248, 15, 26, 18, 2, -26 },
  { 4297, 17, 37, 23, 2, -37 },
  { 4376, 16, 26, 21, 2, -26 },
  { 4428, 13, 37, 11, 0, -37 },
  { 4489, 17, 38, 23, 2, -26 },
  { 4570, 15, 37, 22, 4, -37 },
  { 4640, 3, 35, 9, 3, -35 },
  { 4654, 7, 47, 9, -1, -35 },
  { 4696, 14, 37, 18, 4, -37 },
  { 4761, 1, 37, 9, 4, -37 },
  { 4766, 26, 26, 33, 4, -26 },
  { 4851, 15, 26, 22, 4, -26 },
  { 4900, 18, 26, 22, 2, -26 },
  { 4959, 17, 37, 23, 4, -26 },
  { 5038, 17, 37, 23, 2, -26 },
  { 5117, 10, 26, 15, 4, -26 },
  { 5150, 14, 26, 17, 2, -26 },
  { 5196, 10, 32, 12, 1, -32 },
  { 5236, 15, 26, 22, 4, -26 },
  { 5285, 16, 26, 16, 0, -26 },
  { 5337, 26, 26, 28, 1, -26 },
  { 5422, 16, 26, 18, 1, -26 },
  { 5474, 17, 38, 17, 0, -26 },
  { 5555, 12, 26, 16, 2, -26 },
  { 5594, 13, 43, 17, 2, -35 },
  { 5664, 1, 49, 21, 10, -37 },
  { 5671, 13, 43, 17, 2, -35 },
  { 5741, 18, 4, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Thin49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_THIN49PT7B_H_
