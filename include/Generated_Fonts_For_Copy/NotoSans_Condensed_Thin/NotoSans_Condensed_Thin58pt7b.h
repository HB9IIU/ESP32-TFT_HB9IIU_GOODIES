#ifndef _NOTOSANS_CONDENSED_THIN58PT7B_H_
#define _NOTOSANS_CONDENSED_THIN58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xD8, 0x00, 0x00, 0x9F, 0x60, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xB0,
  0x2C, 0x0B, 0x02, 0xC0, 0xB0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x08,
  0x00, 0x30, 0x0C, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80,
  0x20, 0x00, 0x60, 0x08, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01, 0x00,
  0x03, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08,
  0x02, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00,
  0x10, 0x06, 0x00, 0x04, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x80, 0x20, 0x00, 0x60, 0x08, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x00, 0x60, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFC, 0x0E, 0x10, 0x70, 0xE0, 0x80, 0x86, 0x04, 0x00, 0x60,
  0x20, 0x03, 0x01, 0x00, 0x10, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00,
  0x60, 0x10, 0x03, 0x00, 0x80, 0x08, 0x04, 0x00, 0x60, 0x20, 0x03, 0x01,
  0x00, 0x0C, 0x08, 0x00, 0x30, 0x40, 0x00, 0xE2, 0x00, 0x01, 0xD0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x2E, 0x00, 0x01, 0x1C, 0x00, 0x08,
  0x70, 0x00, 0x40, 0xC0, 0x02, 0x03, 0x00, 0x10, 0x18, 0x00, 0x80, 0x60,
  0x04, 0x03, 0x00, 0x20, 0x18, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40,
  0x30, 0x02, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0x90, 0x04, 0x0C, 0xF0,
  0x21, 0xC3, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x33, 0x80,
  0x02, 0x00, 0xC1, 0x00, 0x0C, 0x03, 0x03, 0x00, 0x10, 0x04, 0x02, 0x00,
  0x60, 0x08, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x06,
  0x00, 0xC0, 0x10, 0x08, 0x01, 0x00, 0x20, 0x30, 0x03, 0x00, 0x40, 0x60,
  0x04, 0x00, 0x80, 0x80, 0x08, 0x01, 0x03, 0x00, 0x10, 0x02, 0x04, 0x00,
  0x20, 0x04, 0x18, 0x00, 0x40, 0x08, 0x30, 0x00, 0x80, 0x10, 0x40, 0x01,
  0x80, 0x21, 0x87, 0xE3, 0x00, 0x42, 0x18, 0x66, 0x01, 0x8C, 0x60, 0x44,
  0x03, 0x18, 0x80, 0xCC, 0x04, 0x23, 0x00, 0x98, 0x18, 0xC6, 0x01, 0x18,
  0x21, 0x0C, 0x03, 0x1D, 0xC6, 0x10, 0x06, 0x1E, 0x0C, 0x20, 0x0C, 0x00,
  0x10, 0x40, 0x08, 0x00, 0x60, 0x80, 0x10, 0x00, 0x81, 0x00, 0x20, 0x03,
  0x02, 0x00, 0x40, 0x06, 0x04, 0x00, 0x80, 0x08, 0x08, 0x01, 0x00, 0x30,
  0x10, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x00, 0x80, 0x40, 0x18, 0x03, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0x80, 0x20, 0x02,
  0x03, 0x00, 0x40, 0x06, 0x04, 0x01, 0x80, 0x06, 0x18, 0x02, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x0C, 0x00,
  0x20, 0x06, 0x00, 0x10, 0x03, 0x00, 0x08, 0x01, 0x80, 0x04, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18,
  0x00, 0x18, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x39,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x30, 0x08, 0x01, 0x18,
  0x06, 0x00, 0x98, 0x01, 0x80, 0xCC, 0x00, 0x40, 0x64, 0x00, 0x30, 0x22,
  0x00, 0x0C, 0x13, 0x00, 0x02, 0x19, 0x80, 0x01, 0x88, 0xC0, 0x00, 0x6C,
  0x60, 0x00, 0x16, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x06, 0x00, 0x03,
  0xC3, 0x00, 0x03, 0x20, 0xC0, 0x03, 0x18, 0x30, 0x03, 0x06, 0x0C, 0x07,
  0x01, 0x03, 0xFE, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xA8,
  0x01, 0xC0, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x38, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03, 0x82, 0x06, 0x71, 0x1C, 0x07,
  0xB8, 0x00, 0x60, 0x00, 0x50, 0x00, 0x64, 0x00, 0x23, 0x00, 0x20, 0xC0,
  0x20, 0x20, 0x30, 0x08, 0x30, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0xC6,
  0x21, 0x18, 0xC4, 0x23, 0x18, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x5F,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7D, 0xE0, 0x0E, 0x03,
  0x00, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00,
  0x04, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x04, 0x30,
  0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x07, 0x0E, 0x00,
  0x3F, 0xC0, 0x00, 0xC0, 0x70, 0x74, 0x39, 0x18, 0x4C, 0x16, 0x07, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x03, 0xF0, 0x01, 0xFB, 0xC0, 0x70,
  0x07, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x0E, 0x00, 0xE1, 0xC0,
  0x01, 0x84, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x18, 0x00, 0x38,
  0xF8, 0x07, 0x81, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00,
  0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x01,
  0x80, 0x40, 0x01, 0x00, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0x40, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x40, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x10,
  0x00, 0x40, 0x30, 0x00, 0x40, 0x60, 0x00, 0x40, 0x60, 0x00, 0x40, 0xC0,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x3F, 0xFF, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x07, 0xFF, 0xE0, 0x70,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x80, 0x03, 0x0F, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x1F, 0xE0, 0xC7, 0x07, 0x0C, 0xC0,
  0x18, 0xD8, 0x00, 0xCF, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x02, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x32, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00,
  0xC0, 0xC0, 0x18, 0x0E, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1C,
  0x03, 0x83, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x64,
  0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x06,
  0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03,
  0x00, 0x60, 0x60, 0x03, 0x9C, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x31,
  0xC0, 0x0E, 0x06, 0x01, 0x80, 0x30, 0x30, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x80, 0x18, 0x1C, 0x07,
  0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x00, 0xFB, 0xC0, 0x18,
  0x06, 0x03, 0x00, 0x30, 0x20, 0x01, 0x86, 0x00, 0x08, 0x40, 0x00, 0xCC,
  0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x40, 0x00, 0xF6, 0x00,
  0x0B, 0x30, 0x01, 0xA1, 0x80, 0x32, 0x0F, 0x3C, 0x20, 0x7F, 0x82, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x38,
  0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x2F, 0xF8, 0x19, 0xCE, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31,
  0x98, 0xC6, 0x21, 0x18, 0xC4, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xC1, 0xFF, 0xE1, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0xC0, 0x06, 0x20, 0x03,
  0xFE, 0x01, 0x98, 0x01, 0xC0, 0x80, 0x66, 0x00, 0xC0, 0x20, 0x09, 0x80,
  0x20, 0x08, 0x02, 0x40, 0x18, 0x02, 0x00, 0xD0, 0x04, 0x00, 0x80, 0x3C,
  0x03, 0x00, 0x20, 0x0F, 0x00, 0xC0, 0x08, 0x03, 0xC0, 0x20, 0x02, 0x00,
  0xF0, 0x08, 0x01, 0x80, 0x3C, 0x02, 0x00, 0x60, 0x0F, 0x01, 0x80, 0x18,
  0x03, 0xC0, 0x60, 0x06, 0x00, 0xF0, 0x18, 0x01, 0x80, 0x3C, 0x02, 0x00,
  0x60, 0x0B, 0x00, 0x80, 0x18, 0x02, 0xC0, 0x20, 0x0E, 0x01, 0xB0, 0x0C,
  0x02, 0x80, 0x64, 0x03, 0x00, 0xA0, 0x11, 0x00, 0x60, 0x6C, 0x0C, 0x40,
  0x1C, 0x31, 0x86, 0x18, 0x03, 0xF8, 0x3F, 0x06, 0x00, 0x18, 0x02, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x04, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x10,
  0x00, 0x0C, 0x08, 0x00, 0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x00,
  0x80, 0x01, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x60,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x40, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x01,
  0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x08, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x66, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFE, 0x04, 0x00,
  0x38, 0x20, 0x00, 0x71, 0x00, 0x01, 0x88, 0x00, 0x06, 0x40, 0x00, 0x32,
  0x00, 0x00, 0x90, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90,
  0x00, 0x18, 0x80, 0x01, 0x84, 0x00, 0x18, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x08, 0x00, 0x70, 0x40, 0x00, 0xE2, 0x00, 0x01, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00,
  0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x62,
  0x00, 0x0E, 0x10, 0x07, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFD, 0xF8, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x0C, 0x00,
  0xFF, 0xFC, 0x01, 0x00, 0x3E, 0x02, 0x00, 0x0E, 0x04, 0x00, 0x06, 0x08,
  0x00, 0x06, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x80,
  0x00, 0x19, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD0,
  0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00,
  0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00,
  0x30, 0x20, 0x01, 0xC0, 0x40, 0x7F, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xE8, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFA, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE7,
  0xF0, 0x03, 0x80, 0x07, 0x80, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0xDC, 0xF1, 0xF8, 0x00, 0x80, 0x00, 0x78, 0x00, 0x0C, 0x80, 0x00,
  0xC8, 0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00,
  0xC0, 0x80, 0x18, 0x08, 0x01, 0x80, 0x80, 0x30, 0x08, 0x06, 0x00, 0x80,
  0xC0, 0x08, 0x0C, 0x00, 0x81, 0x80, 0x08, 0x30, 0x00, 0x87, 0x00, 0x08,
  0x60, 0x00, 0x8E, 0x00, 0x09, 0xB0, 0x00, 0x91, 0x80, 0x0B, 0x18, 0x00,
  0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x08, 0x01, 0x80, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x00,
  0x60, 0x80, 0x02, 0x08, 0x00, 0x30, 0x80, 0x01, 0x08, 0x00, 0x18, 0x80,
  0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E,
  0x80, 0x00, 0x00, 0x2D, 0x80, 0x00, 0x00, 0xDB, 0x00, 0x00, 0x01, 0xB2,
  0x00, 0x00, 0x02, 0x66, 0x00, 0x00, 0x0C, 0xCC, 0x00, 0x00, 0x19, 0x88,
  0x00, 0x00, 0x23, 0x18, 0x00, 0x00, 0xC6, 0x30, 0x00, 0x01, 0x8C, 0x20,
  0x00, 0x02, 0x18, 0x60, 0x00, 0x0C, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x80,
  0x00, 0x20, 0xC1, 0x80, 0x00, 0xC1, 0x83, 0x00, 0x01, 0x83, 0x02, 0x00,
  0x02, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x08, 0x00,
  0x20, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x20, 0x02,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x30, 0x02, 0x02, 0x00,
  0x60, 0x06, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x08, 0x20, 0x03,
  0x00, 0x18, 0xC0, 0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x22, 0x00, 0x18,
  0x00, 0x6C, 0x00, 0x30, 0x00, 0xD8, 0x00, 0x60, 0x00, 0xA0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x73, 0x00, 0x00,
  0xE6, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x0C, 0x00, 0x0E,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x10, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0x20, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x40, 0x07, 0x00, 0xC0, 0x0E, 0x00,
  0x80, 0x1C, 0x01, 0x80, 0x38, 0x01, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x02,
  0x01, 0xC0, 0x06, 0x03, 0x80, 0x04, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x08,
  0x1C, 0x00, 0x18, 0x38, 0x00, 0x10, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x21,
  0xC0, 0x00, 0x63, 0x80, 0x00, 0x47, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x9C,
  0x00, 0x01, 0xB8, 0x00, 0x01, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x08,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xF8, 0x10, 0x03, 0xC2, 0x00, 0x1C, 0x40, 0x00, 0xC8, 0x00, 0x09,
  0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x06, 0x40, 0x01, 0x88,
  0x00, 0x71, 0x00, 0x78, 0x3F, 0xFC, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0xFF, 0xF8, 0x08, 0x01, 0xE0, 0x80, 0x03, 0x08,
  0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00,
  0x18, 0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x1C, 0x0F, 0xFF, 0x00, 0x80,
  0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x08, 0x01, 0x00, 0x80, 0x18, 0x08,
  0x00, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x80, 0x06, 0x08, 0x00, 0x20,
  0x80, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00,
  0xC8, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x30, 0x01,
  0xFE, 0x00, 0x7D, 0xFC, 0x1C, 0x00, 0x63, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC8, 0x00, 0x38, 0xE0, 0x0F, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x33, 0x00, 0x00, 0x46,
  0x00, 0x01, 0x86, 0x00, 0x06, 0x06, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x90,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x04, 0x08, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x20, 0x04, 0x00, 0x30, 0x02, 0x00,
  0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00,
  0xC0, 0x40, 0x00, 0x60, 0x20, 0x00, 0x10, 0x30, 0x00, 0x08, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x02,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x06, 0x40, 0x00,
  0x28, 0x00, 0x06, 0x60, 0x00, 0x2C, 0x00, 0x04, 0x60, 0x00, 0x6C, 0x00,
  0x0C, 0x20, 0x00, 0x6C, 0x00, 0x0C, 0x20, 0x00, 0x44, 0x00, 0x0C, 0x30,
  0x00, 0x46, 0x00, 0x08, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x10, 0x00, 0xC6,
  0x00, 0x18, 0x10, 0x00, 0xC2, 0x00, 0x18, 0x18, 0x00, 0x82, 0x00, 0x10,
  0x18, 0x00, 0x83, 0x00, 0x10, 0x18, 0x01, 0x83, 0x00, 0x30, 0x08, 0x01,
  0x83, 0x00, 0x30, 0x08, 0x01, 0x81, 0x00, 0x20, 0x0C, 0x01, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x04, 0x03, 0x01, 0x80, 0x60, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x06, 0x02, 0x00, 0x80, 0x40, 0x06, 0x02, 0x00,
  0xC0, 0xC0, 0x02, 0x06, 0x00, 0xC0, 0xC0, 0x02, 0x06, 0x00, 0x40, 0xC0,
  0x03, 0x06, 0x00, 0x40, 0x80, 0x03, 0x04, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x01, 0x0C, 0x00, 0x21,
  0x00, 0x01, 0x88, 0x00, 0x21, 0x00, 0x01, 0x88, 0x00, 0x33, 0x00, 0x00,
  0x98, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x32, 0x00, 0x00, 0xD8, 0x00,
  0x12, 0x00, 0x00, 0xD0, 0x00, 0x16, 0x00, 0x00, 0x50, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x61, 0x80, 0x01, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80,
  0x30, 0x02, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x10, 0x18, 0x00, 0x60, 0x40,
  0x00, 0x83, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xA0, 0x00, 0x06, 0xC0, 0x00, 0x11, 0x00, 0x00, 0xC6, 0x00,
  0x02, 0x08, 0x00, 0x18, 0x30, 0x00, 0x40, 0xC0, 0x03, 0x01, 0x00, 0x0C,
  0x06, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x40, 0x30, 0x01,
  0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x42,
  0x00, 0x01, 0x98, 0x00, 0x02, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x81, 0x00, 0x06, 0x06, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x20,
  0x30, 0x00, 0xC0, 0x80, 0x01, 0x06, 0x00, 0x06, 0x18, 0x00, 0x08, 0x40,
  0x00, 0x23, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0xFF, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x18, 0x00, 0x18,
  0x20, 0x00, 0x40, 0xC0, 0x03, 0x01, 0x00, 0x08, 0x06, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x60, 0x01, 0x81, 0x80, 0x02, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x11, 0x80, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x03, 0xF8, 0x0F,
  0x8F, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x03, 0xFE, 0x0F, 0x01, 0x0C, 0x00, 0x9C, 0x00, 0x4C,
  0x00, 0x2C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0xEC, 0x00, 0x53, 0x00, 0x69, 0xC0,
  0xE4, 0x3F, 0xC2, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x1F, 0xC0, 0xC7, 0x87, 0x0C, 0xC0, 0x18, 0xD8, 0x00, 0xCD,
  0x00, 0x04, 0xF0, 0x00, 0x6E, 0x00, 0x02, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x02, 0xE0, 0x00, 0x6F, 0x00, 0x04, 0xD8, 0x00, 0xCC,
  0xC0, 0x18, 0xC6, 0x07, 0x0C, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFE,
  0x01, 0xE1, 0xC3, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x08, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x1F, 0xC3, 0x07, 0x0E, 0x30, 0xC0, 0x33, 0x18, 0x01,
  0xB3, 0x00, 0x0F, 0x20, 0x00, 0x56, 0x00, 0x07, 0x60, 0x00, 0x34, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x40, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x53, 0x00, 0x0D, 0x30, 0x00,
  0x91, 0x80, 0x19, 0x0E, 0x07, 0x10, 0x7F, 0xC1, 0x00, 0x60, 0x00, 0x03,
  0xF8, 0x00, 0xE3, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x40,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x04, 0x1C, 0x03, 0x80, 0xFF,
  0xC0, 0x01, 0x00, 0x01, 0xFC, 0x0C, 0x10, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xFF, 0x8F, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xFC, 0x10, 0x78,
  0xF1, 0x0C, 0x01, 0x91, 0x80, 0x09, 0x30, 0x00, 0xF2, 0x00, 0x07, 0x60,
  0x00, 0x76, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x20, 0x00, 0xF3, 0x00, 0x0B, 0x18, 0x01, 0x30, 0xE0, 0x63, 0x07,
  0xFC, 0x30, 0x06, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC8, 0x00, 0x1C, 0x60, 0x03, 0x83, 0xF7, 0xE0, 0x07, 0xF8,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7F, 0x0C, 0x78, 0xE3, 0x30,
  0x0C, 0xD8, 0x01, 0xB4, 0x00, 0x2F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xA0, 0x00, 0x00, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x06, 0x07, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x0C, 0xFC, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x09,
  0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x04, 0x18, 0x06, 0x0C, 0x06,
  0x06, 0x02, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x31,
  0xC0, 0x19, 0xB0, 0x0C, 0x98, 0x06, 0xC6, 0x03, 0xC3, 0x01, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xF8, 0x07, 0xE1, 0x8E, 0x38, 0x38, 0xF3, 0x30, 0x18, 0xC0,
  0x76, 0xC0, 0x13, 0x00, 0x6D, 0x00, 0x34, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0xF8, 0x00, 0x60, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x80, 0xC1, 0xFC, 0x31, 0xE3, 0x8C, 0xC0, 0x33, 0x60, 0x06, 0xD0,
  0x00, 0xBC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x04,
  0x01, 0xFC, 0x00, 0x70, 0xF0, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00,
  0xC2, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03,
  0x60, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0x61, 0x00, 0x0C, 0x18, 0x01,
  0x80, 0xE0, 0x30, 0x03, 0xFE, 0x00, 0x02, 0x00, 0xC1, 0xFC, 0x0C, 0x78,
  0xF0, 0xCE, 0x01, 0x8C, 0x80, 0x0C, 0xD8, 0x00, 0x4D, 0x00, 0x06, 0xE0,
  0x00, 0x2E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x2F, 0x00,
  0x06, 0xD0, 0x00, 0x4D, 0x80, 0x0C, 0xCC, 0x01, 0x8C, 0x70, 0x70, 0xC3,
  0xFE, 0x0C, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC,
  0x10, 0x70, 0xE1, 0x0C, 0x03, 0x11, 0x80, 0x19, 0x30, 0x00, 0xD2, 0x00,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x30, 0x00, 0xF3, 0x00, 0x1B, 0x18, 0x03, 0x30, 0xE0,
  0x63, 0x07, 0xFC, 0x30, 0x06, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC1, 0xFE, 0x3D, 0xB3, 0x01, 0x90, 0x0D, 0x00, 0x68, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0x1F, 0x38, 0x01, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x06, 0xF0, 0x1C, 0x3F, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xFF, 0xFF, 0xF1, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x10, 0x7F, 0x00, 0x80, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xD0, 0x00, 0x56, 0x00, 0x15, 0x80, 0x09, 0x30, 0x06, 0x46,
  0x07, 0x10, 0xFF, 0x04, 0x0E, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00,
  0x01, 0xB0, 0x00, 0x26, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x21, 0x80,
  0x04, 0x30, 0x01, 0x82, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x01, 0x80, 0x80,
  0x30, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00, 0xC0,
  0x80, 0x18, 0x30, 0x01, 0x06, 0x00, 0x20, 0x80, 0x06, 0x10, 0x00, 0xC6,
  0x00, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x32, 0x00, 0x02, 0xC0, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x14, 0x00, 0x24,
  0x00, 0x28, 0x00, 0x48, 0x00, 0x58, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x30,
  0x03, 0x20, 0x04, 0x20, 0x04, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x30, 0xC0,
  0x31, 0x80, 0x61, 0x80, 0x61, 0x00, 0x81, 0x00, 0x82, 0x01, 0x02, 0x01,
  0x06, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x08, 0x10,
  0x10, 0x20, 0x10, 0x20, 0x30, 0x40, 0x30, 0xC0, 0x61, 0x80, 0x61, 0x80,
  0x43, 0x00, 0x42, 0x00, 0x84, 0x00, 0x84, 0x01, 0x88, 0x01, 0x98, 0x03,
  0x30, 0x03, 0x30, 0x02, 0x60, 0x02, 0x40, 0x04, 0x80, 0x04, 0x80, 0x0D,
  0x00, 0x0F, 0x00, 0x1A, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x4C,
  0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC1, 0x80, 0x10, 0x30, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x41, 0x80, 0x0C, 0x60, 0x00,
  0x8C, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x36, 0x00, 0x06, 0x40, 0x01, 0x8C, 0x00, 0x20, 0x80, 0x0C,
  0x18, 0x01, 0x01, 0x00, 0x60, 0x30, 0x08, 0x02, 0x03, 0x00, 0x60, 0x40,
  0x04, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x18, 0x40,
  0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x80, 0x08,
  0x08, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x02, 0x02, 0x00, 0x20, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x40, 0x01, 0x04, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00,
  0x98, 0x00, 0x0D, 0x80, 0x00, 0xD0, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0D, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x38, 0x00, 0x3C, 0x01,
  0xF0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80,
  0x1E, 0x03, 0x80, 0xE0, 0x03, 0xFE, 0x80, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 41, 12, 4, -41 },
  { 17, 10, 15, 17, 4, -41 },
  { 36, 26, 41, 28, 1, -41 },
  { 170, 21, 47, 26, 2, -44 },
  { 294, 31, 43, 37, 3, -42 },
  { 461, 25, 43, 28, 2, -42 },
  { 596, 2, 15, 10, 4, -41 },
  { 600, 10, 50, 15, 3, -41 },
  { 663, 10, 50, 15, 2, -41 },
  { 726, 17, 17, 23, 3, -44 },
  { 763, 22, 27, 26, 2, -34 },
  { 838, 5, 13, 10, 2, -6 },
  { 847, 13, 2, 16, 2, -17 },
  { 851, 3, 4, 11, 4, -4 },
  { 853, 17, 41, 19, 1, -41 },
  { 941, 20, 42, 26, 3, -42 },
  { 1046, 10, 41, 26, 5, -41 },
  { 1098, 20, 42, 26, 3, -42 },
  { 1203, 21, 43, 26, 2, -42 },
  { 1316, 24, 42, 26, 1, -42 },
  { 1442, 20, 42, 26, 3, -41 },
  { 1547, 20, 43, 26, 3, -42 },
  { 1655, 20, 41, 26, 3, -41 },
  { 1758, 20, 43, 26, 3, -42 },
  { 1866, 20, 43, 26, 3, -42 },
  { 1974, 3, 31, 11, 4, -31 },
  { 1986, 5, 38, 11, 2, -31 },
  { 2010, 22, 25, 26, 2, -33 },
  { 2079, 22, 13, 26, 2, -27 },
  { 2115, 22, 25, 26, 2, -33 },
  { 2184, 15, 42, 18, 1, -42 },
  { 2263, 34, 46, 40, 3, -41 },
  { 2459, 25, 41, 25, 0, -41 },
  { 2588, 21, 41, 28, 5, -41 },
  { 2696, 23, 43, 28, 3, -42 },
  { 2820, 23, 41, 31, 5, -41 },
  { 2938, 17, 41, 25, 5, -41 },
  { 3026, 17, 41, 23, 5, -41 },
  { 3114, 27, 43, 34, 3, -42 },
  { 3260, 22, 41, 32, 5, -41 },
  { 3373, 8, 41, 14, 3, -41 },
  { 3414, 11, 51, 12, -4, -41 },
  { 3485, 20, 41, 25, 5, -41 },
  { 3588, 17, 41, 23, 5, -41 },
  { 3676, 31, 41, 41, 5, -41 },
  { 3835, 23, 41, 33, 5, -41 },
  { 3953, 28, 43, 34, 3, -42 },
  { 4104, 19, 41, 26, 5, -41 },
  { 4202, 28, 52, 34, 3, -42 },
  { 4384, 20, 41, 26, 5, -41 },
  { 4487, 20, 43, 25, 3, -42 },
  { 4595, 22, 41, 22, 0, -41 },
  { 4708, 23, 42, 32, 5, -41 },
  { 4829, 25, 41, 25, 0, -41 },
  { 4958, 40, 41, 41, 1, -41 },
  { 5163, 22, 41, 22, 0, -41 },
  { 5276, 22, 41, 22, 0, -41 },
  { 5389, 20, 41, 23, 2, -41 },
  { 5492, 11, 50, 18, 5, -41 },
  { 5561, 17, 41, 19, 1, -41 },
  { 5649, 11, 50, 18, 2, -41 },
  { 5718, 22, 21, 26, 2, -41 },
  { 5776, 23, 2, 23, 0, 5 },
  { 5782, 9, 9, 13, 2, -44 },
  { 5793, 17, 32, 24, 2, -31 },
  { 5861, 20, 45, 27, 4, -44 },
  { 5974, 17, 32, 21, 3, -31 },
  { 6042, 20, 45, 27, 3, -44 },
  { 6155, 19, 32, 25, 3, -31 },
  { 6231, 14, 44, 13, 1, -44 },
  { 6308, 20, 45, 27, 3, -31 },
  { 6421, 18, 44, 27, 4, -44 },
  { 6520, 3, 42, 11, 4, -42 },
  { 6536, 8, 56, 11, -1, -42 },
  { 6592, 17, 44, 21, 4, -44 },
  { 6686, 2, 44, 10, 4, -44 },
  { 6697, 31, 31, 40, 4, -31 },
  { 6818, 18, 31, 27, 4, -31 },
  { 6888, 20, 32, 26, 3, -31 },
  { 6968, 20, 44, 27, 4, -31 },
  { 7078, 20, 44, 27, 3, -31 },
  { 7188, 13, 31, 17, 4, -31 },
  { 7239, 16, 32, 21, 2, -31 },
  { 7303, 12, 39, 14, 1, -38 },
  { 7362, 18, 32, 27, 4, -31 },
  { 7434, 19, 31, 19, 0, -31 },
  { 7508, 31, 31, 33, 1, -31 },
  { 7629, 19, 31, 21, 1, -31 },
  { 7703, 20, 45, 20, 0, -31 },
  { 7816, 15, 31, 18, 2, -31 },
  { 7875, 14, 50, 20, 3, -41 },
  { 7963, 1, 58, 25, 12, -44 },
  { 7971, 14, 50, 20, 3, -41 },
  { 8059, 22, 5, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Thin58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_THIN58PT7B_H_
