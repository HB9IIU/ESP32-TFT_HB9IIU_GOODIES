#ifndef _NOTOSANS_CONDENSED_THIN38PT7B_H_
#define _NOTOSANS_CONDENSED_THIN38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x3C, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41,
  0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x10, 0x7F, 0xFF, 0x82,
  0x04, 0x01, 0x02, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x20, 0x08, 0x10, 0x7F, 0xFF, 0x82, 0x08, 0x01, 0x04, 0x01, 0x02,
  0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20, 0x04,
  0x10, 0x00, 0x02, 0x00, 0x10, 0x03, 0xE0, 0x64, 0xE4, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x04, 0x20, 0x19,
  0x00, 0x78, 0x00, 0xE0, 0x02, 0xC0, 0x13, 0x00, 0x84, 0x04, 0x30, 0x20,
  0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x18, 0x10, 0xA0, 0x98, 0xFF, 0x80,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x18, 0x00, 0x03, 0x40, 0x10, 0x42, 0x02,
  0x04, 0x20, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x80, 0x81, 0x08, 0x08, 0x10, 0x80, 0x81, 0x10, 0x08, 0x11, 0x18, 0x81,
  0x22, 0x68, 0x12, 0x42, 0x42, 0x24, 0x14, 0x24, 0x81, 0x3C, 0x48, 0x11,
  0x08, 0x81, 0x00, 0x88, 0x10, 0x08, 0x81, 0x01, 0x08, 0x10, 0x10, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x40, 0x41, 0x04, 0x04,
  0x20, 0x80, 0x3C, 0x02, 0x00, 0x1D, 0x80, 0x10, 0xC0, 0x20, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10,
  0x80, 0x09, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x12, 0x00, 0x22, 0x00, 0x41,
  0x02, 0x80, 0x82, 0x80, 0x82, 0x80, 0x42, 0x80, 0x24, 0x80, 0x24, 0x80,
  0x18, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x24, 0x60, 0x42, 0x3F, 0x83, 0xFF,
  0xC0, 0x04, 0x21, 0x84, 0x30, 0x82, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x30, 0x40,
  0x82, 0x04, 0xC0, 0x40, 0x80, 0x81, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x0C, 0x46, 0x7F, 0x01, 0x00, 0x50, 0x11, 0x02, 0x10, 0x82, 0x30, 0x20,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x32, 0x22, 0x24, 0x44,
  0x80, 0xFF, 0x80, 0xF0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x00, 0x02, 0x00, 0xEE, 0x04, 0x18, 0x40,
  0x44, 0x01, 0x20, 0x09, 0x00, 0x58, 0x02, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x20, 0x31, 0x01,
  0x04, 0x10, 0x1F, 0x00, 0x06, 0x1C, 0x69, 0x14, 0x30, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x06, 0x01, 0xFC, 0x30, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0xFF, 0xF0, 0x04, 0x01, 0xDE, 0x30, 0x19, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x0C, 0x0F,
  0x80, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0xA0, 0x19, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0xD0, 0x00, 0x90, 0x01, 0x10,
  0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10,
  0x18, 0x10, 0x10, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F, 0xF2, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xFF, 0x04, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x24, 0x02,
  0x1F, 0xE0, 0x07, 0xF0, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0xC1, 0x39, 0xCA, 0x02, 0x60,
  0x0B, 0x00, 0x58, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xA0, 0x05, 0x00, 0x28, 0x02, 0x20, 0x11, 0x81, 0x07, 0x70, 0x04, 0x00,
  0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x1F, 0xC1, 0x01, 0x10,
  0x04, 0x80, 0x2C, 0x01, 0x40, 0x06, 0x00, 0x68, 0x02, 0x40, 0x11, 0x01,
  0x04, 0x10, 0x13, 0x00, 0x70, 0x06, 0xC0, 0xC1, 0x0C, 0x04, 0x40, 0x14,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x40,
  0x11, 0x01, 0x07, 0xF0, 0x02, 0x00, 0xFC, 0x08, 0x10, 0x80, 0x4C, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0D, 0x00, 0xAC, 0x0D, 0x39, 0xC8, 0x30, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x60,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x33, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x32, 0x22, 0x24, 0x44, 0x80, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x08, 0x3D, 0xC8, 0x18, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xFE, 0x00, 0x0C, 0x06, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08, 0x10,
  0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40, 0x7E,
  0x0D, 0x02, 0x08, 0x1C, 0x18, 0x20, 0x60, 0x40, 0x81, 0x81, 0x02, 0x06,
  0x08, 0x08, 0x18, 0x20, 0x20, 0x60, 0x80, 0x81, 0x82, 0x02, 0x06, 0x08,
  0x08, 0x18, 0x20, 0x60, 0x60, 0x41, 0x82, 0x81, 0x06, 0x09, 0x02, 0x64,
  0x44, 0x07, 0x0E, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x0F, 0x7C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x08, 0x01,
  0x04, 0x01, 0x02, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x3F, 0xF0,
  0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x21, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x02, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60,
  0xFF, 0xC2, 0x00, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x18, 0xFF, 0x82, 0x03,
  0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x01, 0x8F, 0xFC, 0x00,
  0x00, 0x20, 0x07, 0xBC, 0x30, 0x08, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x10, 0x08, 0x1F, 0xF0, 0xFF, 0x81, 0x00, 0xC2, 0x00, 0x44, 0x00,
  0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x02,
  0x40, 0x0C, 0x80, 0x31, 0x01, 0xC3, 0xFE, 0x00, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0F, 0xFF, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0xFB, 0xC0, 0x60, 0x08, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x10, 0x60,
  0x0C, 0x0F, 0xFC, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x99,
  0x80, 0x80, 0x1C, 0x00, 0xA0, 0x09, 0x00, 0xC8, 0x04, 0x40, 0x42, 0x04,
  0x10, 0x60, 0x82, 0x04, 0x20, 0x23, 0x01, 0x30, 0x09, 0x80, 0x52, 0x03,
  0x90, 0x18, 0x40, 0x83, 0x04, 0x08, 0x20, 0x61, 0x01, 0x08, 0x04, 0x40,
  0x22, 0x00, 0x90, 0x04, 0x80, 0x14, 0x00, 0xE0, 0x02, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE8, 0x00, 0x0B, 0x40, 0x00, 0x5A, 0x00, 0x02,
  0xC8, 0x00, 0x26, 0x40, 0x01, 0x32, 0x00, 0x09, 0x88, 0x00, 0x8C, 0x40,
  0x04, 0x62, 0x00, 0x23, 0x08, 0x02, 0x18, 0x40, 0x10, 0xC2, 0x00, 0x86,
  0x08, 0x08, 0x30, 0x40, 0x41, 0x82, 0x02, 0x0C, 0x08, 0x20, 0x60, 0x41,
  0x03, 0x02, 0x08, 0x18, 0x08, 0x80, 0xC0, 0x44, 0x06, 0x02, 0x20, 0x30,
  0x0A, 0x01, 0x80, 0x50, 0x0C, 0x02, 0x80, 0x60, 0x08, 0x02, 0xC0, 0x03,
  0x80, 0x06, 0x80, 0x0D, 0x00, 0x19, 0x00, 0x32, 0x00, 0x62, 0x00, 0xC4,
  0x01, 0x84, 0x03, 0x08, 0x06, 0x08, 0x0C, 0x10, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x20, 0xC0, 0x41, 0x80, 0x43, 0x00, 0x86, 0x00, 0x8C, 0x01, 0x18,
  0x01, 0x30, 0x02, 0x60, 0x02, 0xC0, 0x05, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x08, 0x00, 0x40, 0x01, 0xEE, 0x00, 0x80, 0x40, 0x40, 0x08, 0x20, 0x01,
  0x08, 0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00,
  0x90, 0x00, 0x24, 0x00, 0x08, 0x80, 0x04, 0x30, 0x01, 0x04, 0x00, 0x80,
  0xC0, 0x40, 0x1F, 0xE0, 0xFF, 0x84, 0x06, 0x20, 0x09, 0x00, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x28,
  0x02, 0x40, 0x33, 0xFE, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x01, 0xEE, 0x00, 0x80, 0x60, 0x40, 0x08, 0x20, 0x01, 0x08,
  0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x08, 0x80, 0x04, 0x30, 0x01, 0x04, 0x00, 0x80, 0xC0,
  0x40, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0xFF, 0x84, 0x03, 0x20, 0x09, 0x00, 0x28,
  0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00,
  0x68, 0x06, 0x40, 0xE3, 0xF8, 0x10, 0x20, 0x81, 0x04, 0x04, 0x20, 0x21,
  0x00, 0x88, 0x04, 0x40, 0x12, 0x00, 0x90, 0x02, 0x80, 0x14, 0x00, 0x60,
  0x02, 0x01, 0x00, 0xF7, 0x88, 0x04, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0xA0, 0x19, 0xFF, 0x00, 0xFF,
  0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x60, 0x0C, 0x60, 0x30,
  0x3F, 0x80, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x0C, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x10,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x04, 0x00, 0x68,
  0x00, 0x80, 0x09, 0x00, 0x28, 0x01, 0x20, 0x05, 0x00, 0x22, 0x00, 0xA0,
  0x0C, 0x40, 0x14, 0x01, 0x08, 0x02, 0x80, 0x21, 0x00, 0x88, 0x04, 0x30,
  0x11, 0x00, 0x82, 0x02, 0x20, 0x20, 0x40, 0x44, 0x04, 0x08, 0x18, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x10, 0x41, 0x04, 0x02, 0x08, 0x20, 0x80, 0x41,
  0x04, 0x10, 0x08, 0x40, 0x42, 0x00, 0x88, 0x08, 0x80, 0x11, 0x01, 0x10,
  0x02, 0x20, 0x22, 0x00, 0x4C, 0x02, 0x40, 0x05, 0x00, 0x58, 0x00, 0xA0,
  0x0A, 0x00, 0x14, 0x01, 0x40, 0x02, 0x80, 0x28, 0x00, 0x60, 0x03, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x60, 0x04, 0x80, 0x22, 0x00, 0x84, 0x06, 0x10,
  0x10, 0x20, 0xC0, 0x82, 0x01, 0x08, 0x04, 0x40, 0x19, 0x00, 0x28, 0x00,
  0xA0, 0x01, 0x00, 0x04, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x40, 0x11, 0x00,
  0x82, 0x02, 0x08, 0x10, 0x30, 0x40, 0x42, 0x01, 0x08, 0x02, 0x60, 0x09,
  0x00, 0x1C, 0x00, 0x40, 0x80, 0x05, 0x00, 0x34, 0x00, 0x90, 0x02, 0x20,
  0x10, 0x80, 0x41, 0x03, 0x04, 0x08, 0x10, 0x20, 0x21, 0x00, 0x84, 0x01,
  0x30, 0x04, 0x80, 0x12, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x3F, 0xFE,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xFE, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE,
  0x01, 0x80, 0x07, 0x00, 0x0B, 0x00, 0x32, 0x00, 0x44, 0x01, 0x04, 0x02,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x40, 0x10, 0x80, 0x22, 0x00, 0x24, 0x00,
  0x50, 0x00, 0x40, 0xFF, 0xFE, 0x86, 0x18, 0x41, 0x04, 0x3F, 0x88, 0x18,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x63, 0xF4, 0x80,
  0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x15, 0x02, 0x9F,
  0x90, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0xFE, 0x2C, 0x09, 0x40, 0x6C, 0x01, 0x60, 0x0A,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x16, 0x00, 0xB0, 0x09, 0x40, 0xC9, 0xFC,
  0x00, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0xFE, 0x4C, 0x0A, 0x40,
  0x74, 0x01, 0xA0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x1A, 0x00, 0xD8,
  0x0A, 0x40, 0xD1, 0xFC, 0x80, 0x1F, 0x83, 0x04, 0x20, 0x24, 0x01, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x10, 0xFE, 0x07,
  0xC3, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x00,
  0x1F, 0xC9, 0x81, 0x58, 0x06, 0x80, 0x34, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x28, 0x03, 0x40, 0x1B, 0x01, 0x48, 0x1A, 0x3F, 0x90, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x80, 0xC3, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x09, 0xF8, 0xB0, 0x4A, 0x02, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xE0, 0x02, 0xAA, 0xAA,
  0xAA, 0xAA, 0xA8, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x02, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x21, 0x3C, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x0A, 0x02, 0x40, 0x88, 0x31,
  0x04, 0x21, 0x04, 0x40, 0x88, 0x13, 0x02, 0xA0, 0x52, 0x0C, 0x41, 0x04,
  0x20, 0x84, 0x08, 0x81, 0x10, 0x12, 0x02, 0x40, 0x28, 0x06, 0xFF, 0xFF,
  0xFF, 0xF8, 0x9F, 0x8F, 0xCA, 0x09, 0x82, 0xC0, 0x50, 0x3C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20,
  0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02,
  0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80,
  0x20, 0x18, 0x02, 0x01, 0x9F, 0xCB, 0x06, 0xC0, 0x2C, 0x02, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x1F, 0xC1,
  0x81, 0x18, 0x04, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x01,
  0x40, 0x13, 0x00, 0x8C, 0x08, 0x3F, 0x80, 0x9F, 0xC5, 0x81, 0x28, 0x0D,
  0x80, 0x2C, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x02, 0xC0, 0x15, 0x01,
  0x2C, 0x19, 0x3F, 0x88, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC9, 0x81, 0x58, 0x0A,
  0x80, 0x34, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x03, 0x40, 0x1B, 0x01,
  0x4C, 0x1A, 0x3F, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x9F, 0xA0, 0xA0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1F, 0xE4, 0x05, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x0E, 0x01, 0x3F, 0xC0, 0x20, 0x20, 0x20, 0x20, 0x20,
  0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1E, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x78, 0x0D, 0x02, 0x9F, 0x90,
  0x80, 0x1A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x80, 0x84,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x21, 0x00, 0x88, 0x04, 0x40, 0x24,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x30, 0x0A,
  0x01, 0x80, 0x50, 0x0C, 0x04, 0x80, 0xA0, 0x22, 0x04, 0x81, 0x10, 0x24,
  0x08, 0x81, 0x20, 0x84, 0x11, 0x04, 0x10, 0x84, 0x20, 0x84, 0x21, 0x04,
  0x21, 0x08, 0x22, 0x08, 0x81, 0x10, 0x44, 0x04, 0x81, 0x20, 0x24, 0x09,
  0x01, 0x40, 0x50, 0x0A, 0x02, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x08,
  0x02, 0x00, 0xC0, 0x34, 0x02, 0x60, 0x42, 0x04, 0x10, 0x81, 0x08, 0x09,
  0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0xB0, 0x09, 0x01, 0x18, 0x10,
  0x82, 0x04, 0x20, 0x44, 0x02, 0x40, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x02, 0x10, 0x10, 0x80, 0x88, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0xFF, 0x03, 0x82, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x60, 0xC0, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x01, 0x83,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0xE0, 0x00, 0x3E, 0x02, 0x83, 0x0E, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 27, 8, 3, -27 },
  { 8, 6, 10, 11, 3, -27 },
  { 16, 17, 27, 19, 1, -27 },
  { 74, 13, 31, 17, 2, -29 },
  { 125, 20, 28, 24, 2, -28 },
  { 195, 16, 28, 18, 2, -28 },
  { 251, 1, 10, 6, 3, -27 },
  { 253, 6, 33, 10, 2, -27 },
  { 278, 7, 33, 10, 1, -27 },
  { 307, 11, 12, 15, 2, -29 },
  { 324, 15, 17, 17, 1, -22 },
  { 356, 4, 9, 7, 1, -4 },
  { 361, 9, 1, 11, 1, -11 },
  { 363, 2, 2, 7, 3, -2 },
  { 364, 11, 27, 12, 1, -27 },
  { 402, 13, 28, 17, 2, -28 },
  { 448, 7, 27, 17, 3, -27 },
  { 472, 13, 28, 17, 2, -28 },
  { 518, 13, 28, 17, 2, -28 },
  { 564, 16, 27, 17, 1, -27 },
  { 618, 13, 27, 17, 2, -27 },
  { 662, 13, 28, 17, 2, -27 },
  { 708, 13, 27, 17, 2, -27 },
  { 752, 13, 27, 17, 2, -27 },
  { 796, 13, 28, 17, 2, -28 },
  { 842, 2, 20, 7, 3, -20 },
  { 847, 4, 25, 7, 1, -20 },
  { 860, 15, 16, 17, 1, -22 },
  { 890, 15, 9, 17, 1, -18 },
  { 907, 15, 16, 17, 1, -22 },
  { 937, 10, 28, 12, 1, -28 },
  { 972, 22, 31, 26, 2, -27 },
  { 1058, 17, 27, 17, 0, -27 },
  { 1116, 14, 27, 18, 3, -27 },
  { 1164, 15, 28, 18, 2, -28 },
  { 1217, 15, 27, 20, 3, -27 },
  { 1268, 11, 27, 16, 3, -27 },
  { 1306, 11, 27, 15, 3, -27 },
  { 1344, 18, 28, 22, 2, -28 },
  { 1407, 15, 27, 21, 3, -27 },
  { 1458, 5, 27, 9, 2, -27 },
  { 1475, 6, 34, 8, -2, -27 },
  { 1501, 13, 27, 16, 3, -27 },
  { 1545, 11, 27, 15, 3, -27 },
  { 1583, 21, 27, 27, 3, -27 },
  { 1654, 15, 27, 21, 3, -27 },
  { 1705, 18, 28, 22, 2, -28 },
  { 1768, 13, 27, 17, 3, -27 },
  { 1812, 18, 34, 22, 2, -28 },
  { 1889, 13, 27, 17, 3, -27 },
  { 1933, 13, 28, 17, 2, -28 },
  { 1979, 14, 27, 15, 0, -27 },
  { 2027, 15, 27, 21, 3, -27 },
  { 2078, 16, 27, 16, 0, -27 },
  { 2132, 27, 27, 27, 0, -27 },
  { 2224, 14, 27, 15, 0, -27 },
  { 2272, 14, 27, 14, 0, -27 },
  { 2320, 13, 27, 15, 1, -27 },
  { 2364, 7, 33, 12, 3, -27 },
  { 2393, 11, 27, 12, 1, -27 },
  { 2431, 7, 33, 12, 1, -27 },
  { 2460, 15, 14, 17, 1, -27 },
  { 2487, 15, 1, 15, 0, 3 },
  { 2489, 5, 6, 9, 2, -29 },
  { 2493, 11, 20, 16, 2, -20 },
  { 2521, 13, 29, 18, 3, -29 },
  { 2569, 11, 20, 14, 2, -20 },
  { 2597, 13, 29, 18, 2, -29 },
  { 2645, 12, 20, 16, 2, -20 },
  { 2675, 10, 29, 9, 0, -29 },
  { 2712, 13, 29, 18, 2, -20 },
  { 2760, 12, 29, 17, 3, -29 },
  { 2804, 2, 27, 7, 3, -27 },
  { 2811, 6, 36, 7, -1, -27 },
  { 2838, 11, 29, 14, 3, -29 },
  { 2878, 1, 29, 7, 3, -29 },
  { 2882, 20, 20, 26, 3, -20 },
  { 2932, 12, 20, 17, 3, -20 },
  { 2962, 13, 20, 17, 2, -20 },
  { 2995, 13, 29, 18, 3, -20 },
  { 3043, 13, 29, 18, 2, -20 },
  { 3091, 8, 20, 11, 3, -20 },
  { 3111, 11, 20, 14, 1, -20 },
  { 3139, 8, 25, 9, 1, -25 },
  { 3164, 11, 20, 17, 3, -20 },
  { 3192, 13, 20, 13, 0, -20 },
  { 3225, 21, 20, 21, 0, -20 },
  { 3278, 12, 20, 14, 1, -20 },
  { 3308, 13, 29, 13, 0, -20 },
  { 3356, 10, 20, 12, 1, -20 },
  { 3381, 9, 33, 13, 2, -27 },
  { 3419, 1, 38, 16, 8, -29 },
  { 3424, 9, 33, 13, 2, -27 },
  { 3462, 15, 3, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Thin38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_THIN38PT7B_H_
