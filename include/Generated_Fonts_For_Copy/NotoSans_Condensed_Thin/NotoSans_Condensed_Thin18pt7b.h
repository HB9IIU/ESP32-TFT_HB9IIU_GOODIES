#ifndef _NOTOSANS_CONDENSED_THIN18PT7B_H_
#define _NOTOSANS_CONDENSED_THIN18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC8, 0xB6, 0xDA, 0x12, 0x12, 0x12, 0x12, 0x7F, 0x22, 0x24,
  0x24, 0xFF, 0x24, 0x24, 0x24, 0x44, 0x21, 0xFA, 0x28, 0xA2, 0x86, 0x0C,
  0x28, 0x92, 0x49, 0x27, 0xE2, 0x00, 0x61, 0x24, 0x89, 0x22, 0x50, 0x94,
  0x25, 0x69, 0xA5, 0xA9, 0x14, 0x45, 0x11, 0x44, 0x89, 0x23, 0x80, 0x70,
  0x91, 0x22, 0x44, 0x86, 0x18, 0x49, 0x8B, 0x16, 0x14, 0x27, 0xA0, 0xF8,
  0x29, 0x49, 0x24, 0x92, 0x48, 0x91, 0x91, 0x22, 0x49, 0x24, 0x94, 0xA4,
  0x21, 0x3E, 0x45, 0x44, 0x10, 0x41, 0x04, 0xFC, 0x41, 0x04, 0x10, 0xF0,
  0xF0, 0x80, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x80,
  0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x51, 0x78, 0x2E, 0x92,
  0x49, 0x24, 0x92, 0xF8, 0x10, 0x41, 0x04, 0x20, 0x84, 0x10, 0x84, 0x20,
  0xFC, 0xF8, 0x10, 0x41, 0x04, 0x27, 0x81, 0x04, 0x10, 0x41, 0xF8, 0x04,
  0x0C, 0x0C, 0x14, 0x14, 0x24, 0x24, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x04,
  0x7A, 0x08, 0x20, 0x83, 0xE0, 0x41, 0x04, 0x10, 0x41, 0xF8, 0x3D, 0x08,
  0x20, 0x83, 0xE8, 0x61, 0x86, 0x18, 0x61, 0x78, 0xFC, 0x10, 0x42, 0x08,
  0x21, 0x04, 0x10, 0x82, 0x08, 0x40, 0x7A, 0x18, 0x61, 0x85, 0x23, 0x32,
  0x86, 0x18, 0x61, 0x78, 0x72, 0x28, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10,
  0x42, 0xF0, 0xC0, 0x40, 0xC0, 0xF0, 0x04, 0x66, 0x20, 0x60, 0x40, 0xC0,
  0xFC, 0x00, 0x3F, 0xC0, 0x81, 0x81, 0x08, 0xCC, 0x00, 0xF0, 0x42, 0x10,
  0x88, 0x44, 0x21, 0x00, 0x02, 0x00, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x8E,
  0x64, 0x99, 0x26, 0x49, 0x92, 0x64, 0x98, 0xDA, 0x00, 0x40, 0x08, 0x01,
  0xE0, 0x10, 0x18, 0x18, 0x28, 0x24, 0x24, 0x24, 0x7E, 0x42, 0x42, 0x82,
  0x81, 0x81, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0xA1, 0x86, 0x18, 0x61, 0xF8,
  0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x03, 0xE0,
  0xF1, 0x12, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14, 0x6F, 0x00,
  0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x0F, 0x80, 0xFC, 0x21, 0x08,
  0x43, 0xF0, 0x84, 0x21, 0x08, 0x00, 0x1F, 0x60, 0x40, 0x80, 0x80, 0x80,
  0x86, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x86, 0x18, 0x61, 0x86, 0x1F,
  0xE1, 0x86, 0x18, 0x61, 0x84, 0xD5, 0x55, 0x55, 0xC0, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x4F, 0x86, 0x29, 0x28, 0xA3, 0x0C, 0x28, 0xA2, 0x48, 0xA2,
  0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0x80, 0xC0,
  0x60, 0x70, 0x3C, 0x1E, 0x16, 0x8B, 0x45, 0xA4, 0xCA, 0x65, 0x33, 0x18,
  0x88, 0x83, 0x06, 0x0E, 0x1C, 0x34, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x38,
  0x20, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x3E, 0xF4, 0x63, 0x18, 0xC6, 0x7C, 0x84, 0x21, 0x08, 0x00, 0x3E,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E,
  0x04, 0x04, 0x02, 0xF2, 0x28, 0x61, 0x86, 0x2D, 0x28, 0x92, 0x48, 0xA2,
  0x84, 0x7E, 0x08, 0x20, 0x81, 0x03, 0x02, 0x04, 0x10, 0x41, 0xF8, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0x81, 0x81, 0x82, 0x42, 0x42, 0x44, 0x44, 0x24, 0x24, 0x28, 0x18, 0x18,
  0x10, 0x82, 0x0C, 0x10, 0x51, 0x84, 0x8A, 0x24, 0x51, 0x22, 0x89, 0x14,
  0x85, 0x14, 0x28, 0xA1, 0x45, 0x0A, 0x30, 0x20, 0x81, 0x04, 0x00, 0x82,
  0x89, 0x11, 0x42, 0x82, 0x04, 0x14, 0x28, 0x49, 0x12, 0x28, 0x20, 0x83,
  0x09, 0x12, 0x24, 0x85, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0xFC,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x08, 0x20, 0xFC, 0xF2, 0x49, 0x24,
  0x92, 0x49, 0x27, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x08, 0x18, 0x24, 0x24, 0x42,
  0x42, 0x81, 0xFE, 0xA4, 0x74, 0x42, 0x13, 0xA6, 0x31, 0x8F, 0xC0, 0x81,
  0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x5F, 0x00,
  0x3A, 0x21, 0x08, 0x42, 0x10, 0x83, 0xC0, 0x04, 0x10, 0x41, 0x3D, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x31, 0x28, 0x61, 0xFE, 0x08, 0x20,
  0x81, 0xF0, 0x19, 0x10, 0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x39,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x07, 0xE0, 0x82, 0x08,
  0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x8F, 0xF8, 0x40,
  0x55, 0x55, 0x55, 0xC0, 0x84, 0x21, 0x08, 0x46, 0x54, 0xA7, 0x25, 0x28,
  0xC4, 0xFF, 0xFC, 0x33, 0xB3, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46,
  0x11, 0x84, 0x61, 0x10, 0x3B, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10,
  0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x39, 0x8A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xC5, 0x72, 0x04, 0x08, 0x10, 0x00, 0x39, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x04, 0x10, 0x3C, 0x88, 0x88, 0x88,
  0x88, 0x7C, 0x21, 0x04, 0x18, 0x21, 0x0F, 0x80, 0x44, 0xF4, 0x44, 0x44,
  0x44, 0x47, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x86, 0x14, 0x92,
  0x49, 0x43, 0x0C, 0x20, 0x84, 0x63, 0x14, 0xC5, 0x2A, 0x52, 0x94, 0xA3,
  0x28, 0x84, 0x21, 0x00, 0x45, 0x22, 0x84, 0x10, 0xA4, 0x91, 0x84, 0x85,
  0x14, 0x52, 0x48, 0xA3, 0x04, 0x10, 0x42, 0x08, 0xC0, 0xF1, 0x22, 0x44,
  0x88, 0xF0, 0x12, 0x44, 0x44, 0x44, 0xC4, 0x44, 0x44, 0x21, 0xFF, 0xFF,
  0xC0, 0xC2, 0x22, 0x22, 0x22, 0x32, 0x22, 0x22, 0x2C, 0xFC,
};

const GFXglyph NotoSans_Condensed_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 13, 4, 1, -13 },
  { 3, 3, 5, 5, 1, -13 },
  { 5, 8, 13, 9, 0, -13 },
  { 18, 6, 15, 8, 1, -14 },
  { 30, 10, 13, 11, 1, -13 },
  { 47, 7, 13, 9, 1, -13 },
  { 59, 1, 5, 3, 1, -13 },
  { 60, 3, 16, 5, 1, -13 },
  { 66, 3, 16, 5, 1, -13 },
  { 72, 5, 6, 7, 1, -14 },
  { 76, 6, 9, 8, 1, -11 },
  { 83, 1, 4, 3, 1, -2 },
  { 84, 4, 1, 5, 1, -5 },
  { 85, 1, 1, 3, 1, -1 },
  { 86, 6, 13, 6, 0, -13 },
  { 96, 6, 13, 8, 1, -13 },
  { 106, 3, 13, 8, 2, -13 },
  { 111, 6, 13, 8, 1, -13 },
  { 121, 6, 13, 8, 1, -13 },
  { 131, 8, 13, 8, 0, -13 },
  { 144, 6, 13, 8, 1, -13 },
  { 154, 6, 13, 8, 1, -13 },
  { 164, 6, 13, 8, 1, -13 },
  { 174, 6, 13, 8, 1, -13 },
  { 184, 6, 13, 8, 1, -13 },
  { 194, 1, 10, 3, 1, -10 },
  { 196, 1, 12, 3, 1, -10 },
  { 198, 6, 7, 8, 1, -10 },
  { 204, 6, 4, 8, 1, -8 },
  { 207, 6, 7, 8, 1, -10 },
  { 213, 5, 13, 6, 0, -13 },
  { 222, 10, 15, 12, 1, -13 },
  { 241, 8, 13, 8, 0, -13 },
  { 254, 6, 13, 9, 2, -13 },
  { 264, 7, 13, 9, 1, -13 },
  { 276, 7, 13, 10, 2, -13 },
  { 288, 5, 13, 8, 2, -13 },
  { 297, 5, 13, 7, 2, -13 },
  { 306, 8, 13, 10, 1, -13 },
  { 319, 6, 13, 10, 2, -13 },
  { 329, 2, 13, 4, 1, -13 },
  { 333, 3, 16, 4, -1, -13 },
  { 339, 6, 13, 8, 2, -13 },
  { 349, 5, 13, 7, 2, -13 },
  { 358, 9, 13, 13, 2, -13 },
  { 373, 7, 13, 10, 2, -13 },
  { 385, 8, 13, 11, 1, -13 },
  { 398, 5, 13, 8, 2, -13 },
  { 407, 8, 16, 11, 1, -13 },
  { 423, 6, 13, 8, 2, -13 },
  { 433, 6, 13, 8, 1, -13 },
  { 443, 7, 13, 7, 0, -13 },
  { 455, 8, 13, 10, 1, -13 },
  { 468, 8, 13, 8, 0, -13 },
  { 481, 13, 13, 13, 0, -13 },
  { 503, 7, 13, 7, 0, -13 },
  { 515, 7, 13, 7, 0, -13 },
  { 527, 6, 13, 7, 1, -13 },
  { 537, 3, 16, 6, 2, -13 },
  { 543, 6, 13, 6, 0, -13 },
  { 553, 3, 16, 6, 1, -13 },
  { 559, 8, 7, 8, 0, -13 },
  { 566, 7, 1, 7, 0, 1 },
  { 567, 2, 3, 4, 1, -14 },
  { 568, 5, 10, 7, 1, -10 },
  { 575, 7, 14, 9, 1, -14 },
  { 588, 5, 10, 7, 1, -10 },
  { 595, 6, 14, 9, 1, -14 },
  { 606, 6, 10, 8, 1, -10 },
  { 614, 5, 14, 4, 0, -14 },
  { 623, 6, 14, 8, 1, -10 },
  { 634, 6, 14, 8, 1, -14 },
  { 645, 1, 13, 3, 1, -13 },
  { 647, 2, 17, 3, 0, -13 },
  { 652, 5, 14, 7, 1, -14 },
  { 661, 1, 14, 3, 1, -14 },
  { 663, 10, 10, 12, 1, -10 },
  { 676, 6, 10, 8, 1, -10 },
  { 684, 6, 10, 8, 1, -10 },
  { 692, 7, 14, 8, 1, -10 },
  { 705, 6, 14, 8, 1, -10 },
  { 716, 4, 10, 5, 1, -10 },
  { 721, 5, 10, 6, 1, -10 },
  { 728, 4, 12, 4, 0, -12 },
  { 734, 6, 9, 8, 1, -9 },
  { 741, 6, 9, 6, 0, -9 },
  { 748, 10, 9, 10, 0, -9 },
  { 760, 6, 9, 7, 0, -9 },
  { 767, 6, 13, 6, 0, -9 },
  { 777, 4, 9, 6, 1, -9 },
  { 782, 4, 16, 6, 1, -13 },
  { 790, 1, 18, 8, 3, -14 },
  { 793, 4, 16, 6, 1, -13 },
  { 801, 6, 1, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Thin18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_THIN18PT7B_H_
