#ifndef _NOTOSANS_CONDENSED_THIN46PT7B_H_
#define _NOTOSANS_CONDENSED_THIN46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x17, 0x60, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x81,
  0x81, 0x81, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x60, 0x20, 0x03, 0x03,
  0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x00, 0x08, 0x08, 0x1F, 0xFF, 0xFE, 0x04, 0x06, 0x00, 0x20, 0x20,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x30,
  0x10, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40, 0x7F, 0xFF, 0xF0,
  0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x60, 0x60, 0x02, 0x03,
  0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x00, 0x18, 0x18, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x0F,
  0xF8, 0x31, 0x0E, 0x61, 0x00, 0x41, 0x00, 0xC1, 0x00, 0x81, 0x00, 0x81,
  0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x41, 0x00, 0x61, 0x00, 0x31,
  0x00, 0x19, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x60, 0x01, 0x18, 0x01,
  0x0C, 0x01, 0x06, 0x01, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x01, 0x02, 0x81, 0x04, 0xF1, 0x18, 0x3F,
  0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1F, 0x00, 0x30,
  0x10, 0xC0, 0x10, 0x18, 0x20, 0x08, 0x08, 0x18, 0x08, 0x04, 0x04, 0x04,
  0x02, 0x02, 0x06, 0x03, 0x01, 0x02, 0x01, 0x80, 0x81, 0x00, 0x80, 0x41,
  0x00, 0x40, 0x20, 0x80, 0x20, 0x10, 0xC0, 0x10, 0x08, 0x40, 0x0C, 0x04,
  0x20, 0x06, 0x02, 0x31, 0xE1, 0x01, 0x11, 0x08, 0x80, 0x99, 0x82, 0x40,
  0x88, 0x81, 0x30, 0x44, 0x40, 0xCC, 0x66, 0x60, 0x23, 0xE2, 0x20, 0x10,
  0x01, 0x10, 0x08, 0x01, 0x08, 0x04, 0x00, 0x84, 0x02, 0x00, 0xC2, 0x01,
  0x00, 0x41, 0x00, 0x80, 0x20, 0x80, 0x40, 0x20, 0x40, 0x20, 0x10, 0x30,
  0x10, 0x18, 0x08, 0x18, 0x08, 0x04, 0x08, 0x04, 0x02, 0x04, 0x04, 0x00,
  0x84, 0x02, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xC3, 0x00, 0x18, 0x10,
  0x01, 0x01, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00,
  0x80, 0x10, 0x08, 0x01, 0x01, 0x80, 0x08, 0x10, 0x00, 0x83, 0x00, 0x04,
  0x60, 0x00, 0x4C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x01,
  0x88, 0x00, 0x30, 0xC0, 0x06, 0x04, 0x02, 0x40, 0x20, 0x6C, 0x03, 0x04,
  0x80, 0x10, 0x48, 0x00, 0x84, 0x80, 0x04, 0x88, 0x00, 0x68, 0x80, 0x03,
  0x88, 0x00, 0x10, 0xC0, 0x03, 0x84, 0x00, 0x68, 0x60, 0x0C, 0x43, 0x01,
  0x86, 0x1F, 0xE0, 0x30, 0xFA, 0xAA, 0xAA, 0x01, 0x02, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x10, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02,
  0x02, 0x02, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03,
  0x84, 0x71, 0xD6, 0x00, 0xE0, 0x02, 0x80, 0x12, 0x00, 0xC4, 0x02, 0x08,
  0x10, 0x30, 0x80, 0x40, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x3F, 0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x32, 0x22, 0x66, 0x44, 0xC8, 0x80, 0xFF, 0xE0, 0x5F, 0x80, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x0C, 0x18, 0x18, 0x0C, 0x10,
  0x04, 0x20, 0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40,
  0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20,
  0x02, 0x20, 0x04, 0x10, 0x04, 0x18, 0x08, 0x0C, 0x18, 0x07, 0xF0, 0x01,
  0x07, 0x0D, 0x19, 0x31, 0x61, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x0F, 0xE0, 0x30, 0x38,
  0x40, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0x1F, 0xE0, 0x70, 0x18, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0xC0, 0x18, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x19,
  0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x04, 0x10, 0x00, 0x82,
  0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x60, 0x20, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x80, 0x08,
  0x30, 0x01, 0x04, 0x00, 0x20, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x7F, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x40, 0x3F, 0xF8, 0x20, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x60, 0x18, 0x7F, 0xC0, 0x03, 0xFC, 0x0C, 0x08, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0xFC, 0x26, 0x0C, 0x58, 0x04, 0xE0,
  0x05, 0x80, 0x0A, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x4C,
  0x00, 0x88, 0x02, 0x08, 0x0C, 0x0F, 0xF0, 0x02, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x07, 0xF0, 0x18, 0x18, 0x30, 0x04, 0x20, 0x02, 0x60,
  0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x02, 0x20,
  0x02, 0x30, 0x04, 0x18, 0x0C, 0x0C, 0x10, 0x07, 0x60, 0x01, 0x80, 0x06,
  0x60, 0x0C, 0x30, 0x10, 0x0C, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40,
  0x03, 0x40, 0x02, 0x20, 0x06, 0x18, 0x0C, 0x0F, 0xF0, 0x0F, 0xE0, 0x18,
  0x10, 0x30, 0x08, 0x60, 0x04, 0x40, 0x04, 0x40, 0x02, 0xC0, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x0D, 0x10, 0x19, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x3F, 0xC0, 0x04, 0x00, 0xFD, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xBF, 0x77, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x22, 0x26, 0x64, 0x4C, 0x88, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0x8C, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x44,
  0x00, 0x20, 0x08, 0x80, 0x3F, 0x81, 0x30, 0x18, 0x10, 0x34, 0x02, 0x02,
  0x02, 0x80, 0x80, 0x40, 0x50, 0x10, 0x08, 0x0A, 0x06, 0x03, 0x01, 0x40,
  0x80, 0x60, 0x38, 0x10, 0x0C, 0x07, 0x02, 0x01, 0x80, 0xE0, 0x40, 0x30,
  0x1C, 0x08, 0x06, 0x03, 0x81, 0x00, 0x80, 0x50, 0x20, 0x10, 0x1A, 0x06,
  0x05, 0x02, 0x40, 0x40, 0xA0, 0x48, 0x08, 0x34, 0x11, 0x00, 0xCC, 0x46,
  0x30, 0x0F, 0x07, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x00, 0x90, 0x00, 0x09,
  0x00, 0x00, 0x88, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0xC0, 0x03,
  0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x60, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x00, 0xFF, 0xF0,
  0x08, 0x01, 0x81, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00,
  0xC2, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x2C, 0x00, 0x03, 0x80, 0x00, 0x10, 0xFF, 0xC0, 0x80,
  0xF8, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x0C, 0x80, 0x18, 0xFF, 0xE0, 0x80, 0x78, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C, 0x80,
  0x38, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x02, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x20, 0x7C, 0x08, 0x01,
  0xC2, 0x00, 0x18, 0x80, 0x02, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x20,
  0x01, 0x08, 0x01, 0x82, 0x01, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x1C, 0x03, 0x81, 0x80, 0x04, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x58, 0x00, 0x02, 0x40, 0x00, 0x11, 0x00,
  0x00, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x20, 0x60, 0x07, 0x01, 0xFF, 0xE0,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0xFE, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x86, 0xFC, 0x80, 0x03, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x10, 0x80, 0x30, 0x80, 0x60, 0x80,
  0x40, 0x80, 0xC0, 0x81, 0x80, 0x81, 0x00, 0x82, 0x00, 0x86, 0x00, 0x8C,
  0x00, 0x88, 0x00, 0x94, 0x00, 0xB6, 0x00, 0xA2, 0x00, 0xC3, 0x00, 0x81,
  0x00, 0x81, 0x80, 0x80, 0x80, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80,
  0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x7A, 0x00, 0x00,
  0x7D, 0x80, 0x00, 0x2E, 0x40, 0x00, 0x17, 0x20, 0x00, 0x1B, 0x98, 0x00,
  0x09, 0xC4, 0x00, 0x04, 0xE2, 0x00, 0x06, 0x71, 0x80, 0x02, 0x38, 0x40,
  0x01, 0x1C, 0x20, 0x01, 0x8E, 0x18, 0x00, 0x87, 0x04, 0x00, 0x43, 0x82,
  0x00, 0x61, 0xC1, 0x80, 0x20, 0xE0, 0x40, 0x10, 0x70, 0x20, 0x18, 0x38,
  0x18, 0x08, 0x1C, 0x04, 0x04, 0x0E, 0x02, 0x06, 0x07, 0x01, 0x82, 0x03,
  0x80, 0x41, 0x01, 0xC0, 0x21, 0x80, 0xE0, 0x18, 0x80, 0x70, 0x04, 0x40,
  0x38, 0x02, 0x60, 0x1C, 0x01, 0xA0, 0x0E, 0x00, 0x50, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x80, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x19, 0x00, 0x06, 0x20, 0x01, 0x88,
  0x00, 0x61, 0x00, 0x18, 0x40, 0x06, 0x08, 0x01, 0x83, 0x00, 0x60, 0x40,
  0x18, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x18, 0x06, 0x06,
  0x00, 0x81, 0x80, 0x30, 0x60, 0x04, 0x18, 0x01, 0x86, 0x00, 0x21, 0x80,
  0x0C, 0x60, 0x01, 0x18, 0x00, 0x66, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00,
  0x58, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0x30,
  0x18, 0x02, 0x00, 0x20, 0x20, 0x00, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11,
  0x00, 0x00, 0xC8, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x40,
  0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06,
  0x08, 0x00, 0x20, 0x20, 0x02, 0x00, 0xC0, 0x60, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0x03, 0xC2, 0x00, 0x64, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50,
  0x00, 0xA0, 0x03, 0x40, 0x04, 0x80, 0x19, 0x01, 0xC3, 0xFE, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x30, 0x18, 0x02, 0x00, 0x20, 0x20, 0x00, 0x83,
  0x00, 0x06, 0x10, 0x00, 0x11, 0x00, 0x00, 0xC8, 0x00, 0x02, 0xC0, 0x00,
  0x16, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x0C,
  0x40, 0x00, 0x43, 0x00, 0x06, 0x08, 0x00, 0x20, 0x20, 0x02, 0x00, 0xC0,
  0x60, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0xFF, 0x80, 0x80, 0xF0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x18, 0x80, 0x70, 0xFF,
  0xC0, 0x81, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x60, 0x80,
  0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80,
  0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x07, 0xFC, 0x1C, 0x06, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0xC0, 0x18, 0x7F,
  0xF0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0B, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00, 0x42, 0x00, 0x30, 0x60, 0x18,
  0x0F, 0xF8, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x06, 0x40, 0x00, 0x46, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20,
  0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x81, 0x00, 0x10, 0x18, 0x01, 0x00,
  0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x20, 0x0C, 0x02, 0x00, 0x40, 0x20,
  0x04, 0x04, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08,
  0x00, 0x30, 0x80, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x09,
  0x00, 0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x24, 0x00, 0x28, 0x00, 0x48, 0x00, 0x50,
  0x00, 0x90, 0x01, 0xA0, 0x03, 0x30, 0x02, 0x60, 0x06, 0x20, 0x04, 0x40,
  0x08, 0x40, 0x08, 0x80, 0x10, 0x80, 0x31, 0x00, 0x21, 0x00, 0x62, 0x00,
  0xC3, 0x00, 0x86, 0x01, 0x02, 0x01, 0x04, 0x02, 0x04, 0x02, 0x08, 0x04,
  0x08, 0x0C, 0x10, 0x18, 0x18, 0x10, 0x30, 0x20, 0x10, 0x20, 0x20, 0x40,
  0x20, 0x40, 0x40, 0x80, 0x41, 0x80, 0x83, 0x00, 0xC3, 0x01, 0x04, 0x00,
  0x84, 0x03, 0x08, 0x01, 0x08, 0x02, 0x10, 0x02, 0x10, 0x04, 0x60, 0x04,
  0x60, 0x08, 0xC0, 0x0C, 0x80, 0x19, 0x00, 0x09, 0x00, 0x12, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x24, 0x00, 0x58, 0x00, 0x78, 0x00, 0xA0, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x90, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61, 0x80, 0x20, 0x40, 0x30, 0x30,
  0x10, 0x08, 0x18, 0x04, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x62, 0x00,
  0x12, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x48, 0x00, 0x24, 0x00, 0x31, 0x00, 0x10, 0x80, 0x18, 0x60, 0x08,
  0x10, 0x0C, 0x0C, 0x04, 0x02, 0x06, 0x01, 0x82, 0x00, 0x43, 0x00, 0x21,
  0x00, 0x09, 0x80, 0x04, 0x80, 0x03, 0xC0, 0x00, 0x80, 0x80, 0x00, 0xA0,
  0x00, 0xD0, 0x00, 0x4C, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x40, 0x18,
  0x20, 0x08, 0x18, 0x04, 0x04, 0x04, 0x02, 0x02, 0x00, 0x83, 0x00, 0x41,
  0x00, 0x30, 0x80, 0x08, 0x80, 0x04, 0x40, 0x03, 0x60, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x08, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x40, 0x00,
  0x38, 0x00, 0x0A, 0x00, 0x06, 0xC0, 0x01, 0x10, 0x00, 0xC6, 0x00, 0x20,
  0x80, 0x18, 0x30, 0x04, 0x04, 0x03, 0x01, 0x80, 0x80, 0x20, 0x60, 0x0C,
  0x10, 0x01, 0x0C, 0x00, 0x62, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0x40,
  0xFF, 0xFF, 0xC0, 0xC0, 0x80, 0x81, 0x81, 0x81, 0x81, 0x80, 0x07, 0x81,
  0xF7, 0x08, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x01, 0xF0, 0xF0, 0x98, 0x05, 0x80, 0x28, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xE0, 0x0D, 0x00, 0xAC,
  0x0D, 0x3F, 0xC8, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1,
  0xE0, 0xC7, 0x78, 0xD8, 0x0C, 0xD0, 0x06, 0xE0, 0x02, 0xE0, 0x02, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xE0, 0x02, 0xE0, 0x06, 0xD0, 0x04, 0xC8, 0x18, 0xC7,
  0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x01, 0x07, 0xF8, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x01, 0xC1, 0x0F, 0x71, 0x18, 0x09, 0x30,
  0x05, 0x20, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x03, 0x20,
  0x05, 0x30, 0x05, 0x18, 0x19, 0x0F, 0xF1, 0x03, 0xC0, 0x1E, 0xE0, 0x60,
  0x61, 0x80, 0x62, 0x00, 0x4C, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x06, 0x03, 0x07, 0xFC, 0x03, 0xF0, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x01,
  0xC0, 0x0F, 0x79, 0x18, 0x0D, 0x30, 0x05, 0x20, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40,
  0x03, 0x40, 0x03, 0x60, 0x03, 0x20, 0x05, 0x30, 0x0D, 0x18, 0x19, 0x0F,
  0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x40, 0x0C, 0x70, 0x38, 0x1F, 0xE0, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x38, 0x27, 0xB8, 0xB0, 0x32, 0x80, 0x6C,
  0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0xDD, 0x00, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x40, 0x0C, 0x30, 0x40, 0x00, 0x00, 0x00, 0x00, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x21, 0xBC, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x68, 0x06, 0x40, 0x22, 0x02, 0x10,
  0x30, 0x83, 0x04, 0x10, 0x21, 0x01, 0x18, 0x08, 0x80, 0x4E, 0x02, 0xD0,
  0x14, 0xC0, 0xC2, 0x04, 0x18, 0x20, 0x41, 0x03, 0x08, 0x08, 0x40, 0x22,
  0x01, 0x10, 0x0C, 0x80, 0x24, 0x00, 0xA0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x60, 0x9D, 0xC3, 0x9C, 0xB0, 0x62, 0x06, 0xE0, 0x24,
  0x02, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x10, 0x01, 0x03, 0x82, 0x7B, 0x8B, 0x01, 0x28, 0x06, 0xC0,
  0x0B, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x01, 0xC0, 0x07, 0xBC, 0x06, 0x03, 0x06, 0x00, 0xC2, 0x00, 0x23, 0x00,
  0x19, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x58,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x26, 0x00, 0x21, 0x00, 0x10, 0x40,
  0x10, 0x30, 0x18, 0x07, 0xF0, 0x00, 0x03, 0x81, 0x1D, 0xE2, 0x40, 0x65,
  0x00, 0x6C, 0x00, 0x58, 0x00, 0xB0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x5C, 0x01, 0xA8,
  0x02, 0x4C, 0x18, 0x8F, 0xE1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xC0, 0x0F, 0x71, 0x18, 0x09, 0x30, 0x05, 0x20, 0x03,
  0x60, 0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x20, 0x05, 0x30, 0x0D,
  0x18, 0x19, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x07, 0x4F, 0xEC, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x03, 0x81, 0xFF, 0x98, 0x04,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xD8, 0x0C, 0x7F, 0xC0,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x83, 0xFE, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x7C, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x80,
  0x53, 0x02, 0x47, 0xF1, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x22,
  0x00, 0x44, 0x01, 0x88, 0x02, 0x18, 0x04, 0x10, 0x18, 0x20, 0x20, 0x40,
  0x40, 0xC0, 0x80, 0x83, 0x01, 0x04, 0x03, 0x08, 0x02, 0x30, 0x04, 0x40,
  0x08, 0x80, 0x19, 0x00, 0x16, 0x00, 0x28, 0x00, 0x50, 0x00, 0x60, 0x00,
  0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14,
  0x03, 0x40, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x60, 0x22,
  0x06, 0x20, 0x62, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x30, 0x41,
  0x04, 0x10, 0xC1, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x18, 0x80,
  0x88, 0x09, 0x80, 0x98, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x0D, 0x00,
  0xD0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xC0, 0x04, 0xC0, 0x18, 0x80, 0x21, 0x80, 0x81, 0x01, 0x03, 0x04,
  0x02, 0x18, 0x06, 0x20, 0x04, 0xC0, 0x05, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0x38, 0x00, 0x50, 0x01, 0x30, 0x06, 0x20, 0x08, 0x60, 0x30, 0x40, 0x40,
  0xC1, 0x80, 0x82, 0x00, 0x8C, 0x01, 0x10, 0x01, 0x60, 0x03, 0x40, 0x03,
  0x40, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x30, 0x04, 0x10, 0x04,
  0x10, 0x0C, 0x10, 0x08, 0x08, 0x08, 0x08, 0x18, 0x08, 0x10, 0x0C, 0x10,
  0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40,
  0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x88, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x70, 0x1C, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x07, 0x00, 0xF0,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x1E, 0x00, 0xF0, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x0F, 0x00, 0x3E,
  0x00, 0xE0, 0xC0, 0x60, 0x1F, 0xC0, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 33, 9, 3, -33 },
  { 14, 8, 12, 14, 3, -33 },
  { 26, 21, 33, 23, 1, -33 },
  { 113, 16, 38, 21, 2, -35 },
  { 189, 25, 33, 29, 2, -33 },
  { 293, 20, 33, 22, 2, -33 },
  { 376, 2, 12, 8, 3, -33 },
  { 379, 8, 40, 12, 2, -33 },
  { 419, 8, 40, 12, 2, -33 },
  { 459, 14, 14, 19, 2, -35 },
  { 484, 17, 21, 21, 2, -27 },
  { 529, 4, 11, 8, 2, -5 },
  { 535, 11, 1, 13, 1, -13 },
  { 537, 3, 3, 9, 3, -3 },
  { 539, 13, 33, 15, 1, -33 },
  { 593, 16, 33, 21, 2, -33 },
  { 659, 8, 33, 21, 4, -33 },
  { 692, 16, 33, 21, 2, -33 },
  { 758, 16, 33, 21, 2, -33 },
  { 824, 19, 33, 21, 1, -33 },
  { 903, 15, 33, 21, 3, -33 },
  { 965, 15, 34, 21, 3, -33 },
  { 1029, 16, 33, 21, 2, -33 },
  { 1095, 16, 33, 21, 2, -33 },
  { 1161, 16, 34, 21, 2, -33 },
  { 1229, 3, 24, 9, 3, -24 },
  { 1238, 4, 30, 9, 2, -24 },
  { 1253, 17, 19, 21, 2, -26 },
  { 1294, 17, 11, 21, 2, -22 },
  { 1318, 17, 19, 21, 2, -26 },
  { 1359, 12, 33, 14, 1, -33 },
  { 1409, 27, 37, 32, 2, -33 },
  { 1534, 20, 33, 20, 0, -33 },
  { 1617, 16, 33, 22, 4, -33 },
  { 1683, 18, 33, 22, 3, -33 },
  { 1758, 18, 33, 25, 4, -33 },
  { 1833, 13, 33, 20, 4, -33 },
  { 1887, 13, 33, 18, 4, -33 },
  { 1941, 21, 33, 27, 3, -33 },
  { 2028, 17, 33, 25, 4, -33 },
  { 2099, 7, 33, 11, 2, -33 },
  { 2128, 8, 41, 9, -3, -33 },
  { 2169, 16, 33, 20, 4, -33 },
  { 2235, 13, 33, 18, 4, -33 },
  { 2289, 25, 33, 33, 4, -33 },
  { 2393, 18, 33, 26, 4, -33 },
  { 2468, 21, 33, 27, 3, -33 },
  { 2555, 15, 33, 21, 4, -33 },
  { 2617, 21, 41, 27, 3, -33 },
  { 2725, 16, 33, 21, 4, -33 },
  { 2791, 16, 33, 20, 2, -33 },
  { 2857, 17, 33, 18, 0, -33 },
  { 2928, 18, 33, 25, 4, -33 },
  { 3003, 20, 33, 20, 0, -33 },
  { 3086, 31, 33, 33, 1, -33 },
  { 3214, 17, 33, 18, 0, -33 },
  { 3285, 17, 33, 17, 0, -33 },
  { 3356, 16, 33, 18, 1, -33 },
  { 3422, 9, 40, 14, 4, -33 },
  { 3467, 13, 33, 15, 1, -33 },
  { 3521, 8, 40, 14, 2, -33 },
  { 3561, 18, 17, 21, 1, -33 },
  { 3600, 18, 1, 18, 0, 4 },
  { 3603, 7, 7, 11, 2, -35 },
  { 3610, 13, 25, 19, 2, -25 },
  { 3651, 16, 35, 22, 3, -35 },
  { 3721, 14, 25, 17, 2, -25 },
  { 3765, 16, 35, 22, 2, -35 },
  { 3835, 15, 25, 20, 2, -25 },
  { 3882, 12, 35, 11, 0, -35 },
  { 3935, 16, 36, 22, 2, -25 },
  { 4007, 14, 35, 21, 4, -35 },
  { 4069, 3, 33, 9, 3, -33 },
  { 4082, 6, 44, 9, -1, -33 },
  { 4115, 13, 35, 17, 4, -35 },
  { 4172, 1, 35, 8, 4, -35 },
  { 4177, 24, 25, 31, 4, -25 },
  { 4252, 14, 25, 21, 4, -25 },
  { 4296, 17, 25, 21, 2, -25 },
  { 4350, 15, 36, 22, 4, -25 },
  { 4418, 16, 36, 22, 2, -25 },
  { 4490, 9, 25, 14, 4, -25 },
  { 4519, 13, 25, 16, 2, -25 },
  { 4560, 9, 30, 11, 1, -30 },
  { 4594, 14, 24, 21, 3, -24 },
  { 4636, 15, 24, 15, 0, -24 },
  { 4681, 24, 24, 26, 1, -24 },
  { 4753, 15, 24, 17, 1, -24 },
  { 4798, 16, 35, 16, 0, -24 },
  { 4868, 11, 24, 15, 2, -24 },
  { 4901, 12, 40, 16, 2, -33 },
  { 4961, 1, 46, 20, 9, -35 },
  { 4967, 12, 40, 16, 2, -33 },
  { 5027, 17, 4, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_Thin46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_THIN46PT7B_H_
