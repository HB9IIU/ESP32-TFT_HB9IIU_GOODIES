#ifndef _NOTOSANS_CONDENSED_THIN25PT7B_H_
#define _NOTOSANS_CONDENSED_THIN25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xC0, 0x99, 0x99, 0x99, 0x90, 0x08, 0x82, 0x10, 0x42,
  0x08, 0x41, 0x11, 0xFF, 0xC4, 0x40, 0x88, 0x21, 0x04, 0x20, 0x84, 0x7F,
  0xE2, 0x20, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0x40, 0x08, 0x0F, 0x1A,
  0x51, 0x08, 0x84, 0x42, 0x21, 0x10, 0x48, 0x1C, 0x03, 0x01, 0x60, 0x88,
  0x44, 0x22, 0x11, 0x09, 0x65, 0x0B, 0x01, 0x00, 0x30, 0x21, 0x21, 0x08,
  0x44, 0x21, 0x10, 0x84, 0x82, 0x12, 0x08, 0x50, 0x21, 0x4C, 0x85, 0x49,
  0x2A, 0x13, 0x28, 0x40, 0xA1, 0x04, 0x84, 0x12, 0x10, 0x88, 0x42, 0x21,
  0x08, 0x48, 0x41, 0xE0, 0x1C, 0x04, 0x41, 0x08, 0x21, 0x04, 0x20, 0x44,
  0x09, 0x00, 0xC0, 0x10, 0x05, 0x01, 0x11, 0x42, 0x28, 0x25, 0x02, 0xA0,
  0x24, 0x04, 0x41, 0x47, 0xC4, 0xFE, 0x18, 0x88, 0x44, 0x21, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x08, 0x41, 0x0C, 0x84, 0x42, 0x21, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x08, 0x08, 0x89, 0x6E, 0x18,
  0x24, 0x24, 0x42, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x55, 0xA0, 0xF8, 0xC0, 0x02, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x00, 0x1E, 0x10, 0x90, 0x48, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x82, 0x21, 0x0F, 0x00, 0x09, 0xD3,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x7E, 0x40,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x7F, 0xC0, 0x7E, 0x40, 0x80, 0x40, 0x20,
  0x08, 0x08, 0x04, 0x04, 0x3C, 0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x7F, 0x00, 0x01, 0x00, 0x20, 0x0A, 0x01, 0x40, 0x48, 0x11,
  0x02, 0x20, 0x84, 0x10, 0x84, 0x10, 0x82, 0x20, 0x44, 0x09, 0x7F, 0xC0,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xF8, 0x42, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x7F, 0x00, 0x0F, 0x08, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x3C, 0xA1,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x02, 0x81, 0x41, 0x1F, 0x00, 0xFF,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x00, 0x3E, 0x20, 0x90, 0x30,
  0x18, 0x0A, 0x09, 0x04, 0x6C, 0x08, 0x1B, 0x10, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x41, 0x1F, 0x00, 0x3C, 0x21, 0x20, 0x50, 0x28, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xA0, 0xCF, 0xA0, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x3E, 0x00, 0x80, 0x18, 0x40, 0x00, 0x05, 0x5A, 0x00, 0x81, 0x83, 0x06,
  0x0C, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0x00, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x42, 0x10, 0x82, 0x10,
  0x41, 0x00, 0x00, 0x41, 0x80, 0x07, 0xE0, 0x10, 0x20, 0x40, 0x21, 0x00,
  0x24, 0x00, 0x48, 0x38, 0x50, 0x88, 0xC2, 0x21, 0x88, 0x43, 0x10, 0x86,
  0x21, 0x0C, 0x42, 0x18, 0x84, 0x30, 0x88, 0x91, 0xEF, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x04, 0x01, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x22, 0x04, 0x40, 0x88, 0x11, 0x04, 0x10, 0xFE, 0x10, 0x44,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x30, 0x04, 0xFE, 0x40, 0xA0, 0x50,
  0x18, 0x0C, 0x06, 0x05, 0x02, 0xFE, 0x41, 0xA0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x7F, 0x00, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x03, 0xF0, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02,
  0x83, 0x3F, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFC, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x0F, 0xE1, 0x01, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x12,
  0x01, 0x10, 0x10, 0xFE, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xFF, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0xF8, 0x81, 0xC0, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x41, 0x40, 0xA0,
  0x68, 0x22, 0x11, 0x08, 0x44, 0x22, 0x09, 0x02, 0x81, 0x40, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0xFC, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x05, 0xA0, 0x16,
  0x80, 0x5A, 0x02, 0x64, 0x09, 0x90, 0x26, 0x41, 0x18, 0x84, 0x62, 0x11,
  0x88, 0x86, 0x12, 0x18, 0x48, 0x61, 0x41, 0x83, 0x06, 0x08, 0x10, 0x80,
  0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x19, 0x06, 0x21, 0x88, 0x61, 0x18,
  0x46, 0x09, 0x82, 0x60, 0x58, 0x16, 0x03, 0x80, 0xE0, 0x10, 0x0F, 0x83,
  0x04, 0x20, 0x24, 0x02, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x22, 0x02, 0x20, 0x41,
  0xF8, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x8C, 0xF0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x81, 0x04, 0x20, 0x24,
  0x02, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x12, 0x02, 0x20, 0x41, 0xF8, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x82, 0x7E, 0x22, 0x10, 0x88, 0x44, 0x12, 0x09, 0x02, 0x81, 0x40,
  0x40, 0x3F, 0x20, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x7F, 0x00, 0xFF, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x02, 0x40, 0x8F, 0xC0, 0x80, 0x30, 0x0A, 0x01,
  0x20, 0x24, 0x04, 0x81, 0x08, 0x21, 0x04, 0x21, 0x04, 0x20, 0x44, 0x08,
  0x81, 0x20, 0x24, 0x02, 0x80, 0x50, 0x0C, 0x00, 0x80, 0x80, 0x80, 0x60,
  0x30, 0x24, 0x0C, 0x09, 0x03, 0x02, 0x41, 0x40, 0x90, 0x48, 0x42, 0x12,
  0x10, 0x84, 0x84, 0x21, 0x21, 0x08, 0x88, 0x81, 0x21, 0x20, 0x48, 0x48,
  0x12, 0x12, 0x05, 0x04, 0x81, 0x40, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x02,
  0x02, 0x00, 0x40, 0xA0, 0x48, 0x44, 0x21, 0x20, 0x90, 0x48, 0x18, 0x08,
  0x06, 0x03, 0x02, 0x41, 0x21, 0x08, 0x84, 0x82, 0x40, 0xC0, 0x40, 0x80,
  0xC0, 0x50, 0x28, 0x22, 0x11, 0x10, 0x88, 0x24, 0x14, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0xFF, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x7C, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x08, 0x03,
  0x01, 0x40, 0x48, 0x22, 0x08, 0x44, 0x11, 0x02, 0x80, 0xC0, 0xFF, 0xC0,
  0x84, 0x21, 0x7C, 0x04, 0x08, 0x10, 0x21, 0xCC, 0xA1, 0x83, 0x06, 0x0C,
  0x17, 0xE0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xC2, 0x99, 0x82, 0x81,
  0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x61, 0x2F, 0x80,
  0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x03, 0xE0,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x64, 0xCA, 0x83, 0x40, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40, 0xA0, 0xCF, 0xA0, 0x3E, 0x41,
  0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x1E,
  0x40, 0x81, 0x02, 0x04, 0x3E, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x3E, 0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x50, 0x28, 0x33, 0xE8, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x9F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x98, 0xA6, 0xC2, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC7, 0xFF, 0xC0,
  0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4E, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x61, 0x42, 0x89, 0x22, 0x85, 0x0D, 0x12, 0x22, 0x44, 0x85,
  0x0A, 0x08, 0xFF, 0xFF, 0xE0, 0xFC, 0xF4, 0x18, 0x60, 0x83, 0x04, 0x18,
  0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x20, 0x80, 0xBE, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x50, 0x28, 0x23, 0xE0, 0xBE, 0x60, 0xA0, 0x50, 0x28,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x58, 0x4B, 0xE4, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x00, 0x3E, 0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x50, 0x28, 0x33, 0xE8, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x00,
  0x7F, 0x02, 0x04, 0x08, 0x0C, 0x06, 0x02, 0x02, 0x04, 0x08, 0x1F, 0xC0,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x83,
  0x7D, 0x81, 0x81, 0x41, 0x42, 0x42, 0x22, 0x22, 0x24, 0x24, 0x14, 0x18,
  0x18, 0x08, 0x81, 0x05, 0x0C, 0x14, 0x30, 0x90, 0xA2, 0x44, 0x89, 0x12,
  0x22, 0x49, 0x09, 0x14, 0x28, 0x50, 0xA1, 0x41, 0x86, 0x06, 0x08, 0x10,
  0x20, 0x41, 0x20, 0x88, 0x82, 0x41, 0x40, 0x40, 0x20, 0x28, 0x14, 0x11,
  0x08, 0x88, 0x2C, 0x18, 0x80, 0xA0, 0x90, 0x48, 0x22, 0x21, 0x10, 0x88,
  0x44, 0x14, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10,
  0x38, 0x00, 0xFC, 0x10, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0xFC,
  0x0C, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x38, 0x20, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x40, 0x83, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x13, 0x80, 0x70, 0xC7, 0xC0,
};

const GFXglyph NotoSans_Condensed_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 18, 5, 2, -18 },
  { 4, 4, 7, 8, 2, -18 },
  { 8, 11, 18, 12, 1, -18 },
  { 33, 9, 20, 11, 1, -19 },
  { 56, 14, 18, 16, 1, -18 },
  { 88, 11, 18, 12, 1, -18 },
  { 113, 1, 7, 4, 2, -18 },
  { 114, 5, 22, 7, 1, -18 },
  { 128, 4, 22, 7, 1, -18 },
  { 139, 8, 8, 10, 1, -19 },
  { 147, 9, 12, 11, 1, -15 },
  { 161, 2, 6, 4, 1, -3 },
  { 163, 5, 1, 7, 1, -7 },
  { 164, 1, 2, 5, 2, -2 },
  { 165, 7, 18, 8, 1, -18 },
  { 181, 9, 18, 11, 1, -18 },
  { 202, 5, 18, 11, 2, -18 },
  { 214, 9, 18, 11, 1, -18 },
  { 235, 9, 18, 11, 1, -18 },
  { 256, 11, 18, 11, 0, -18 },
  { 281, 9, 18, 11, 1, -18 },
  { 302, 9, 18, 11, 1, -18 },
  { 323, 9, 18, 11, 1, -18 },
  { 344, 9, 18, 11, 1, -18 },
  { 365, 9, 18, 11, 1, -18 },
  { 386, 1, 13, 5, 2, -13 },
  { 388, 2, 16, 5, 1, -13 },
  { 392, 9, 10, 11, 1, -14 },
  { 404, 9, 6, 11, 1, -12 },
  { 411, 9, 10, 11, 1, -14 },
  { 423, 6, 18, 8, 1, -18 },
  { 437, 15, 20, 17, 1, -18 },
  { 475, 11, 18, 11, 0, -18 },
  { 500, 9, 18, 12, 2, -18 },
  { 521, 10, 18, 12, 1, -18 },
  { 544, 10, 18, 13, 2, -18 },
  { 567, 7, 18, 11, 2, -18 },
  { 583, 8, 18, 10, 2, -18 },
  { 601, 12, 18, 15, 1, -18 },
  { 628, 10, 18, 14, 2, -18 },
  { 651, 4, 18, 6, 1, -18 },
  { 660, 5, 22, 5, -2, -18 },
  { 674, 9, 18, 11, 2, -18 },
  { 695, 7, 18, 10, 2, -18 },
  { 711, 14, 18, 18, 2, -18 },
  { 743, 10, 18, 14, 2, -18 },
  { 766, 12, 18, 15, 1, -18 },
  { 793, 8, 18, 11, 2, -18 },
  { 811, 12, 22, 15, 1, -18 },
  { 844, 9, 18, 11, 2, -18 },
  { 865, 9, 18, 11, 1, -18 },
  { 886, 10, 18, 10, 0, -18 },
  { 909, 10, 18, 14, 2, -18 },
  { 932, 11, 18, 11, 0, -18 },
  { 957, 18, 18, 18, 0, -18 },
  { 998, 9, 18, 10, 0, -18 },
  { 1019, 9, 18, 9, 0, -18 },
  { 1040, 8, 18, 10, 1, -18 },
  { 1058, 5, 22, 8, 2, -18 },
  { 1072, 7, 18, 8, 1, -18 },
  { 1088, 5, 22, 8, 1, -18 },
  { 1102, 10, 9, 11, 1, -18 },
  { 1114, 10, 1, 10, 0, 2 },
  { 1116, 4, 4, 6, 1, -19 },
  { 1118, 7, 13, 10, 1, -13 },
  { 1130, 9, 19, 12, 2, -19 },
  { 1152, 7, 13, 9, 1, -13 },
  { 1164, 9, 19, 12, 1, -19 },
  { 1186, 8, 13, 11, 1, -13 },
  { 1199, 7, 19, 6, 0, -19 },
  { 1216, 9, 19, 12, 1, -13 },
  { 1238, 8, 19, 11, 2, -19 },
  { 1257, 1, 18, 5, 2, -18 },
  { 1260, 3, 24, 5, 0, -18 },
  { 1269, 7, 19, 9, 2, -19 },
  { 1286, 1, 19, 4, 2, -19 },
  { 1289, 13, 13, 17, 2, -13 },
  { 1311, 8, 13, 11, 2, -13 },
  { 1324, 9, 13, 11, 1, -13 },
  { 1339, 9, 19, 12, 2, -13 },
  { 1361, 9, 19, 12, 1, -13 },
  { 1383, 5, 13, 7, 2, -13 },
  { 1392, 7, 13, 9, 1, -13 },
  { 1404, 6, 16, 6, 0, -16 },
  { 1416, 8, 13, 11, 2, -13 },
  { 1429, 8, 13, 8, 0, -13 },
  { 1442, 14, 13, 14, 0, -13 },
  { 1465, 9, 13, 9, 0, -13 },
  { 1480, 9, 19, 9, 0, -13 },
  { 1502, 6, 13, 8, 1, -13 },
  { 1512, 6, 22, 9, 1, -18 },
  { 1529, 1, 25, 11, 5, -19 },
  { 1533, 6, 22, 9, 1, -18 },
  { 1550, 9, 2, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Thin25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_THIN25PT7B_H_
