#ifndef _NOTOSANS_CONDENSED_THIN28PT7B_H_
#define _NOTOSANS_CONDENSED_THIN28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA8, 0x0B, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x41, 0x08, 0xFF, 0xF1, 0x08, 0x10,
  0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x0F, 0xFE, 0x21, 0x02, 0x10, 0x21,
  0x02, 0x10, 0x21, 0x02, 0x20, 0x08, 0x07, 0xC2, 0x89, 0x20, 0x88, 0x22,
  0x08, 0x82, 0x20, 0x48, 0x0A, 0x01, 0x80, 0x18, 0x09, 0x82, 0x20, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x8B, 0xAC, 0x1C, 0x02, 0x00, 0x80, 0x38, 0x10,
  0x88, 0x21, 0x10, 0x84, 0x21, 0x08, 0x22, 0x10, 0x48, 0x20, 0x90, 0x41,
  0x40, 0x84, 0x9C, 0x89, 0x45, 0x14, 0x89, 0xCA, 0x10, 0x24, 0x20, 0x48,
  0x40, 0x90, 0x82, 0x21, 0x04, 0x42, 0x10, 0x44, 0x20, 0x88, 0x40, 0xE0,
  0x1E, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x01, 0x20,
  0x14, 0x01, 0x80, 0x24, 0x04, 0x41, 0x42, 0x18, 0x12, 0x80, 0xA8, 0x0A,
  0x80, 0x48, 0x0A, 0x41, 0xA3, 0xE1, 0xFE, 0x08, 0x84, 0x42, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x82, 0x10, 0x41, 0x82, 0x08,
  0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x11,
  0x18, 0x08, 0x04, 0x22, 0x2F, 0xE0, 0x80, 0xA0, 0x88, 0x42, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x55, 0x68, 0xFC, 0xC0, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x1F, 0x08, 0x24, 0x09, 0x02, 0x40, 0x50, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x01,
  0x40, 0x88, 0x22, 0x10, 0x78, 0x08, 0xCB, 0x90, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x3E, 0x10, 0x40, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0xFF, 0x3F, 0x30, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x07, 0x80, 0x30, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x09, 0xFC, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x20,
  0x82, 0x08, 0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x7F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFC,
  0x01, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0xDF,
  0x80, 0x1F, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0xBE, 0x60,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x47, 0xC0,
  0xFF, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x40, 0x50, 0x14, 0x08, 0x86, 0x12,
  0x03, 0x01, 0x30, 0x82, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14,
  0x08, 0xFC, 0x3E, 0x10, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x34, 0x0C, 0xF9, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x21, 0xF0, 0xC0, 0x06, 0x4C, 0x00, 0x00, 0x00, 0x04, 0x92, 0x52,
  0x00, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x00, 0xF8, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x08, 0x10, 0x41, 0x02, 0x04, 0x08, 0x00, 0x00, 0x00,
  0x81, 0x00, 0x03, 0xF0, 0x06, 0x04, 0x04, 0x01, 0x02, 0x00, 0x42, 0x00,
  0x12, 0x00, 0x09, 0x07, 0xC4, 0x84, 0x21, 0x42, 0x10, 0xC2, 0x08, 0x61,
  0x04, 0x30, 0x82, 0x18, 0x41, 0x0C, 0x21, 0x05, 0x10, 0xC4, 0x84, 0xA2,
  0x41, 0x8E, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x61,
  0x80, 0x0E, 0x00, 0x02, 0x00, 0x60, 0x05, 0x00, 0x50, 0x09, 0x00, 0x90,
  0x08, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x43, 0xFC, 0x20, 0x42, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0xFF, 0x20, 0x28,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x81, 0xBF, 0x88, 0x1A, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0xF8, 0x0F, 0xE6,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0xC0,
  0x07, 0xE0, 0xFE, 0x10, 0x32, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x50, 0x0A, 0x06, 0x7F, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x1F, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x3F, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x00, 0x0F, 0xE1, 0x01, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x81, 0xF8, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x12, 0x01, 0x30, 0x10, 0xFF, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFE,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2F,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0xF0, 0x80, 0x60, 0x28, 0x12, 0x08, 0x82, 0x21, 0x08,
  0x82, 0x20, 0x90, 0x2C, 0x0C, 0x83, 0x20, 0x84, 0x20, 0x88, 0x22, 0x04,
  0x81, 0x20, 0x28, 0x0A, 0x01, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1D, 0x00, 0x3A, 0x00, 0x74, 0x01,
  0x64, 0x02, 0xC8, 0x05, 0x90, 0x13, 0x10, 0x26, 0x20, 0x4C, 0x41, 0x18,
  0x42, 0x30, 0x84, 0x61, 0x10, 0xC1, 0x21, 0x82, 0x43, 0x05, 0x06, 0x06,
  0x0C, 0x0C, 0x10, 0x80, 0x38, 0x06, 0x80, 0xD0, 0x19, 0x03, 0x20, 0x62,
  0x0C, 0x41, 0x84, 0x30, 0x86, 0x08, 0xC1, 0x18, 0x13, 0x02, 0x60, 0x2C,
  0x05, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x10, 0x1F, 0x81, 0x02, 0x10, 0x08,
  0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x40, 0x12, 0x01,
  0x08, 0x10, 0x3F, 0x00, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xA1, 0x9F, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x00, 0x1F, 0x81, 0x02, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x50, 0x02, 0x40, 0x12, 0x01, 0x08, 0x10, 0x3F, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0xFE, 0x20, 0x48, 0x0A,
  0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x4F, 0xC2, 0x10, 0x84,
  0x20, 0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x01, 0x1F, 0xD8, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x07, 0x00, 0x20, 0x06,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x0B, 0xFC, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x28, 0x04, 0x81, 0x0F, 0xC0, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08,
  0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x80, 0x40, 0x14, 0x06, 0x02, 0x40, 0x60, 0x24, 0x06, 0x02, 0x40, 0xA0,
  0x22, 0x09, 0x04, 0x20, 0x90, 0x42, 0x09, 0x04, 0x20, 0x90, 0x42, 0x10,
  0x88, 0x11, 0x08, 0x81, 0x10, 0x88, 0x11, 0x08, 0x81, 0x20, 0x88, 0x0A,
  0x05, 0x00, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xA0, 0x50, 0x04, 0x06, 0x00,
  0x40, 0x20, 0x40, 0x48, 0x08, 0x82, 0x10, 0x41, 0x10, 0x22, 0x02, 0x40,
  0x50, 0x06, 0x00, 0x80, 0x10, 0x05, 0x00, 0xA0, 0x22, 0x04, 0x41, 0x04,
  0x20, 0x88, 0x09, 0x01, 0x40, 0x30, 0x80, 0x60, 0x14, 0x05, 0x02, 0x20,
  0x88, 0x42, 0x10, 0x44, 0x12, 0x02, 0x80, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x1F, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0x04,
  0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x41, 0x08, 0x22, 0x04, 0x40, 0x50,
  0x0C, 0xFF, 0xE0, 0xC4, 0x21, 0x3E, 0x41, 0x01, 0x01, 0x01, 0x01, 0x03,
  0x3D, 0x41, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7D, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xE2, 0x84, 0xC0, 0xA0, 0x28, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x2C, 0x0B, 0x04, 0xBE, 0x00, 0x0F,
  0x30, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x11, 0xF4, 0x83,
  0x40, 0xD0, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50,
  0x14, 0x04, 0x83, 0x1F, 0x40, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x40, 0x60,
  0x18, 0x07, 0xFE, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0xF8,
  0x1E, 0x20, 0x81, 0x02, 0x04, 0x3F, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x1F, 0x48, 0x34, 0x05, 0x01,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0xC8,
  0x31, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x41, 0x0F, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x42, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0xC7,
  0xFF, 0xF0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x27,
  0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x84, 0x88, 0x88,
  0x90, 0xB0, 0xB0, 0xC8, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0xFF, 0xFF,
  0xF8, 0xBC, 0x79, 0x85, 0x0B, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0x40, 0x80, 0x9E, 0x50, 0xB0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x1F,
  0x08, 0x24, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x05, 0x01, 0x40, 0x48, 0x21, 0xF0, 0x9E, 0x28, 0x4C, 0x0A, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xC0, 0xA8, 0x4B,
  0xE2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1F, 0x48,
  0x34, 0x0D, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05,
  0x01, 0x40, 0xC8, 0x31, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x9E, 0x8C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x00, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x40, 0x20, 0x18, 0x06, 0x02,
  0x01, 0x01, 0x01, 0x02, 0xFE, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x70, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1A, 0x15, 0xF2,
  0x80, 0xC0, 0x50, 0x28, 0x24, 0x12, 0x08, 0x84, 0x44, 0x22, 0x09, 0x05,
  0x02, 0x81, 0x40, 0x40, 0x20, 0x80, 0x82, 0x83, 0x05, 0x06, 0x0A, 0x0C,
  0x14, 0x24, 0x28, 0x48, 0x88, 0x91, 0x11, 0x22, 0x24, 0x24, 0x48, 0x50,
  0x50, 0xA0, 0xA1, 0x41, 0x81, 0x81, 0x02, 0x02, 0x04, 0x00, 0x81, 0x40,
  0x90, 0x88, 0x42, 0x40, 0xA0, 0x60, 0x10, 0x18, 0x12, 0x09, 0x08, 0x44,
  0x24, 0x0A, 0x06, 0x80, 0x50, 0x24, 0x09, 0x02, 0x20, 0x88, 0x42, 0x10,
  0x84, 0x12, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x30, 0x00, 0xFE, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x3F, 0x80, 0x06, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x0E, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20,
  0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x61, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x70, 0x78, 0x30, 0xF8,
};

const GFXglyph NotoSans_Condensed_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 5, 7, 8, 2, -20 },
  { 11, 12, 20, 14, 1, -20 },
  { 41, 10, 23, 13, 1, -21 },
  { 70, 15, 20, 18, 1, -20 },
  { 108, 12, 20, 13, 1, -20 },
  { 138, 1, 7, 5, 2, -20 },
  { 139, 5, 24, 7, 1, -20 },
  { 154, 5, 24, 7, 1, -20 },
  { 169, 9, 8, 11, 1, -21 },
  { 178, 11, 13, 13, 1, -16 },
  { 196, 2, 7, 5, 1, -3 },
  { 198, 6, 1, 8, 1, -8 },
  { 199, 1, 2, 5, 2, -2 },
  { 200, 8, 20, 9, 1, -20 },
  { 220, 10, 20, 13, 1, -20 },
  { 245, 5, 20, 13, 2, -20 },
  { 258, 10, 20, 13, 1, -20 },
  { 283, 10, 20, 13, 1, -20 },
  { 308, 12, 20, 13, 0, -20 },
  { 338, 9, 20, 13, 2, -20 },
  { 361, 9, 20, 13, 2, -20 },
  { 384, 10, 20, 13, 1, -20 },
  { 409, 10, 20, 13, 1, -20 },
  { 434, 10, 20, 13, 1, -20 },
  { 459, 1, 15, 5, 2, -15 },
  { 461, 3, 19, 5, 1, -15 },
  { 469, 11, 12, 13, 1, -16 },
  { 486, 11, 6, 13, 1, -13 },
  { 495, 11, 12, 13, 1, -16 },
  { 512, 7, 20, 9, 1, -20 },
  { 530, 17, 23, 19, 1, -20 },
  { 579, 12, 20, 12, 0, -20 },
  { 609, 10, 20, 14, 2, -20 },
  { 634, 11, 20, 13, 2, -20 },
  { 662, 11, 20, 15, 2, -20 },
  { 690, 9, 20, 12, 2, -20 },
  { 713, 9, 20, 11, 2, -20 },
  { 736, 12, 20, 16, 2, -20 },
  { 766, 11, 20, 15, 2, -20 },
  { 794, 4, 20, 7, 1, -20 },
  { 804, 5, 25, 6, -2, -20 },
  { 820, 10, 20, 12, 2, -20 },
  { 845, 8, 20, 11, 2, -20 },
  { 865, 15, 20, 20, 2, -20 },
  { 903, 11, 20, 16, 2, -20 },
  { 931, 13, 20, 16, 2, -20 },
  { 964, 9, 20, 13, 2, -20 },
  { 987, 13, 25, 16, 2, -20 },
  { 1028, 10, 20, 13, 2, -20 },
  { 1053, 10, 20, 12, 1, -20 },
  { 1078, 11, 20, 11, 0, -20 },
  { 1106, 11, 20, 16, 2, -20 },
  { 1134, 12, 20, 12, 0, -20 },
  { 1164, 20, 20, 20, 0, -20 },
  { 1214, 11, 20, 11, 0, -20 },
  { 1242, 10, 20, 10, 0, -20 },
  { 1267, 9, 20, 11, 1, -20 },
  { 1290, 6, 24, 9, 2, -20 },
  { 1308, 8, 20, 9, 1, -20 },
  { 1328, 5, 24, 9, 1, -20 },
  { 1343, 11, 10, 13, 1, -20 },
  { 1357, 11, 1, 11, 0, 2 },
  { 1359, 4, 4, 7, 1, -21 },
  { 1361, 8, 15, 11, 1, -15 },
  { 1376, 10, 21, 13, 2, -21 },
  { 1403, 8, 15, 10, 1, -15 },
  { 1418, 10, 21, 13, 1, -21 },
  { 1445, 10, 15, 12, 1, -15 },
  { 1464, 7, 21, 6, 0, -21 },
  { 1483, 10, 22, 13, 1, -15 },
  { 1511, 9, 21, 13, 2, -21 },
  { 1535, 1, 20, 5, 2, -20 },
  { 1538, 3, 27, 5, 0, -20 },
  { 1549, 8, 21, 10, 2, -21 },
  { 1570, 1, 21, 5, 2, -21 },
  { 1573, 15, 15, 19, 2, -15 },
  { 1602, 9, 15, 13, 2, -15 },
  { 1619, 10, 15, 13, 1, -15 },
  { 1638, 10, 22, 13, 2, -15 },
  { 1666, 10, 22, 13, 1, -15 },
  { 1694, 6, 15, 8, 2, -15 },
  { 1706, 8, 15, 10, 1, -15 },
  { 1721, 6, 18, 7, 0, -18 },
  { 1735, 9, 15, 13, 2, -15 },
  { 1752, 9, 15, 9, 0, -15 },
  { 1769, 15, 15, 16, 0, -15 },
  { 1798, 9, 15, 10, 1, -15 },
  { 1815, 10, 22, 10, 0, -15 },
  { 1843, 7, 15, 9, 1, -15 },
  { 1857, 7, 24, 10, 1, -20 },
  { 1878, 1, 28, 12, 5, -21 },
  { 1882, 7, 24, 10, 1, -20 },
  { 1903, 11, 2, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Thin28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_THIN28PT7B_H_
