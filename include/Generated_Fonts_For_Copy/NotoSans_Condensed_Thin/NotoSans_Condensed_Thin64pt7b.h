#ifndef _NOTOSANS_CONDENSED_THIN64PT7B_H_
#define _NOTOSANS_CONDENSED_THIN64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x34,
  0x06, 0x80, 0xD0, 0x1A, 0x03, 0x40, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x40, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x60, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x40,
  0x0C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xC2,
  0x07, 0x0C, 0x08, 0x04, 0x60, 0x20, 0x01, 0x80, 0x80, 0x0C, 0x02, 0x00,
  0x30, 0x08, 0x00, 0xC0, 0x20, 0x02, 0x00, 0x80, 0x08, 0x02, 0x00, 0x20,
  0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x18, 0x08,
  0x00, 0x60, 0x20, 0x00, 0xE0, 0x80, 0x01, 0xC2, 0x00, 0x01, 0xC8, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0xC0, 0x00,
  0x23, 0x80, 0x00, 0x83, 0x80, 0x02, 0x07, 0x00, 0x08, 0x0E, 0x00, 0x20,
  0x18, 0x00, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x0C, 0x00,
  0x80, 0x20, 0x02, 0x01, 0x80, 0x08, 0x0C, 0x80, 0x20, 0x63, 0xE0, 0x87,
  0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x20,
  0x03, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x01, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x60, 0x02, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x08, 0x00, 0x60, 0x06, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x18, 0x18, 0x00, 0x30, 0x03, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x18, 0x01,
  0x82, 0x00, 0x03, 0x00, 0x30, 0xC1, 0xF0, 0x20, 0x06, 0x18, 0x73, 0x84,
  0x00, 0xC2, 0x18, 0x30, 0xC0, 0x10, 0xC2, 0x03, 0x18, 0x06, 0x18, 0xC0,
  0x23, 0x00, 0xC6, 0x10, 0x06, 0x30, 0x10, 0xC2, 0x00, 0xC6, 0x06, 0x10,
  0xC0, 0x18, 0x71, 0x86, 0x18, 0x01, 0x07, 0xE0, 0xC3, 0x00, 0x20, 0x00,
  0x30, 0x60, 0x06, 0x00, 0x06, 0x08, 0x00, 0xC0, 0x00, 0x81, 0x00, 0x18,
  0x00, 0x30, 0x20, 0x03, 0x00, 0x06, 0x04, 0x00, 0x60, 0x01, 0x80, 0x80,
  0x0C, 0x00, 0x30, 0x10, 0x01, 0x80, 0x04, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x04, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x20, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x0C,
  0x30, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x01, 0x00, 0x02, 0x00, 0x30, 0x00, 0x40, 0x06,
  0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x04,
  0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x03, 0x30, 0x02, 0x00, 0x66, 0x00, 0x60, 0x0D,
  0x80, 0x06, 0x01, 0x30, 0x00, 0x60, 0x26, 0x00, 0x0C, 0x0C, 0x80, 0x00,
  0xC1, 0x90, 0x00, 0x0C, 0x22, 0x00, 0x01, 0x8C, 0x40, 0x00, 0x19, 0x08,
  0x00, 0x01, 0xE1, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xF0, 0x40, 0x00, 0x1A, 0x0C, 0x00, 0x06, 0x60, 0xC0, 0x01, 0x86, 0x1C,
  0x00, 0xE0, 0x41, 0xE0, 0x78, 0x0C, 0x0F, 0xFC, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xD5, 0x55, 0x40, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x07, 0x02, 0x03, 0x38, 0x43, 0xC0, 0xE9, 0xC0, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x30,
  0x20, 0x04, 0x06, 0x01, 0x80, 0x60, 0x60, 0x06, 0x04, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x18, 0x61,
  0x8C, 0x00, 0xFF, 0xFC, 0xDF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0x1E, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x00,
  0xC1, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x18, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x34, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x03, 0x83, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x1B, 0x07, 0x30, 0xE3,
  0x1C, 0x33, 0x03, 0xE0, 0x34, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x03, 0xFE, 0x00, 0x7C, 0x3C, 0x03, 0x80, 0x1C, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x3E,
  0x07, 0x80, 0x1C, 0x38, 0x00, 0x18, 0x80, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x30, 0xF8, 0x07, 0x80, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x60, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x40, 0x08,
  0x00, 0x18, 0x01, 0x00, 0x02, 0x00, 0x20, 0x00, 0xC0, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x40,
  0x0C, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x18, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x9F, 0xF8, 0x0F, 0xF3, 0xF0,
  0x20, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x31, 0x00, 0x07,
  0x0F, 0x00, 0xF0, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xE7, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x0F,
  0xC0, 0x20, 0xFF, 0xC0, 0x8E, 0x01, 0xC2, 0x60, 0x01, 0x8B, 0x00, 0x06,
  0x28, 0x00, 0x0C, 0xE0, 0x00, 0x13, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02,
  0xC0, 0x00, 0x19, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x04, 0x20,
  0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x30, 0x0E, 0x03,
  0x80, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x0F, 0x80, 0x38, 0x03, 0x80, 0xC0,
  0x03, 0x83, 0x00, 0x03, 0x06, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x84, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x1C, 0x18, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xC3, 0x80, 0x07,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x87, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x20, 0x00, 0x06, 0x60, 0x00, 0x08,
  0xE0, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0xE0, 0x03, 0x00, 0xF0, 0x1C, 0x00,
  0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x3C, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x30, 0x30, 0x00, 0x60, 0x80, 0x00, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x04, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x40, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x03, 0xCC, 0x00, 0x0B,
  0x30, 0x00, 0x6C, 0x60, 0x07, 0x30, 0xF0, 0x78, 0xC0, 0xFF, 0x83, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x20, 0x1C, 0x00, 0xFF, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x37, 0xFC, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC6, 0x18, 0x43,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x7E, 0x1E, 0x10, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x78, 0x00,
  0xC3, 0x00, 0x0F, 0xFC, 0x01, 0x8C, 0x00, 0x70, 0x30, 0x06, 0x20, 0x03,
  0x00, 0xC0, 0x19, 0x80, 0x18, 0x03, 0x00, 0x66, 0x00, 0x60, 0x0C, 0x00,
  0x98, 0x03, 0x00, 0x30, 0x02, 0x60, 0x0C, 0x00, 0xC0, 0x09, 0x00, 0x60,
  0x03, 0x00, 0x34, 0x01, 0x80, 0x0C, 0x00, 0xD0, 0x06, 0x00, 0x30, 0x03,
  0xC0, 0x18, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0x80,
  0x0C, 0x00, 0xF0, 0x04, 0x00, 0x30, 0x02, 0xC0, 0x10, 0x00, 0xC0, 0x0B,
  0x00, 0x60, 0x03, 0x00, 0x2C, 0x01, 0x80, 0x18, 0x01, 0x90, 0x06, 0x00,
  0x70, 0x06, 0x40, 0x18, 0x01, 0xC0, 0x19, 0x00, 0x60, 0x0F, 0x00, 0xC6,
  0x00, 0xC0, 0x34, 0x03, 0x18, 0x03, 0x01, 0x98, 0x18, 0x60, 0x06, 0x0C,
  0x60, 0xE0, 0x80, 0x0F, 0xE0, 0xFF, 0x03, 0x00, 0x1F, 0x00, 0xF0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x06, 0x00,
  0x7F, 0xFF, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x10, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03,
  0x00, 0x07, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x60, 0x00, 0xF0, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x07,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x38, 0x00, 0x40, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x10, 0x0F, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x0C, 0x00, 0x3C, 0x03, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF6, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xD8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x30,
  0x07, 0x80, 0x1F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC7, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x37, 0xFC, 0xFF, 0x00, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81,
  0x80, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xF0,
  0x00, 0x33, 0x60, 0x00, 0x6C, 0x60, 0x00, 0xD8, 0x60, 0x01, 0xE0, 0xC0,
  0x03, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x10, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x00, 0x1F, 0xB0,
  0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x00, 0xDE, 0x40, 0x00, 0x00, 0x1B,
  0xCC, 0x00, 0x00, 0x06, 0x79, 0x80, 0x00, 0x00, 0xCF, 0x10, 0x00, 0x00,
  0x19, 0xE3, 0x00, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x00, 0xC7, 0x84, 0x00,
  0x00, 0x18, 0xF0, 0xC0, 0x00, 0x06, 0x1E, 0x18, 0x00, 0x00, 0xC3, 0xC1,
  0x00, 0x00, 0x18, 0x78, 0x30, 0x00, 0x06, 0x0F, 0x06, 0x00, 0x00, 0xC1,
  0xE0, 0x40, 0x00, 0x18, 0x3C, 0x0C, 0x00, 0x06, 0x07, 0x81, 0x80, 0x00,
  0xC0, 0xF0, 0x10, 0x00, 0x18, 0x1E, 0x03, 0x00, 0x06, 0x03, 0xC0, 0x60,
  0x00, 0xC0, 0x78, 0x04, 0x00, 0x18, 0x0F, 0x00, 0xC0, 0x06, 0x01, 0xE0,
  0x18, 0x00, 0xC0, 0x3C, 0x01, 0x00, 0x18, 0x07, 0x80, 0x30, 0x06, 0x00,
  0xF0, 0x06, 0x00, 0xC0, 0x1E, 0x00, 0x40, 0x18, 0x03, 0xC0, 0x0C, 0x06,
  0x00, 0x78, 0x01, 0x80, 0xC0, 0x0F, 0x00, 0x10, 0x18, 0x01, 0xE0, 0x03,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0xC0, 0x07, 0x80, 0x04, 0x18, 0x00, 0xF0,
  0x00, 0xC6, 0x00, 0x1E, 0x00, 0x18, 0xC0, 0x03, 0xC0, 0x01, 0x18, 0x00,
  0x78, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x58,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xD0, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x0F, 0x30, 0x00,
  0x03, 0xC4, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x3C, 0x20, 0x00, 0x0F, 0x0C,
  0x00, 0x03, 0xC1, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x0F,
  0x03, 0x00, 0x03, 0xC0, 0x60, 0x00, 0xF0, 0x18, 0x00, 0x3C, 0x03, 0x00,
  0x0F, 0x00, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0xF0, 0x06, 0x00, 0x3C, 0x00,
  0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0xF0, 0x01, 0x80, 0x3C,
  0x00, 0x30, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x01, 0x80, 0xF0, 0x00, 0x60,
  0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0xF0, 0x00,
  0x18, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x18, 0xF0,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x06,
  0xF0, 0x00, 0x00, 0xBC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x30, 0x01, 0xE1, 0x80, 0x03,
  0x8C, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x02, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x33,
  0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x1F, 0x07, 0xFF, 0xE0, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x0E,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x07, 0x80, 0xFF, 0xFC,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0x07, 0xE0, 0xE0, 0x01, 0x86, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x20, 0x00, 0x30, 0xF8, 0x07, 0x81, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x18, 0x00,
  0x30, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x30, 0x02,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x02, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x24, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x46,
  0x00, 0x01, 0xB0, 0x00, 0x0C, 0x20, 0x00, 0x19, 0x00, 0x00, 0xC3, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x30, 0x00, 0x11, 0x80, 0x00, 0x83, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x31, 0x80, 0x01, 0x81, 0x80, 0x03, 0x08,
  0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x0C, 0x00,
  0x30, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x04, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x00, 0x20, 0x18, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x10,
  0x0C, 0x00, 0x30, 0x18, 0x01, 0x80, 0x80, 0x03, 0x01, 0x00, 0x18, 0x18,
  0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x81, 0x00, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x18,
  0x20, 0x00, 0xC3, 0x00, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x43, 0x00, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00,
  0x66, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x66,
  0x00, 0x00, 0x6C, 0x00, 0x02, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x28, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x04, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0x61, 0x80, 0x00, 0x61,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x32, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x08, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81,
  0x80, 0x00, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x1F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x04, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x07, 0xFC, 0x03,
  0xE1, 0xE0, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x03, 0xFF, 0x03,
  0xF8, 0x61, 0xC0, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x36, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x02, 0xD8, 0x00, 0xDB, 0x00,
  0x33, 0x38, 0x0C, 0x63, 0xFF, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x7F, 0xC0, 0xC7, 0x83, 0x83, 0x30, 0x03, 0x0D, 0x80,
  0x06, 0x34, 0x00, 0x0C, 0xF0, 0x00, 0x33, 0x80, 0x00, 0x6E, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0x38, 0x00, 0x0C, 0xB0, 0x00,
  0x72, 0x60, 0x01, 0x88, 0xC0, 0x0C, 0x21, 0xC0, 0xE0, 0x83, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x3C, 0x18, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x3F, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x7F, 0xC1, 0x03,
  0x83, 0x84, 0x38, 0x03, 0x10, 0xC0, 0x06, 0x46, 0x00, 0x0D, 0x30, 0x00,
  0x14, 0xC0, 0x00, 0x72, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x34,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00,
  0x01, 0xCC, 0x00, 0x05, 0x30, 0x00, 0x34, 0x60, 0x01, 0x90, 0xC0, 0x0C,
  0x41, 0xC0, 0x61, 0x03, 0xFF, 0x04, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x3C, 0x3C, 0x03, 0x80, 0x70, 0x18, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00,
  0x10, 0xC0, 0x00, 0xC4, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x02, 0x07, 0x80, 0xF0,
  0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x04, 0x1F, 0x1F,
  0x10, 0xE0, 0x0C, 0x43, 0x00, 0x19, 0x18, 0x00, 0x34, 0xC0, 0x00, 0x53,
  0x00, 0x01, 0xC8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x34, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0xC8, 0x00, 0x05,
  0x30, 0x00, 0x14, 0x40, 0x00, 0xD1, 0x80, 0x06, 0x43, 0x00, 0x31, 0x07,
  0x03, 0x84, 0x0F, 0xFC, 0x10, 0x03, 0x80, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC6, 0x00, 0x0E, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x1F, 0xE0, 0xC7, 0x87, 0x0C, 0xE0, 0x18, 0xD8, 0x00, 0xCD, 0x00, 0x04,
  0xF0, 0x00, 0x6A, 0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x03, 0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x91, 0x8F, 0x80, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x03, 0x30,
  0x00, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x04, 0x00,
  0xC3, 0x00, 0x31, 0xC0, 0x0C, 0xD8, 0x03, 0x36, 0x00, 0xD8, 0xC0, 0x3C,
  0x30, 0x0E, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x83, 0xFC, 0x03, 0xFC, 0x21, 0xC3, 0x83, 0xC3, 0x88, 0xC0, 0x30,
  0xC0, 0x32, 0x60, 0x0C, 0x60, 0x06, 0xB0, 0x01, 0xB0, 0x01, 0xA8, 0x00,
  0x68, 0x00, 0x2A, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x30, 0x81, 0xFE, 0x08, 0x78, 0x78, 0x8C, 0x01, 0xC9, 0x80, 0x0C,
  0x90, 0x00, 0x6B, 0x00, 0x06, 0xA0, 0x00, 0x6E, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x0F, 0x07, 0x80, 0x38, 0x03, 0x80,
  0xE0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x02,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0x43,
  0x00, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x30, 0x07,
  0x01, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x81, 0xFE, 0x02, 0x1F,
  0x1E, 0x08, 0xE0, 0x0C, 0x23, 0x00, 0x18, 0x98, 0x00, 0x32, 0xC0, 0x00,
  0xCA, 0x00, 0x01, 0xA8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xA8, 0x00,
  0x04, 0xF0, 0x00, 0x33, 0x40, 0x00, 0x8D, 0x80, 0x06, 0x33, 0x00, 0x30,
  0xC7, 0x03, 0x83, 0x0F, 0xFC, 0x0C, 0x03, 0x80, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x04, 0x0E, 0x0E, 0x10, 0xE0, 0x0C, 0x43, 0x00, 0x19, 0x18, 0x00,
  0x34, 0xC0, 0x00, 0x53, 0x00, 0x01, 0x48, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x01, 0xC8, 0x00, 0x05, 0x30, 0x00, 0x34, 0xE0, 0x00, 0x91, 0x80, 0x06,
  0x43, 0x00, 0x31, 0x07, 0x03, 0x84, 0x0F, 0xFC, 0x10, 0x03, 0x80, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x83, 0xFC, 0x3C, 0xE3, 0x01, 0x30, 0x09, 0x00, 0x58, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xFF,
  0x03, 0xC1, 0xF1, 0x80, 0x08, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1B, 0x00, 0x0E, 0xF8, 0x0F,
  0x0F, 0xFF, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xC3, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x08,
  0x1F, 0xC0, 0x38, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0A,
  0x80, 0x03, 0x58, 0x00, 0xC9, 0x80, 0x31, 0x3C, 0x1C, 0x21, 0xFF, 0x04,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x26, 0x00, 0x03, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x80, 0x80,
  0x0C, 0x06, 0x00, 0x40, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x08, 0x01, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x30, 0x20, 0x01, 0x83,
  0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00, 0x0C, 0x60, 0x00,
  0x23, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x60,
  0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x03,
  0x80, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x98, 0x00, 0x68, 0x00, 0x66, 0x00,
  0x1B, 0x00, 0x18, 0x80, 0x04, 0xC0, 0x06, 0x20, 0x03, 0x10, 0x01, 0x0C,
  0x00, 0xC4, 0x00, 0x43, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x0C,
  0x10, 0x06, 0x08, 0x02, 0x06, 0x01, 0x82, 0x00, 0x81, 0x80, 0x60, 0xC0,
  0x60, 0x60, 0x10, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01,
  0x01, 0x00, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0x20, 0x18, 0x30, 0x04, 0x18,
  0x02, 0x0C, 0x01, 0x86, 0x00, 0x82, 0x00, 0x61, 0x80, 0x30, 0x80, 0x18,
  0x40, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x18, 0x00, 0xCC, 0x00, 0x44, 0x00,
  0x33, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xB0,
  0x00, 0x58, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x39, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x80, 0x0C, 0x06,
  0x00, 0x60, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x64, 0x00, 0x03,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x16, 0x00,
  0x01, 0xB0, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x06, 0x03, 0x00, 0x30, 0x08, 0x03, 0x00, 0x60, 0x18, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x00, 0x06, 0x60, 0x00,
  0x36, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x20, 0x00, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x04, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x40, 0x01,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x04, 0x40, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x21, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0x38,
  0x78, 0x01, 0x60, 0x1E, 0x03, 0xC0, 0x07, 0xFE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 46, 13, 5, -46 },
  { 19, 11, 17, 19, 4, -46 },
  { 43, 29, 46, 31, 1, -46 },
  { 210, 22, 53, 29, 3, -49 },
  { 356, 35, 47, 41, 3, -46 },
  { 562, 27, 47, 31, 3, -46 },
  { 721, 2, 17, 11, 4, -46 },
  { 726, 11, 56, 17, 3, -46 },
  { 803, 12, 56, 17, 2, -46 },
  { 887, 19, 20, 26, 3, -49 },
  { 935, 24, 29, 29, 2, -37 },
  { 1022, 6, 15, 11, 2, -7 },
  { 1034, 14, 1, 18, 2, -18 },
  { 1036, 3, 4, 12, 5, -4 },
  { 1038, 19, 46, 21, 1, -46 },
  { 1148, 22, 46, 29, 3, -46 },
  { 1275, 12, 46, 29, 5, -46 },
  { 1344, 22, 46, 29, 3, -46 },
  { 1471, 22, 47, 29, 3, -46 },
  { 1601, 27, 46, 29, 1, -46 },
  { 1757, 21, 47, 29, 4, -46 },
  { 1881, 22, 47, 29, 4, -46 },
  { 2011, 22, 46, 29, 3, -46 },
  { 2138, 23, 47, 29, 3, -46 },
  { 2274, 22, 47, 29, 3, -46 },
  { 2404, 3, 34, 12, 5, -34 },
  { 2417, 6, 42, 12, 2, -34 },
  { 2449, 24, 27, 29, 2, -36 },
  { 2530, 24, 15, 29, 2, -30 },
  { 2575, 24, 27, 29, 2, -36 },
  { 2656, 17, 46, 20, 1, -46 },
  { 2754, 38, 52, 44, 3, -46 },
  { 3001, 28, 46, 28, 0, -46 },
  { 3162, 23, 46, 31, 5, -46 },
  { 3295, 25, 47, 30, 4, -46 },
  { 3442, 26, 46, 34, 5, -46 },
  { 3592, 19, 46, 28, 5, -46 },
  { 3702, 19, 46, 25, 5, -46 },
  { 3812, 29, 47, 37, 4, -46 },
  { 3983, 25, 46, 35, 5, -46 },
  { 4127, 9, 46, 15, 3, -46 },
  { 4179, 11, 57, 13, -4, -46 },
  { 4258, 23, 46, 28, 5, -46 },
  { 4391, 19, 46, 25, 5, -46 },
  { 4501, 35, 46, 45, 5, -46 },
  { 4703, 26, 46, 36, 5, -46 },
  { 4853, 30, 47, 37, 4, -46 },
  { 5030, 21, 46, 29, 5, -46 },
  { 5151, 30, 57, 37, 4, -46 },
  { 5365, 23, 46, 29, 5, -46 },
  { 5498, 22, 47, 28, 3, -46 },
  { 5628, 24, 46, 25, 0, -46 },
  { 5766, 25, 47, 35, 5, -46 },
  { 5913, 27, 46, 27, 0, -46 },
  { 6069, 44, 46, 46, 1, -46 },
  { 6322, 24, 46, 25, 0, -46 },
  { 6460, 24, 46, 24, 0, -46 },
  { 6598, 22, 46, 26, 2, -46 },
  { 6725, 13, 56, 20, 5, -46 },
  { 6816, 19, 46, 21, 1, -46 },
  { 6926, 12, 56, 20, 2, -46 },
  { 7010, 25, 24, 29, 2, -46 },
  { 7085, 25, 1, 25, 0, 6 },
  { 7089, 9, 10, 15, 3, -49 },
  { 7101, 19, 35, 26, 3, -34 },
  { 7185, 22, 50, 30, 5, -49 },
  { 7323, 19, 35, 23, 3, -34 },
  { 7407, 22, 50, 30, 3, -49 },
  { 7545, 21, 35, 27, 3, -34 },
  { 7637, 16, 49, 15, 1, -49 },
  { 7735, 22, 49, 30, 3, -34 },
  { 7870, 20, 49, 29, 5, -49 },
  { 7993, 4, 46, 12, 4, -46 },
  { 8016, 9, 61, 12, -1, -46 },
  { 8085, 18, 49, 23, 5, -49 },
  { 8196, 2, 49, 11, 5, -49 },
  { 8209, 34, 34, 44, 5, -34 },
  { 8354, 20, 34, 29, 5, -34 },
  { 8439, 23, 35, 29, 3, -34 },
  { 8540, 22, 49, 30, 5, -34 },
  { 8675, 22, 49, 30, 3, -34 },
  { 8810, 13, 34, 19, 5, -34 },
  { 8866, 18, 35, 23, 2, -34 },
  { 8945, 13, 43, 15, 1, -42 },
  { 9015, 19, 35, 29, 5, -34 },
  { 9099, 21, 34, 21, 0, -34 },
  { 9189, 34, 34, 36, 1, -34 },
  { 9334, 21, 34, 23, 1, -34 },
  { 9424, 22, 49, 22, 0, -34 },
  { 9559, 16, 34, 20, 2, -34 },
  { 9627, 16, 56, 22, 3, -46 },
  { 9739, 1, 65, 27, 13, -49 },
  { 9748, 16, 56, 22, 3, -46 },
  { 9860, 24, 5, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_Thin64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_THIN64PT7B_H_
