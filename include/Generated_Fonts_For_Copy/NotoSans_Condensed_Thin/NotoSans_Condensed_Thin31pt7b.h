#ifndef _NOTOSANS_CONDENSED_THIN31PT7B_H_
#define _NOTOSANS_CONDENSED_THIN31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0xF0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x21, 0x07, 0xFF,
  0xC2, 0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x42,
  0x0F, 0xFF, 0x84, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x21,
  0x00, 0x84, 0x00, 0x04, 0x00, 0x80, 0x7E, 0x12, 0x24, 0x41, 0x08, 0x21,
  0x04, 0x20, 0x84, 0x08, 0x81, 0x10, 0x1A, 0x00, 0xC0, 0x0E, 0x01, 0x20,
  0x22, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0xBD, 0xE0, 0x60,
  0x04, 0x00, 0x80, 0x78, 0x08, 0x84, 0x10, 0x84, 0x10, 0x84, 0x20, 0x84,
  0x20, 0x84, 0x20, 0x84, 0x40, 0x84, 0x40, 0x84, 0x88, 0x84, 0x92, 0x84,
  0xA1, 0x85, 0x21, 0x59, 0x21, 0x22, 0x41, 0x02, 0x41, 0x02, 0x41, 0x04,
  0x41, 0x04, 0x21, 0x08, 0x21, 0x08, 0x21, 0x08, 0x22, 0x10, 0x1E, 0x1F,
  0x00, 0x42, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x01, 0x08, 0x04,
  0x40, 0x12, 0x00, 0x30, 0x00, 0xC0, 0x0D, 0x00, 0x42, 0x09, 0x04, 0x28,
  0x08, 0xA0, 0x24, 0x80, 0x52, 0x00, 0xC8, 0x02, 0x10, 0x14, 0x40, 0x88,
  0xFC, 0x30, 0xFF, 0x0C, 0x21, 0x04, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40,
  0xC1, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x41, 0x08, 0x21, 0x08, 0x00, 0x08, 0x04, 0x02,
  0x01, 0x1E, 0xB0, 0xE0, 0x50, 0x48, 0x42, 0x20, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x25, 0x24, 0xA0, 0xFE, 0xF0, 0x01,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x00,
  0x3F, 0x10, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09,
  0x02, 0x21, 0x07, 0x80, 0x09, 0xDB, 0x18, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0x08, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFF,
  0xC0, 0x3F, 0x98, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0xC0, 0x20, 0x78, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x28, 0x0C, 0xFE, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x01, 0x10, 0x10, 0x80, 0x84,
  0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x42, 0x02, 0x10, 0x10, 0x7F, 0xF8,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0x90, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xC0, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x81, 0x3F, 0x80,
  0x0F, 0x8C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x8E, 0x2C,
  0x4C, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05,
  0x01, 0x40, 0x8F, 0xC0, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x1F,
  0x84, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x09, 0x02, 0x10, 0x81,
  0x60, 0x38, 0x08, 0xC2, 0x04, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x05,
  0x00, 0xA0, 0x12, 0x04, 0x3F, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x01, 0xA0, 0x33, 0x1A,
  0x1C, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0xFC,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x64, 0x00, 0x00, 0x00, 0x00, 0x4A, 0x4A,
  0x40, 0x00, 0x10, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x08, 0x00, 0xFC, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x20, 0x03, 0xF8, 0x03, 0x01, 0x01, 0x00, 0x20,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x24, 0x0F, 0x0A, 0x0C, 0x42, 0x82,
  0x10, 0x61, 0x04, 0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10, 0x61, 0x04,
  0x18, 0x41, 0x0A, 0x10, 0xC2, 0x84, 0x30, 0xA0, 0x92, 0x48, 0x08, 0x61,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x20, 0x60, 0x07,
  0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x88, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x04, 0x04, 0x08, 0x1F,
  0xE0, 0x80, 0x82, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x00, 0x90,
  0x02, 0x80, 0x0A, 0x00, 0x30, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x23, 0xFC, 0x40, 0x48, 0x05, 0x00,
  0xA0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0xFE, 0x00,
  0x0F, 0xF1, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xFE, 0x08, 0x18,
  0x80, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x48, 0x0C, 0x81, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFC, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xE8, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0xF8, 0x60, 0x12,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x3F, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x05, 0x00, 0x14, 0x00, 0x48, 0x01, 0x18, 0x04, 0x1F, 0xE0, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x7C, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x2F, 0x80, 0x80, 0x60, 0x28, 0x12, 0x0C, 0x82, 0x21,
  0x08, 0x82, 0x20, 0x90, 0x28, 0x0D, 0x03, 0x20, 0x88, 0x21, 0x08, 0x42,
  0x08, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0x60, 0x10, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFC, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x05, 0xA0, 0x05, 0xA0, 0x05,
  0x90, 0x09, 0x90, 0x09, 0x90, 0x09, 0x88, 0x11, 0x88, 0x11, 0x88, 0x11,
  0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x82, 0x41, 0x82, 0x41, 0x82, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01,
  0xA0, 0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x81, 0x84, 0x18, 0x21,
  0x82, 0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x58, 0x03,
  0x80, 0x38, 0x01, 0x0F, 0xE0, 0xC0, 0x42, 0x00, 0x90, 0x02, 0x40, 0x0A,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x24, 0x00,
  0x88, 0x04, 0x10, 0x30, 0x3F, 0x00, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x12, 0x18, 0xE8, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE0,
  0xC0, 0x42, 0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04, 0x10, 0x30, 0x3F,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0xFE, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x13,
  0xF8, 0x84, 0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x02, 0x80,
  0x60, 0x10, 0x1F, 0xE4, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x0D, 0xFE, 0x00, 0xFF, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x50,
  0x04, 0x80, 0x22, 0x02, 0x0F, 0xE0, 0x80, 0x0C, 0x00, 0x50, 0x02, 0x80,
  0x24, 0x01, 0x20, 0x08, 0x80, 0x84, 0x04, 0x20, 0x20, 0x81, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x20, 0x01, 0x00, 0x80, 0x30, 0x05, 0x00, 0xC0, 0x24,
  0x03, 0x00, 0x90, 0x0C, 0x02, 0x40, 0x28, 0x08, 0x81, 0x20, 0x42, 0x04,
  0x81, 0x08, 0x12, 0x04, 0x20, 0x48, 0x10, 0x42, 0x10, 0x41, 0x08, 0x42,
  0x04, 0x21, 0x08, 0x10, 0x84, 0x20, 0x42, 0x08, 0x80, 0x90, 0x24, 0x02,
  0x40, 0x90, 0x09, 0x02, 0x40, 0x24, 0x09, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x40, 0x32, 0x02, 0x20, 0x42,
  0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0x90, 0x05, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x05, 0x00, 0x90, 0x08, 0x81, 0x08, 0x10, 0x82, 0x04, 0x20, 0x44,
  0x02, 0x40, 0x28, 0x01, 0x80, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42,
  0x08, 0x10, 0x81, 0x08, 0x11, 0x00, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0xC0, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0xFF, 0xC0, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x1F, 0xC0, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08,
  0x20, 0x42, 0x04, 0x40, 0x24, 0x02, 0x80, 0x10, 0xFF, 0xF0, 0x82, 0x08,
  0x20, 0x80, 0x0E, 0x38, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x1F,
  0x90, 0x50, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83, 0x3E, 0x80, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x70, 0x91, 0x94, 0x0B,
  0x01, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0xA8, 0x24, 0xF8, 0x0E, 0x31, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x39, 0x31, 0x50,
  0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x34, 0x0C, 0xFD, 0x1C, 0x08, 0xC4, 0x0A, 0x02, 0x80,
  0xA0, 0x18, 0x06, 0x01, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x01, 0x3F, 0x80, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFC, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x1E, 0x08, 0x54, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0D, 0x03,
  0x3E, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0B, 0xFC, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x38, 0x91, 0xA8, 0x2C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xE0, 0x0A, 0xAA, 0xAA, 0xAA, 0xA0, 0x18, 0x80,
  0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x2F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x81, 0x41, 0x20, 0x90, 0x88, 0x84, 0x42, 0x41, 0x50, 0xC8,
  0x62, 0x21, 0x10, 0x48, 0x24, 0x0A, 0x05, 0x01, 0xFF, 0xFF, 0xFF, 0x0E,
  0x0C, 0x58, 0x99, 0xA8, 0x50, 0x58, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x80,
  0x0E, 0x24, 0x6A, 0x0B, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x1E, 0x04,
  0x21, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x12, 0x04, 0x3F, 0x00, 0x0E, 0x12,
  0x32, 0x81, 0x60, 0x2C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0xB0, 0x15, 0x04, 0x9F, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0E, 0x0C, 0x54, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0D, 0x05, 0x3F, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x05, 0x26, 0x86, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x1C, 0x10, 0xD0, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x10, 0x08, 0x04, 0x03, 0x02, 0x7E, 0x00,
  0x41, 0x04, 0x10, 0xFD, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x02, 0x0F, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xD0, 0x34, 0x14, 0xF9, 0x80,
  0x50, 0x14, 0x05, 0x02, 0x40, 0x88, 0x22, 0x10, 0x84, 0x11, 0x04, 0x41,
  0x20, 0x48, 0x0A, 0x03, 0x00, 0xC0, 0x10, 0x80, 0xC0, 0xA0, 0x60, 0x50,
  0x30, 0x28, 0x28, 0x24, 0x12, 0x11, 0x09, 0x08, 0x84, 0x84, 0x44, 0x44,
  0x22, 0x12, 0x09, 0x09, 0x04, 0x84, 0x82, 0x82, 0x81, 0x40, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x10, 0x10, 0x80, 0x90, 0x44, 0x10, 0x88, 0x22, 0x05,
  0x01, 0x40, 0x20, 0x0C, 0x05, 0x01, 0x20, 0x88, 0x41, 0x10, 0x48, 0x0A,
  0x03, 0xC0, 0x68, 0x09, 0x01, 0x10, 0x22, 0x08, 0x41, 0x08, 0x20, 0x88,
  0x11, 0x02, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x2C, 0x02, 0x00, 0x7F, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0xFF, 0x07, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x30, 0xC0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x03, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0xE0,
  0x7C, 0x18, 0x3E,
};

const GFXglyph NotoSans_Condensed_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 5, 8, 9, 2, -22 },
  { 12, 14, 22, 15, 1, -22 },
  { 51, 11, 26, 14, 1, -24 },
  { 87, 16, 22, 20, 2, -22 },
  { 131, 14, 22, 15, 1, -22 },
  { 170, 1, 8, 5, 2, -22 },
  { 171, 6, 27, 8, 1, -22 },
  { 192, 6, 27, 8, 1, -22 },
  { 213, 9, 10, 13, 2, -24 },
  { 225, 12, 14, 14, 1, -18 },
  { 246, 3, 7, 6, 1, -3 },
  { 249, 7, 1, 9, 1, -9 },
  { 250, 2, 2, 6, 2, -2 },
  { 251, 9, 22, 10, 1, -22 },
  { 276, 10, 22, 14, 2, -22 },
  { 304, 5, 22, 14, 3, -22 },
  { 318, 11, 22, 14, 1, -22 },
  { 349, 11, 22, 14, 1, -22 },
  { 380, 13, 22, 14, 1, -22 },
  { 416, 10, 22, 14, 2, -22 },
  { 444, 10, 22, 14, 2, -22 },
  { 472, 11, 22, 14, 1, -22 },
  { 503, 11, 22, 14, 1, -22 },
  { 534, 11, 22, 14, 1, -22 },
  { 565, 2, 16, 6, 2, -16 },
  { 569, 3, 20, 6, 1, -16 },
  { 577, 12, 14, 14, 1, -18 },
  { 598, 12, 8, 14, 1, -15 },
  { 610, 12, 14, 14, 1, -18 },
  { 631, 8, 22, 10, 1, -22 },
  { 653, 18, 25, 21, 2, -22 },
  { 710, 14, 22, 14, 0, -22 },
  { 749, 11, 22, 15, 3, -22 },
  { 780, 12, 22, 15, 2, -22 },
  { 813, 12, 22, 17, 3, -22 },
  { 846, 9, 22, 13, 3, -22 },
  { 871, 9, 22, 12, 3, -22 },
  { 896, 14, 22, 18, 2, -22 },
  { 935, 11, 22, 17, 3, -22 },
  { 966, 5, 22, 7, 1, -22 },
  { 980, 6, 27, 6, -2, -22 },
  { 1001, 10, 22, 13, 3, -22 },
  { 1029, 9, 22, 12, 3, -22 },
  { 1054, 16, 22, 22, 3, -22 },
  { 1098, 12, 22, 17, 3, -22 },
  { 1131, 14, 22, 18, 2, -22 },
  { 1170, 10, 22, 14, 3, -22 },
  { 1198, 14, 27, 18, 2, -22 },
  { 1246, 10, 22, 14, 3, -22 },
  { 1274, 11, 22, 13, 1, -22 },
  { 1305, 12, 22, 12, 0, -22 },
  { 1338, 13, 22, 17, 2, -22 },
  { 1374, 13, 22, 13, 0, -22 },
  { 1410, 22, 22, 22, 0, -22 },
  { 1471, 12, 22, 12, 0, -22 },
  { 1504, 12, 22, 12, 0, -22 },
  { 1537, 11, 22, 12, 1, -22 },
  { 1568, 6, 27, 10, 3, -22 },
  { 1589, 9, 22, 10, 1, -22 },
  { 1614, 6, 27, 10, 1, -22 },
  { 1635, 12, 11, 14, 1, -22 },
  { 1652, 12, 1, 12, 0, 3 },
  { 1654, 5, 5, 7, 1, -24 },
  { 1658, 9, 17, 13, 1, -17 },
  { 1678, 11, 24, 15, 2, -24 },
  { 1711, 8, 17, 11, 2, -17 },
  { 1728, 10, 24, 15, 2, -24 },
  { 1758, 10, 17, 13, 2, -17 },
  { 1780, 8, 24, 7, 0, -24 },
  { 1804, 10, 24, 15, 2, -17 },
  { 1834, 10, 24, 14, 2, -24 },
  { 1864, 2, 22, 6, 2, -22 },
  { 1870, 5, 29, 6, -1, -22 },
  { 1889, 9, 24, 11, 2, -24 },
  { 1916, 1, 24, 6, 2, -24 },
  { 1919, 17, 17, 21, 2, -17 },
  { 1956, 10, 17, 14, 2, -17 },
  { 1978, 11, 17, 14, 2, -17 },
  { 2002, 11, 24, 15, 2, -17 },
  { 2035, 10, 24, 15, 2, -17 },
  { 2065, 7, 17, 9, 2, -17 },
  { 2080, 9, 17, 11, 1, -17 },
  { 2100, 6, 20, 8, 1, -20 },
  { 2115, 10, 16, 14, 2, -16 },
  { 2135, 10, 16, 10, 0, -16 },
  { 2155, 17, 16, 17, 0, -16 },
  { 2189, 10, 16, 11, 1, -16 },
  { 2209, 11, 24, 11, 0, -16 },
  { 2242, 8, 16, 10, 1, -16 },
  { 2258, 8, 27, 11, 1, -22 },
  { 2285, 1, 32, 13, 6, -24 },
  { 2289, 8, 27, 11, 1, -22 },
  { 2316, 12, 2, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Thin31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_THIN31PT7B_H_
