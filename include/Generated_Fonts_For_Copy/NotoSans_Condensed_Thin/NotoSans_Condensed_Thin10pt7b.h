#ifndef _NOTOSANS_CONDENSED_THIN10PT7B_H_
#define _NOTOSANS_CONDENSED_THIN10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xC0, 0x52, 0xBE, 0xAF, 0x29, 0x80, 0x2F, 0xAA, 0x63, 0x3E,
  0x20, 0xEA, 0xCB, 0xAD, 0x74, 0xD4, 0xC0, 0x72, 0x98, 0x8A, 0xCB, 0xE0,
  0xC0, 0x5A, 0xA9, 0x40, 0x95, 0x55, 0x80, 0x2B, 0x60, 0x22, 0xF2, 0x20,
  0xC0, 0xE0, 0x80, 0x25, 0x25, 0x20, 0xF6, 0xDB, 0x78, 0xD5, 0x54, 0x71,
  0x11, 0x24, 0xF0, 0xF1, 0x16, 0x11, 0xF0, 0x22, 0x55, 0x97, 0x10, 0xF3,
  0x12, 0x78, 0xF3, 0x5B, 0x78, 0xF1, 0x22, 0x24, 0x40, 0xF9, 0x56, 0x99,
  0x70, 0xF9, 0x99, 0x71, 0x60, 0x08, 0x0C, 0x12, 0xC2, 0x10, 0xF0, 0xF0,
  0x86, 0x16, 0x80, 0xE4, 0xA4, 0x10, 0x7C, 0x7F, 0x39, 0xFE, 0x0E, 0x26,
  0x65, 0xB9, 0x90, 0xF6, 0xFB, 0x78, 0xF2, 0x49, 0x38, 0xE9, 0x99, 0x99,
  0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0xF8, 0x8B, 0x99, 0xF0, 0x99,
  0x9F, 0x99, 0x90, 0xD5, 0x5C, 0x55, 0x55, 0xC0, 0xBA, 0x4D, 0x68, 0x92,
  0x49, 0x38, 0x8C, 0x63, 0x3D, 0xEE, 0xA0, 0x99, 0x9D, 0xBB, 0x90, 0xF9,
  0x99, 0x99, 0xF0, 0xF6, 0xF9, 0x20, 0xF9, 0x99, 0x99, 0xD2, 0x10, 0xF6,
  0xED, 0x68, 0xF8, 0x86, 0x11, 0xF0, 0xF4, 0x44, 0x44, 0x40, 0x99, 0x99,
  0x99, 0xF0, 0x99, 0x95, 0x62, 0x40, 0x93, 0x26, 0xAB, 0x56, 0xC8, 0x92,
  0x00, 0x96, 0x64, 0x6A, 0x90, 0x9A, 0x64, 0x44, 0x40, 0xF2, 0x24, 0x44,
  0xF0, 0xEA, 0xAA, 0xC0, 0x91, 0x22, 0x48, 0xD5, 0x55, 0xC0, 0x25, 0x99,
  0xF0, 0x90, 0x65, 0xDE, 0x93, 0x5B, 0x6F, 0xEA, 0xC0, 0x11, 0x35, 0x99,
  0x97, 0xF7, 0x4E, 0x6B, 0x24, 0x92, 0xF9, 0x99, 0x71, 0x70, 0x93, 0x5B,
  0x6D, 0x3E, 0x3F, 0x80, 0x92, 0x69, 0x35, 0xFF, 0xFD, 0x6B, 0x5A, 0x80,
  0xF6, 0xDA, 0xF9, 0x99, 0x70, 0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10,
  0xEA, 0x80, 0xF1, 0x9E, 0xBA, 0xAC, 0xB6, 0xDE, 0xB6, 0xA4, 0xA6, 0xAB,
  0x92, 0x48, 0xA9, 0x3A, 0xB5, 0xA4, 0xB0, 0xE9, 0x2E, 0x69, 0x2C, 0x92,
  0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_Thin10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 1, 2, 3, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 4, 0, -8 },
  { 13, 6, 7, 6, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 2, 2, 0, -7 },
  { 25, 2, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 4, 3, 4, 0, -8 },
  { 33, 4, 5, 5, 0, -6 },
  { 36, 1, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 0, -1 },
  { 39, 3, 7, 3, 0, -7 },
  { 42, 3, 7, 4, 1, -7 },
  { 45, 2, 7, 4, 1, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 3, 7, 4, 1, -7 },
  { 62, 3, 7, 4, 1, -7 },
  { 65, 4, 7, 4, 0, -7 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 4, 7, 4, 0, -7 },
  { 77, 1, 5, 2, 0, -5 },
  { 78, 1, 6, 2, 0, -5 },
  { 79, 4, 5, 5, 0, -6 },
  { 82, 4, 3, 5, 0, -5 },
  { 84, 4, 5, 5, 0, -6 },
  { 87, 3, 7, 3, 0, -7 },
  { 90, 5, 8, 7, 1, -7 },
  { 95, 4, 7, 4, 0, -7 },
  { 99, 3, 7, 5, 1, -7 },
  { 102, 3, 7, 5, 1, -7 },
  { 105, 4, 7, 5, 1, -7 },
  { 109, 3, 7, 4, 1, -7 },
  { 112, 3, 7, 4, 1, -7 },
  { 115, 4, 7, 6, 1, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 2, 7, 2, 0, -7 },
  { 125, 2, 9, 2, -1, -7 },
  { 128, 3, 7, 4, 1, -7 },
  { 131, 3, 7, 4, 1, -7 },
  { 134, 5, 7, 7, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 3, 7, 4, 1, -7 },
  { 150, 4, 9, 6, 1, -7 },
  { 155, 3, 7, 5, 1, -7 },
  { 158, 4, 7, 4, 0, -7 },
  { 162, 4, 7, 4, 0, -7 },
  { 166, 4, 7, 6, 1, -7 },
  { 170, 4, 7, 4, 0, -7 },
  { 174, 7, 7, 7, 0, -7 },
  { 181, 4, 7, 4, 0, -7 },
  { 185, 4, 7, 4, 0, -7 },
  { 189, 4, 7, 4, 0, -7 },
  { 193, 2, 9, 3, 1, -7 },
  { 196, 3, 7, 3, 0, -7 },
  { 199, 2, 9, 3, 0, -7 },
  { 202, 4, 4, 4, 0, -7 },
  { 204, 4, 1, 4, 0, 1 },
  { 205, 2, 2, 2, 0, -8 },
  { 206, 3, 5, 4, 0, -5 },
  { 208, 3, 8, 5, 1, -8 },
  { 211, 2, 5, 4, 1, -5 },
  { 213, 4, 8, 5, 0, -8 },
  { 217, 3, 5, 4, 1, -5 },
  { 219, 3, 8, 2, 0, -8 },
  { 222, 4, 7, 5, 0, -5 },
  { 226, 3, 8, 5, 1, -8 },
  { 229, 1, 7, 2, 0, -7 },
  { 230, 1, 9, 2, 0, -7 },
  { 232, 3, 8, 4, 1, -8 },
  { 235, 1, 8, 2, 0, -8 },
  { 236, 5, 5, 7, 1, -5 },
  { 240, 3, 5, 5, 1, -5 },
  { 242, 4, 5, 5, 0, -5 },
  { 245, 3, 7, 5, 1, -5 },
  { 248, 4, 7, 5, 0, -5 },
  { 252, 2, 5, 3, 1, -5 },
  { 254, 3, 5, 4, 0, -5 },
  { 256, 2, 7, 2, 0, -7 },
  { 258, 3, 5, 5, 1, -5 },
  { 260, 3, 5, 3, 0, -5 },
  { 262, 6, 5, 6, 0, -5 },
  { 266, 3, 5, 4, 0, -5 },
  { 268, 3, 7, 4, 0, -5 },
  { 271, 3, 5, 3, 0, -5 },
  { 273, 3, 9, 3, 0, -7 },
  { 277, 1, 10, 4, 2, -8 },
  { 279, 3, 9, 3, 0, -7 },
  { 283, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Thin10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_THIN10PT7B_H_
