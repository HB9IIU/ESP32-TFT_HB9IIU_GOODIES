#ifndef _NOTOSANS_CONDENSED_THIN71PT7B_H_
#define _NOTOSANS_CONDENSED_THIN71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin71pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x72, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02,
  0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x20, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x3C, 0x60, 0xF8, 0x38, 0x30, 0x08, 0x38, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0E,
  0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x67, 0x80, 0x00, 0x30, 0xE0,
  0x00, 0x18, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x0C, 0x80, 0x18, 0x0C, 0x70, 0x0C, 0x1C, 0x3F, 0x86, 0x7C, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0C, 0x00, 0x71, 0xC0, 0x00, 0x60, 0x03, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x08, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x60, 0x00, 0x80, 0x06, 0x01, 0x80, 0x02,
  0x00, 0x18, 0x04, 0x00, 0x08, 0x00, 0x60, 0x30, 0x00, 0x20, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0x06, 0x06, 0x00, 0x02, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x00, 0x60, 0x40, 0x00, 0x20, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x06, 0x0C,
  0x1F, 0x83, 0x00, 0x18, 0x60, 0xE7, 0x0C, 0x00, 0x41, 0x86, 0x06, 0x30,
  0x03, 0x04, 0x18, 0x0C, 0xC0, 0x0C, 0x30, 0xC0, 0x31, 0x80, 0x30, 0xC3,
  0x00, 0x66, 0x01, 0x86, 0x18, 0x01, 0x8C, 0x06, 0x18, 0x60, 0x06, 0x30,
  0x30, 0x41, 0x80, 0x18, 0x73, 0xC3, 0x06, 0x00, 0x20, 0xFC, 0x0C, 0x10,
  0x00, 0xC0, 0x00, 0x60, 0x40, 0x03, 0x00, 0x01, 0x83, 0x00, 0x0C, 0x00,
  0x04, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0xC0,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x60, 0x03, 0x00, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x60, 0x02,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x63, 0x00, 0x30,
  0x01, 0x98, 0x00, 0x60, 0x06, 0x60, 0x00, 0xC0, 0x19, 0x80, 0x03, 0x00,
  0x4C, 0x00, 0x06, 0x03, 0x30, 0x00, 0x0C, 0x0C, 0xC0, 0x00, 0x30, 0x23,
  0x00, 0x00, 0x61, 0x8C, 0x00, 0x00, 0xC6, 0x30, 0x00, 0x01, 0xB0, 0xC0,
  0x00, 0x06, 0xC3, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x06, 0xC1, 0x80, 0x00, 0x39, 0x83, 0x00, 0x01,
  0xC6, 0x0E, 0x00, 0x0E, 0x0C, 0x1C, 0x00, 0x70, 0x18, 0x3C, 0x0F, 0x80,
  0x60, 0x3F, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x10, 0x04, 0x03,
  0xF0, 0x20, 0x79, 0xE1, 0x1E, 0x01, 0xEB, 0x80, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x6C, 0x00, 0x06, 0x20, 0x00, 0x61, 0x80, 0x02, 0x06, 0x00,
  0x30, 0x18, 0x03, 0x00, 0x60, 0x30, 0x03, 0x01, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x61, 0x86, 0x18, 0xE3,
  0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x03, 0xB0, 0x39,
  0x83, 0x8C, 0x38, 0x67, 0x03, 0x70, 0x1F, 0x00, 0xD0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x01, 0xFF, 0x80, 0x07, 0xE3, 0xE0, 0x0F, 0x00, 0x1C,
  0x0E, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xE3,
  0xF0, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0x7E, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x67, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0xE0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xE0, 0x04, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x7F, 0x00, 0xC1, 0xFF, 0xE0, 0xC7, 0x80, 0x70, 0xCE,
  0x00, 0x38, 0xD8, 0x00, 0x1C, 0xD8, 0x00, 0x0C, 0xF0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x80, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xF9, 0xF8,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x10, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0E,
  0x00, 0x06, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x0E, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x0E, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x05, 0x98, 0x00, 0x06, 0xCE, 0x00,
  0x06, 0x63, 0x00, 0x07, 0x20, 0xE0, 0x07, 0x10, 0x3C, 0x1F, 0x18, 0x07,
  0xFE, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x18, 0x07,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x6F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xEF, 0xFE, 0x18, 0xF3, 0xCF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18,
  0xC3, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x3F, 0x1F, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x7F, 0xC0, 0x06, 0x30, 0x00, 0x7D, 0xF0, 0x03, 0x30,
  0x00, 0x60, 0x18, 0x01, 0x98, 0x00, 0x60, 0x0C, 0x00, 0xCC, 0x00, 0x60,
  0x06, 0x00, 0x36, 0x00, 0x70, 0x03, 0x00, 0x1E, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0x60, 0x03, 0xC0,
  0x0C, 0x00, 0x30, 0x01, 0xE0, 0x06, 0x00, 0x18, 0x00, 0xF0, 0x02, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0x00, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x03, 0x00,
  0x1E, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x80,
  0x30, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x70, 0x01, 0xE0, 0x0C, 0x00,
  0x38, 0x00, 0xF0, 0x06, 0x00, 0x1C, 0x00, 0xD8, 0x01, 0x80, 0x0E, 0x00,
  0x6C, 0x00, 0xC0, 0x07, 0x00, 0x36, 0x00, 0x60, 0x07, 0x80, 0x33, 0x00,
  0x18, 0x02, 0x40, 0x18, 0x80, 0x0C, 0x03, 0x30, 0x18, 0x60, 0x03, 0x03,
  0x1C, 0x1C, 0x30, 0x00, 0xFF, 0x07, 0xFC, 0x18, 0x00, 0x3F, 0x01, 0xF8,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x7C, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x03, 0xC1,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x60, 0x01, 0xF8, 0x30, 0x00, 0x0E,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x78, 0xC0, 0x00, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x78, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x30, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xC0, 0x03, 0xE0, 0x0C, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x07, 0x80, 0xC0, 0x03, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF6, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x03, 0xE3, 0xFF, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xEF, 0x7C, 0xFF, 0x00, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x03, 0x8C,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x8F,
  0x00, 0x00, 0xCE, 0xC0, 0x00, 0x66, 0x60, 0x00, 0x36, 0x18, 0x00, 0x1E,
  0x0C, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x60,
  0x00, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x00,
  0x1B, 0xCC, 0x00, 0x00, 0x00, 0x6F, 0x30, 0x00, 0x00, 0x03, 0x3C, 0xC0,
  0x00, 0x00, 0x0C, 0xF1, 0x80, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00, 0x01,
  0x8F, 0x18, 0x00, 0x00, 0x06, 0x3C, 0x30, 0x00, 0x00, 0x18, 0xF0, 0xC0,
  0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x03, 0x0F, 0x06, 0x00, 0x00, 0x0C,
  0x3C, 0x18, 0x00, 0x00, 0x60, 0xF0, 0x60, 0x00, 0x01, 0x83, 0xC0, 0xC0,
  0x00, 0x06, 0x0F, 0x03, 0x00, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x00, 0xC0,
  0xF0, 0x18, 0x00, 0x03, 0x03, 0xC0, 0x60, 0x00, 0x18, 0x0F, 0x01, 0x80,
  0x00, 0x60, 0x3C, 0x03, 0x00, 0x01, 0x80, 0xF0, 0x0C, 0x00, 0x0C, 0x03,
  0xC0, 0x30, 0x00, 0x30, 0x0F, 0x00, 0x60, 0x00, 0xC0, 0x3C, 0x01, 0x80,
  0x06, 0x00, 0xF0, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x0C, 0x00, 0x60, 0x0F,
  0x00, 0x30, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x01, 0x80,
  0x20, 0x03, 0xC0, 0x06, 0x01, 0x80, 0x0F, 0x00, 0x18, 0x06, 0x00, 0x3C,
  0x00, 0x30, 0x10, 0x00, 0xF0, 0x00, 0xC0, 0xC0, 0x03, 0xC0, 0x03, 0x03,
  0x00, 0x0F, 0x00, 0x06, 0x18, 0x00, 0x3C, 0x00, 0x18, 0x60, 0x00, 0xF0,
  0x00, 0x61, 0x80, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x0F, 0x00, 0x03, 0x30,
  0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x03, 0xD8,
  0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x3C, 0x60, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x3C,
  0x18, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0xC0, 0xC0,
  0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x03, 0x00, 0x03,
  0xC0, 0x30, 0x00, 0x3C, 0x01, 0x80, 0x03, 0xC0, 0x18, 0x00, 0x3C, 0x00,
  0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x30, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x18, 0x03, 0xC0,
  0x01, 0x80, 0x3C, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x18, 0x3C,
  0x00, 0x01, 0x83, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC3, 0xC0, 0x00,
  0x06, 0x3C, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x33,
  0xC0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x1F, 0x06, 0x00, 0x07, 0x0C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0xC3, 0x00, 0x07, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x30, 0x01, 0xF0, 0x18, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xE0,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0xFF, 0x01, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x78,
  0x7F, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x81, 0x80, 0x00, 0x63, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x20, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x58, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0x80, 0x70, 0x20, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xC0, 0x7F, 0x86, 0x0F, 0x00,
  0x31, 0xE0, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7B, 0x00,
  0x06, 0xD8, 0x00, 0x36, 0x60, 0x03, 0x31, 0xC0, 0x71, 0x87, 0xFE, 0x0C,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x7F, 0x80, 0x60, 0xFF, 0xF0, 0x30,
  0xE0, 0x1C, 0x18, 0xC0, 0x03, 0x0C, 0xC0, 0x00, 0xC6, 0xC0, 0x00, 0x63,
  0x60, 0x00, 0x19, 0xA0, 0x00, 0x0C, 0xF0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x1B, 0xC0, 0x00, 0x19, 0xA0, 0x00, 0x0C, 0xD8, 0x00, 0x0C,
  0x6C, 0x00, 0x06, 0x33, 0x00, 0x06, 0x18, 0xE0, 0x0E, 0x0C, 0x3C, 0x1E,
  0x06, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF,
  0x03, 0x80, 0x30, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x70, 0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0xFF, 0x03,
  0x03, 0xFF, 0xC3, 0x07, 0x00, 0xE3, 0x0C, 0x00, 0x33, 0x18, 0x00, 0x1B,
  0x38, 0x00, 0x0B, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x30, 0x00, 0x0B,
  0x38, 0x00, 0x1B, 0x18, 0x00, 0x31, 0x0E, 0x00, 0x71, 0x07, 0x81, 0xC1,
  0x03, 0xFF, 0x81, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1C, 0x03, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x10, 0x70,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x3C, 0xF0, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x3F, 0xFF, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0x07, 0x00, 0xE3, 0x0C, 0x00,
  0x33, 0x18, 0x00, 0x1B, 0x38, 0x00, 0x0B, 0x30, 0x00, 0x0F, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x0F, 0x30, 0x00, 0x0B, 0x38, 0x00, 0x1B, 0x18, 0x00, 0x33, 0x0E, 0x00,
  0x63, 0x07, 0x81, 0xC3, 0x03, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x38, 0x78, 0x00, 0xE0, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x7F, 0x03, 0x07, 0xFF, 0x0C,
  0x38, 0x0E, 0x31, 0x80, 0x0C, 0xCC, 0x00, 0x1B, 0x60, 0x00, 0x6D, 0x80,
  0x00, 0xBC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x30, 0xEF, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x3F, 0x9F, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x30, 0x00, 0x31,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x01,
  0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC3, 0xC0,
  0x06, 0x36, 0x00, 0x31, 0x98, 0x01, 0x98, 0xC0, 0x0D, 0x83, 0x00, 0x6C,
  0x18, 0x03, 0xC0, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x83, 0x0F, 0xFE, 0x03, 0xFF, 0x8C, 0x70, 0x18, 0x1C, 0x07,
  0x33, 0x00, 0x30, 0xC0, 0x0C, 0xC8, 0x00, 0x66, 0x00, 0x1B, 0x60, 0x01,
  0x90, 0x00, 0x6D, 0x00, 0x02, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x7F, 0x83, 0x07, 0xFF, 0x0C, 0x38, 0x0F, 0x31, 0x80, 0x0C, 0xCC, 0x00,
  0x1B, 0x60, 0x00, 0x6D, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x07, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x60, 0xFF, 0xF0, 0x30, 0xE0, 0x1C, 0x18, 0xC0, 0x03, 0x0C, 0xC0,
  0x00, 0xC6, 0x60, 0x00, 0x63, 0x60, 0x00, 0x19, 0xA0, 0x00, 0x0C, 0xF0,
  0x00, 0x03, 0x78, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x2E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x5C, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x37, 0x80, 0x00, 0x1B, 0xC0, 0x00, 0x19, 0xA0,
  0x00, 0x0C, 0xD8, 0x00, 0x0C, 0x66, 0x00, 0x06, 0x33, 0x80, 0x06, 0x18,
  0xE0, 0x0E, 0x0C, 0x3C, 0x1E, 0x06, 0x0F, 0xFE, 0x03, 0x00, 0x78, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF0, 0xC0, 0xE0, 0x1C, 0x60, 0xC0, 0x03, 0x30,
  0xC0, 0x00, 0xD8, 0xE0, 0x00, 0x2C, 0x60, 0x00, 0x1E, 0x60, 0x00, 0x07,
  0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E,
  0x60, 0x00, 0x0F, 0x18, 0x00, 0x0D, 0x8E, 0x00, 0x06, 0xC3, 0x80, 0x06,
  0x60, 0xE0, 0x06, 0x30, 0x3C, 0x1E, 0x18, 0x0F, 0xFE, 0x0C, 0x00, 0x78,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0xFD, 0x83, 0xFF, 0x0C, 0x0E, 0x30, 0x0C, 0xC0, 0x19, 0x00, 0x36,
  0x00, 0x68, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x1C, 0x00, 0xE3, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x80, 0x00, 0xCC, 0x00, 0x18, 0xF8, 0x0F, 0x03, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x03, 0xFF, 0xF8, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x70, 0x40, 0x7F, 0x80, 0x3C, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1D, 0x00, 0x00, 0x76, 0x00, 0x03, 0xD8, 0x00, 0x0B,
  0x70, 0x00, 0x6C, 0xC0, 0x03, 0x33, 0x80, 0x18, 0x47, 0x81, 0xC1, 0x07,
  0xFE, 0x04, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x02,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x00, 0x83, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x34, 0x00, 0x03, 0x80, 0x00, 0xD8, 0x00,
  0x1A, 0x00, 0x06, 0x60, 0x00, 0x68, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00,
  0x62, 0x00, 0x06, 0xC0, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x04, 0x30, 0x00,
  0xC4, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0xC1, 0x00, 0x0C, 0x60, 0x03,
  0x06, 0x00, 0x61, 0x80, 0x08, 0x18, 0x01, 0x82, 0x00, 0x60, 0x60, 0x06,
  0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x10,
  0x0C, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0x80, 0x80,
  0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x00, 0xC3, 0x00,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x30, 0x01, 0x8C, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00,
  0x22, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00,
  0x2C, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00,
  0x50, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x38, 0x06,
  0x00, 0x60, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x10, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x41, 0x80, 0x00, 0x61, 0x80,
  0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x03, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x0F, 0x80, 0x03, 0xFF, 0x20,
  0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 52, 14, 5, -51 },
  { 27, 12, 19, 21, 5, -51 },
  { 56, 32, 51, 35, 1, -51 },
  { 260, 25, 58, 32, 3, -54 },
  { 442, 38, 52, 45, 4, -51 },
  { 689, 30, 52, 34, 3, -51 },
  { 884, 2, 19, 12, 5, -51 },
  { 889, 13, 62, 19, 3, -51 },
  { 990, 12, 62, 19, 3, -51 },
  { 1083, 21, 21, 29, 4, -54 },
  { 1139, 26, 32, 32, 3, -41 },
  { 1243, 6, 16, 13, 3, -7 },
  { 1255, 16, 2, 20, 2, -20 },
  { 1259, 4, 5, 14, 5, -4 },
  { 1262, 21, 51, 23, 1, -51 },
  { 1396, 24, 52, 32, 4, -51 },
  { 1552, 13, 51, 32, 6, -51 },
  { 1635, 25, 51, 32, 3, -51 },
  { 1795, 25, 52, 32, 3, -51 },
  { 1958, 30, 51, 32, 1, -51 },
  { 2150, 24, 52, 32, 4, -51 },
  { 2306, 24, 52, 32, 4, -51 },
  { 2462, 25, 51, 32, 3, -51 },
  { 2622, 25, 52, 32, 3, -51 },
  { 2785, 25, 52, 32, 3, -51 },
  { 2948, 4, 38, 14, 5, -38 },
  { 2967, 6, 47, 13, 3, -38 },
  { 3003, 26, 30, 32, 3, -40 },
  { 3101, 26, 16, 32, 3, -33 },
  { 3153, 26, 30, 32, 3, -40 },
  { 3251, 18, 52, 22, 2, -51 },
  { 3368, 41, 58, 49, 4, -51 },
  { 3666, 31, 51, 31, 0, -51 },
  { 3864, 25, 51, 34, 6, -51 },
  { 4024, 28, 52, 34, 4, -51 },
  { 4206, 28, 51, 38, 6, -51 },
  { 4385, 21, 51, 31, 6, -51 },
  { 4519, 21, 51, 28, 6, -51 },
  { 4653, 33, 52, 41, 4, -51 },
  { 4868, 27, 51, 39, 6, -51 },
  { 5041, 11, 51, 17, 3, -51 },
  { 5112, 12, 63, 14, -4, -51 },
  { 5207, 25, 51, 31, 6, -51 },
  { 5367, 20, 51, 28, 6, -51 },
  { 5495, 38, 51, 50, 6, -51 },
  { 5738, 28, 51, 40, 6, -51 },
  { 5917, 33, 52, 41, 4, -51 },
  { 6132, 23, 51, 32, 6, -51 },
  { 6279, 33, 63, 41, 4, -51 },
  { 6539, 25, 51, 32, 6, -51 },
  { 6699, 25, 52, 31, 3, -51 },
  { 6862, 27, 51, 27, 0, -51 },
  { 7035, 28, 52, 39, 6, -51 },
  { 7217, 30, 51, 30, 0, -51 },
  { 7409, 49, 51, 51, 1, -51 },
  { 7722, 27, 51, 27, 0, -51 },
  { 7895, 26, 51, 26, 0, -51 },
  { 8061, 24, 51, 28, 2, -51 },
  { 8214, 14, 62, 22, 6, -51 },
  { 8323, 21, 51, 23, 1, -51 },
  { 8457, 14, 62, 22, 2, -51 },
  { 8566, 28, 27, 32, 2, -51 },
  { 8661, 28, 2, 28, 0, 6 },
  { 8668, 11, 11, 16, 3, -54 },
  { 8684, 21, 39, 29, 3, -38 },
  { 8787, 25, 55, 34, 5, -54 },
  { 8959, 20, 39, 26, 4, -38 },
  { 9057, 24, 55, 34, 4, -54 },
  { 9222, 23, 39, 30, 4, -38 },
  { 9335, 18, 54, 16, 1, -54 },
  { 9457, 24, 55, 33, 4, -38 },
  { 9622, 22, 54, 32, 5, -54 },
  { 9771, 4, 51, 13, 5, -51 },
  { 9797, 9, 68, 13, -1, -51 },
  { 9874, 21, 54, 26, 5, -54 },
  { 10016, 2, 54, 13, 5, -54 },
  { 10030, 38, 38, 48, 5, -38 },
  { 10211, 22, 38, 32, 5, -38 },
  { 10316, 25, 39, 32, 4, -38 },
  { 10438, 25, 54, 33, 5, -38 },
  { 10607, 25, 54, 33, 3, -38 },
  { 10776, 15, 38, 21, 5, -38 },
  { 10848, 20, 39, 25, 3, -38 },
  { 10946, 15, 48, 17, 1, -47 },
  { 11036, 22, 38, 32, 5, -37 },
  { 11141, 24, 37, 24, 0, -37 },
  { 11252, 38, 37, 40, 1, -37 },
  { 11428, 23, 37, 26, 1, -37 },
  { 11535, 24, 54, 25, 0, -37 },
  { 11697, 18, 37, 23, 2, -37 },
  { 11781, 18, 62, 24, 3, -51 },
  { 11921, 2, 71, 30, 14, -54 },
  { 11939, 18, 62, 24, 3, -51 },
  { 12079, 26, 6, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_Thin71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_THIN71PT7B_H_
