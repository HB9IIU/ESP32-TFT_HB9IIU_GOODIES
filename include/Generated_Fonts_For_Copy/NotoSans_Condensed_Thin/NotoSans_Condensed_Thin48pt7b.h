#ifndef _NOTOSANS_CONDENSED_THIN48PT7B_H_
#define _NOTOSANS_CONDENSED_THIN48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xA0, 0x03, 0xF0, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0x00, 0x80,
  0xC0, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80,
  0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x20, 0x01, 0x01, 0x80, 0x04,
  0x04, 0x07, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x20, 0x01, 0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x0F, 0xFF,
  0xFF, 0x01, 0x01, 0x80, 0x04, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40,
  0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0xC0, 0x02,
  0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0xFC, 0x03, 0xD7, 0xC3, 0x08, 0x23, 0x04, 0x01, 0x02, 0x01, 0x81,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x0C, 0x08, 0x02,
  0x04, 0x01, 0x82, 0x00, 0x61, 0x00, 0x18, 0x80, 0x03, 0x40, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x09, 0x80, 0x04, 0x70, 0x02, 0x08, 0x01, 0x02, 0x00,
  0x81, 0x80, 0x40, 0xC0, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x0C,
  0x02, 0x04, 0x01, 0x06, 0x80, 0x86, 0x78, 0x4E, 0x07, 0xFC, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x08, 0x06, 0x60,
  0x04, 0x02, 0x08, 0x01, 0x01, 0x83, 0x00, 0xC0, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x06, 0x04, 0x01, 0x01, 0x81, 0x00, 0xC0, 0x60, 0xC0,
  0x30, 0x08, 0x20, 0x0C, 0x02, 0x08, 0x03, 0x00, 0x84, 0x00, 0xC0, 0x21,
  0x00, 0x30, 0x18, 0xC0, 0x04, 0x06, 0x21, 0xE1, 0x01, 0x08, 0xC4, 0x40,
  0x44, 0x60, 0x90, 0x11, 0x10, 0x26, 0x0C, 0xCC, 0x0C, 0x82, 0x22, 0x01,
  0x1B, 0x08, 0x80, 0x43, 0x86, 0x20, 0x10, 0x01, 0x08, 0x04, 0x00, 0xC2,
  0x01, 0x00, 0x20, 0x80, 0x40, 0x08, 0x20, 0x10, 0x06, 0x08, 0x04, 0x01,
  0x02, 0x01, 0x00, 0xC0, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x0C,
  0x06, 0x01, 0x02, 0x01, 0x00, 0x40, 0x80, 0x40, 0x08, 0x40, 0x20, 0x01,
  0xF0, 0x01, 0xC0, 0x00, 0x3B, 0x80, 0x03, 0x04, 0x00, 0x10, 0x10, 0x01,
  0x00, 0x80, 0x08, 0x04, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x10, 0x0C,
  0x00, 0x80, 0x40, 0x06, 0x02, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x00, 0x02,
  0x18, 0x00, 0x19, 0x80, 0x00, 0x58, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x06, 0x20, 0x00, 0x60, 0x80, 0x02, 0x06, 0x03, 0x30, 0x10, 0x11, 0x00,
  0x40, 0x98, 0x03, 0x04, 0x80, 0x08, 0x24, 0x00, 0x22, 0x20, 0x01, 0x91,
  0x00, 0x05, 0x88, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x00, 0x0F, 0x08, 0x00,
  0x48, 0x20, 0x04, 0x21, 0x80, 0xC1, 0x83, 0xFC, 0x06, 0xFF, 0xFF, 0xFF,
  0x01, 0x81, 0x01, 0x80, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x02,
  0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x08,
  0x18, 0x10, 0x30, 0x60, 0x40, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x08, 0x10, 0x2E, 0x23, 0x83, 0xF8, 0x00, 0x80, 0x02, 0x80, 0x0C,
  0x80, 0x10, 0x80, 0x41, 0x01, 0x01, 0x06, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x03, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x33,
  0x22, 0x26, 0x44, 0x4C, 0x80, 0xFF, 0xFF, 0xFC, 0x7D, 0x80, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xBC, 0x03, 0x03, 0x03, 0x00, 0x81, 0x00, 0x21, 0x80, 0x10, 0x80,
  0x0C, 0x40, 0x02, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x34,
  0x00, 0x1A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80,
  0x03, 0x40, 0x01, 0xA0, 0x00, 0x98, 0x00, 0x4C, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x08, 0x04, 0x06, 0x0C, 0x00, 0xFC,
  0x00, 0x01, 0x83, 0xC3, 0x63, 0x33, 0x1B, 0x0E, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x03, 0xC0, 0x0F, 0x78, 0x1C, 0x03, 0x08, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x18,
  0x03, 0x18, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x07, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x70, 0x0E, 0x1F, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x01, 0xA0, 0x00, 0x12, 0x00, 0x03,
  0x20, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x08, 0x20, 0x01,
  0x82, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x06, 0x02, 0x00,
  0x40, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x02, 0x03, 0x00, 0x20,
  0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x20, 0xFF, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x7F,
  0xFC, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x40, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x80, 0x08, 0xC0, 0x30, 0x7F, 0xE0, 0x00, 0x78, 0x03, 0xFC, 0x06,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87,
  0xE0, 0x8C, 0x38, 0xB0, 0x0C, 0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x20, 0x06, 0x30,
  0x04, 0x18, 0x18, 0x0F, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC,
  0x06, 0x01, 0x06, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x20, 0x00, 0x98, 0x00, 0x44, 0x00, 0x63, 0x00, 0x20,
  0xC0, 0x20, 0x30, 0x60, 0x0E, 0x60, 0x01, 0xC0, 0x01, 0xB0, 0x01, 0x86,
  0x03, 0x01, 0x83, 0x00, 0x61, 0x00, 0x19, 0x00, 0x04, 0x80, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05,
  0x00, 0x04, 0xC0, 0x06, 0x30, 0x02, 0x0C, 0x06, 0x03, 0xFE, 0x00, 0x03,
  0xC0, 0x07, 0xF8, 0x06, 0x02, 0x06, 0x00, 0x86, 0x00, 0x62, 0x00, 0x11,
  0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x40, 0x03, 0xB0,
  0x01, 0xC8, 0x01, 0x66, 0x01, 0xB0, 0xE7, 0x10, 0x3E, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x30, 0x0F,
  0xF0, 0x01, 0xC0, 0x00, 0x5F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xEC, 0x23, 0x32, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x32, 0x22, 0x64, 0x44, 0x88, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x00, 0x0E, 0x07, 0xBC, 0x80, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x4C, 0x00, 0x60, 0x09, 0x00, 0x7F, 0x81, 0xA0, 0x18, 0x10,
  0x1C, 0x06, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04,
  0x03, 0x01, 0x80, 0x80, 0x60, 0x30, 0x30, 0x0C, 0x06, 0x06, 0x01, 0x80,
  0xC0, 0xC0, 0x20, 0x18, 0x18, 0x04, 0x03, 0x03, 0x00, 0x80, 0x60, 0x60,
  0x10, 0x0C, 0x04, 0x06, 0x03, 0x80, 0x80, 0xA0, 0x50, 0x18, 0x14, 0x0A,
  0x01, 0x04, 0x83, 0x60, 0x3F, 0x0F, 0xC4, 0x01, 0x80, 0x60, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41,
  0x00, 0x06, 0x0C, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x0C, 0x00,
  0xC0, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x60, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x04, 0x00, 0x40, 0x60, 0x03, 0x02, 0x00, 0x08, 0x10,
  0x00, 0x41, 0x80, 0x03, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02,
  0x30, 0x00, 0x19, 0x00, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x40, 0xFF, 0xF0, 0x40, 0x0E, 0x20, 0x01, 0x90, 0x00, 0x68, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x68, 0x00, 0x24, 0x00, 0x32, 0x00, 0x31, 0xFF, 0xE0,
  0xFF, 0xF8, 0x40, 0x06, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x0C, 0x80, 0x3C,
  0x7F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0xFC, 0x0C, 0x01, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x08,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x10, 0x07, 0x02, 0x00, 0x18, 0x40, 0x01,
  0x88, 0x00, 0x11, 0x00, 0x03, 0x20, 0x00, 0x24, 0x00, 0x06, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x19,
  0x00, 0x06, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80, 0x78, 0x1F, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x3F, 0xFE, 0xFF, 0xFA, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0xCF, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x58, 0x00, 0x01, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x11, 0x80,
  0x00, 0x43, 0x00, 0x01, 0x06, 0x00, 0x04, 0x0E, 0x00, 0x70, 0x0F, 0xFF,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x02, 0x7E, 0x00,
  0x80, 0x03, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x88, 0x01, 0x84, 0x00,
  0x82, 0x00, 0xC1, 0x00, 0xC0, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x60, 0x10,
  0x60, 0x08, 0x20, 0x04, 0x30, 0x02, 0x30, 0x01, 0x38, 0x00, 0x96, 0x00,
  0x51, 0x00, 0x38, 0x40, 0x18, 0x30, 0x08, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x01, 0x00, 0xC0, 0x80, 0x20, 0x40, 0x08, 0x20, 0x06, 0x10, 0x01, 0x08,
  0x00, 0xC4, 0x00, 0x22, 0x00, 0x19, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00,
  0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x16, 0x80,
  0x00, 0x05, 0xB0, 0x00, 0x03, 0x64, 0x00, 0x00, 0x99, 0x00, 0x00, 0x26,
  0x60, 0x00, 0x19, 0x88, 0x00, 0x04, 0x62, 0x00, 0x01, 0x18, 0xC0, 0x00,
  0xC6, 0x10, 0x00, 0x21, 0x84, 0x00, 0x08, 0x61, 0x80, 0x06, 0x18, 0x20,
  0x01, 0x06, 0x08, 0x00, 0x41, 0x83, 0x00, 0x30, 0x60, 0x40, 0x08, 0x18,
  0x10, 0x02, 0x06, 0x06, 0x01, 0x81, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x0C, 0x0C, 0x06, 0x01, 0x02, 0x01, 0x80, 0x40, 0x80, 0x60, 0x18,
  0x60, 0x18, 0x02, 0x10, 0x06, 0x00, 0x84, 0x01, 0x80, 0x33, 0x00, 0x60,
  0x04, 0x80, 0x18, 0x01, 0x20, 0x06, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x80, 0x00, 0xD0,
  0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x84,
  0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x10, 0x03, 0x02,
  0x00, 0x60, 0x20, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x00,
  0x80, 0xC0, 0x18, 0x18, 0x01, 0x03, 0x00, 0x30, 0x60, 0x02, 0x0C, 0x00,
  0x61, 0x80, 0x04, 0x30, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x01, 0x98, 0x00,
  0x13, 0x00, 0x03, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x60, 0x1C, 0x02, 0x00, 0x10,
  0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x06, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x90, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00, 0x43,
  0x00, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x80, 0x38, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x08,
  0x80, 0x30, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xBC, 0x00, 0x60, 0x1C, 0x02, 0x00, 0x18, 0x10, 0x00, 0x20,
  0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x06, 0x40, 0x00, 0x09, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00, 0x43, 0x00, 0x03, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xE0, 0x40,
  0x1C, 0x20, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x32, 0x00, 0x11, 0x00, 0x18, 0x80, 0x38, 0x7F, 0xF0, 0x3F,
  0xE0, 0x10, 0x18, 0x08, 0x04, 0x04, 0x03, 0x02, 0x00, 0x81, 0x00, 0x60,
  0x80, 0x10, 0x40, 0x0C, 0x20, 0x02, 0x10, 0x01, 0x88, 0x00, 0x44, 0x00,
  0x32, 0x00, 0x09, 0x00, 0x06, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x01, 0xF0,
  0x07, 0xDF, 0x86, 0x00, 0x46, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x60, 0x0E, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x24, 0x00, 0x04, 0x80, 0x01, 0x98, 0x00, 0x21, 0x80, 0x08, 0x18, 0x06,
  0x00, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00,
  0x02, 0x60, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x04, 0x30,
  0x00, 0x41, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x18, 0x00, 0x80,
  0x80, 0x18, 0x08, 0x01, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x40, 0x20,
  0x04, 0x02, 0x00, 0x60, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x09,
  0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xB0, 0x00, 0x60, 0x00, 0x48, 0x00, 0x30, 0x00, 0x64, 0x00, 0x3C, 0x00,
  0x32, 0x00, 0x12, 0x00, 0x11, 0x00, 0x09, 0x00, 0x08, 0xC0, 0x04, 0x80,
  0x0C, 0x20, 0x06, 0x60, 0x06, 0x10, 0x03, 0x10, 0x02, 0x08, 0x01, 0x08,
  0x01, 0x06, 0x00, 0x84, 0x00, 0x81, 0x00, 0x42, 0x00, 0xC0, 0x80, 0x61,
  0x80, 0x40, 0x40, 0x20, 0x40, 0x20, 0x30, 0x10, 0x20, 0x10, 0x18, 0x08,
  0x10, 0x18, 0x04, 0x04, 0x0C, 0x08, 0x02, 0x06, 0x02, 0x04, 0x01, 0x02,
  0x01, 0x02, 0x00, 0xC1, 0x00, 0x83, 0x00, 0x20, 0x80, 0x41, 0x00, 0x10,
  0xC0, 0x30, 0x80, 0x08, 0x60, 0x08, 0x40, 0x06, 0x20, 0x04, 0x60, 0x01,
  0x10, 0x02, 0x30, 0x00, 0x88, 0x01, 0x90, 0x00, 0x4C, 0x00, 0x48, 0x00,
  0x34, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x16, 0x00, 0x05, 0x00, 0x0A, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0xCC, 0x00, 0x21, 0x00, 0x18, 0x60, 0x04, 0x08, 0x03,
  0x02, 0x00, 0x80, 0xC0, 0x60, 0x10, 0x10, 0x06, 0x0C, 0x00, 0x82, 0x00,
  0x30, 0x80, 0x04, 0x40, 0x01, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x03,
  0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0xC0, 0x01, 0x10,
  0x00, 0xC6, 0x00, 0x20, 0x80, 0x18, 0x30, 0x04, 0x04, 0x03, 0x01, 0x00,
  0x80, 0x60, 0x60, 0x08, 0x10, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x19, 0x80,
  0x02, 0x40, 0x00, 0xB0, 0x00, 0x10, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00,
  0x18, 0x80, 0x04, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x18,
  0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x10, 0x20, 0x04, 0x18, 0x01,
  0x84, 0x00, 0x21, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xFF, 0xC0,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x02, 0x40, 0x00, 0x4C, 0x00, 0x10, 0x80,
  0x02, 0x10, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x06, 0x01, 0x80, 0x40,
  0x20, 0x0C, 0x0C, 0x00, 0x81, 0x00, 0x18, 0x60, 0x01, 0x08, 0x00, 0x33,
  0x00, 0x02, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x01, 0x01, 0x03, 0xC0, 0x7B, 0xC2, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x03, 0xFC, 0x70, 0x13, 0x00, 0x58, 0x01, 0x40, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xD0, 0x05, 0x60,
  0x24, 0x7F, 0x10, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x83,
  0xC0, 0x8E, 0x70, 0x90, 0x0C, 0xA0, 0x04, 0xE0, 0x06, 0xC0, 0x02, 0xC0,
  0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xE0, 0x04, 0xA0, 0x0C, 0x98,
  0x18, 0x8F, 0xF0, 0x00, 0xF0, 0x1F, 0x70, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x04, 0x1F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x78,
  0x20, 0xE7, 0x11, 0x80, 0xC8, 0x80, 0x34, 0xC0, 0x0A, 0x40, 0x03, 0x60,
  0x01, 0xA0, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x14, 0x00, 0x1A, 0x00, 0x0D, 0x80, 0x06, 0x40, 0x07, 0x20, 0x02, 0x88,
  0x03, 0x47, 0x03, 0x20, 0xFE, 0x10, 0x01, 0xC0, 0x07, 0x78, 0x18, 0x0C,
  0x10, 0x04, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x06, 0x07, 0xFC, 0x00, 0xF0,
  0x1D, 0xC1, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x0F, 0xFC, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01,
  0xE0, 0x07, 0xBC, 0x46, 0x01, 0x22, 0x00, 0x52, 0x00, 0x29, 0x00, 0x0D,
  0x80, 0x06, 0x80, 0x03, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0xD0, 0x00, 0x68, 0x00, 0x36, 0x00, 0x19, 0x00, 0x14, 0x80, 0x0A,
  0x20, 0x09, 0x08, 0x0C, 0x83, 0xF8, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x8C, 0x01, 0x83, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x3C, 0x23, 0xBC, 0x90, 0x1A, 0x80, 0x2E, 0x00, 0xF0, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x5F,
  0x80, 0x00, 0x01, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x00, 0x04, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x60, 0x9F, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x28, 0x02, 0x40, 0x32, 0x03, 0x10, 0x10, 0x81, 0x04, 0x18,
  0x20, 0x81, 0x08, 0x08, 0xC0, 0x46, 0x02, 0x58, 0x14, 0x40, 0xE3, 0x06,
  0x08, 0x20, 0x61, 0x01, 0x08, 0x0C, 0x40, 0x22, 0x01, 0x90, 0x04, 0x80,
  0x34, 0x00, 0xA0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x78, 0x4E, 0x70, 0xE7, 0x2C, 0x0C, 0xC0, 0xD4, 0x02, 0x40, 0x2C,
  0x01, 0x40, 0x1E, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x03, 0xC2, 0x39,
  0xC9, 0x01, 0xA8, 0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x01, 0xE0, 0x03, 0xBC, 0x06,
  0x01, 0x82, 0x00, 0x42, 0x00, 0x31, 0x00, 0x09, 0x80, 0x06, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x36, 0x00, 0x11, 0x00, 0x08, 0xC0, 0x0C, 0x20, 0x0C, 0x0C, 0x0C,
  0x03, 0xFC, 0x00, 0x03, 0xC0, 0x8F, 0x70, 0x98, 0x0C, 0xB0, 0x04, 0xA0,
  0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xA0,
  0x04, 0xB0, 0x0C, 0x98, 0x18, 0x8F, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x03, 0x9C, 0x46, 0x03, 0x22,
  0x00, 0xD3, 0x00, 0x29, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01,
  0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x36,
  0x00, 0x19, 0x00, 0x14, 0xC0, 0x0A, 0x20, 0x09, 0x1C, 0x08, 0x83, 0xF8,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x03, 0xA3, 0xF9, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC0, 0xF7,
  0xD8, 0x02, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x70, 0x02,
  0xC0, 0x33, 0xFE, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x03, 0xFF, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x3F, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x6C,
  0x01, 0x48, 0x06, 0x98, 0x19, 0x1F, 0xE2, 0xC0, 0x03, 0x40, 0x02, 0x40,
  0x02, 0x60, 0x06, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x30, 0x0C, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x18, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C,
  0x30, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x0C, 0x00,
  0xE0, 0x03, 0x00, 0x2C, 0x01, 0xC0, 0x0B, 0x00, 0x50, 0x06, 0x40, 0x16,
  0x01, 0x10, 0x04, 0x80, 0x44, 0x03, 0x20, 0x11, 0x80, 0x88, 0x0C, 0x20,
  0x23, 0x02, 0x08, 0x08, 0x40, 0x82, 0x06, 0x10, 0x20, 0xC1, 0x04, 0x08,
  0x10, 0x41, 0x86, 0x04, 0x10, 0x21, 0x01, 0x0C, 0x08, 0x40, 0x62, 0x02,
  0x10, 0x08, 0x80, 0xCC, 0x02, 0x20, 0x12, 0x00, 0x98, 0x04, 0x80, 0x34,
  0x01, 0x20, 0x05, 0x00, 0x58, 0x01, 0x40, 0x0C, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x06, 0xC0, 0x08, 0x80,
  0x31, 0x80, 0x41, 0x01, 0x81, 0x02, 0x02, 0x0C, 0x02, 0x10, 0x04, 0x40,
  0x05, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xB0, 0x02,
  0x20, 0x0C, 0x20, 0x10, 0x40, 0x60, 0x40, 0x80, 0xC3, 0x00, 0x84, 0x01,
  0x98, 0x01, 0x20, 0x03, 0xC0, 0x02, 0x40, 0x01, 0x60, 0x01, 0x20, 0x03,
  0x20, 0x02, 0x20, 0x02, 0x30, 0x02, 0x10, 0x06, 0x10, 0x04, 0x18, 0x04,
  0x08, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x18, 0x04, 0x10, 0x04, 0x10,
  0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x03, 0x60, 0x01, 0x40,
  0x01, 0x40, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0xFF, 0xF0, 0x00, 0xF0,
  0x18, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x70, 0x0E, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0xF8, 0x08, 0x00, 0x3E,
  0x00, 0x58, 0xE0, 0x18, 0x06, 0x1A, 0x00, 0x7C,
};

const GFXglyph NotoSans_Condensed_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 34, 10, 4, -34 },
  { 10, 8, 12, 14, 3, -34 },
  { 22, 22, 34, 24, 1, -34 },
  { 116, 17, 39, 21, 2, -36 },
  { 199, 26, 35, 31, 2, -35 },
  { 313, 21, 35, 23, 2, -35 },
  { 405, 2, 12, 8, 3, -34 },
  { 408, 9, 42, 13, 2, -34 },
  { 456, 8, 42, 13, 2, -34 },
  { 498, 15, 14, 19, 2, -36 },
  { 525, 18, 22, 22, 2, -28 },
  { 575, 4, 11, 9, 2, -5 },
  { 581, 11, 2, 13, 1, -14 },
  { 584, 3, 3, 9, 3, -3 },
  { 586, 14, 34, 16, 1, -34 },
  { 646, 17, 35, 21, 2, -35 },
  { 721, 9, 34, 21, 4, -34 },
  { 760, 17, 35, 21, 2, -35 },
  { 835, 17, 35, 21, 2, -35 },
  { 910, 20, 34, 21, 1, -34 },
  { 995, 16, 34, 21, 3, -34 },
  { 1063, 16, 36, 21, 3, -35 },
  { 1135, 17, 34, 21, 2, -34 },
  { 1208, 17, 35, 21, 2, -35 },
  { 1283, 17, 36, 21, 2, -35 },
  { 1360, 3, 26, 9, 3, -26 },
  { 1370, 4, 32, 9, 2, -26 },
  { 1386, 18, 20, 22, 2, -27 },
  { 1431, 18, 12, 22, 2, -23 },
  { 1458, 18, 20, 22, 2, -27 },
  { 1503, 12, 35, 15, 1, -35 },
  { 1556, 27, 39, 33, 3, -34 },
  { 1688, 21, 34, 21, 0, -34 },
  { 1778, 17, 34, 23, 4, -34 },
  { 1851, 19, 35, 23, 3, -35 },
  { 1935, 19, 34, 26, 4, -34 },
  { 2016, 14, 34, 21, 4, -34 },
  { 2076, 14, 34, 19, 4, -34 },
  { 2136, 22, 35, 28, 3, -35 },
  { 2233, 18, 34, 27, 4, -34 },
  { 2310, 7, 34, 11, 2, -34 },
  { 2340, 9, 42, 10, -3, -34 },
  { 2388, 17, 34, 21, 4, -34 },
  { 2461, 14, 34, 19, 4, -34 },
  { 2521, 26, 34, 34, 4, -34 },
  { 2632, 19, 34, 27, 4, -34 },
  { 2713, 22, 35, 28, 3, -35 },
  { 2810, 16, 34, 22, 4, -34 },
  { 2878, 22, 43, 28, 3, -35 },
  { 2997, 17, 34, 22, 4, -34 },
  { 3070, 17, 35, 21, 2, -35 },
  { 3145, 18, 34, 19, 0, -34 },
  { 3222, 19, 34, 27, 4, -34 },
  { 3303, 20, 34, 20, 0, -34 },
  { 3388, 33, 34, 34, 1, -34 },
  { 3529, 18, 34, 18, 0, -34 },
  { 3606, 18, 34, 18, 0, -34 },
  { 3683, 17, 34, 19, 1, -34 },
  { 3756, 9, 42, 15, 4, -34 },
  { 3804, 14, 34, 16, 1, -34 },
  { 3864, 9, 42, 15, 2, -34 },
  { 3912, 19, 17, 21, 1, -34 },
  { 3953, 19, 2, 19, 0, 4 },
  { 3958, 7, 8, 11, 2, -37 },
  { 3965, 14, 26, 20, 2, -26 },
  { 4011, 16, 36, 23, 4, -36 },
  { 4083, 14, 26, 17, 2, -26 },
  { 4129, 17, 36, 23, 2, -36 },
  { 4206, 16, 26, 21, 2, -26 },
  { 4258, 13, 37, 11, 0, -37 },
  { 4319, 17, 38, 23, 2, -26 },
  { 4400, 14, 36, 22, 4, -36 },
  { 4463, 3, 35, 9, 3, -35 },
  { 4477, 7, 47, 9, -1, -35 },
  { 4519, 13, 36, 17, 4, -36 },
  { 4578, 1, 36, 9, 4, -36 },
  { 4583, 25, 26, 33, 4, -26 },
  { 4665, 14, 26, 22, 4, -26 },
  { 4711, 17, 26, 22, 2, -26 },
  { 4767, 16, 37, 23, 4, -26 },
  { 4841, 17, 37, 23, 2, -26 },
  { 4920, 10, 26, 14, 4, -26 },
  { 4953, 13, 26, 17, 2, -26 },
  { 4996, 10, 32, 12, 1, -32 },
  { 5036, 15, 25, 22, 3, -25 },
  { 5083, 16, 25, 16, 0, -25 },
  { 5133, 26, 25, 27, 1, -25 },
  { 5215, 15, 25, 17, 1, -25 },
  { 5262, 16, 37, 17, 0, -25 },
  { 5336, 12, 25, 15, 2, -25 },
  { 5374, 12, 42, 16, 2, -34 },
  { 5437, 1, 49, 20, 10, -37 },
  { 5444, 12, 42, 16, 2, -34 },
  { 5507, 18, 4, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Thin48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_THIN48PT7B_H_
