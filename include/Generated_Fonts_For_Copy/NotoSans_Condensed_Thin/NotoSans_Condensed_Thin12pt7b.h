#ifndef _NOTOSANS_CONDENSED_THIN12PT7B_H_
#define _NOTOSANS_CONDENSED_THIN12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x28, 0xA2, 0x9F, 0x49, 0x4F, 0x94, 0x50, 0x75,
  0x29, 0x46, 0x1C, 0xA5, 0x71, 0x00, 0x8B, 0x2B, 0x2A, 0xF6, 0xD3, 0x55,
  0x4C, 0x21, 0x45, 0x14, 0x21, 0x59, 0x62, 0x74, 0xF0, 0x6A, 0xAA, 0xA4,
  0x89, 0x12, 0x49, 0x4A, 0x00, 0x5F, 0x80, 0x21, 0x3E, 0x42, 0x10, 0xE0,
  0xE0, 0x80, 0x11, 0x22, 0x24, 0x48, 0x80, 0x69, 0x99, 0x99, 0x99, 0xE0,
  0x75, 0x55, 0x40, 0xE1, 0x11, 0x22, 0x48, 0xF0, 0x74, 0x42, 0x13, 0x04,
  0x21, 0xF0, 0x10, 0x8C, 0x65, 0x4B, 0xE2, 0x10, 0xE8, 0x88, 0x61, 0x11,
  0xE0, 0x68, 0x8C, 0xB9, 0x99, 0xE0, 0xF1, 0x22, 0x24, 0x44, 0x80, 0x69,
  0x9A, 0x69, 0x99, 0xE0, 0x69, 0x99, 0x97, 0x12, 0xE0, 0x04, 0x40, 0x1A,
  0x09, 0xB0, 0xC1, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0xC4, 0x92,
  0x90, 0x40, 0x38, 0x8A, 0x0D, 0xDC, 0xB9, 0x74, 0xD6, 0x80, 0xF0, 0x21,
  0x14, 0xA5, 0x3A, 0x31, 0x88, 0xE9, 0x99, 0xE9, 0x99, 0xF0, 0x78, 0x88,
  0x88, 0x88, 0x70, 0xE4, 0xA3, 0x18, 0xC6, 0x31, 0xF0, 0xF8, 0x88, 0xE8,
  0x88, 0xF0, 0xF8, 0x88, 0xE8, 0x88, 0x80, 0x7C, 0x21, 0x09, 0x46, 0x31,
  0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xFF, 0x80, 0x55, 0x55, 0x5C,
  0x99, 0xAC, 0xCA, 0xA9, 0x90, 0x92, 0x49, 0x24, 0xE0, 0x86, 0x18, 0x71,
  0xCE, 0xBA, 0xED, 0x94, 0x8C, 0x63, 0x9A, 0xD6, 0x71, 0x88, 0x74, 0x63,
  0x18, 0xC6, 0x31, 0x70, 0xE9, 0x99, 0x9E, 0x88, 0x80, 0x74, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0x84, 0xE9, 0x99, 0xDA, 0xA9, 0x90, 0x78, 0x88, 0x43,
  0x11, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xF0, 0x8C, 0x63, 0x15, 0x29, 0x44, 0x20, 0x89, 0x89, 0x99, 0x59,
  0x55, 0x55, 0x66, 0x62, 0x22, 0x8A, 0x94, 0xC2, 0x31, 0x52, 0x88, 0x99,
  0x95, 0x62, 0x22, 0x20, 0x71, 0x12, 0x22, 0x44, 0xF0, 0xEA, 0xAA, 0xAC,
  0x88, 0x44, 0x42, 0x22, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x21, 0x14,
  0x98, 0x80, 0xF8, 0xD0, 0x71, 0x79, 0x9F, 0x88, 0xE9, 0x99, 0x99, 0xF0,
  0xF2, 0x49, 0xC0, 0x11, 0x79, 0x99, 0x99, 0xF0, 0xE9, 0xF8, 0x8F, 0x6B,
  0x24, 0x92, 0x40, 0xF9, 0x99, 0x9F, 0x11, 0xE0, 0x88, 0xE9, 0x99, 0x99,
  0x90, 0x9F, 0x80, 0x9F, 0xF0, 0x92, 0x5D, 0xB5, 0xA0, 0xFF, 0x80, 0xFE,
  0x59, 0x65, 0x96, 0x50, 0xF9, 0x99, 0x99, 0xF9, 0x99, 0x9E, 0xF9, 0x99,
  0x9F, 0x88, 0x80, 0xF9, 0x99, 0x9F, 0x11, 0x10, 0xEA, 0xA0, 0xF8, 0x61,
  0x1F, 0x5D, 0x24, 0x93, 0x99, 0x99, 0x9F, 0x99, 0xA6, 0x64, 0x93, 0x66,
  0xB3, 0x64, 0x89, 0x00, 0x96, 0x22, 0x59, 0x99, 0x56, 0x22, 0x44, 0x80,
  0x64, 0xA5, 0xC0, 0x72, 0x49, 0x24, 0x91, 0x80, 0xFF, 0xF0, 0x89, 0x24,
  0xD2, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_Thin12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 2, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 5, 10, 5, 0, -9 },
  { 18, 6, 9, 8, 1, -9 },
  { 25, 6, 9, 6, 0, -9 },
  { 32, 1, 4, 2, 0, -9 },
  { 33, 2, 11, 3, 1, -9 },
  { 36, 3, 11, 3, 0, -9 },
  { 41, 3, 3, 5, 1, -9 },
  { 43, 5, 6, 5, 0, -7 },
  { 47, 1, 3, 2, 0, -1 },
  { 48, 3, 1, 3, 0, -4 },
  { 49, 1, 1, 2, 1, -1 },
  { 50, 4, 9, 4, 0, -9 },
  { 55, 4, 9, 5, 1, -9 },
  { 60, 2, 9, 5, 1, -9 },
  { 63, 4, 9, 5, 1, -9 },
  { 68, 5, 9, 5, 0, -9 },
  { 74, 5, 9, 5, 0, -9 },
  { 80, 4, 9, 5, 1, -9 },
  { 85, 4, 9, 5, 1, -9 },
  { 90, 4, 9, 5, 1, -9 },
  { 95, 4, 9, 5, 1, -9 },
  { 100, 4, 9, 5, 1, -9 },
  { 105, 1, 6, 2, 1, -6 },
  { 106, 2, 8, 2, 0, -6 },
  { 108, 5, 5, 5, 0, -7 },
  { 112, 5, 3, 5, 0, -6 },
  { 114, 5, 5, 5, 0, -7 },
  { 118, 3, 9, 4, 0, -9 },
  { 122, 7, 10, 8, 1, -9 },
  { 131, 5, 9, 5, 0, -9 },
  { 137, 4, 9, 6, 1, -9 },
  { 142, 4, 9, 6, 1, -9 },
  { 147, 5, 9, 6, 1, -9 },
  { 153, 4, 9, 5, 1, -9 },
  { 158, 4, 9, 5, 1, -9 },
  { 163, 5, 9, 7, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 1, 9, 3, 1, -9 },
  { 177, 2, 11, 2, -1, -9 },
  { 180, 4, 9, 5, 1, -9 },
  { 185, 3, 9, 5, 1, -9 },
  { 189, 6, 9, 8, 1, -9 },
  { 196, 5, 9, 7, 1, -9 },
  { 202, 5, 9, 7, 1, -9 },
  { 208, 4, 9, 5, 1, -9 },
  { 213, 5, 11, 7, 1, -9 },
  { 220, 4, 9, 5, 1, -9 },
  { 225, 4, 9, 5, 1, -9 },
  { 230, 5, 9, 5, 0, -9 },
  { 236, 5, 9, 7, 1, -9 },
  { 242, 5, 9, 5, 0, -9 },
  { 248, 8, 9, 9, 0, -9 },
  { 257, 5, 9, 5, 0, -9 },
  { 263, 4, 9, 4, 0, -9 },
  { 268, 4, 9, 5, 0, -9 },
  { 273, 2, 11, 4, 1, -9 },
  { 276, 4, 9, 4, 0, -9 },
  { 281, 3, 11, 4, 0, -9 },
  { 286, 5, 5, 5, 0, -9 },
  { 290, 5, 1, 5, 0, 1 },
  { 291, 2, 2, 3, 0, -9 },
  { 292, 4, 6, 5, 0, -6 },
  { 295, 4, 9, 6, 1, -9 },
  { 300, 3, 6, 4, 1, -6 },
  { 303, 4, 9, 6, 1, -9 },
  { 308, 4, 6, 5, 1, -6 },
  { 311, 3, 9, 3, 0, -9 },
  { 315, 4, 9, 6, 1, -6 },
  { 320, 4, 9, 5, 1, -9 },
  { 325, 1, 9, 2, 1, -9 },
  { 327, 1, 12, 2, 0, -9 },
  { 329, 3, 9, 4, 1, -9 },
  { 333, 1, 9, 2, 1, -9 },
  { 335, 6, 6, 8, 1, -6 },
  { 340, 4, 6, 5, 1, -6 },
  { 343, 4, 6, 5, 1, -6 },
  { 346, 4, 9, 6, 1, -6 },
  { 351, 4, 9, 6, 1, -6 },
  { 356, 2, 6, 4, 1, -6 },
  { 358, 4, 6, 4, 0, -6 },
  { 361, 3, 8, 3, 0, -8 },
  { 364, 4, 6, 5, 1, -6 },
  { 367, 4, 6, 4, 0, -6 },
  { 370, 7, 6, 7, 0, -6 },
  { 376, 4, 6, 4, 0, -6 },
  { 379, 4, 9, 4, 0, -6 },
  { 384, 3, 6, 4, 0, -6 },
  { 387, 3, 11, 4, 1, -9 },
  { 392, 1, 12, 5, 2, -9 },
  { 394, 3, 11, 4, 1, -9 },
  { 399, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_Thin12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_THIN12PT7B_H_
