#ifndef _NOTOSANS_CONDENSED_THIN9PT7B_H_
#define _NOTOSANS_CONDENSED_THIN9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x5F, 0x5F, 0x66, 0x6C, 0xC4, 0x75, 0xE4, 0x45, 0xA9,
  0x77, 0x9D, 0x60, 0x46, 0x64, 0xB9, 0xF0, 0xC0, 0x6A, 0xA4, 0xD5, 0x5C,
  0x5D, 0x80, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x69, 0x99,
  0x99, 0x60, 0xFC, 0x61, 0x12, 0x24, 0xF0, 0x54, 0xB2, 0x78, 0x26, 0x6A,
  0x72, 0xE8, 0xE1, 0x1E, 0x24, 0x8E, 0x99, 0x70, 0xF2, 0x22, 0x44, 0x69,
  0x96, 0x99, 0xF0, 0x69, 0x99, 0x71, 0x60, 0x88, 0x8C, 0x3C, 0x61, 0xFF,
  0xC3, 0x68, 0xC4, 0xA4, 0x10, 0x7A, 0x5B, 0x6D, 0xBD, 0x07, 0x00, 0x46,
  0x6F, 0x99, 0xF7, 0x5B, 0xC0, 0x72, 0x49, 0x38, 0xF6, 0xDB, 0xC0, 0xEE,
  0xB0, 0xEE, 0xA0, 0x78, 0x8A, 0x99, 0xF0, 0xB7, 0xDB, 0x40, 0xD5, 0x70,
  0x55, 0x56, 0xBA, 0x4D, 0x40, 0xAA, 0xB0, 0x8C, 0x67, 0x3E, 0xE4, 0xB7,
  0xFB, 0x40, 0x69, 0x99, 0x99, 0xE0, 0xF6, 0xE9, 0x00, 0x69, 0x99, 0x99,
  0xE2, 0x20, 0xF6, 0xEB, 0x40, 0x68, 0x86, 0x11, 0xE0, 0xE9, 0x24, 0x80,
  0xB6, 0xDB, 0xC0, 0x99, 0xA6, 0x44, 0x96, 0x5B, 0x52, 0x49, 0x20, 0xA9,
  0x2B, 0x40, 0xB5, 0x24, 0x80, 0xE5, 0x29, 0xC0, 0xFE, 0x89, 0x22, 0x40,
  0xD5, 0x5C, 0x66, 0x90, 0xF0, 0x90, 0xE5, 0xDE, 0x93, 0x5B, 0x78, 0x72,
  0x46, 0x11, 0x79, 0x99, 0xF0, 0x77, 0xC6, 0x6E, 0xA8, 0x79, 0x99, 0xF1,
  0x70, 0xAF, 0xFC, 0xBE, 0xBF, 0x80, 0xAE, 0xAC, 0xFE, 0xFB, 0xBB, 0xB0,
  0xFF, 0xC0, 0x69, 0x99, 0x70, 0xD6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10,
  0xEA, 0x80, 0xF1, 0x1E, 0xBA, 0xB0, 0xFF, 0xC0, 0xB6, 0xA4, 0xAD, 0x6A,
  0xA5, 0x00, 0xA9, 0x2A, 0xB6, 0xA4, 0xB0, 0xE9, 0x2E, 0x69, 0x44, 0x98,
  0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Thin9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 5, 7, 6, 0, -7 },
  { 15, 4, 7, 4, 0, -7 },
  { 19, 1, 2, 1, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 2, 7, 2, 0, -6 },
  { 24, 3, 3, 4, 0, -7 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 3, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 7, 4, 0, -7 },
  { 38, 1, 6, 4, 1, -6 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 3, 7, 4, 0, -7 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 1, 5, 2, 0, -5 },
  { 68, 1, 6, 2, 0, -5 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 4, 2, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -5 },
  { 74, 3, 7, 3, 0, -7 },
  { 77, 6, 7, 6, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 3, 6, 4, 1, -6 },
  { 89, 3, 7, 4, 1, -7 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 2, 6, 4, 1, -6 },
  { 97, 2, 6, 4, 1, -6 },
  { 99, 4, 7, 5, 1, -7 },
  { 103, 3, 6, 5, 1, -6 },
  { 106, 2, 6, 2, 0, -6 },
  { 108, 2, 8, 2, -1, -6 },
  { 110, 3, 6, 4, 1, -6 },
  { 113, 2, 6, 4, 1, -6 },
  { 115, 5, 6, 6, 1, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 4, 7, 5, 1, -7 },
  { 126, 3, 6, 4, 1, -6 },
  { 129, 4, 9, 5, 1, -7 },
  { 134, 3, 6, 4, 1, -6 },
  { 137, 4, 7, 4, 0, -7 },
  { 141, 3, 6, 3, 0, -6 },
  { 144, 3, 6, 5, 1, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 6, 6, 6, 0, -6 },
  { 155, 3, 6, 3, 0, -6 },
  { 158, 3, 6, 3, 0, -6 },
  { 161, 3, 6, 4, 0, -6 },
  { 164, 1, 7, 3, 1, -6 },
  { 165, 3, 6, 3, 0, -6 },
  { 168, 2, 7, 3, 0, -6 },
  { 170, 4, 3, 4, 0, -6 },
  { 172, 4, 1, 4, 0, 0 },
  { 173, 2, 2, 2, 0, -7 },
  { 174, 3, 5, 4, 0, -5 },
  { 176, 3, 7, 4, 1, -7 },
  { 179, 3, 5, 3, 0, -5 },
  { 181, 4, 7, 4, 0, -7 },
  { 185, 3, 5, 4, 0, -5 },
  { 187, 2, 7, 2, 0, -7 },
  { 189, 4, 7, 4, 0, -5 },
  { 193, 2, 7, 4, 1, -7 },
  { 195, 1, 7, 2, 0, -7 },
  { 196, 1, 9, 2, 0, -7 },
  { 198, 2, 7, 3, 1, -7 },
  { 200, 1, 7, 2, 0, -7 },
  { 201, 4, 5, 6, 1, -5 },
  { 204, 2, 5, 4, 1, -5 },
  { 206, 4, 5, 4, 0, -5 },
  { 209, 3, 7, 4, 1, -5 },
  { 212, 4, 7, 4, 0, -5 },
  { 216, 2, 5, 3, 1, -5 },
  { 218, 3, 5, 3, 0, -5 },
  { 220, 2, 6, 2, 0, -6 },
  { 222, 2, 5, 4, 1, -5 },
  { 224, 3, 5, 3, 0, -5 },
  { 226, 5, 5, 5, 0, -5 },
  { 230, 3, 5, 3, 0, -5 },
  { 232, 3, 7, 3, 0, -5 },
  { 235, 3, 5, 3, 0, -5 },
  { 237, 3, 7, 3, 0, -6 },
  { 240, 1, 9, 4, 1, -7 },
  { 242, 3, 7, 3, 0, -6 },
  { 245, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_Thin9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_THIN9PT7B_H_
