#ifndef _NOTOSANS_CONDENSED_THIN44PT7B_H_
#define _NOTOSANS_CONDENSED_THIN44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x05,
  0xF8, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x01,
  0x81, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x03, 0x00,
  0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x07, 0xFF, 0xFF,
  0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x06, 0x04,
  0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40,
  0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x81, 0x80, 0x08, 0x10, 0x01,
  0x01, 0x00, 0x10, 0x10, 0x00, 0x01, 0x00, 0x02, 0x00, 0x3F, 0xC1, 0xC8,
  0xE6, 0x10, 0x48, 0x20, 0x30, 0x40, 0x40, 0x80, 0x81, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x0C, 0x10, 0x0C, 0x20, 0x0C, 0x40, 0x0C, 0x80, 0x07,
  0x00, 0x03, 0x80, 0x05, 0x80, 0x08, 0xC0, 0x10, 0xC0, 0x20, 0xC0, 0x40,
  0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x40,
  0x21, 0xB8, 0x4E, 0x1F, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x1E, 0x00, 0x20, 0x33, 0x00, 0x40, 0x61, 0x80, 0x40, 0x40, 0x80,
  0x40, 0x40, 0x80, 0x80, 0x40, 0x80, 0x80, 0x80, 0xC1, 0x00, 0x80, 0x41,
  0x00, 0x80, 0x41, 0x00, 0x80, 0x42, 0x00, 0x80, 0x42, 0x00, 0x80, 0x46,
  0x00, 0x80, 0x44, 0x00, 0x80, 0xC4, 0x78, 0x40, 0x88, 0x84, 0x40, 0x89,
  0x82, 0x40, 0x99, 0x02, 0x61, 0x11, 0x02, 0x33, 0x11, 0x03, 0x1C, 0x23,
  0x01, 0x00, 0x23, 0x01, 0x00, 0x62, 0x01, 0x00, 0x42, 0x01, 0x00, 0x42,
  0x01, 0x00, 0x83, 0x01, 0x00, 0x83, 0x01, 0x01, 0x81, 0x03, 0x01, 0x01,
  0x02, 0x01, 0x01, 0x02, 0x02, 0x01, 0x82, 0x02, 0x00, 0x84, 0x06, 0x00,
  0x78, 0x03, 0x80, 0x01, 0x8C, 0x00, 0x60, 0x80, 0x08, 0x08, 0x01, 0x01,
  0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x02, 0x02,
  0x00, 0x40, 0xC0, 0x04, 0x10, 0x00, 0x84, 0x00, 0x09, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x19, 0x00, 0x06, 0x30, 0x00, 0x82, 0x01, 0x20, 0x20,
  0x2C, 0x02, 0x0D, 0x00, 0x61, 0x20, 0x04, 0x24, 0x00, 0x44, 0x80, 0x0D,
  0x10, 0x00, 0xA2, 0x00, 0x08, 0x40, 0x03, 0x84, 0x00, 0x50, 0xC0, 0x11,
  0x0C, 0x0C, 0x30, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x06, 0x03, 0xC0, 0x80, 0x81,
  0x81, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x82,
  0x04, 0x10, 0x20, 0x83, 0x04, 0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x0C, 0x20, 0x9D, 0x38, 0x1E, 0x00, 0x60, 0x04, 0x80, 0x46, 0x06,
  0x10, 0x20, 0x42, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x24,
  0xB6, 0x92, 0x92, 0x00, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00, 0x03,
  0xC0, 0x1C, 0xE0, 0x60, 0x60, 0x80, 0x42, 0x00, 0xC4, 0x00, 0x98, 0x01,
  0x20, 0x03, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x08,
  0x80, 0x11, 0x00, 0x23, 0x00, 0x82, 0x01, 0x03, 0x0C, 0x03, 0xF0, 0x07,
  0x0F, 0x1B, 0x33, 0x43, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0xC0, 0x70, 0xE1, 0x80, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0x0F, 0x80, 0x70, 0xE3, 0x00, 0x64,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x18, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x30, 0x0C, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x40, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40, 0x03, 0x10,
  0x00, 0x84, 0x00, 0x61, 0x00, 0x10, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01,
  0x01, 0x00, 0x40, 0x40, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x03, 0x00,
  0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00, 0x43, 0xFF, 0xFF,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0xFC, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x78, 0x0F, 0x9E, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x98, 0x06, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0x8C, 0x06, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47, 0xF0, 0x48, 0x18, 0xD0,
  0x0C, 0xE0, 0x04, 0xE0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0x40,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20,
  0x02, 0x20, 0x04, 0x10, 0x0C, 0x18, 0x18, 0x0F, 0xF0, 0x00, 0x80, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0,
  0x1E, 0x70, 0x30, 0x08, 0x20, 0x04, 0x40, 0x04, 0x40, 0x06, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x18, 0x18,
  0x0C, 0x30, 0x06, 0xC0, 0x03, 0x80, 0x06, 0x60, 0x18, 0x30, 0x30, 0x08,
  0x60, 0x04, 0x40, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x18,
  0x0F, 0xF0, 0x07, 0xC0, 0x38, 0xC0, 0xC0, 0x43, 0x00, 0x44, 0x00, 0xC8,
  0x00, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x01, 0xA0, 0x03, 0x40, 0x0A, 0x40, 0x34,
  0x61, 0xC8, 0x7E, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x38,
  0x3F, 0xC0, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x67, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x26, 0x64, 0x44, 0x88, 0x80, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x3E, 0x1C, 0x72, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x02,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x02, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x88, 0x07, 0xF0, 0x26, 0x03, 0x04, 0x09, 0x01, 0x01, 0x03,
  0x40, 0x40, 0x40, 0x50, 0x20, 0x10, 0x1C, 0x08, 0x04, 0x07, 0x02, 0x01,
  0x01, 0xC0, 0x80, 0x40, 0x70, 0x60, 0x30, 0x1C, 0x18, 0x0C, 0x07, 0x06,
  0x03, 0x03, 0xC0, 0x80, 0xC0, 0xF0, 0x20, 0x30, 0x24, 0x08, 0x14, 0x09,
  0x03, 0x05, 0x06, 0x40, 0x62, 0x63, 0x10, 0x0F, 0x0F, 0x86, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x58,
  0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x40, 0x03, 0x08,
  0x00, 0x41, 0x00, 0x08, 0x30, 0x01, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08,
  0x01, 0x01, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x3F, 0xFC,
  0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x07,
  0x80, 0x00, 0x60, 0x00, 0x08, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x34, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x68, 0x01, 0x90, 0x06, 0x3F, 0xF0, 0x40, 0x18, 0x80,
  0x0D, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x90,
  0x0E, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xC3, 0xC3, 0x00, 0x23, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x02, 0x07, 0xFE,
  0xFF, 0xE0, 0x40, 0x18, 0x20, 0x03, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00,
  0x1A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x20, 0x01, 0x90, 0x01, 0x88,
  0x01, 0x84, 0x03, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xD0, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFE, 0xFF,
  0xF4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3C, 0x1C, 0x06, 0x00, 0x20, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x20, 0x00, 0x13, 0x00, 0x01, 0x18, 0x00,
  0x10, 0xC0, 0x01, 0x06, 0x00, 0x70, 0x1F, 0xFC, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x3F, 0x80, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0xEE, 0x78, 0x80, 0x07, 0x00,
  0x12, 0x00, 0x64, 0x01, 0x88, 0x02, 0x10, 0x08, 0x20, 0x30, 0x40, 0xC0,
  0x81, 0x01, 0x06, 0x02, 0x18, 0x04, 0x20, 0x08, 0x80, 0x13, 0x00, 0x2F,
  0x00, 0x52, 0x00, 0xC2, 0x01, 0x84, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x10, 0x18, 0x20, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x22, 0x00, 0x64,
  0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x80, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x7A, 0x00, 0x00, 0xB4, 0x00, 0x01,
  0x64, 0x00, 0x06, 0xC8, 0x00, 0x09, 0x90, 0x00, 0x13, 0x10, 0x00, 0x66,
  0x20, 0x00, 0x8C, 0x60, 0x01, 0x18, 0x40, 0x06, 0x30, 0x80, 0x08, 0x61,
  0x80, 0x10, 0xC1, 0x00, 0x61, 0x82, 0x00, 0x83, 0x06, 0x01, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x30, 0x10, 0x40, 0x60, 0x20,
  0x80, 0xC0, 0x61, 0x01, 0x80, 0x44, 0x03, 0x00, 0x88, 0x06, 0x01, 0x90,
  0x0C, 0x01, 0x40, 0x18, 0x02, 0x80, 0x30, 0x07, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x1B, 0x00, 0x0C,
  0x80, 0x06, 0x60, 0x03, 0x10, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x61, 0x80,
  0x30, 0x40, 0x18, 0x30, 0x0C, 0x08, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0xC0, 0x20, 0x60, 0x18, 0x30, 0x04, 0x18, 0x03, 0x0C, 0x00, 0x86,
  0x00, 0x63, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x02, 0x60, 0x00, 0xB0, 0x00,
  0x58, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x70, 0xE0,
  0x0C, 0x03, 0x01, 0x00, 0x18, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00,
  0x64, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0x81, 0x80, 0x18, 0x0C, 0x03,
  0x00, 0x3F, 0xC0, 0xFF, 0xC2, 0x01, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x0A,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x1C, 0xFF, 0xC3, 0xE0, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x70, 0xE0, 0x0C, 0x03, 0x01, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00,
  0x04, 0x40, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x40, 0x00,
  0x24, 0x00, 0x02, 0x60, 0x00, 0x42, 0x00, 0x04, 0x30, 0x00, 0x81, 0x80,
  0x18, 0x0C, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0xFF, 0xC1, 0x00, 0xE2, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x68, 0x00,
  0x90, 0x03, 0x20, 0x0C, 0x40, 0xE0, 0xFF, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x04, 0x10, 0x08, 0x20, 0x08, 0x40, 0x10, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x80, 0x03,
  0xF0, 0x38, 0x3C, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x20, 0x0E, 0x3F, 0xF0, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40,
  0x00, 0xD0, 0x00, 0x26, 0x00, 0x08, 0x80, 0x06, 0x30, 0x03, 0x06, 0x01,
  0x80, 0x7F, 0xC0, 0x80, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x64, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x30, 0x01,
  0x02, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x80, 0x60, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x20,
  0x03, 0x04, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x08, 0x80,
  0x01, 0x10, 0x00, 0x26, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x28, 0x00, 0x70, 0x00, 0xB0, 0x01, 0x40, 0x02, 0x40, 0x05, 0x00, 0x19,
  0x00, 0x16, 0x00, 0x44, 0x00, 0x48, 0x01, 0x18, 0x03, 0x20, 0x04, 0x20,
  0x08, 0x80, 0x10, 0x80, 0x22, 0x00, 0xC2, 0x00, 0x8C, 0x02, 0x0C, 0x06,
  0x10, 0x08, 0x10, 0x10, 0x40, 0x20, 0x40, 0x41, 0x01, 0x81, 0x01, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x10, 0x18, 0x30, 0x20, 0x40, 0x20, 0x80, 0x83,
  0x00, 0x82, 0x02, 0x08, 0x02, 0x08, 0x0C, 0x20, 0x0C, 0x60, 0x10, 0x80,
  0x11, 0x00, 0x46, 0x00, 0x44, 0x01, 0x10, 0x01, 0x10, 0x06, 0x40, 0x06,
  0x40, 0x09, 0x00, 0x0B, 0x00, 0x24, 0x00, 0x28, 0x00, 0xA0, 0x00, 0xA0,
  0x02, 0x80, 0x02, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x60, 0x01, 0x10, 0x01, 0x84, 0x00, 0x82, 0x00, 0xC0, 0x80,
  0x40, 0x40, 0x60, 0x30, 0x20, 0x08, 0x10, 0x06, 0x10, 0x01, 0x08, 0x00,
  0x88, 0x00, 0x24, 0x00, 0x14, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x40, 0x00, 0xB0, 0x00, 0x88, 0x00, 0x46, 0x00, 0x61, 0x00, 0x20,
  0x80, 0x30, 0x20, 0x10, 0x10, 0x18, 0x04, 0x08, 0x02, 0x0C, 0x01, 0x84,
  0x00, 0x46, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0x40, 0x03,
  0x40, 0x02, 0x20, 0x02, 0x20, 0x04, 0x30, 0x04, 0x10, 0x0C, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x20, 0x02, 0x20,
  0x02, 0x60, 0x02, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0xFE,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x12, 0x00, 0x04, 0xC0, 0x02, 0x10, 0x00, 0x86, 0x00, 0x40,
  0x80, 0x10, 0x30, 0x08, 0x04, 0x06, 0x01, 0x01, 0x00, 0x20, 0xC0, 0x08,
  0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x0B, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x07, 0x03, 0xFF, 0x08, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x07, 0xF1, 0xC0, 0x90, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x02, 0xE0, 0x15, 0x81, 0x27, 0xF1, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x81, 0xC0, 0x8F, 0x70, 0x98, 0x08, 0xB0, 0x0C, 0xA0,
  0x04, 0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x04, 0xA0, 0x04, 0xB0, 0x08, 0x98,
  0x18, 0x8F, 0xE0, 0x00, 0xC0, 0x3F, 0xC2, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x20, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03,
  0x04, 0x3F, 0xC8, 0xC0, 0xD3, 0x00, 0xE4, 0x00, 0xD0, 0x01, 0xA0, 0x01,
  0x40, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x64, 0x00, 0xCC, 0x02, 0x8C, 0x0D, 0x0F, 0xE2, 0x03, 0x80, 0x1F, 0xC0,
  0x60, 0x41, 0x80, 0x42, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x05, 0x80, 0x0E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x03, 0x03, 0xFC, 0x01, 0xC0, 0x33, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x01, 0x80, 0x1F, 0xE4,
  0x60, 0x69, 0x80, 0x72, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x32, 0x00, 0x66,
  0x01, 0x46, 0x04, 0x87, 0xF1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x40, 0x18, 0x7F, 0xE0,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x06, 0x0C, 0xFF, 0x36, 0x04, 0xF0,
  0x0A, 0x80, 0x2C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x04,
  0x7C, 0x00, 0x15, 0x55, 0x55, 0x55, 0x55, 0x55, 0x04, 0x30, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC2, 0x0B, 0xE4, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0D, 0x80,
  0x4C, 0x04, 0x60, 0x63, 0x02, 0x18, 0x20, 0xC2, 0x06, 0x30, 0x31, 0x01,
  0x98, 0x0D, 0xE0, 0x69, 0x03, 0x8C, 0x18, 0x20, 0xC1, 0x86, 0x04, 0x30,
  0x31, 0x80, 0x8C, 0x06, 0x60, 0x13, 0x00, 0xD8, 0x02, 0xC0, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x70, 0x8E,
  0xE1, 0xDC, 0x90, 0x22, 0x06, 0xA0, 0x14, 0x02, 0xA0, 0x14, 0x02, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0,
  0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0x01, 0x82, 0x3B, 0xC9,
  0x81, 0xAC, 0x02, 0xA0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x01, 0x80, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x04,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x30, 0x0C, 0x18, 0x18,
  0x0F, 0xF0, 0x01, 0x80, 0x8F, 0xF0, 0x98, 0x18, 0x90, 0x0C, 0xA0, 0x04,
  0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0xA0, 0x04, 0xA0, 0x04, 0xD0, 0x08, 0xD8, 0x18,
  0xCF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x1F, 0xE4, 0x60, 0x69, 0x80, 0x52, 0x00, 0x68, 0x00, 0xD0, 0x00, 0xA0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x32,
  0x00, 0x66, 0x01, 0x46, 0x04, 0x87, 0xF1, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x03, 0x63, 0xE9, 0x82, 0x40, 0xA0, 0x28, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x03, 0x03, 0xDF, 0x60,
  0x1C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x80, 0x67, 0xF8, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x83, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x02, 0x00, 0xF8, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xD0, 0x05, 0x40, 0x34, 0x81, 0x91, 0xFC, 0x40, 0xC0, 0x06,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x66, 0x00, 0x84, 0x01, 0x08, 0x06, 0x10,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0xC1, 0x00, 0x82, 0x01, 0x0C,
  0x02, 0x10, 0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x1A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xA0, 0x0E, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x05, 0x80, 0x90,
  0x19, 0x01, 0x30, 0x22, 0x06, 0x20, 0x44, 0x08, 0x40, 0x8C, 0x10, 0x83,
  0x08, 0x21, 0x84, 0x10, 0xC1, 0x08, 0x21, 0x02, 0x10, 0x62, 0x04, 0x40,
  0x44, 0x08, 0x80, 0x88, 0x09, 0x01, 0x20, 0x12, 0x03, 0x40, 0x28, 0x02,
  0x80, 0x50, 0x05, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x10,
  0x00, 0xC0, 0x0D, 0x00, 0x22, 0x01, 0x0C, 0x04, 0x10, 0x20, 0x61, 0x80,
  0x84, 0x03, 0x30, 0x04, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x80,
  0x12, 0x00, 0xCC, 0x02, 0x10, 0x18, 0x60, 0x40, 0x83, 0x03, 0x08, 0x04,
  0x60, 0x19, 0x00, 0x28, 0x00, 0xC0, 0x40, 0x02, 0x80, 0x0D, 0x80, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x18, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x80, 0xC2, 0x00, 0x84, 0x01, 0x08, 0x02, 0x30,
  0x02, 0x40, 0x04, 0x80, 0x0B, 0x00, 0x14, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x7F, 0xF0,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x40,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x03, 0x80, 0x38,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x03, 0x80, 0xE0,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x81, 0xC0,
  0x00, 0x7F, 0x01, 0x81, 0x83, 0x80, 0x7E,
};

const GFXglyph NotoSans_Condensed_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 7, 11, 13, 3, -31 },
  { 23, 20, 31, 22, 1, -31 },
  { 101, 15, 36, 20, 2, -33 },
  { 169, 24, 32, 28, 2, -32 },
  { 265, 19, 32, 21, 2, -32 },
  { 341, 1, 11, 7, 3, -31 },
  { 343, 8, 38, 11, 2, -31 },
  { 381, 7, 38, 11, 2, -31 },
  { 415, 13, 13, 18, 2, -33 },
  { 437, 16, 21, 20, 2, -26 },
  { 479, 3, 11, 8, 2, -5 },
  { 484, 10, 2, 12, 1, -13 },
  { 487, 2, 3, 8, 3, -3 },
  { 488, 13, 31, 14, 1, -31 },
  { 539, 15, 32, 20, 2, -32 },
  { 599, 8, 31, 20, 4, -31 },
  { 630, 15, 32, 20, 2, -32 },
  { 690, 15, 32, 20, 2, -32 },
  { 750, 18, 32, 20, 1, -32 },
  { 822, 15, 31, 20, 2, -31 },
  { 881, 16, 33, 20, 2, -32 },
  { 947, 15, 31, 20, 2, -31 },
  { 1006, 16, 32, 20, 2, -32 },
  { 1070, 15, 32, 20, 2, -32 },
  { 1130, 2, 23, 8, 3, -23 },
  { 1136, 4, 29, 8, 2, -23 },
  { 1151, 16, 19, 20, 2, -25 },
  { 1189, 16, 11, 20, 2, -21 },
  { 1211, 16, 19, 20, 2, -25 },
  { 1249, 11, 32, 14, 1, -32 },
  { 1293, 26, 35, 30, 2, -31 },
  { 1407, 19, 31, 19, 0, -31 },
  { 1481, 15, 31, 21, 4, -31 },
  { 1540, 17, 32, 21, 3, -32 },
  { 1608, 17, 31, 24, 4, -31 },
  { 1674, 13, 31, 19, 4, -31 },
  { 1725, 13, 31, 17, 4, -31 },
  { 1776, 20, 32, 26, 3, -32 },
  { 1856, 17, 31, 24, 4, -31 },
  { 1922, 7, 31, 10, 2, -31 },
  { 1950, 8, 39, 9, -3, -31 },
  { 1989, 15, 31, 19, 4, -31 },
  { 2048, 12, 31, 17, 4, -31 },
  { 2095, 23, 31, 31, 4, -31 },
  { 2185, 17, 31, 25, 4, -31 },
  { 2251, 20, 32, 26, 3, -32 },
  { 2331, 14, 31, 20, 4, -31 },
  { 2386, 20, 39, 26, 3, -32 },
  { 2484, 15, 31, 20, 4, -31 },
  { 2543, 15, 32, 19, 2, -32 },
  { 2603, 17, 31, 17, 0, -31 },
  { 2669, 18, 31, 24, 3, -31 },
  { 2739, 19, 31, 19, 0, -31 },
  { 2813, 30, 31, 31, 1, -31 },
  { 2930, 17, 31, 17, 0, -31 },
  { 2996, 16, 31, 16, 0, -31 },
  { 3058, 15, 31, 18, 1, -31 },
  { 3117, 8, 38, 14, 4, -31 },
  { 3155, 13, 31, 14, 1, -31 },
  { 3206, 9, 38, 14, 1, -31 },
  { 3249, 18, 16, 20, 1, -31 },
  { 3285, 17, 1, 17, 0, 4 },
  { 3288, 6, 7, 10, 2, -34 },
  { 3294, 13, 24, 18, 2, -24 },
  { 3333, 16, 33, 21, 3, -33 },
  { 3399, 13, 24, 16, 2, -24 },
  { 3438, 15, 33, 21, 2, -33 },
  { 3500, 15, 24, 19, 2, -24 },
  { 3545, 12, 34, 10, 0, -34 },
  { 3596, 15, 35, 21, 2, -24 },
  { 3662, 14, 33, 20, 3, -33 },
  { 3720, 2, 32, 8, 3, -32 },
  { 3728, 6, 43, 8, -1, -32 },
  { 3761, 13, 33, 16, 3, -33 },
  { 3815, 2, 33, 8, 3, -33 },
  { 3824, 24, 24, 30, 3, -24 },
  { 3896, 14, 24, 20, 3, -24 },
  { 3938, 16, 24, 20, 2, -24 },
  { 3986, 16, 34, 21, 3, -24 },
  { 4054, 15, 34, 21, 2, -24 },
  { 4118, 10, 24, 13, 3, -24 },
  { 4148, 12, 24, 16, 2, -24 },
  { 4184, 9, 29, 11, 1, -29 },
  { 4217, 14, 23, 20, 3, -23 },
  { 4258, 15, 23, 15, 0, -23 },
  { 4302, 23, 23, 25, 1, -23 },
  { 4369, 14, 23, 16, 1, -23 },
  { 4410, 15, 34, 15, 0, -23 },
  { 4474, 12, 23, 14, 1, -23 },
  { 4509, 11, 38, 15, 2, -31 },
  { 4562, 1, 45, 19, 9, -34 },
  { 4568, 11, 38, 15, 2, -31 },
  { 4621, 16, 3, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_Thin44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_THIN44PT7B_H_
