#ifndef _NOTOSANS_CONDENSED_THIN39PT7B_H_
#define _NOTOSANS_CONDENSED_THIN39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEA, 0x80, 0x0F, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40,
  0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20, 0x08, 0x10, 0x04, 0x08, 0x3F,
  0xFF, 0xC1, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x20, 0x40,
  0x10, 0x20, 0x08, 0x10, 0x04, 0x08, 0x3F, 0xFF, 0xC1, 0x02, 0x00, 0x81,
  0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x10, 0x04,
  0x08, 0x02, 0x04, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0xE6, 0x21,
  0x61, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x04,
  0x20, 0x31, 0x00, 0x68, 0x01, 0xC0, 0x03, 0x80, 0x16, 0x00, 0x8C, 0x04,
  0x30, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x85,
  0x04, 0x47, 0xFC, 0x01, 0x00, 0x08, 0x00, 0x40, 0x3C, 0x01, 0x02, 0x10,
  0x08, 0x10, 0x40, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x02,
  0x04, 0x10, 0x10, 0x20, 0x80, 0x81, 0x08, 0x04, 0x08, 0x40, 0x20, 0x44,
  0x01, 0x02, 0x23, 0xC8, 0x11, 0x23, 0x40, 0x92, 0x09, 0x0C, 0x90, 0x48,
  0x48, 0x81, 0x3C, 0x44, 0x08, 0x02, 0x20, 0x40, 0x21, 0x02, 0x01, 0x10,
  0x10, 0x10, 0x40, 0x80, 0x82, 0x04, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x20, 0x81, 0x00, 0x84, 0x18, 0x03, 0xC0, 0x0F, 0x80,
  0x10, 0xC0, 0x30, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x10, 0x40, 0x10, 0x40, 0x18, 0x80, 0x09, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x12, 0x00, 0x21, 0x00, 0x41, 0x01, 0x80, 0x82, 0x80, 0x42,
  0x80, 0x62, 0x80, 0x22, 0x80, 0x14, 0x80, 0x1C, 0x80, 0x08, 0x80, 0x14,
  0x40, 0x32, 0x60, 0x62, 0x3F, 0x81, 0xFF, 0xC0, 0x06, 0x18, 0x20, 0x81,
  0x04, 0x08, 0x30, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x0C, 0x83, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x20, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x08, 0x20, 0x84, 0x10,
  0xC2, 0x18, 0x42, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x84, 0x37,
  0x4C, 0x0F, 0x00, 0x60, 0x09, 0x01, 0x08, 0x20, 0x82, 0x04, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x33, 0x22, 0x26, 0x44,
  0xC0, 0xFF, 0x80, 0xF0, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x83, 0x08, 0x08,
  0x40, 0x24, 0x01, 0x20, 0x0D, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x20, 0x11,
  0x01, 0x04, 0x18, 0x1F, 0x80, 0x02, 0x0C, 0x29, 0x96, 0x38, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x1F, 0x87, 0x03, 0x10, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x01, 0xFF, 0xF0, 0x3F, 0x83, 0x03, 0x20, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x0F, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0xA0, 0x18,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0xD0,
  0x00, 0x90, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10,
  0x0C, 0x10, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x10, 0x20, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F, 0xF1,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x8E, 0x07, 0x9C, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0xA0, 0x18, 0xFF, 0x00, 0x03, 0xF0, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x23, 0xF0, 0x98, 0x22, 0x80, 0x4C, 0x00, 0xB0, 0x02,
  0xC0, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0D, 0x00, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x08, 0x80, 0x41, 0x02, 0x03, 0xF0, 0x03, 0x00, 0xFF,
  0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0xC0,
  0x86, 0x01, 0x10, 0x06, 0x40, 0x0B, 0x00, 0x2C, 0x00, 0x90, 0x02, 0x40,
  0x19, 0x80, 0x43, 0x02, 0x06, 0x10, 0x05, 0x80, 0x1C, 0x01, 0x8C, 0x0C,
  0x18, 0x60, 0x11, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x02, 0x80, 0x09, 0x00, 0x42, 0x03, 0x07, 0xF0, 0x1F, 0x81,
  0x02, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x0D, 0x00, 0xA4, 0x0D,
  0x1F, 0x88, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFE, 0x00, 0xBC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x23, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x32,
  0x22, 0x64, 0x4C, 0x00, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x7E, 0x20, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x03,
  0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x7E, 0x00, 0x03, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x60, 0x01, 0x01, 0x80, 0x01, 0x02, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x40, 0x3E, 0x04, 0x80, 0xC2, 0x09,
  0x02, 0x04, 0x16, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60,
  0x40, 0xC0, 0xC1, 0x01, 0x01, 0x82, 0x02, 0x03, 0x04, 0x04, 0x06, 0x0C,
  0x08, 0x14, 0x08, 0x10, 0x28, 0x10, 0x50, 0x58, 0x20, 0xA1, 0x10, 0x36,
  0x66, 0x20, 0x18, 0x30, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x10, 0x00, 0xE3, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x12, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x10, 0x02, 0x08,
  0x01, 0x04, 0x00, 0x82, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x18, 0x1F, 0xFC, 0x08, 0x02, 0x04, 0x01, 0x04, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x0C, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0xA0, 0x00,
  0x30, 0x00, 0x10, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A,
  0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04,
  0x80, 0x63, 0xFF, 0x08, 0x03, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00,
  0x68, 0x03, 0x3F, 0xF0, 0x01, 0xFF, 0x06, 0x02, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x01, 0x03, 0xFE,
  0xFF, 0x80, 0x80, 0xE0, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x10, 0x80, 0x60, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x01, 0xFF, 0x01, 0x80,
  0x30, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x12, 0x00, 0x04,
  0xC0, 0x01, 0x10, 0x00, 0x42, 0x00, 0x10, 0x60, 0x04, 0x07, 0xFE, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x02, 0x05, 0x13, 0xC0, 0x80, 0x0E, 0x00, 0x68,
  0x01, 0x20, 0x08, 0x80, 0x42, 0x03, 0x08, 0x08, 0x20, 0x40, 0x83, 0x02,
  0x18, 0x08, 0x40, 0x22, 0x00, 0x98, 0x02, 0x50, 0x0A, 0x40, 0x30, 0x80,
  0xC2, 0x02, 0x04, 0x08, 0x18, 0x20, 0x20, 0x80, 0xC2, 0x01, 0x08, 0x02,
  0x20, 0x08, 0x80, 0x12, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE8, 0x00, 0x07, 0x40, 0x00, 0x3A, 0x00,
  0x02, 0xC8, 0x00, 0x16, 0x40, 0x00, 0xB2, 0x00, 0x09, 0x88, 0x00, 0x4C,
  0x40, 0x02, 0x62, 0x00, 0x23, 0x08, 0x01, 0x18, 0x40, 0x08, 0xC2, 0x00,
  0x86, 0x08, 0x04, 0x30, 0x40, 0x21, 0x82, 0x02, 0x0C, 0x08, 0x10, 0x60,
  0x40, 0x83, 0x02, 0x08, 0x18, 0x08, 0x40, 0xC0, 0x42, 0x06, 0x02, 0x20,
  0x30, 0x09, 0x01, 0x80, 0x48, 0x0C, 0x02, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x10, 0xC0, 0x01, 0xC0, 0x01, 0xA0, 0x01, 0xA0, 0x01, 0x90, 0x01,
  0x90, 0x01, 0x88, 0x01, 0x88, 0x01, 0x84, 0x01, 0x84, 0x01, 0x82, 0x01,
  0x82, 0x01, 0x81, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0x81, 0x80, 0x41,
  0x80, 0x41, 0x80, 0x21, 0x80, 0x21, 0x80, 0x11, 0x80, 0x11, 0x80, 0x09,
  0x80, 0x09, 0x80, 0x05, 0x80, 0x05, 0x80, 0x03, 0x80, 0x03, 0x03, 0xF8,
  0x01, 0x80, 0xC0, 0x60, 0x0C, 0x08, 0x00, 0x82, 0x00, 0x08, 0x40, 0x01,
  0x10, 0x00, 0x32, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04,
  0x80, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04, 0x10, 0x01, 0x03, 0x00, 0x60,
  0x30, 0x18, 0x01, 0xFC, 0x00, 0xFF, 0x04, 0x06, 0x20, 0x09, 0x00, 0x28,
  0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x28, 0x01, 0x40, 0x12, 0x03, 0x1F, 0xF0, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x08, 0x00,
  0x82, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04,
  0x10, 0x01, 0x03, 0x00, 0x60, 0x30, 0x18, 0x01, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0xFF, 0x02, 0x03, 0x08, 0x03, 0x20, 0x04, 0x80, 0x1A,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04,
  0x80, 0x32, 0x01, 0x8F, 0xF8, 0x20, 0x40, 0x81, 0x02, 0x02, 0x08, 0x08,
  0x20, 0x30, 0x80, 0x42, 0x01, 0x88, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00,
  0x68, 0x00, 0xA0, 0x03, 0x0F, 0xF1, 0x80, 0xD8, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0xA0, 0x19,
  0xFF, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x30,
  0x18, 0x0F, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x22, 0x00, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x04, 0x08, 0x02,
  0x04, 0x01, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x20, 0x08, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x84, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x28, 0x00, 0xC0, 0x05, 0x00, 0x18,
  0x00, 0xA0, 0x03, 0x00, 0x32, 0x00, 0xA0, 0x04, 0x40, 0x16, 0x00, 0x88,
  0x02, 0x40, 0x11, 0x00, 0x48, 0x02, 0x20, 0x19, 0x00, 0x82, 0x02, 0x20,
  0x10, 0x40, 0x42, 0x02, 0x08, 0x08, 0x40, 0x41, 0x01, 0x08, 0x10, 0x10,
  0x41, 0x02, 0x02, 0x08, 0x30, 0x40, 0x41, 0x02, 0x08, 0x08, 0x20, 0x42,
  0x00, 0x84, 0x08, 0x40, 0x11, 0x01, 0x08, 0x02, 0x20, 0x11, 0x00, 0x44,
  0x02, 0x60, 0x0C, 0x80, 0x48, 0x00, 0xA0, 0x09, 0x00, 0x14, 0x01, 0xA0,
  0x02, 0x80, 0x14, 0x00, 0x50, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x40, 0x08, 0x80, 0x20, 0x80, 0x41, 0x01, 0x81,
  0x02, 0x02, 0x04, 0x06, 0x10, 0x04, 0x20, 0x08, 0x80, 0x09, 0x00, 0x14,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x01, 0x40, 0x02, 0x40, 0x08, 0x80,
  0x11, 0x80, 0x41, 0x00, 0x82, 0x02, 0x02, 0x04, 0x04, 0x18, 0x04, 0x20,
  0x08, 0xC0, 0x09, 0x00, 0x16, 0x00, 0x30, 0x80, 0x06, 0x80, 0x09, 0x00,
  0x32, 0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x10, 0x40, 0x21, 0x00, 0x62, 0x00, 0x44, 0x00, 0x90, 0x00, 0xA0, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x7F, 0xF8, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF,
  0x01, 0x80, 0x03, 0x00, 0x0B, 0x00, 0x12, 0x00, 0x46, 0x00, 0x84, 0x02,
  0x0C, 0x04, 0x08, 0x10, 0x18, 0x20, 0x10, 0x80, 0x21, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xFE, 0x86, 0x10, 0x41, 0x04, 0x1F,
  0x0C, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x3C, 0x78, 0xB0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xA0, 0x53, 0xF2, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x7C, 0x26, 0x19, 0x40, 0x6C,
  0x01, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x05,
  0x40, 0x6B, 0x06, 0x4F, 0xE0, 0x07, 0xC3, 0x04, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFE, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x7C, 0x46, 0x1A, 0x40, 0x76, 0x01, 0xA0, 0x05, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0A, 0x00, 0x50, 0x06, 0xC0, 0x33, 0x02, 0x8F, 0xE4, 0x0F,
  0x80, 0xC2, 0x08, 0x08, 0xC0, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x01,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x20, 0xFE, 0x00, 0x03, 0xC1,
  0x10, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xC0, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x0F, 0x88, 0xC3, 0x48, 0x06, 0x80, 0x34, 0x00, 0xA0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x06, 0x60, 0x51, 0xFC, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x24, 0x02, 0x3F,
  0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0xF8, 0x98, 0x4A, 0x02, 0xC0, 0x2C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF0, 0x02,
  0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x02, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0xF0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x0A, 0x01,
  0x40, 0x48, 0x11, 0x06, 0x20, 0x84, 0x20, 0x88, 0x11, 0x02, 0x60, 0x52,
  0x0A, 0x41, 0x84, 0x20, 0x84, 0x08, 0x81, 0x10, 0x12, 0x02, 0x40, 0x28,
  0x05, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x8F, 0x03, 0xC5, 0x84, 0x61,
  0x28, 0x16, 0x05, 0x80, 0xA0, 0x2C, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x80, 0x8F, 0x89, 0x84, 0xA0, 0x2C, 0x03, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0F,
  0x80, 0x61, 0x82, 0x01, 0x10, 0x04, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xA0, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x0C, 0x08, 0x0F, 0xC0,
  0x8F, 0x84, 0xC3, 0x28, 0x0D, 0x40, 0x2C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0xA8, 0x05, 0x60, 0x49, 0xFC, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x07, 0x88, 0xC3, 0x48, 0x0E, 0xC0, 0x34, 0x00, 0xA0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x06, 0x60, 0xD1, 0xFC, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x8F, 0x91, 0xA0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F,
  0xC6, 0x0D, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0xE0, 0x27, 0xF8, 0x20, 0x20, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x30, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x54, 0x09,
  0x3F, 0x10, 0x80, 0x0C, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x10, 0x10,
  0x80, 0x84, 0x04, 0x20, 0x20, 0x82, 0x04, 0x10, 0x20, 0x80, 0x88, 0x04,
  0x40, 0x22, 0x01, 0x10, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x20,
  0x00, 0xC0, 0x10, 0x05, 0x00, 0xC0, 0x24, 0x03, 0x00, 0x90, 0x0C, 0x02,
  0x40, 0x28, 0x08, 0x81, 0x20, 0x42, 0x04, 0x81, 0x08, 0x12, 0x04, 0x20,
  0x44, 0x10, 0x42, 0x10, 0x81, 0x08, 0x42, 0x04, 0x21, 0x08, 0x10, 0x82,
  0x20, 0x24, 0x09, 0x00, 0x90, 0x24, 0x02, 0x40, 0x90, 0x09, 0x01, 0x40,
  0x18, 0x05, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x80,
  0x14, 0x03, 0x40, 0x22, 0x04, 0x20, 0x41, 0x08, 0x10, 0x80, 0x90, 0x0D,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08, 0x20,
  0x42, 0x06, 0x40, 0x24, 0x03, 0x80, 0x10, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x40, 0x32, 0x01, 0x10, 0x08, 0x80, 0x42, 0x04, 0x10, 0x20, 0x81, 0x02,
  0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x78, 0x00, 0x7F, 0xC0, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0xFF, 0xC0, 0x01,
  0xC1, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x60, 0x38, 0x01, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x03, 0x00, 0x70, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x18, 0x38, 0x00, 0x7F, 0x03, 0x83, 0x8E, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 28, 8, 3, -28 },
  { 8, 6, 10, 12, 3, -28 },
  { 16, 17, 28, 19, 1, -28 },
  { 76, 13, 32, 17, 2, -30 },
  { 128, 21, 28, 25, 2, -28 },
  { 202, 16, 28, 19, 2, -28 },
  { 258, 1, 10, 6, 3, -28 },
  { 260, 7, 34, 10, 2, -28 },
  { 290, 6, 34, 10, 2, -28 },
  { 316, 12, 12, 16, 2, -30 },
  { 334, 15, 18, 18, 1, -23 },
  { 368, 4, 9, 7, 1, -4 },
  { 373, 9, 1, 11, 1, -11 },
  { 375, 2, 2, 7, 3, -2 },
  { 376, 11, 28, 13, 1, -28 },
  { 415, 13, 28, 17, 2, -28 },
  { 461, 7, 28, 17, 3, -28 },
  { 486, 13, 28, 17, 2, -28 },
  { 532, 13, 28, 17, 2, -28 },
  { 578, 16, 28, 17, 1, -28 },
  { 634, 13, 28, 17, 2, -28 },
  { 680, 14, 29, 17, 2, -28 },
  { 731, 13, 28, 17, 2, -28 },
  { 777, 14, 28, 17, 2, -28 },
  { 826, 13, 28, 17, 2, -28 },
  { 872, 2, 21, 7, 3, -21 },
  { 878, 4, 26, 7, 1, -21 },
  { 891, 15, 16, 18, 1, -22 },
  { 921, 15, 9, 18, 1, -18 },
  { 938, 15, 16, 18, 1, -22 },
  { 968, 10, 28, 12, 1, -28 },
  { 1003, 23, 32, 27, 2, -28 },
  { 1095, 17, 28, 17, 0, -28 },
  { 1155, 14, 28, 19, 3, -28 },
  { 1204, 16, 28, 19, 2, -28 },
  { 1260, 16, 28, 21, 3, -28 },
  { 1316, 12, 28, 17, 3, -28 },
  { 1358, 12, 28, 15, 3, -28 },
  { 1400, 18, 28, 23, 2, -28 },
  { 1463, 15, 28, 22, 3, -28 },
  { 1516, 6, 28, 9, 2, -28 },
  { 1537, 7, 35, 8, -2, -28 },
  { 1568, 14, 28, 17, 3, -28 },
  { 1617, 11, 28, 15, 3, -28 },
  { 1656, 21, 28, 28, 3, -28 },
  { 1730, 16, 28, 22, 3, -28 },
  { 1786, 19, 28, 23, 2, -28 },
  { 1853, 13, 28, 17, 3, -28 },
  { 1899, 19, 35, 23, 2, -28 },
  { 1983, 14, 28, 18, 3, -28 },
  { 2032, 13, 28, 17, 2, -28 },
  { 2078, 15, 28, 15, 0, -28 },
  { 2131, 16, 28, 22, 3, -28 },
  { 2187, 17, 28, 17, 0, -28 },
  { 2247, 27, 28, 28, 0, -28 },
  { 2342, 15, 28, 15, 0, -28 },
  { 2395, 15, 28, 15, 0, -28 },
  { 2448, 14, 28, 16, 1, -28 },
  { 2497, 8, 34, 12, 3, -28 },
  { 2531, 11, 28, 13, 1, -28 },
  { 2570, 8, 34, 12, 1, -28 },
  { 2604, 15, 15, 17, 1, -28 },
  { 2633, 15, 1, 15, 0, 4 },
  { 2635, 5, 6, 9, 2, -30 },
  { 2639, 11, 21, 16, 2, -21 },
  { 2668, 13, 30, 18, 3, -30 },
  { 2717, 11, 21, 14, 2, -21 },
  { 2746, 13, 30, 18, 2, -30 },
  { 2795, 13, 21, 17, 2, -21 },
  { 2830, 10, 30, 9, 0, -30 },
  { 2868, 13, 30, 18, 2, -21 },
  { 2917, 12, 30, 18, 3, -30 },
  { 2962, 2, 28, 7, 3, -28 },
  { 2969, 6, 37, 7, -1, -28 },
  { 2997, 11, 30, 14, 3, -30 },
  { 3039, 1, 30, 7, 3, -30 },
  { 3043, 21, 21, 27, 3, -21 },
  { 3099, 12, 21, 18, 3, -21 },
  { 3131, 14, 21, 18, 2, -21 },
  { 3168, 13, 30, 18, 3, -21 },
  { 3217, 13, 30, 18, 2, -21 },
  { 3266, 8, 21, 12, 3, -21 },
  { 3287, 11, 21, 14, 1, -21 },
  { 3316, 8, 26, 9, 1, -26 },
  { 3342, 12, 21, 18, 3, -21 },
  { 3374, 13, 21, 13, 0, -21 },
  { 3409, 22, 21, 22, 0, -21 },
  { 3467, 12, 21, 14, 1, -21 },
  { 3499, 13, 30, 14, 0, -21 },
  { 3548, 10, 21, 12, 1, -21 },
  { 3575, 10, 34, 13, 2, -28 },
  { 3618, 1, 40, 17, 8, -30 },
  { 3623, 10, 34, 13, 2, -28 },
  { 3666, 15, 3, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_Thin39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_THIN39PT7B_H_
