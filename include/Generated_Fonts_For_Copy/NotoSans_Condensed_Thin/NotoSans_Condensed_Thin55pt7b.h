#ifndef _NOTOSANS_CONDENSED_THIN55PT7B_H_
#define _NOTOSANS_CONDENSED_THIN55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x0F, 0xF8, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x08, 0x00, 0x18, 0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x01, 0x00,
  0x02, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x20,
  0x00, 0x60, 0x10, 0x00, 0x20, 0x08, 0x00, 0x10, 0x04, 0x03, 0xFF, 0xFF,
  0xF8, 0x04, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80,
  0x40, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x08, 0x00, 0x10,
  0x0C, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x03,
  0x00, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x80, 0x20, 0x00, 0x40, 0x30, 0x00,
  0x20, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00,
  0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x60,
  0x00, 0x40, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x81, 0xC4,
  0x1C, 0x30, 0x40, 0x06, 0x04, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0xC0,
  0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x04,
  0x04, 0x00, 0x60, 0x40, 0x03, 0x04, 0x00, 0x18, 0x40, 0x00, 0xC4, 0x00,
  0x07, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x05, 0xC0, 0x00, 0x47,
  0x00, 0x04, 0x18, 0x00, 0x40, 0xC0, 0x04, 0x06, 0x00, 0x40, 0x20, 0x04,
  0x02, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00,
  0x40, 0x20, 0x04, 0x06, 0x00, 0x40, 0x60, 0x04, 0x0C, 0xE0, 0x43, 0x87,
  0xE5, 0xF0, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x30, 0x08, 0x30,
  0x01, 0x00, 0xC0, 0x80, 0x18, 0x04, 0x06, 0x00, 0xC0, 0x60, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x81, 0x80, 0x20, 0x0C, 0x08, 0x01, 0x00, 0x60, 0xC0, 0x08, 0x03,
  0x04, 0x00, 0x40, 0x18, 0x20, 0x02, 0x00, 0xC3, 0x00, 0x10, 0x06, 0x10,
  0x00, 0x80, 0x21, 0x87, 0xC4, 0x01, 0x08, 0x63, 0x30, 0x08, 0x46, 0x0D,
  0x80, 0x46, 0x20, 0x24, 0x06, 0x23, 0x01, 0x30, 0x23, 0x18, 0x0C, 0x83,
  0x10, 0x80, 0x27, 0xF0, 0x84, 0x01, 0x0E, 0x0C, 0x20, 0x08, 0x00, 0x41,
  0x00, 0x40, 0x06, 0x18, 0x02, 0x00, 0x20, 0xC0, 0x10, 0x01, 0x06, 0x00,
  0x80, 0x18, 0x30, 0x04, 0x00, 0x80, 0x80, 0x20, 0x0C, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00,
  0x60, 0x30, 0x18, 0x01, 0x01, 0x00, 0xC0, 0x0C, 0x18, 0x04, 0x00, 0x21,
  0x80, 0x60, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x06, 0x04, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x08,
  0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x08,
  0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x04,
  0x06, 0x00, 0x06, 0x04, 0x00, 0x02, 0x08, 0x00, 0x03, 0x18, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x20, 0x00, 0x18, 0x30, 0x00, 0x30, 0x18, 0x06, 0x20, 0x08, 0x06, 0x60,
  0x0C, 0x04, 0x40, 0x06, 0x04, 0xC0, 0x02, 0x04, 0xC0, 0x03, 0x0C, 0xC0,
  0x01, 0x88, 0xC0, 0x00, 0x88, 0xC0, 0x00, 0xD0, 0xC0, 0x00, 0x70, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x70, 0x60, 0x00, 0xD8, 0x20, 0x01, 0x88, 0x30,
  0x03, 0x04, 0x1C, 0x0E, 0x06, 0x07, 0xFC, 0x03, 0x00, 0x40, 0x00, 0xFF,
  0xFC, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x83, 0x38, 0x9C, 0x07,
  0xE0, 0x01, 0x80, 0x03, 0x40, 0x02, 0x60, 0x04, 0x20, 0x08, 0x10, 0x18,
  0x18, 0x30, 0x0C, 0x20, 0x04, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x0F, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x18,
  0xC4, 0x63, 0x18, 0x84, 0x63, 0x10, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x30, 0x18, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x60, 0x03, 0x08, 0x00, 0x63,
  0x00, 0x04, 0x60, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0x2C,
  0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x60,
  0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0x90, 0x00, 0x32, 0x00, 0x06, 0x60,
  0x00, 0x84, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0x81, 0x80, 0x30, 0x18,
  0x0C, 0x03, 0x83, 0x00, 0x1F, 0xC0, 0x01, 0x81, 0xC1, 0xA1, 0x91, 0x8B,
  0x87, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0x00, 0xE3, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x01, 0xFF,
  0xC0, 0xE0, 0x1C, 0x70, 0x00, 0xC4, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x09,
  0x00, 0x07, 0x3C, 0x01, 0xC1, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x68,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80,
  0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x18, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40, 0x03, 0x00, 0x80, 0x04,
  0x01, 0x00, 0x18, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x10, 0x04, 0x00, 0x20, 0x18, 0x00, 0x40, 0x20, 0x00, 0x80, 0xC0, 0x01,
  0x01, 0x00, 0x02, 0x06, 0x00, 0x04, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xFF, 0x84, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x5F, 0xF8, 0x0E, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x88, 0x00, 0x61, 0xC0, 0x38, 0x0F, 0xFE, 0x00,
  0x08, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC1, 0xF8, 0x18, 0xF3, 0xC3, 0x30, 0x0C, 0x68,
  0x00, 0xCA, 0x00, 0x09, 0x40, 0x01, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x4C, 0x00, 0x08, 0x80,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x30, 0x02, 0x03, 0x01, 0x80, 0x3F,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0C, 0x03, 0x81, 0x80, 0x08, 0x10,
  0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x26,
  0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x61, 0x00, 0x0C,
  0x18, 0x00, 0x80, 0xC0, 0x18, 0x06, 0x07, 0x00, 0x38, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x03, 0x9C, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x81, 0x80,
  0x08, 0x30, 0x00, 0xC2, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x03, 0x40,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x34,
  0x00, 0x03, 0x60, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x1C,
  0x0E, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00,
  0x33, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00,
  0x28, 0x00, 0x0D, 0x80, 0x01, 0x90, 0x00, 0x73, 0x00, 0x0A, 0x20, 0x03,
  0x46, 0x00, 0xC8, 0x7D, 0xE1, 0x03, 0xF0, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x08, 0x0E, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x39, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x18, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x11, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xFF,
  0x8C, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x06, 0x20, 0x03, 0xF8, 0x06, 0x60, 0x07, 0x1C, 0x02, 0x60,
  0x0C, 0x04, 0x02, 0x40, 0x18, 0x0C, 0x02, 0x40, 0x30, 0x0C, 0x03, 0xC0,
  0x30, 0x0C, 0x03, 0xC0, 0x20, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0,
  0x60, 0x0C, 0x03, 0x80, 0x40, 0x0C, 0x03, 0x80, 0x40, 0x0C, 0x03, 0x80,
  0x40, 0x0C, 0x03, 0x80, 0x40, 0x0C, 0x03, 0x80, 0x40, 0x08, 0x03, 0x80,
  0x40, 0x08, 0x02, 0xC0, 0x60, 0x18, 0x02, 0xC0, 0x60, 0x1C, 0x06, 0xC0,
  0x60, 0x14, 0x06, 0xC0, 0x30, 0x34, 0x04, 0x40, 0x30, 0x66, 0x0C, 0x40,
  0x1F, 0xC3, 0xF8, 0x60, 0x07, 0x81, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x26, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x00, 0x80,
  0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x20, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10, 0x08, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x10, 0x03, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00, 0x0D,
  0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x64,
  0x00, 0x08, 0x80, 0x07, 0x10, 0x07, 0x83, 0xFF, 0xE0, 0x40, 0x07, 0x08,
  0x00, 0x39, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x03, 0x40,
  0x00, 0xC8, 0x00, 0x31, 0x00, 0x7C, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x1C, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x1F, 0xFC, 0x00,
  0x02, 0x00, 0xFF, 0xF0, 0x04, 0x01, 0xF0, 0x20, 0x01, 0xC1, 0x00, 0x03,
  0x08, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x06, 0x80,
  0x00, 0x34, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xD0,
  0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x06, 0x20, 0x00, 0x61, 0x00, 0x07,
  0x08, 0x00, 0xE0, 0x40, 0x7E, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0x60, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x10, 0x60, 0x00, 0x08, 0x1C, 0x00, 0x04, 0x03, 0x80, 0x1E, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x0D, 0xFC, 0x70, 0x00, 0x80, 0x00, 0xD0, 0x00, 0x32, 0x00, 0x04,
  0x40, 0x01, 0x88, 0x00, 0x61, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0xC0,
  0x80, 0x30, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x60, 0x08, 0x18, 0x01,
  0x02, 0x00, 0x20, 0xC0, 0x04, 0x30, 0x00, 0x8C, 0x00, 0x11, 0xC0, 0x02,
  0x68, 0x00, 0x59, 0x80, 0x0A, 0x10, 0x01, 0xC3, 0x00, 0x30, 0x30, 0x04,
  0x06, 0x00, 0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0xC0, 0x40, 0x08, 0x08,
  0x01, 0x81, 0x00, 0x10, 0x20, 0x03, 0x04, 0x00, 0x30, 0x80, 0x02, 0x10,
  0x00, 0x62, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x09, 0x00, 0x01, 0xA0,
  0x00, 0x18, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x40, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x06, 0xD8, 0x00,
  0x00, 0x36, 0x40, 0x00, 0x01, 0x32, 0x00, 0x00, 0x19, 0x98, 0x00, 0x00,
  0xCC, 0x40, 0x00, 0x04, 0x62, 0x00, 0x00, 0x63, 0x18, 0x00, 0x03, 0x18,
  0x40, 0x00, 0x10, 0xC2, 0x00, 0x01, 0x86, 0x18, 0x00, 0x0C, 0x30, 0x40,
  0x00, 0x41, 0x83, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x40, 0x01,
  0x03, 0x02, 0x00, 0x18, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x40, 0x04, 0x06,
  0x03, 0x00, 0x60, 0x30, 0x18, 0x03, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x40, 0x40, 0x18, 0x03, 0x06,
  0x00, 0xC0, 0x18, 0x30, 0x06, 0x00, 0x41, 0x00, 0x30, 0x03, 0x18, 0x01,
  0x80, 0x18, 0xC0, 0x0C, 0x00, 0x44, 0x00, 0x60, 0x03, 0x60, 0x03, 0x00,
  0x1B, 0x00, 0x18, 0x00, 0x50, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x20, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40, 0x00,
  0x1B, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60, 0x00, 0x31, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x20, 0x00, 0x61, 0x80, 0x03, 0x04, 0x00, 0x18, 0x30, 0x00,
  0xC0, 0x80, 0x06, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0xC0, 0x0C, 0x02,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x08, 0x06,
  0x00, 0x60, 0x30, 0x01, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x60, 0x01,
  0x83, 0x00, 0x04, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x86, 0x00, 0x06, 0x30,
  0x00, 0x11, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x38, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x20,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xF0, 0x40, 0x1E, 0x20, 0x03, 0x90, 0x00, 0x68, 0x00, 0x14, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x40,
  0x01, 0xA0, 0x01, 0x90, 0x01, 0xC8, 0x07, 0x87, 0xFF, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xF0, 0x10, 0x07, 0x82, 0x00, 0x18, 0x40, 0x01, 0x88,
  0x00, 0x11, 0x00, 0x03, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x64, 0x00, 0x0C, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x38, 0x40,
  0x1C, 0x0F, 0xFE, 0x01, 0x01, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x30, 0x10, 0x06, 0x02, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x00, 0xC1, 0x00,
  0x18, 0x20, 0x01, 0x84, 0x00, 0x30, 0x80, 0x03, 0x10, 0x00, 0x62, 0x00,
  0x06, 0x40, 0x00, 0xC8, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x18, 0x01,
  0xFC, 0x03, 0xFF, 0xE1, 0xC0, 0x0C, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01,
  0xCE, 0x00, 0xE1, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x09, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x1C, 0x00, 0x60, 0x38, 0x07, 0x00,
  0x3F, 0xF0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x26, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00,
  0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00,
  0x40, 0xC0, 0x00, 0x80, 0x80, 0x03, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08,
  0x06, 0x00, 0x10, 0x04, 0x00, 0x60, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x20, 0x00,
  0x80, 0xC0, 0x01, 0x01, 0x80, 0x02, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x08, 0x20, 0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00, 0x23,
  0x00, 0x00, 0x44, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x40,
  0x00, 0x02, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x2C, 0x00, 0x07, 0x00, 0x01,
  0x90, 0x00, 0x14, 0x00, 0x06, 0x40, 0x00, 0x50, 0x00, 0x11, 0x80, 0x01,
  0x60, 0x00, 0x46, 0x00, 0x0D, 0x80, 0x03, 0x08, 0x00, 0x36, 0x00, 0x0C,
  0x20, 0x00, 0x88, 0x00, 0x20, 0x80, 0x02, 0x20, 0x00, 0x83, 0x00, 0x18,
  0xC0, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x10, 0x01, 0x84, 0x00, 0x60,
  0x40, 0x04, 0x10, 0x01, 0x01, 0x80, 0x10, 0x60, 0x04, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x08, 0x03, 0x06, 0x00, 0xC0, 0x20, 0x08, 0x08, 0x02, 0x00,
  0xC0, 0x20, 0x20, 0x08, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x10, 0x18, 0x04, 0x04, 0x00, 0x40, 0x40, 0x10, 0x10, 0x01,
  0x81, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x08, 0x30, 0x06,
  0x08, 0x00, 0x20, 0x80, 0x08, 0x20, 0x00, 0xC2, 0x00, 0x21, 0x80, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x04, 0x60, 0x03, 0x18, 0x00, 0x11, 0x80, 0x04,
  0x40, 0x00, 0x64, 0x00, 0x11, 0x00, 0x01, 0x90, 0x00, 0x4C, 0x00, 0x02,
  0xC0, 0x01, 0xB0, 0x00, 0x0B, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x19, 0x80, 0x01, 0x84, 0x00, 0x08,
  0x30, 0x00, 0xC0, 0x80, 0x04, 0x06, 0x00, 0x60, 0x10, 0x02, 0x00, 0xC0,
  0x30, 0x02, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x04, 0x00,
  0x18, 0x60, 0x00, 0x42, 0x00, 0x03, 0x30, 0x00, 0x09, 0x00, 0x00, 0x78,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x24, 0x00, 0x03, 0x30, 0x00, 0x11, 0x80, 0x01, 0x84, 0x00, 0x08, 0x30,
  0x00, 0xC0, 0x80, 0x04, 0x06, 0x00, 0x60, 0x10, 0x02, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x02, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x46, 0x00, 0x03, 0x30, 0x00, 0x0B, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x14, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x63,
  0x00, 0x04, 0x10, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0x80, 0x18,
  0x0C, 0x01, 0x00, 0x40, 0x30, 0x06, 0x02, 0x00, 0x60, 0x20, 0x02, 0x06,
  0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x18, 0x80, 0x01, 0x88, 0x00, 0x09,
  0x80, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x1F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x02, 0xC0,
  0x00, 0x19, 0x00, 0x00, 0x46, 0x00, 0x03, 0x08, 0x00, 0x08, 0x30, 0x00,
  0x60, 0x40, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x03, 0x04, 0x00, 0x0C,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x0F, 0xF8, 0x38, 0x0E, 0x10, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x07, 0x01, 0xFF, 0x0F, 0x01, 0x18, 0x01, 0x30,
  0x01, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x05, 0x60, 0x0D, 0x30, 0x19, 0x1F,
  0xF1, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x01, 0x87, 0xF8,
  0x33, 0x81, 0xC6, 0xC0, 0x08, 0xD0, 0x01, 0x9E, 0x00, 0x1B, 0x80, 0x03,
  0x70, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0x60, 0x00, 0x2E, 0x00, 0x0D, 0xC0, 0x01, 0x34, 0x00, 0x66,
  0xC0, 0x18, 0x8E, 0x06, 0x10, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0x06, 0x02, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x02, 0x07, 0xFE, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x04, 0x06, 0x0F, 0xF8, 0xC3, 0x01, 0x98,
  0xC0, 0x1B, 0x30, 0x01, 0x64, 0x00, 0x1D, 0x80, 0x03, 0xA0, 0x00, 0x74,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xA0,
  0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x48, 0xC0, 0x19, 0x1C,
  0x06, 0x20, 0xFF, 0x04, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00,
  0xC0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x19, 0x00,
  0x02, 0x40, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x02, 0x0E, 0x03,
  0x81, 0xFF, 0x80, 0x03, 0x00, 0x01, 0xFC, 0x0E, 0x20, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x03, 0xFF, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x8C,
  0x30, 0x19, 0x8C, 0x01, 0xB3, 0x00, 0x1E, 0x40, 0x01, 0xD8, 0x00, 0x3A,
  0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1A, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x3C, 0xC0, 0x05, 0x8C,
  0x01, 0x30, 0xC0, 0xE6, 0x0F, 0xF0, 0xC0, 0x20, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x40, 0x03, 0x0F, 0x03, 0xC0, 0x7F,
  0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x04, 0x06, 0x1F, 0xE3, 0x38, 0x39, 0xB0, 0x06,
  0xD0, 0x03, 0x70, 0x00, 0xB8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x40, 0xDF, 0xE0, 0x00, 0x00,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x06,
  0x06, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x04, 0x8C, 0xF8, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x08,
  0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x40, 0xC0, 0xC0, 0xC1, 0x80,
  0xC1, 0x00, 0xC3, 0x00, 0xC6, 0x00, 0xC7, 0x00, 0xCB, 0x00, 0xD9, 0x80,
  0xF1, 0x80, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06,
  0xC0, 0x02, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x02, 0x04, 0x3F, 0x80, 0xFE, 0x23, 0x06,
  0x1C, 0x19, 0x30, 0x18, 0x80, 0x6B, 0x00, 0x68, 0x01, 0xD0, 0x01, 0x40,
  0x0F, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x04, 0x00, 0x60, 0x41, 0xFE, 0x23, 0x81, 0x93, 0x00,
  0x69, 0x00, 0x15, 0x00, 0x0E, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x60, 0x00, 0xFF,
  0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x40, 0x01, 0x98, 0x00,
  0x32, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1A, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x10, 0xC0, 0x06,
  0x0C, 0x01, 0x80, 0xC0, 0x60, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x10, 0x7F, 0x82, 0x38, 0x1C, 0x44, 0x01, 0x89, 0x00, 0x19, 0x60, 0x01,
  0xA8, 0x00, 0x35, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x17, 0x00, 0x02, 0xE0, 0x00, 0xDE, 0x00, 0x13,
  0x40, 0x06, 0x6C, 0x01, 0x8C, 0xE0, 0x61, 0x8F, 0xF8, 0x30, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x8C, 0x30, 0x19,
  0x8C, 0x01, 0xB3, 0x00, 0x16, 0x40, 0x01, 0xD8, 0x00, 0x3A, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A,
  0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x3C, 0xC0, 0x05, 0x8C, 0x01, 0x30,
  0xC0, 0xE6, 0x0F, 0xF0, 0xC0, 0x20, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x87, 0xF8, 0xC1, 0x98, 0x0D, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x1F, 0xF8,
  0xE0, 0x19, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x6E, 0x01, 0x8F, 0xFE, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x07, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x03, 0xF0, 0x08, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x05, 0x40, 0x02, 0xB0, 0x02, 0x58, 0x03, 0x27, 0x03, 0x11, 0xFF, 0x08,
  0x0C, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x02, 0x60,
  0x01, 0x88, 0x00, 0x63, 0x00, 0x10, 0xC0, 0x04, 0x10, 0x03, 0x04, 0x00,
  0xC1, 0x80, 0x20, 0x60, 0x18, 0x08, 0x06, 0x02, 0x01, 0x00, 0xC0, 0x40,
  0x10, 0x30, 0x04, 0x08, 0x01, 0x82, 0x00, 0x61, 0x80, 0x08, 0x60, 0x02,
  0x10, 0x00, 0xC4, 0x00, 0x13, 0x00, 0x04, 0x80, 0x01, 0xA0, 0x00, 0x68,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0A, 0x00, 0x34, 0x00,
  0x58, 0x01, 0x20, 0x02, 0xC0, 0x09, 0x80, 0x32, 0x00, 0xCC, 0x01, 0x90,
  0x06, 0x20, 0x08, 0xC0, 0x21, 0x00, 0x46, 0x01, 0x0C, 0x06, 0x10, 0x08,
  0x60, 0x30, 0x80, 0xC1, 0x01, 0x06, 0x04, 0x08, 0x08, 0x30, 0x20, 0x60,
  0xC0, 0x81, 0x03, 0x06, 0x04, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x41, 0x01,
  0x84, 0x03, 0x18, 0x04, 0x20, 0x18, 0xC0, 0x23, 0x00, 0x44, 0x01, 0x98,
  0x02, 0x20, 0x0C, 0x80, 0x1B, 0x00, 0x24, 0x00, 0xD8, 0x01, 0x20, 0x02,
  0x80, 0x0B, 0x00, 0x14, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x00, 0x98, 0x00, 0x63, 0x00,
  0x30, 0xC0, 0x0C, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x10, 0x20,
  0x06, 0x18, 0x00, 0x84, 0x00, 0x33, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0x20, 0x00, 0xCC, 0x00, 0x21,
  0x00, 0x18, 0x60, 0x04, 0x08, 0x03, 0x03, 0x00, 0x80, 0x40, 0x60, 0x18,
  0x30, 0x02, 0x0C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xC0,
  0x40, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x18, 0x01, 0x01, 0x00, 0x20,
  0x20, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x08, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x20, 0x02, 0x04, 0x00, 0x41, 0x80, 0x0C, 0x20, 0x00, 0x84, 0x00,
  0x11, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x8C,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x03, 0x80, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x3C,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0xF0, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x03, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0x01, 0xFE,
  0x00, 0x70, 0x1C, 0x07, 0x00, 0x3F, 0xE8, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 39, 11, 4, -39 },
  { 16, 9, 14, 17, 4, -39 },
  { 32, 25, 39, 27, 1, -39 },
  { 154, 20, 45, 25, 2, -42 },
  { 267, 29, 41, 35, 3, -40 },
  { 416, 24, 41, 26, 2, -40 },
  { 539, 1, 14, 9, 4, -39 },
  { 541, 9, 48, 14, 3, -39 },
  { 595, 10, 48, 14, 2, -39 },
  { 655, 16, 17, 22, 3, -42 },
  { 689, 21, 25, 25, 2, -32 },
  { 755, 5, 13, 10, 2, -6 },
  { 764, 12, 2, 15, 2, -16 },
  { 767, 3, 3, 11, 4, -3 },
  { 769, 16, 39, 18, 1, -39 },
  { 847, 19, 40, 25, 3, -40 },
  { 942, 9, 39, 25, 5, -39 },
  { 986, 18, 40, 25, 3, -40 },
  { 1076, 19, 41, 25, 2, -40 },
  { 1174, 23, 39, 25, 1, -39 },
  { 1287, 19, 40, 25, 3, -39 },
  { 1382, 19, 41, 25, 3, -40 },
  { 1480, 19, 39, 25, 3, -39 },
  { 1573, 20, 41, 25, 2, -40 },
  { 1676, 19, 41, 25, 2, -40 },
  { 1774, 3, 29, 11, 4, -29 },
  { 1785, 5, 36, 10, 2, -29 },
  { 1808, 21, 23, 25, 2, -31 },
  { 1869, 21, 13, 25, 2, -26 },
  { 1904, 21, 23, 25, 2, -31 },
  { 1965, 14, 40, 17, 1, -40 },
  { 2035, 32, 44, 38, 3, -39 },
  { 2211, 24, 39, 24, 0, -39 },
  { 2328, 19, 39, 27, 5, -39 },
  { 2421, 22, 41, 26, 3, -40 },
  { 2534, 21, 39, 30, 5, -39 },
  { 2637, 16, 39, 24, 5, -39 },
  { 2715, 16, 39, 22, 5, -39 },
  { 2793, 25, 41, 32, 3, -40 },
  { 2922, 21, 39, 30, 5, -39 },
  { 3025, 9, 39, 13, 2, -39 },
  { 3069, 9, 49, 11, -3, -39 },
  { 3125, 19, 39, 24, 5, -39 },
  { 3218, 15, 39, 21, 5, -39 },
  { 3292, 29, 39, 39, 5, -39 },
  { 3434, 21, 39, 31, 5, -39 },
  { 3537, 26, 41, 32, 3, -40 },
  { 3671, 17, 39, 25, 5, -39 },
  { 3754, 26, 49, 32, 3, -40 },
  { 3914, 19, 39, 25, 5, -39 },
  { 4007, 18, 41, 24, 3, -40 },
  { 4100, 21, 39, 21, 0, -39 },
  { 4203, 22, 40, 30, 4, -39 },
  { 4313, 23, 39, 23, 0, -39 },
  { 4426, 38, 39, 39, 1, -39 },
  { 4612, 21, 39, 21, 0, -39 },
  { 4715, 20, 39, 20, 0, -39 },
  { 4813, 19, 39, 22, 2, -39 },
  { 4906, 10, 48, 17, 5, -39 },
  { 4966, 16, 39, 18, 1, -39 },
  { 5044, 10, 48, 17, 2, -39 },
  { 5104, 22, 20, 25, 1, -39 },
  { 5159, 22, 1, 22, 0, 5 },
  { 5162, 9, 9, 13, 2, -42 },
  { 5173, 16, 31, 23, 2, -30 },
  { 5235, 19, 43, 26, 4, -42 },
  { 5338, 16, 31, 20, 3, -30 },
  { 5400, 19, 43, 26, 3, -42 },
  { 5503, 18, 31, 24, 3, -30 },
  { 5573, 14, 42, 13, 1, -42 },
  { 5647, 19, 43, 26, 3, -30 },
  { 5750, 17, 42, 25, 4, -42 },
  { 5840, 3, 40, 10, 4, -40 },
  { 5855, 8, 53, 10, -1, -40 },
  { 5908, 16, 42, 20, 4, -42 },
  { 5992, 2, 42, 10, 4, -42 },
  { 6003, 29, 30, 37, 4, -30 },
  { 6112, 17, 30, 25, 4, -30 },
  { 6176, 19, 31, 25, 3, -30 },
  { 6250, 19, 43, 26, 4, -30 },
  { 6353, 19, 43, 26, 3, -30 },
  { 6456, 12, 29, 16, 4, -29 },
  { 6500, 15, 31, 20, 2, -30 },
  { 6559, 11, 37, 13, 1, -36 },
  { 6610, 17, 30, 25, 4, -29 },
  { 6674, 18, 29, 18, 0, -29 },
  { 6740, 29, 29, 31, 1, -29 },
  { 6846, 18, 29, 20, 1, -29 },
  { 6912, 19, 42, 19, 0, -29 },
  { 7012, 14, 29, 17, 2, -29 },
  { 7063, 14, 48, 19, 2, -39 },
  { 7147, 1, 55, 23, 11, -42 },
  { 7154, 13, 48, 19, 3, -39 },
  { 7232, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Thin55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_THIN55PT7B_H_
