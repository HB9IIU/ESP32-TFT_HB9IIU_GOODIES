#ifndef _NOTOSANS_CONDENSED_THIN61PT7B_H_
#define _NOTOSANS_CONDENSED_THIN61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xD8, 0x00, 0x00, 0xDF, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x20, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00,
  0x04, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x30, 0x00, 0x08,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x18, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x01,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x08, 0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xE0, 0x38, 0xC1, 0xC1, 0x83, 0x01, 0x0C, 0x0C, 0x00, 0x60, 0x30,
  0x01, 0x80, 0xC0, 0x04, 0x03, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0xC0, 0x04, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xDC, 0x00,
  0x03, 0x3C, 0x00, 0x0C, 0x38, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x80,
  0x0C, 0x06, 0x00, 0x30, 0x31, 0x00, 0xC1, 0xC7, 0x83, 0x1C, 0x0F, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x0C, 0x60,
  0x00, 0x40, 0x0C, 0x18, 0x00, 0x60, 0x04, 0x06, 0x00, 0x30, 0x06, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x30, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x04, 0x02, 0x00, 0x30,
  0x02, 0x03, 0x00, 0x18, 0x01, 0x01, 0x80, 0x0C, 0x00, 0x81, 0x80, 0x06,
  0x00, 0x40, 0xC0, 0x03, 0x00, 0x20, 0x40, 0x01, 0x80, 0x10, 0x60, 0x00,
  0xC0, 0x08, 0x30, 0x00, 0x60, 0x04, 0x10, 0x38, 0x30, 0x06, 0x18, 0x7F,
  0x18, 0x03, 0x08, 0x60, 0xC4, 0x01, 0x8C, 0x60, 0x62, 0x00, 0x86, 0x30,
  0x19, 0x80, 0xC2, 0x10, 0x0C, 0x40, 0x63, 0x18, 0x02, 0x30, 0x61, 0x0C,
  0x01, 0x0C, 0x61, 0x86, 0x00, 0xC3, 0xE0, 0xC2, 0x00, 0x60, 0x00, 0x41,
  0x00, 0x30, 0x00, 0x60, 0x80, 0x18, 0x00, 0x20, 0x40, 0x0C, 0x00, 0x30,
  0x20, 0x06, 0x00, 0x18, 0x10, 0x03, 0x00, 0x08, 0x08, 0x01, 0x80, 0x0C,
  0x04, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x60, 0x06, 0x01, 0x00, 0x30, 0x03,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x08, 0x06, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x60, 0x01, 0x03, 0x00,
  0x20, 0x00, 0xC3, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x40, 0x08, 0x00, 0x08, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x02, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x08, 0x00,
  0x03, 0x01, 0x80, 0x18, 0xC0, 0x18, 0x02, 0x10, 0x01, 0x00, 0x46, 0x00,
  0x30, 0x08, 0xC0, 0x03, 0x03, 0x10, 0x00, 0x20, 0x42, 0x00, 0x06, 0x08,
  0xC0, 0x00, 0x63, 0x18, 0x00, 0x06, 0x41, 0x00, 0x00, 0xD8, 0x20, 0x00,
  0x0F, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x81,
  0x80, 0x01, 0x98, 0x30, 0x00, 0x61, 0x03, 0x00, 0x18, 0x30, 0x38, 0x0E,
  0x03, 0x01, 0xFF, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0E, 0x04, 0x0C, 0xE1, 0x1E,
  0x07, 0x5C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x06, 0x80, 0x03, 0x10, 0x00,
  0x82, 0x00, 0x40, 0xC0, 0x30, 0x18, 0x18, 0x02, 0x04, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x18,
  0xC6, 0x31, 0x88, 0xC6, 0x31, 0x18, 0xC4, 0x60, 0xFF, 0xF8, 0x7F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1C, 0x78, 0x01, 0x80, 0xE0, 0x18,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x04,
  0x20, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x24, 0x00,
  0x01, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00,
  0x68, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x0C, 0x40,
  0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18,
  0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xE1, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x20, 0x1C, 0x07, 0x81, 0xB0, 0x66, 0x18, 0xCE, 0x1B, 0x83, 0xC0, 0x68,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0xFC, 0x00, 0xF8, 0xF0, 0x1E, 0x00, 0xE0, 0xC0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xF8,
  0xF8, 0x1C, 0x00, 0xE1, 0x80, 0x01, 0x88, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC4, 0x00, 0x0C, 0x3C, 0x01,
  0xC0, 0x7F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00,
  0xC0, 0x20, 0x00, 0x30, 0x08, 0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0xC0,
  0x00, 0x80, 0x30, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04, 0x00, 0x02, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x0C, 0x3C, 0x03, 0xC0, 0x7F,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x03, 0xC0, 0x10, 0xFF, 0xC0, 0x8E, 0x03, 0x8C, 0xC0, 0x0C,
  0x6C, 0x00, 0x33, 0x40, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x05,
  0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00,
  0x06, 0xC0, 0x00, 0x32, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x60, 0x60, 0x06, 0x01, 0xC0, 0x60, 0x07, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3E, 0x78, 0x03, 0x00, 0x70, 0x30, 0x01, 0xC3, 0x00,
  0x06, 0x10, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x12,
  0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x26, 0x00, 0x03, 0x10, 0x00,
  0x18, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0xC0, 0x70, 0x0C, 0x01,
  0xC1, 0xC0, 0x03, 0x98, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0E, 0x38,
  0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x06, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0x64, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x30, 0x00, 0x60,
  0xC0, 0x06, 0x03, 0x80, 0xE0, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x7C, 0xF0, 0x07, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x0C,
  0x30, 0x00, 0x21, 0x80, 0x01, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x74, 0x00, 0x03, 0xB0, 0x00, 0x3D, 0x80, 0x01, 0x66,
  0x00, 0x1B, 0x18, 0x03, 0x98, 0x70, 0x78, 0x80, 0xFF, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x08, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xB0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFB, 0x1C, 0x71,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC2,
  0x08, 0x61, 0x84, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFC, 0x78, 0x40, 0x1C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x43, 0x00, 0x0F, 0xF0,
  0x06, 0x30, 0x01, 0xC7, 0x80, 0x62, 0x00, 0x30, 0x18, 0x06, 0x60, 0x06,
  0x01, 0x80, 0x26, 0x00, 0xC0, 0x18, 0x02, 0x60, 0x08, 0x01, 0x80, 0x24,
  0x01, 0x80, 0x18, 0x03, 0x40, 0x18, 0x01, 0x80, 0x3C, 0x01, 0x00, 0x10,
  0x03, 0xC0, 0x30, 0x01, 0x00, 0x3C, 0x03, 0x00, 0x10, 0x03, 0xC0, 0x30,
  0x01, 0x00, 0x3C, 0x03, 0x00, 0x10, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x3C,
  0x03, 0x00, 0x30, 0x02, 0xC0, 0x30, 0x03, 0x00, 0x2C, 0x03, 0x00, 0x30,
  0x02, 0xC0, 0x30, 0x03, 0x00, 0x6C, 0x01, 0x00, 0x70, 0x06, 0x40, 0x18,
  0x05, 0x80, 0x44, 0x01, 0x80, 0xD8, 0x0C, 0x60, 0x0C, 0x0C, 0x81, 0x86,
  0x00, 0x63, 0x8E, 0x70, 0x60, 0x03, 0xE0, 0x7E, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x10, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80, 0x1F,
  0xFF, 0xF0, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x30,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0C, 0x00, 0x3C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x4C,
  0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x07, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0xE0, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x78, 0x07, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x0F,
  0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFB, 0xFF,
  0xFE, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x40, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x03, 0x80, 0x00, 0x10, 0x0E, 0x00,
  0x01, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xC2, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x1F, 0xF0, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x68, 0x19, 0xFE, 0x0F,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x38, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0xF0, 0x00, 0x66, 0xC0, 0x03, 0x66,
  0x00, 0x1E, 0x18, 0x00, 0xE0, 0x40, 0x07, 0x03, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x80, 0xC0, 0x06, 0x06, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x0C, 0xC0, 0x00,
  0x26, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x00,
  0x3F, 0x60, 0x00, 0x00, 0x37, 0xB0, 0x00, 0x00, 0x1B, 0xC8, 0x00, 0x00,
  0x0D, 0xE6, 0x00, 0x00, 0x0C, 0xF3, 0x00, 0x00, 0x06, 0x78, 0x80, 0x00,
  0x02, 0x3C, 0x60, 0x00, 0x03, 0x1E, 0x30, 0x00, 0x01, 0x8F, 0x08, 0x00,
  0x00, 0x87, 0x86, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x61, 0xE0, 0x80,
  0x00, 0x20, 0xF0, 0x60, 0x00, 0x30, 0x78, 0x30, 0x00, 0x18, 0x3C, 0x08,
  0x00, 0x08, 0x1E, 0x06, 0x00, 0x0C, 0x0F, 0x03, 0x00, 0x06, 0x07, 0x80,
  0x80, 0x02, 0x03, 0xC0, 0x60, 0x03, 0x01, 0xE0, 0x30, 0x01, 0x80, 0xF0,
  0x08, 0x00, 0x80, 0x78, 0x06, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x60, 0x1E,
  0x00, 0x80, 0x20, 0x0F, 0x00, 0x60, 0x30, 0x07, 0x80, 0x30, 0x18, 0x03,
  0xC0, 0x08, 0x08, 0x01, 0xE0, 0x06, 0x0C, 0x00, 0xF0, 0x03, 0x06, 0x00,
  0x78, 0x00, 0x82, 0x00, 0x3C, 0x00, 0x63, 0x00, 0x1E, 0x00, 0x31, 0x80,
  0x0F, 0x00, 0x08, 0x80, 0x07, 0x80, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x01, 0xE0, 0x00, 0xA0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xD0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCC,
  0x00, 0x01, 0xCC, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3,
  0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xC0,
  0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x01, 0xC0,
  0x0C, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x06, 0x01, 0xC0,
  0x03, 0x01, 0xC0, 0x01, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x81, 0xC0,
  0x00, 0xC1, 0xC0, 0x00, 0x41, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x21, 0xC0,
  0x00, 0x31, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x09, 0xC0,
  0x00, 0x0D, 0xC0, 0x00, 0x05, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0, 0x00, 0xCC, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x01, 0xE0, 0xFF, 0xF8,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x30, 0x03, 0xC1,
  0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x04, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x26, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60,
  0x01, 0x83, 0x00, 0x78, 0x1F, 0xFF, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x30,
  0x01, 0xFF, 0x80, 0x3E, 0x3F, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE4,
  0x00, 0x0E, 0x3C, 0x01, 0xC0, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x40, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x98, 0x00,
  0x05, 0x80, 0x00, 0x66, 0x00, 0x01, 0x60, 0x00, 0x11, 0x80, 0x00, 0xD8,
  0x00, 0x0C, 0x20, 0x00, 0x32, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x80, 0x00,
  0xC3, 0x00, 0x02, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x10,
  0x00, 0x63, 0x00, 0x06, 0x04, 0x00, 0x18, 0x40, 0x01, 0x81, 0x80, 0x04,
  0x18, 0x00, 0x40, 0x60, 0x01, 0x06, 0x00, 0x10, 0x08, 0x00, 0xC1, 0x80,
  0x0C, 0x02, 0x00, 0x30, 0x20, 0x03, 0x00, 0xC0, 0x0C, 0x08, 0x00, 0xC0,
  0x30, 0x02, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x01, 0x00,
  0x60, 0x30, 0x06, 0x00, 0x60, 0x18, 0x04, 0x01, 0x80, 0x18, 0x04, 0x01,
  0x80, 0x40, 0x06, 0x01, 0x00, 0x60, 0x30, 0x00, 0x80, 0xC0, 0x18, 0x0C,
  0x00, 0x20, 0x30, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x03,
  0x02, 0x00, 0x30, 0x60, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0x10, 0x60,
  0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x41, 0x00, 0x01, 0x84, 0x00, 0x18,
  0x40, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00,
  0x03, 0x30, 0x00, 0x22, 0x00, 0x00, 0xCC, 0x00, 0x08, 0x80, 0x00, 0x32,
  0x00, 0x03, 0x60, 0x00, 0x04, 0x80, 0x00, 0xD8, 0x00, 0x01, 0x60, 0x00,
  0x36, 0x00, 0x00, 0x78, 0x00, 0x05, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x40, 0x80,
  0x01, 0x81, 0x80, 0x02, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x30, 0x40, 0x00, 0x21, 0x80, 0x00, 0x62, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x26, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x60, 0x01, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x19,
  0x80, 0x00, 0x16, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x09,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x62, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x04, 0x08, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x80,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x02, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x04, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x13, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66, 0x00, 0x00, 0x42, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x08, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0xF8, 0x00, 0xFF, 0xC0,
  0x70, 0x0C, 0x08, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x03, 0xFF, 0x03, 0xE0, 0x61,
  0xC0, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD0,
  0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1D, 0x00, 0x03, 0xA0,
  0x00, 0x76, 0x00, 0x16, 0xC0, 0x06, 0xCC, 0x00, 0x98, 0xC0, 0x63, 0x0F,
  0xF8, 0x60, 0x18, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x7C, 0x02, 0x1F, 0xF8, 0x11, 0xC0, 0x70, 0x98, 0x01,
  0xC4, 0x80, 0x06, 0x2C, 0x00, 0x19, 0x40, 0x00, 0x4E, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x02, 0xC0, 0x00, 0x14, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05,
  0x00, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x04, 0xA0, 0x00, 0x65, 0x00, 0x02, 0x24, 0x00, 0x31, 0x30, 0x03, 0x08,
  0xE0, 0x70, 0x43, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xF0, 0x78, 0x08, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x03, 0xFF, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x3C, 0x04, 0x0F, 0xFC, 0x20, 0xC0, 0x71, 0x0C, 0x00, 0xC8, 0xC0, 0x02,
  0x4C, 0x00, 0x1A, 0x60, 0x00, 0x56, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x20, 0x00,
  0x29, 0x80, 0x03, 0x46, 0x00, 0x12, 0x38, 0x01, 0x10, 0xE0, 0x38, 0x81,
  0xFF, 0x04, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x06, 0x03,
  0x00, 0xC0, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x66, 0x00,
  0x02, 0x60, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x70,
  0x1E, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xFC, 0x0C, 0x08,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x7F, 0xF8,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xF8, 0x43, 0x80, 0x62, 0x18, 0x01, 0x91, 0x80, 0x06,
  0x98, 0x00, 0x14, 0xC0, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1A, 0x00,
  0x00, 0xD0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x68,
  0x00, 0x03, 0x40, 0x00, 0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0A, 0x40, 0x00,
  0x53, 0x00, 0x07, 0x8C, 0x00, 0x6C, 0x70, 0x06, 0x61, 0xC0, 0x63, 0x03,
  0xFE, 0x18, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC4, 0x00, 0x0C, 0x3C, 0x01, 0xC0,
  0x7F, 0xFC, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x3C,
  0x08, 0x7F, 0xE2, 0x38, 0x1C, 0x98, 0x01, 0xA4, 0x00, 0x6B, 0x00, 0x0E,
  0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x7F, 0xB0, 0x00, 0x00, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x07, 0x07, 0x07, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x0C, 0xFC, 0x70, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x0D, 0x00, 0x0C, 0x80, 0x0C, 0x40, 0x04, 0x20, 0x06, 0x10, 0x06, 0x08,
  0x02, 0x04, 0x03, 0x02, 0x03, 0x01, 0x03, 0x00, 0x81, 0x80, 0x41, 0x80,
  0x21, 0x80, 0x10, 0xE0, 0x08, 0xF0, 0x04, 0xCC, 0x02, 0xC6, 0x01, 0x41,
  0x80, 0xE0, 0xC0, 0x60, 0x30, 0x20, 0x18, 0x10, 0x06, 0x08, 0x03, 0x04,
  0x00, 0xC2, 0x00, 0x61, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x03, 0x20, 0x01,
  0x90, 0x00, 0x68, 0x00, 0x34, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x01, 0xE0, 0x87, 0xF8, 0x0F, 0xF8, 0x8C, 0x0C, 0x18,
  0x1C, 0x98, 0x06, 0x30, 0x06, 0xB0, 0x02, 0x60, 0x06, 0xA0, 0x03, 0x40,
  0x02, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x00, 0xF8, 0x21, 0xFF, 0x88, 0xE0, 0x72, 0x60, 0x06, 0xB0, 0x01,
  0xA8, 0x00, 0x3A, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18,
  0x00, 0x04, 0x60, 0x00, 0x19, 0x00, 0x00, 0x64, 0x00, 0x00, 0xB0, 0x00,
  0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x90, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF8, 0x04, 0x1F, 0xF0, 0x23, 0x80, 0xE1, 0x38, 0x03,
  0x89, 0x00, 0x0C, 0x58, 0x00, 0x32, 0x80, 0x00, 0x9C, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB8, 0x00,
  0x09, 0x40, 0x00, 0xCB, 0x00, 0x04, 0x4C, 0x00, 0x62, 0x70, 0x06, 0x11,
  0xC0, 0xE0, 0x83, 0xFE, 0x04, 0x03, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x41,
  0x80, 0xE2, 0x18, 0x01, 0x91, 0x80, 0x04, 0x98, 0x00, 0x34, 0xC0, 0x00,
  0xAC, 0x00, 0x07, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40, 0x00, 0x1B,
  0x00, 0x01, 0xD8, 0x00, 0x0A, 0x40, 0x00, 0x53, 0x00, 0x05, 0x8C, 0x00,
  0x6C, 0x70, 0x06, 0x61, 0xC0, 0xE3, 0x03, 0xFE, 0x18, 0x03, 0x80, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xE8,
  0x7F, 0x8E, 0x19, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0x87, 0x00, 0xE6, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0B, 0x00, 0x0D, 0xE0, 0x1C, 0x3F, 0xF8, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0xFF, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x20, 0x7F, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x1D, 0x80, 0x02,
  0xB0, 0x00, 0xD3, 0x00, 0x12, 0x60, 0x06, 0x47, 0x03, 0x88, 0x7F, 0xC1,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00,
  0x06, 0x20, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x10,
  0x00, 0xC1, 0x80, 0x08, 0x18, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x80,
  0xC0, 0x10, 0x0C, 0x03, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x60, 0x20,
  0x06, 0x06, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x0C,
  0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x0D,
  0x00, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x48,
  0x00, 0x28, 0x00, 0x64, 0x00, 0x14, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x11,
  0x80, 0x0D, 0x80, 0x08, 0x40, 0x04, 0x40, 0x0C, 0x20, 0x02, 0x20, 0x06,
  0x18, 0x03, 0x18, 0x02, 0x0C, 0x01, 0x8C, 0x01, 0x02, 0x00, 0x82, 0x01,
  0x81, 0x00, 0xC1, 0x00, 0xC0, 0xC0, 0x60, 0xC0, 0x40, 0x60, 0x30, 0x60,
  0x20, 0x10, 0x10, 0x10, 0x30, 0x08, 0x18, 0x08, 0x18, 0x06, 0x0C, 0x06,
  0x0C, 0x03, 0x06, 0x03, 0x04, 0x00, 0x82, 0x00, 0x82, 0x00, 0x43, 0x00,
  0x43, 0x00, 0x31, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x0C, 0x40,
  0x04, 0x40, 0x02, 0x60, 0x02, 0x60, 0x01, 0xB0, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0xD0, 0x00, 0x68, 0x00, 0x28, 0x00, 0x14, 0x00, 0x14, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x72, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x80,
  0xC0, 0x10, 0x0C, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x30, 0x40,
  0x03, 0x0C, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x18,
  0x80, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0x60, 0x20, 0x0C,
  0x03, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0xC2,
  0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0x88, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x08, 0x00, 0x10, 0x40,
  0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x40, 0x40, 0x02, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x40, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x20, 0x02, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x02, 0x04, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x02, 0x10, 0x00, 0x11, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0xFC, 0x03, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x70, 0x0F, 0x80, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x71, 0xE0,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0x7F, 0xE8, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 44, 12, 5, -44 },
  { 18, 10, 16, 18, 4, -44 },
  { 38, 28, 44, 30, 1, -44 },
  { 192, 22, 50, 27, 2, -46 },
  { 330, 33, 45, 39, 3, -44 },
  { 516, 27, 45, 29, 2, -44 },
  { 668, 2, 16, 10, 4, -44 },
  { 672, 11, 54, 16, 3, -44 },
  { 747, 11, 54, 16, 2, -44 },
  { 822, 18, 18, 25, 3, -46 },
  { 863, 23, 29, 27, 2, -36 },
  { 947, 5, 14, 11, 2, -6 },
  { 956, 13, 1, 17, 2, -17 },
  { 958, 3, 4, 12, 4, -4 },
  { 960, 18, 44, 20, 1, -44 },
  { 1059, 21, 44, 27, 3, -44 },
  { 1175, 11, 44, 27, 5, -44 },
  { 1236, 21, 44, 27, 3, -44 },
  { 1352, 21, 45, 27, 3, -44 },
  { 1471, 26, 44, 27, 1, -44 },
  { 1614, 21, 45, 27, 3, -44 },
  { 1733, 21, 45, 27, 3, -44 },
  { 1852, 21, 44, 27, 3, -44 },
  { 1968, 21, 45, 27, 3, -44 },
  { 2087, 21, 45, 27, 3, -44 },
  { 2206, 3, 32, 12, 4, -32 },
  { 2218, 6, 40, 12, 2, -32 },
  { 2248, 23, 26, 27, 2, -35 },
  { 2323, 23, 15, 27, 2, -29 },
  { 2367, 23, 26, 27, 2, -35 },
  { 2442, 16, 44, 19, 1, -44 },
  { 2530, 36, 50, 42, 3, -44 },
  { 2755, 27, 44, 27, 0, -44 },
  { 2904, 22, 44, 30, 5, -44 },
  { 3025, 24, 45, 29, 3, -44 },
  { 3160, 24, 44, 33, 5, -44 },
  { 3292, 18, 44, 26, 5, -44 },
  { 3391, 18, 44, 24, 5, -44 },
  { 3490, 28, 45, 35, 3, -44 },
  { 3648, 23, 44, 34, 5, -44 },
  { 3775, 9, 44, 15, 3, -44 },
  { 3825, 11, 55, 12, -4, -44 },
  { 3901, 21, 44, 26, 5, -44 },
  { 4017, 18, 44, 24, 5, -44 },
  { 4116, 33, 44, 43, 5, -44 },
  { 4298, 24, 44, 34, 5, -44 },
  { 4430, 29, 45, 36, 3, -44 },
  { 4594, 20, 44, 27, 5, -44 },
  { 4704, 29, 54, 36, 3, -44 },
  { 4900, 21, 44, 28, 5, -44 },
  { 5016, 21, 45, 27, 3, -44 },
  { 5135, 23, 44, 24, 0, -44 },
  { 5262, 24, 45, 34, 5, -44 },
  { 5397, 26, 44, 26, 0, -44 },
  { 5540, 42, 44, 44, 1, -44 },
  { 5771, 23, 44, 23, 0, -44 },
  { 5898, 23, 44, 23, 0, -44 },
  { 6025, 21, 44, 24, 2, -44 },
  { 6141, 12, 54, 19, 5, -44 },
  { 6222, 18, 44, 20, 1, -44 },
  { 6321, 12, 54, 19, 2, -44 },
  { 6402, 24, 23, 27, 2, -44 },
  { 6471, 24, 1, 24, 0, 6 },
  { 6474, 10, 10, 14, 2, -47 },
  { 6487, 19, 34, 25, 2, -33 },
  { 6568, 21, 47, 29, 5, -46 },
  { 6692, 18, 34, 22, 3, -33 },
  { 6769, 21, 47, 29, 3, -46 },
  { 6893, 20, 34, 26, 3, -33 },
  { 6978, 15, 47, 14, 1, -47 },
  { 7067, 21, 48, 29, 3, -33 },
  { 7193, 18, 46, 28, 5, -46 },
  { 7297, 3, 44, 11, 4, -44 },
  { 7314, 8, 59, 11, -1, -44 },
  { 7373, 17, 46, 22, 5, -46 },
  { 7471, 1, 46, 11, 5, -46 },
  { 7477, 32, 33, 42, 5, -33 },
  { 7609, 18, 33, 28, 5, -33 },
  { 7684, 22, 34, 28, 3, -33 },
  { 7778, 21, 47, 29, 5, -33 },
  { 7902, 21, 47, 29, 3, -33 },
  { 8026, 12, 33, 18, 5, -33 },
  { 8076, 17, 34, 22, 2, -33 },
  { 8149, 13, 41, 15, 1, -40 },
  { 8216, 19, 33, 28, 4, -32 },
  { 8295, 20, 32, 20, 0, -32 },
  { 8375, 33, 32, 34, 1, -32 },
  { 8507, 20, 32, 22, 1, -32 },
  { 8587, 21, 47, 21, 0, -32 },
  { 8711, 16, 32, 19, 2, -32 },
  { 8775, 15, 54, 21, 3, -44 },
  { 8877, 2, 61, 26, 12, -46 },
  { 8893, 15, 54, 21, 3, -44 },
  { 8995, 23, 5, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Thin61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_THIN61PT7B_H_
