#ifndef _NOTOSANS_CONDENSED_THIN20PT7B_H_
#define _NOTOSANS_CONDENSED_THIN20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x99, 0x99, 0x90, 0x11, 0x08, 0x84, 0x42, 0x27, 0xF8,
  0x90, 0x48, 0x24, 0x22, 0x7F, 0xC8, 0x84, 0x42, 0x41, 0x20, 0x10, 0xFA,
  0x44, 0x89, 0x12, 0x14, 0x10, 0x18, 0x2C, 0x48, 0x91, 0x32, 0x9E, 0x08,
  0xF1, 0x12, 0x22, 0x24, 0x45, 0x08, 0xA1, 0x19, 0xA5, 0x4C, 0xB1, 0x6A,
  0x21, 0x44, 0x48, 0x89, 0x11, 0x12, 0x43, 0x80, 0x78, 0x44, 0x44, 0x44,
  0x48, 0x30, 0x20, 0x50, 0x89, 0x85, 0x85, 0x82, 0x85, 0x79, 0xF8, 0x29,
  0x29, 0x24, 0x92, 0x48, 0x91, 0x20, 0x89, 0x12, 0x49, 0x24, 0x92, 0x52,
  0x80, 0x10, 0x4D, 0xCC, 0x49, 0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0x10, 0x20, 0xF8, 0xF0, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04,
  0x20, 0x84, 0x10, 0x42, 0x00, 0x7C, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x14, 0x47, 0x00, 0x2E, 0x92, 0x49, 0x24, 0x92, 0x40,
  0xFC, 0x08, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x82, 0x04, 0x1F,
  0xC0, 0xFC, 0x08, 0x08, 0x10, 0x40, 0x8E, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x5F, 0x00, 0x02, 0x03, 0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x84, 0x42,
  0x41, 0x1F, 0xE0, 0x40, 0x20, 0x10, 0x7D, 0x02, 0x04, 0x08, 0x1F, 0x01,
  0x01, 0x02, 0x04, 0x08, 0x10, 0x5F, 0x00, 0x3C, 0x81, 0x04, 0x08, 0x17,
  0x31, 0x41, 0x83, 0x06, 0x0C, 0x14, 0x27, 0x80, 0xFE, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x00, 0x7D, 0x06, 0x0C,
  0x14, 0x45, 0x0C, 0x26, 0x83, 0x06, 0x0C, 0x18, 0x2F, 0x80, 0x7D, 0x0A,
  0x0C, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04, 0x10, 0x20, 0x5F, 0x00, 0xC0,
  0x20, 0xB0, 0x00, 0x1A, 0xA0, 0x06, 0x31, 0x84, 0x04, 0x06, 0x03, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x30, 0x10, 0x43, 0x18, 0x40, 0xF8,
  0x10, 0x41, 0x04, 0x21, 0x08, 0x20, 0x82, 0x00, 0x00, 0x80, 0x1F, 0x82,
  0x04, 0x40, 0x24, 0x02, 0x8F, 0x18, 0x91, 0x91, 0x19, 0x11, 0x91, 0x19,
  0x11, 0x93, 0x28, 0xCC, 0x40, 0x04, 0x00, 0x20, 0x01, 0xF0, 0x08, 0x0A,
  0x05, 0x02, 0x82, 0x41, 0x10, 0x88, 0x44, 0x5E, 0x20, 0x90, 0x50, 0x28,
  0x0C, 0x04, 0xFD, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x42, 0x83, 0x06, 0x0C,
  0x18, 0x5F, 0x00, 0x3F, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x20, 0x1F, 0xF8, 0x84, 0x82, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x0F,
  0xA0, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3E,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x0F, 0x18, 0x50, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xC0, 0x60, 0x30, 0x14, 0x09, 0x04, 0x7E, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xE9,
  0x24, 0x92, 0x49, 0x25, 0xC0, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x38,
  0x85, 0x12, 0x24, 0x8A, 0x18, 0x30, 0x50, 0x91, 0x22, 0x24, 0x48, 0x50,
  0x40, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0x80, 0x60,
  0x18, 0x0F, 0x03, 0xC0, 0xE8, 0x5A, 0x16, 0x85, 0x92, 0x64, 0x99, 0x26,
  0x31, 0x8C, 0x61, 0x10, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91,
  0x89, 0x89, 0x85, 0x83, 0x83, 0x81, 0x3F, 0x10, 0x24, 0x0A, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x09, 0x02, 0x41, 0x0F, 0x80,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3F,
  0x10, 0x24, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x09, 0x02, 0x41, 0x0E, 0x80, 0x40, 0x08, 0x01, 0x00, 0xF9, 0x0A, 0x14,
  0x28, 0x50, 0xA2, 0x78, 0x91, 0x12, 0x24, 0x28, 0x50, 0x40, 0x7F, 0x02,
  0x04, 0x08, 0x08, 0x0C, 0x06, 0x02, 0x04, 0x08, 0x10, 0x5F, 0x00, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x7C, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x22, 0x10, 0x88, 0x44,
  0x24, 0x12, 0x05, 0x03, 0x00, 0x80, 0x40, 0x81, 0x06, 0x0C, 0x14, 0x30,
  0x50, 0xC2, 0x42, 0x89, 0x12, 0x22, 0x48, 0x89, 0x24, 0x24, 0x50, 0xA1,
  0x41, 0x85, 0x06, 0x18, 0x18, 0x20, 0x40, 0x80, 0x42, 0x42, 0x24, 0x24,
  0x18, 0x18, 0x10, 0x18, 0x18, 0x24, 0x24, 0x42, 0x42, 0x81, 0x83, 0x05,
  0x0A, 0x22, 0x45, 0x0A, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0xFC,
  0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x04, 0x20, 0x83, 0xF0, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x04, 0x08, 0x20, 0x81,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49,
  0xE0, 0x10, 0x50, 0xA2, 0x24, 0x50, 0x60, 0x80, 0xFF, 0x88, 0x80, 0x78,
  0x10, 0x41, 0x05, 0xF8, 0x61, 0x86, 0x1F, 0xC0, 0x82, 0x08, 0x20, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3D, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x03, 0xC0, 0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x5F, 0x80, 0x38, 0x8A, 0x14, 0x18, 0x3F,
  0xE0, 0x40, 0x80, 0x80, 0xF0, 0x39, 0x08, 0x4F, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x80, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05,
  0xF8, 0x10, 0x20, 0x61, 0x3C, 0x82, 0x08, 0x20, 0xF2, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x40, 0x9F, 0xFC, 0x41, 0x55, 0x55, 0x55, 0x58,
  0x84, 0x21, 0x08, 0xCA, 0x54, 0xC5, 0x29, 0x29, 0x46, 0x20, 0xFF, 0xFE,
  0xF3, 0xA3, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62,
  0x18, 0x84, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x38,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x85, 0xF0, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x08, 0x20, 0x3A, 0x8E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x0D, 0xE8, 0x10, 0x20, 0x40, 0x81, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x80, 0x7C, 0x21, 0x08, 0x30, 0x61, 0x08, 0x7E,
  0x44, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x30, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x0D, 0xE8, 0x83, 0x06, 0x12, 0x24, 0x49, 0x0A, 0x14,
  0x28, 0x60, 0x40, 0x84, 0x30, 0x86, 0x10, 0xA5, 0x14, 0xA4, 0x94, 0x92,
  0x51, 0x8A, 0x31, 0x86, 0x10, 0x42, 0x00, 0x82, 0x89, 0x11, 0x41, 0x82,
  0x04, 0x14, 0x24, 0x8A, 0x08, 0x83, 0x05, 0x12, 0x24, 0x44, 0x8A, 0x14,
  0x28, 0x20, 0x40, 0x81, 0x04, 0x08, 0x60, 0xF8, 0x44, 0x22, 0x11, 0x08,
  0x84, 0x3E, 0x39, 0x08, 0x42, 0x10, 0x88, 0x82, 0x08, 0x42, 0x10, 0x84,
  0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x19, 0x08, 0x42,
  0x10, 0x84, 0xC0, 0xF3, 0x18,
};

const GFXglyph NotoSans_Condensed_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 2, -14 },
  { 3, 4, 5, 6, 1, -14 },
  { 6, 9, 14, 10, 0, -14 },
  { 22, 7, 16, 9, 1, -15 },
  { 36, 11, 14, 13, 1, -14 },
  { 56, 8, 14, 10, 1, -14 },
  { 70, 1, 5, 3, 1, -14 },
  { 71, 3, 17, 5, 1, -14 },
  { 78, 3, 17, 5, 1, -14 },
  { 85, 6, 6, 8, 1, -15 },
  { 90, 7, 10, 9, 1, -12 },
  { 99, 1, 5, 4, 1, -2 },
  { 100, 4, 1, 6, 1, -6 },
  { 101, 1, 1, 4, 1, -1 },
  { 102, 6, 14, 7, 0, -14 },
  { 113, 7, 14, 9, 1, -14 },
  { 126, 3, 14, 9, 2, -14 },
  { 132, 7, 14, 9, 1, -14 },
  { 145, 7, 14, 9, 1, -14 },
  { 158, 9, 14, 9, 0, -14 },
  { 174, 7, 14, 9, 1, -14 },
  { 187, 7, 14, 9, 1, -14 },
  { 200, 7, 14, 9, 1, -14 },
  { 213, 7, 14, 9, 1, -14 },
  { 226, 7, 14, 9, 1, -14 },
  { 239, 1, 11, 4, 1, -11 },
  { 241, 2, 14, 4, 1, -11 },
  { 245, 7, 8, 9, 1, -11 },
  { 252, 7, 4, 9, 1, -9 },
  { 256, 7, 8, 9, 1, -11 },
  { 263, 6, 14, 6, 0, -14 },
  { 274, 12, 16, 14, 1, -14 },
  { 298, 9, 14, 9, 0, -14 },
  { 314, 7, 14, 10, 2, -14 },
  { 327, 8, 14, 10, 1, -14 },
  { 341, 8, 14, 11, 2, -14 },
  { 355, 6, 14, 9, 2, -14 },
  { 366, 6, 14, 8, 2, -14 },
  { 377, 9, 15, 12, 1, -15 },
  { 394, 7, 14, 11, 2, -14 },
  { 407, 3, 14, 5, 1, -14 },
  { 413, 3, 18, 4, -1, -14 },
  { 420, 7, 14, 9, 2, -14 },
  { 433, 5, 14, 8, 2, -14 },
  { 442, 10, 14, 14, 2, -14 },
  { 460, 8, 14, 11, 2, -14 },
  { 474, 10, 14, 12, 1, -14 },
  { 492, 6, 14, 9, 2, -14 },
  { 503, 10, 17, 12, 1, -14 },
  { 525, 7, 14, 9, 2, -14 },
  { 538, 7, 14, 9, 1, -14 },
  { 551, 8, 14, 8, 0, -14 },
  { 565, 8, 14, 11, 2, -14 },
  { 579, 9, 14, 9, 0, -14 },
  { 595, 14, 14, 14, 0, -14 },
  { 620, 8, 14, 8, 0, -14 },
  { 634, 7, 14, 7, 0, -14 },
  { 647, 6, 14, 8, 1, -14 },
  { 658, 4, 17, 6, 2, -14 },
  { 667, 6, 14, 7, 0, -14 },
  { 678, 3, 17, 6, 1, -14 },
  { 685, 7, 7, 9, 1, -14 },
  { 692, 8, 1, 8, 0, 2 },
  { 693, 3, 3, 5, 1, -15 },
  { 695, 6, 11, 8, 1, -11 },
  { 704, 6, 15, 9, 2, -15 },
  { 716, 6, 11, 7, 1, -11 },
  { 725, 7, 15, 9, 1, -15 },
  { 739, 7, 11, 9, 1, -11 },
  { 749, 5, 15, 5, 0, -15 },
  { 759, 7, 16, 9, 1, -11 },
  { 773, 6, 15, 9, 2, -15 },
  { 785, 1, 14, 4, 1, -14 },
  { 787, 2, 19, 4, 0, -14 },
  { 792, 5, 15, 7, 2, -15 },
  { 802, 1, 15, 4, 1, -15 },
  { 804, 10, 11, 14, 2, -11 },
  { 818, 6, 11, 9, 2, -11 },
  { 827, 7, 11, 9, 1, -11 },
  { 837, 6, 16, 9, 2, -11 },
  { 849, 7, 16, 9, 1, -11 },
  { 863, 4, 11, 6, 2, -11 },
  { 869, 5, 11, 7, 1, -11 },
  { 876, 4, 13, 5, 0, -13 },
  { 883, 7, 11, 9, 1, -11 },
  { 893, 7, 11, 7, 0, -11 },
  { 903, 11, 11, 11, 0, -11 },
  { 919, 7, 11, 7, 0, -11 },
  { 929, 7, 16, 7, 0, -11 },
  { 943, 5, 11, 6, 1, -11 },
  { 950, 5, 17, 7, 1, -14 },
  { 961, 1, 20, 9, 4, -15 },
  { 964, 5, 17, 7, 1, -14 },
  { 975, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Thin20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_THIN20PT7B_H_
