#ifndef _NOTOSANS_CONDENSED_THIN32PT7B_H_
#define _NOTOSANS_CONDENSED_THIN32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x50, 0x1C, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82,
  0x1F, 0xFF, 0x08, 0x20, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x40, 0x41,
  0x01, 0x04, 0x3F, 0xFE, 0x10, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x20,
  0x80, 0x82, 0x02, 0x08, 0x00, 0x04, 0x00, 0xF0, 0x34, 0xE4, 0x40, 0x44,
  0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x04, 0x40, 0x24, 0x01, 0xC0, 0x06,
  0x00, 0x58, 0x04, 0x40, 0x42, 0x04, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x28, 0x44, 0x7F, 0x80, 0x40, 0x04, 0x00, 0x40, 0x78, 0x08, 0x42, 0x04,
  0x21, 0x04, 0x10, 0x82, 0x08, 0x22, 0x04, 0x11, 0x02, 0x08, 0x81, 0x04,
  0x80, 0x82, 0x40, 0x42, 0x27, 0x21, 0x24, 0x50, 0x94, 0x24, 0x52, 0x0B,
  0xC9, 0x04, 0x04, 0x82, 0x04, 0x41, 0x02, 0x20, 0x82, 0x10, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x82, 0x10, 0x40, 0x88, 0x40, 0x38, 0x0F, 0x00, 0x42,
  0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x04, 0x20, 0x11,
  0x00, 0x28, 0x00, 0x40, 0x07, 0x00, 0x22, 0x01, 0x04, 0x24, 0x10, 0xA0,
  0x22, 0x80, 0x4A, 0x01, 0x48, 0x03, 0x20, 0x0C, 0x40, 0x31, 0x83, 0x21,
  0xF0, 0x40, 0xFF, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x21, 0x04, 0x10, 0x81, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x21, 0x04, 0x20, 0x84, 0x30, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0,
  0xC0, 0x50, 0x44, 0x41, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x25, 0x24, 0xA0, 0xFE, 0xF0, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x1F,
  0x04, 0x31, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A,
  0x01, 0x20, 0x24, 0x08, 0x41, 0x07, 0xC0, 0x08, 0xCA, 0x98, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x1F, 0x0C,
  0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF8, 0x3F, 0x18, 0x18, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x0F, 0x80, 0x0C,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x9F, 0xE0, 0x00, 0x40, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20,
  0x11, 0x00, 0x88, 0x08, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04, 0x20,
  0x21, 0x01, 0x10, 0x08, 0xFF, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x11, 0x83, 0x8C, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0D, 0x03, 0x3F, 0x80,
  0x0F, 0xC2, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x13, 0xE2, 0x82, 0x60, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x24, 0x04, 0x41, 0x0F, 0xC0, 0xFF, 0xE0, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x00, 0x1F, 0x82, 0x04, 0x20, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x22, 0x02, 0x20, 0x41, 0x88, 0x06, 0x00, 0xF0, 0x10, 0x82,
  0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x22,
  0x04, 0x1F, 0x80, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x14, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x28, 0x05, 0x00, 0xA0, 0x32, 0x06, 0x3F, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x1F, 0x80, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x09, 0x49, 0x28,
  0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x00, 0xFC, 0x82, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x30, 0x01, 0xF0, 0x01, 0x83, 0x01, 0x80, 0x20, 0x40, 0x04,
  0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x06, 0x07, 0xE1, 0x82, 0x08, 0x60,
  0x82, 0x18, 0x40, 0x86, 0x10, 0x41, 0x84, 0x10, 0x61, 0x04, 0x18, 0x41,
  0x06, 0x10, 0x41, 0x84, 0x10, 0x61, 0x0A, 0x28, 0x34, 0xDA, 0x02, 0x08,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x08, 0x00,
  0xFC, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x7F, 0x82, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x24, 0x00, 0x90,
  0x02, 0x40, 0x0A, 0x00, 0x18, 0x00, 0x40, 0xFE, 0x10, 0x32, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x13, 0xFC, 0x43, 0xC8,
  0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05,
  0x01, 0x3F, 0xC0, 0x07, 0xF1, 0x81, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x80,
  0x07, 0xF0, 0xFE, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x18, 0xFE,
  0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x3F, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x03, 0xFE, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x07, 0xF8, 0x10, 0x08, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x80, 0x05, 0x00, 0x09, 0x00, 0x13, 0x00, 0x23, 0x00, 0x41, 0xFF,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x13, 0xE0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xA6,
  0x60, 0x80, 0x70, 0x0A, 0x02, 0x40, 0x88, 0x21, 0x04, 0x21, 0x04, 0x40,
  0x98, 0x12, 0x02, 0xC0, 0x68, 0x0C, 0x81, 0x08, 0x21, 0x04, 0x10, 0x82,
  0x10, 0x22, 0x04, 0x40, 0x48, 0x09, 0x00, 0xA0, 0x08, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x5A, 0x00, 0x2D, 0x00, 0x16,
  0x80, 0x13, 0x20, 0x09, 0x90, 0x04, 0xC8, 0x04, 0x62, 0x02, 0x31, 0x01,
  0x18, 0x81, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x08, 0x41, 0x82, 0x20, 0xC1,
  0x10, 0x60, 0x90, 0x30, 0x28, 0x18, 0x14, 0x0C, 0x0C, 0x06, 0x02, 0x02,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19, 0x01,
  0x88, 0x18, 0x81, 0x84, 0x18, 0x41, 0x82, 0x18, 0x21, 0x81, 0x18, 0x09,
  0x80, 0x98, 0x05, 0x80, 0x58, 0x03, 0x80, 0x38, 0x01, 0x80, 0x10, 0x0F,
  0xC0, 0x20, 0x60, 0x80, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x42, 0x00, 0x82, 0x02, 0x03, 0xF8, 0x00, 0xFC, 0x20, 0xC8, 0x0A, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x04, 0xFE, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00,
  0x0F, 0xE0, 0x20, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00, 0xA0,
  0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x42, 0x00, 0x82, 0x02, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0xFE, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x41, 0x8F, 0xC1, 0x08,
  0x20, 0x84, 0x10, 0x81, 0x10, 0x22, 0x02, 0x40, 0x48, 0x05, 0x00, 0xA0,
  0x08, 0x0F, 0xC6, 0x05, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xBF, 0xE0, 0xFF, 0xF0, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x24, 0x06, 0x3F, 0x80, 0x80, 0x06, 0x00, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x11, 0x00, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08,
  0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x10, 0x05, 0x00, 0x40, 0x14, 0x03, 0x00, 0x50, 0x0A, 0x01, 0x40,
  0x28, 0x08, 0x80, 0xA0, 0x22, 0x04, 0x80, 0x88, 0x12, 0x02, 0x20, 0x44,
  0x08, 0x41, 0x10, 0x41, 0x04, 0x41, 0x04, 0x21, 0x04, 0x10, 0x82, 0x10,
  0x42, 0x08, 0x80, 0x88, 0x22, 0x02, 0x20, 0x88, 0x09, 0x02, 0x20, 0x24,
  0x05, 0x00, 0x50, 0x14, 0x01, 0x40, 0x50, 0x06, 0x01, 0x40, 0x18, 0x02,
  0x00, 0x20, 0x08, 0x00, 0x40, 0x12, 0x02, 0x20, 0x22, 0x04, 0x10, 0x41,
  0x04, 0x08, 0x80, 0x88, 0x05, 0x00, 0x50, 0x02, 0x00, 0x20, 0x05, 0x00,
  0x50, 0x09, 0x00, 0x88, 0x10, 0x81, 0x04, 0x20, 0x42, 0x02, 0x40, 0x24,
  0x02, 0x80, 0x10, 0x80, 0x18, 0x02, 0x40, 0x24, 0x02, 0x20, 0x42, 0x04,
  0x20, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x3F, 0xF8, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x02, 0x00, 0x30, 0x01, 0x40, 0x12,
  0x00, 0x88, 0x08, 0x40, 0x41, 0x04, 0x08, 0x20, 0x22, 0x01, 0x10, 0x05,
  0x00, 0x30, 0xFF, 0xF8, 0xC1, 0x0C, 0x20, 0x80, 0x3F, 0x10, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0x1C, 0x58, 0x14, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0D, 0x05, 0x3E, 0x40, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x09, 0xF8, 0xA0, 0x4A, 0x04, 0xC0, 0x2C, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x2C, 0x02,
  0xC0, 0x2C, 0x04, 0xA0, 0x49, 0xF8, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0xC0,
  0x1F, 0x80, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0xF9, 0x20, 0xA8, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x80, 0xD0, 0x29, 0xF9, 0x1F,
  0x18, 0x64, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x81, 0x1F, 0x80, 0x0F, 0x88, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x41, 0xFC, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x1F, 0x2C, 0x15, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xD0, 0x2A, 0x05, 0x3F, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x36, 0x0C, 0x1E, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x7C, 0xA0, 0xA8, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xF0, 0x05, 0x55, 0x55, 0x55, 0x54, 0x18,
  0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x0B, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x02, 0x81, 0x20, 0x88, 0x22, 0x10, 0x88, 0x22,
  0x09, 0x82, 0xA0, 0xC4, 0x31, 0x08, 0x22, 0x08, 0x81, 0x20, 0x48, 0x0A,
  0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0x1F, 0x50, 0x90, 0x70, 0x30, 0x38, 0x18,
  0x18, 0x04, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x80, 0x80, 0x9F, 0x28, 0x2A, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x90, 0x12,
  0x04, 0x3F, 0x00, 0x8F, 0x8B, 0x04, 0xA0, 0x4C, 0x02, 0xC0, 0x2C, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0xC0, 0x2C, 0x02,
  0xA0, 0x4A, 0x04, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x1F, 0x2C, 0x15, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xD0, 0x2A,
  0x05, 0x3F, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x9F, 0x42, 0x86, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x3F, 0xA0, 0x10, 0x10, 0x08, 0x02, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x40, 0x10, 0x08, 0x04, 0x03, 0x02, 0x7F, 0x00, 0x41,
  0x04, 0x10, 0xFD, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x08, 0x3C, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x0D, 0x05, 0x3E,
  0x40, 0x80, 0x30, 0x09, 0x01, 0x20, 0x24, 0x08, 0x41, 0x08, 0x21, 0x04,
  0x21, 0x02, 0x20, 0x44, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x04,
  0x00, 0x80, 0x40, 0x50, 0x30, 0x24, 0x0C, 0x09, 0x02, 0x82, 0x40, 0xA0,
  0x88, 0x48, 0x22, 0x12, 0x10, 0x84, 0x44, 0x21, 0x11, 0x04, 0x84, 0x41,
  0x21, 0x20, 0x48, 0x48, 0x12, 0x0A, 0x03, 0x02, 0x80, 0xC0, 0xC0, 0x30,
  0x10, 0x08, 0x04, 0x00, 0x80, 0x50, 0x24, 0x08, 0x84, 0x22, 0x04, 0x81,
  0x40, 0x30, 0x08, 0x03, 0x01, 0x20, 0x48, 0x21, 0x10, 0x44, 0x0A, 0x02,
  0x80, 0x40, 0x40, 0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x41, 0x08, 0x20,
  0x84, 0x10, 0x82, 0x20, 0x44, 0x04, 0x80, 0xA0, 0x14, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0xC0,
  0x00, 0x7F, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x80, 0xFF, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x30, 0xE0, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x30, 0x0E, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x1C, 0x00, 0x10, 0x04,
  0x61, 0x81, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 23, 7, 2, -23 },
  { 7, 5, 8, 10, 2, -23 },
  { 12, 14, 23, 16, 1, -23 },
  { 53, 12, 26, 14, 1, -24 },
  { 92, 17, 23, 20, 2, -23 },
  { 141, 14, 23, 15, 1, -23 },
  { 182, 1, 8, 5, 2, -23 },
  { 183, 5, 28, 8, 2, -23 },
  { 201, 6, 28, 8, 1, -23 },
  { 222, 9, 9, 13, 2, -24 },
  { 233, 12, 15, 14, 1, -19 },
  { 256, 3, 7, 6, 1, -3 },
  { 259, 7, 1, 9, 1, -9 },
  { 260, 2, 2, 6, 2, -2 },
  { 261, 9, 23, 10, 1, -23 },
  { 287, 11, 23, 14, 2, -23 },
  { 319, 5, 23, 14, 3, -23 },
  { 334, 11, 23, 14, 1, -23 },
  { 366, 11, 23, 14, 1, -23 },
  { 398, 13, 23, 14, 1, -23 },
  { 436, 11, 23, 14, 2, -23 },
  { 468, 11, 23, 14, 2, -23 },
  { 500, 11, 23, 14, 2, -23 },
  { 532, 12, 23, 14, 1, -23 },
  { 567, 11, 23, 14, 1, -23 },
  { 599, 2, 17, 6, 2, -17 },
  { 604, 3, 21, 6, 1, -17 },
  { 612, 12, 13, 14, 1, -18 },
  { 632, 12, 8, 14, 1, -15 },
  { 644, 12, 13, 14, 1, -18 },
  { 664, 8, 23, 10, 1, -23 },
  { 687, 18, 26, 22, 2, -23 },
  { 746, 14, 23, 14, 0, -23 },
  { 787, 11, 23, 16, 3, -23 },
  { 819, 12, 23, 15, 2, -23 },
  { 854, 12, 23, 17, 3, -23 },
  { 889, 9, 23, 14, 3, -23 },
  { 915, 9, 23, 13, 3, -23 },
  { 941, 15, 23, 19, 2, -23 },
  { 985, 12, 23, 18, 3, -23 },
  { 1020, 5, 23, 8, 1, -23 },
  { 1035, 6, 29, 6, -2, -23 },
  { 1057, 11, 23, 14, 3, -23 },
  { 1089, 9, 23, 12, 3, -23 },
  { 1115, 17, 23, 23, 3, -23 },
  { 1164, 12, 23, 18, 3, -23 },
  { 1199, 15, 23, 19, 2, -23 },
  { 1243, 10, 23, 14, 3, -23 },
  { 1272, 15, 28, 19, 2, -23 },
  { 1325, 11, 23, 15, 3, -23 },
  { 1357, 11, 23, 14, 1, -23 },
  { 1389, 12, 23, 12, 0, -23 },
  { 1424, 12, 23, 18, 3, -23 },
  { 1459, 14, 23, 14, 0, -23 },
  { 1500, 22, 23, 23, 0, -23 },
  { 1564, 12, 23, 12, 0, -23 },
  { 1599, 12, 23, 12, 0, -23 },
  { 1634, 11, 23, 13, 1, -23 },
  { 1666, 6, 28, 10, 3, -23 },
  { 1687, 9, 23, 10, 1, -23 },
  { 1713, 6, 28, 10, 1, -23 },
  { 1734, 13, 12, 14, 1, -23 },
  { 1754, 13, 1, 13, 0, 3 },
  { 1756, 5, 5, 7, 1, -24 },
  { 1760, 10, 17, 13, 1, -17 },
  { 1782, 12, 24, 15, 2, -24 },
  { 1818, 9, 17, 12, 2, -17 },
  { 1838, 11, 24, 15, 2, -24 },
  { 1871, 10, 17, 14, 2, -17 },
  { 1893, 9, 24, 7, 0, -24 },
  { 1920, 11, 25, 15, 2, -17 },
  { 1955, 10, 24, 15, 2, -24 },
  { 1985, 2, 23, 6, 2, -23 },
  { 1991, 5, 31, 6, -1, -23 },
  { 2011, 10, 24, 12, 2, -24 },
  { 2041, 1, 24, 6, 2, -24 },
  { 2044, 17, 17, 22, 2, -17 },
  { 2081, 10, 17, 15, 2, -17 },
  { 2103, 11, 17, 15, 2, -17 },
  { 2127, 12, 24, 15, 2, -17 },
  { 2163, 11, 24, 15, 2, -17 },
  { 2196, 7, 17, 9, 2, -17 },
  { 2211, 9, 17, 11, 1, -17 },
  { 2231, 6, 21, 8, 1, -21 },
  { 2247, 10, 17, 15, 2, -17 },
  { 2269, 11, 17, 11, 0, -17 },
  { 2293, 18, 17, 18, 0, -17 },
  { 2332, 10, 17, 12, 1, -17 },
  { 2354, 11, 25, 11, 0, -17 },
  { 2389, 8, 17, 10, 1, -17 },
  { 2406, 8, 28, 11, 1, -23 },
  { 2434, 1, 32, 14, 6, -24 },
  { 2438, 9, 28, 11, 1, -23 },
  { 2470, 12, 3, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_Thin32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_THIN32PT7B_H_
