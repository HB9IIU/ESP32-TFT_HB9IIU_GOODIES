#ifndef _NOTOSANS_CONDENSED_THIN33PT7B_H_
#define _NOTOSANS_CONDENSED_THIN33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x04,
  0x10, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x82, 0x1F,
  0xFF, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x40, 0x41, 0x01,
  0x04, 0x3F, 0xFE, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80,
  0x82, 0x02, 0x08, 0x08, 0x20, 0x04, 0x00, 0x40, 0x1F, 0xC2, 0x42, 0x44,
  0x04, 0x40, 0x84, 0x08, 0x40, 0x84, 0x04, 0x40, 0x64, 0x03, 0x40, 0x0C,
  0x00, 0x30, 0x04, 0xC0, 0x42, 0x04, 0x30, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x84, 0x67, 0xF8, 0x04, 0x00, 0x40, 0x04, 0x00, 0x38, 0x04,
  0x22, 0x04, 0x21, 0x02, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08,
  0x81, 0x04, 0x40, 0x82, 0x40, 0x41, 0x23, 0x20, 0x92, 0x50, 0x92, 0x18,
  0x49, 0x0A, 0x25, 0x04, 0xE4, 0x82, 0x02, 0x41, 0x02, 0x20, 0x81, 0x10,
  0x40, 0x88, 0x20, 0x84, 0x10, 0x42, 0x08, 0x40, 0x84, 0x20, 0x42, 0x30,
  0x1E, 0x0F, 0x00, 0x21, 0x00, 0x42, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x08, 0x40, 0x10, 0x80, 0x12, 0x00, 0x28, 0x00, 0x60, 0x01,
  0x20, 0x04, 0x40, 0x10, 0x41, 0x20, 0x42, 0x80, 0x89, 0x00, 0x92, 0x00,
  0xA4, 0x00, 0x84, 0x01, 0x08, 0x05, 0x08, 0x11, 0x0F, 0xC3, 0xFF, 0x80,
  0x08, 0x44, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x41, 0x08, 0x41, 0x08, 0x20, 0x80, 0x81, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x84, 0x10, 0x42, 0x08, 0xC0, 0x08, 0x02, 0x00, 0x82, 0x23, 0x7F, 0x02,
  0x01, 0x40, 0x88, 0x21, 0x10, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x25, 0x24, 0xA0, 0xFE, 0xF0,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x0E, 0x06, 0x31, 0x02, 0x20, 0x24, 0x05, 0x00, 0xA0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x24, 0x04, 0x80, 0x88, 0x20, 0xF8,
  0x04, 0x33, 0x59, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3E, 0x18, 0x30, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x07, 0xFF, 0x1F, 0x06, 0x0C, 0x80, 0x60, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x81, 0xF0, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x80, 0x47, 0xF8, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01,
  0x20, 0x09, 0x00, 0x88, 0x08, 0x40, 0x42, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x21, 0x01, 0x08, 0x08, 0x80, 0x47, 0xFF, 0xC0, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFC, 0x40, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0xA0, 0x27, 0xF8, 0x03, 0xC3, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x7E, 0x50, 0x2C, 0x05, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x88, 0x10, 0xFC,
  0xFF, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x0F, 0x01, 0x04,
  0x20, 0x24, 0x02, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x20, 0x21, 0x04,
  0x09, 0x80, 0x60, 0x09, 0x83, 0x04, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x61, 0xF8, 0x0F, 0x03, 0x08,
  0x20, 0x44, 0x02, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x03, 0x40, 0x52, 0x0D, 0x1F, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x83, 0xE0, 0x74, 0x00, 0x00,
  0x00, 0xF0, 0x2C, 0x80, 0x00, 0x00, 0x00, 0x01, 0x29, 0x25, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x00, 0x7C, 0x82,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x06, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0xE0,
  0x00, 0xE3, 0x80, 0x30, 0x08, 0x08, 0x00, 0x82, 0x00, 0x08, 0x40, 0x00,
  0x90, 0x00, 0x12, 0x07, 0x82, 0x81, 0x08, 0x30, 0x41, 0x06, 0x08, 0x20,
  0xC2, 0x04, 0x18, 0x40, 0x83, 0x08, 0x10, 0x61, 0x02, 0x0C, 0x20, 0x41,
  0x84, 0x18, 0x30, 0x83, 0x0A, 0x08, 0x61, 0x40, 0xF3, 0xC4, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x80,
  0x0F, 0xE0, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x12, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x41, 0xFF, 0x08, 0x04, 0x20, 0x10, 0x80, 0x22, 0x00,
  0x90, 0x02, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFA, 0x08, 0x18,
  0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x8F, 0xE0, 0x81, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0xCF, 0xF0, 0x03, 0xE0, 0x60,
  0xC4, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x00, 0xFF,
  0xFC, 0x04, 0x1C, 0x20, 0x11, 0x00, 0x48, 0x02, 0x40, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x22,
  0x06, 0x1F, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x03, 0xF8, 0x18, 0x0C, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x07, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x05, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x22, 0x00, 0x42, 0x00, 0x83, 0xFE,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x9F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x0B, 0xC0, 0x80, 0x30, 0x0A, 0x03, 0x40, 0x48, 0x11, 0x04, 0x20, 0x84,
  0x20, 0x88, 0x13, 0x02, 0x40, 0x58, 0x0C, 0x81, 0x90, 0x21, 0x04, 0x20,
  0x82, 0x10, 0x22, 0x04, 0x40, 0x48, 0x09, 0x00, 0xA0, 0x14, 0x01, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x17, 0x00, 0x05, 0xA0,
  0x01, 0x68, 0x00, 0x9A, 0x00, 0x26, 0x40, 0x09, 0x90, 0x04, 0x64, 0x01,
  0x18, 0x80, 0x46, 0x20, 0x21, 0x88, 0x08, 0x61, 0x02, 0x18, 0x41, 0x06,
  0x10, 0x41, 0x82, 0x10, 0x60, 0x88, 0x18, 0x22, 0x06, 0x04, 0x81, 0x81,
  0x40, 0x60, 0x50, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x1A, 0x00, 0xD0, 0x06, 0x40, 0x32, 0x01, 0x88, 0x0C, 0x40,
  0x61, 0x03, 0x08, 0x18, 0x20, 0xC1, 0x06, 0x04, 0x30, 0x21, 0x80, 0x8C,
  0x04, 0x60, 0x13, 0x00, 0x58, 0x02, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x07,
  0xC0, 0x30, 0x60, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x0A, 0x00,
  0x22, 0x00, 0x44, 0x01, 0x04, 0x04, 0x07, 0xF0, 0xF0, 0x21, 0xC8, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x81,
  0x3F, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x07, 0xC0, 0x30, 0x60, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x05,
  0x00, 0x0A, 0x00, 0x22, 0x00, 0x44, 0x01, 0x04, 0x04, 0x07, 0xF0, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0xF0,
  0x10, 0xE2, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x4F, 0xF1, 0x08, 0x20, 0x84, 0x10, 0x81, 0x10, 0x22,
  0x02, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x0F, 0x84, 0x09, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x27, 0xF8, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x20, 0x09, 0x80, 0x83, 0xF8, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x50, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x21, 0x00,
  0x84, 0x02, 0x10, 0x08, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x80, 0x10, 0x02, 0x80, 0x20, 0x05, 0x00,
  0x60, 0x0A, 0x00, 0xC0, 0x24, 0x02, 0x80, 0x44, 0x05, 0x00, 0x88, 0x09,
  0x01, 0x10, 0x12, 0x04, 0x20, 0x44, 0x08, 0x40, 0x88, 0x10, 0x41, 0x10,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x21, 0x02, 0x10, 0x42, 0x02, 0x20, 0x84,
  0x04, 0x40, 0x88, 0x08, 0x81, 0x20, 0x12, 0x02, 0x40, 0x14, 0x04, 0x80,
  0x28, 0x09, 0x00, 0x50, 0x0C, 0x00, 0xA0, 0x18, 0x00, 0x80, 0x30, 0x01,
  0x00, 0x60, 0x40, 0x14, 0x01, 0x20, 0x22, 0x02, 0x10, 0x41, 0x04, 0x08,
  0x40, 0x88, 0x04, 0x80, 0x50, 0x05, 0x00, 0x20, 0x02, 0x00, 0x50, 0x05,
  0x00, 0x88, 0x08, 0x81, 0x04, 0x10, 0x42, 0x02, 0x20, 0x24, 0x02, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x22, 0x04, 0x20,
  0x41, 0x04, 0x10, 0x80, 0x88, 0x09, 0x00, 0x90, 0x05, 0x00, 0x60, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x7F, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x07, 0xFF, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01,
  0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x02, 0x00,
  0x18, 0x01, 0x40, 0x09, 0x00, 0x88, 0x04, 0x40, 0x41, 0x02, 0x08, 0x20,
  0x23, 0x01, 0x10, 0x05, 0x00, 0x28, 0x00, 0x80, 0xFF, 0xF8, 0xC3, 0x08,
  0x20, 0x80, 0x0E, 0x0C, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x07, 0xC6, 0x16, 0x05, 0x01, 0x80, 0x60, 0x18, 0x05, 0x03, 0x40, 0xCF,
  0xD0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x70,
  0xB1, 0x98, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xB0, 0x16, 0x04, 0xBF, 0x00,
  0x0F, 0x08, 0x48, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xC0, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x71, 0x31, 0xA8, 0x0D, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x50, 0x1B, 0x05, 0x3F, 0x20, 0x0E, 0x0C, 0x44, 0x09,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x47, 0xE0, 0x0F, 0x84, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0xFE, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x0E, 0x06, 0x35, 0x01, 0xA0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1A, 0x03, 0x60, 0xA7,
  0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0xC0, 0x87, 0xE0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x38, 0xB1, 0x30,
  0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xF0, 0x01, 0x55, 0x55,
  0x55, 0x55, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x88, 0x5C, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x81, 0x41, 0x21, 0x10, 0x88,
  0x84, 0x82, 0x41, 0x60, 0xC8, 0x44, 0x21, 0x10, 0x88, 0x24, 0x12, 0x05,
  0x02, 0x80, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x0C, 0x51, 0x11, 0xB0,
  0x50, 0x50, 0x28, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04,
  0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x0C, 0x2C,
  0x4C, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0E, 0x06, 0x31,
  0x01, 0x20, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x60, 0xC3, 0xF0, 0x0E, 0x16,
  0x33, 0x03, 0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x16, 0x02, 0xE0, 0x97, 0xE2, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x0E, 0x06,
  0x35, 0x01, 0xA0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1A, 0x03, 0x60, 0xA7, 0xE4, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1E, 0x9C,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x1F, 0x08, 0x24, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x08, 0x02, 0x80, 0x9F, 0xC0, 0x20,
  0x84, 0x10, 0x43, 0xF4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x08, 0x20, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x80, 0xD0,
  0x2A, 0x05, 0x3F, 0x20, 0x80, 0x28, 0x09, 0x01, 0x20, 0x24, 0x04, 0x41,
  0x08, 0x21, 0x04, 0x11, 0x02, 0x20, 0x44, 0x08, 0x80, 0xA0, 0x14, 0x02,
  0x80, 0x60, 0x04, 0x00, 0xC0, 0x40, 0x50, 0x30, 0x14, 0x0A, 0x05, 0x02,
  0x82, 0x20, 0xA0, 0x88, 0x48, 0x22, 0x11, 0x08, 0x84, 0x44, 0x21, 0x11,
  0x04, 0x84, 0x41, 0x20, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x03, 0x02, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x80, 0x50, 0x24, 0x08, 0x84,
  0x12, 0x04, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x20, 0x48, 0x21, 0x08,
  0x44, 0x0A, 0x01, 0x80, 0x40, 0x40, 0x28, 0x05, 0x00, 0x90, 0x22, 0x04,
  0x40, 0x88, 0x20, 0x84, 0x10, 0x82, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0xE0, 0x00, 0x7F, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0xFF, 0x80,
  0x01, 0x83, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x83, 0x80, 0x60, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x60, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x07, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0xE0, 0x7C, 0x0C, 0x18, 0xA0, 0x30,
};

const GFXglyph NotoSans_Condensed_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 24, 7, 3, -24 },
  { 4, 6, 9, 10, 2, -24 },
  { 11, 14, 24, 16, 1, -24 },
  { 53, 12, 27, 15, 1, -25 },
  { 94, 17, 24, 21, 2, -24 },
  { 145, 15, 24, 16, 1, -24 },
  { 190, 1, 9, 5, 2, -24 },
  { 192, 5, 29, 9, 2, -24 },
  { 211, 6, 29, 9, 1, -24 },
  { 233, 10, 10, 13, 2, -25 },
  { 246, 13, 15, 15, 1, -19 },
  { 271, 3, 7, 6, 1, -3 },
  { 274, 7, 1, 9, 1, -9 },
  { 275, 2, 2, 6, 2, -2 },
  { 276, 9, 24, 11, 1, -24 },
  { 303, 11, 24, 15, 2, -24 },
  { 336, 6, 24, 15, 3, -24 },
  { 354, 11, 24, 15, 2, -24 },
  { 387, 12, 24, 15, 1, -24 },
  { 423, 13, 24, 15, 1, -24 },
  { 462, 11, 24, 15, 2, -24 },
  { 495, 11, 24, 15, 2, -24 },
  { 528, 11, 24, 15, 2, -24 },
  { 561, 12, 24, 15, 1, -24 },
  { 597, 12, 24, 15, 1, -24 },
  { 633, 2, 18, 6, 2, -18 },
  { 638, 3, 22, 6, 1, -18 },
  { 647, 13, 14, 15, 1, -19 },
  { 670, 13, 8, 15, 1, -16 },
  { 683, 13, 14, 15, 1, -19 },
  { 706, 8, 24, 10, 1, -24 },
  { 730, 19, 27, 23, 2, -24 },
  { 795, 14, 24, 14, 0, -24 },
  { 837, 12, 24, 16, 3, -24 },
  { 873, 13, 24, 16, 2, -24 },
  { 912, 13, 24, 18, 3, -24 },
  { 951, 10, 24, 14, 3, -24 },
  { 981, 10, 24, 13, 3, -24 },
  { 1011, 15, 24, 19, 2, -24 },
  { 1056, 12, 24, 18, 3, -24 },
  { 1092, 5, 24, 8, 1, -24 },
  { 1107, 6, 30, 7, -2, -24 },
  { 1130, 11, 24, 14, 3, -24 },
  { 1163, 9, 24, 13, 3, -24 },
  { 1190, 18, 24, 23, 3, -24 },
  { 1244, 13, 24, 19, 3, -24 },
  { 1283, 15, 24, 19, 2, -24 },
  { 1328, 10, 24, 15, 3, -24 },
  { 1358, 15, 30, 19, 2, -24 },
  { 1415, 11, 24, 15, 3, -24 },
  { 1448, 11, 24, 14, 2, -24 },
  { 1481, 13, 24, 13, 0, -24 },
  { 1520, 13, 24, 18, 3, -24 },
  { 1559, 14, 24, 14, 0, -24 },
  { 1601, 23, 24, 24, 0, -24 },
  { 1670, 12, 24, 13, 0, -24 },
  { 1706, 12, 24, 12, 0, -24 },
  { 1742, 11, 24, 13, 1, -24 },
  { 1775, 6, 29, 10, 3, -24 },
  { 1797, 9, 24, 11, 1, -24 },
  { 1824, 6, 29, 10, 1, -24 },
  { 1846, 13, 13, 15, 1, -24 },
  { 1868, 13, 1, 13, 0, 3 },
  { 1870, 5, 5, 8, 1, -25 },
  { 1874, 10, 18, 14, 1, -18 },
  { 1897, 11, 25, 16, 3, -25 },
  { 1932, 9, 18, 12, 2, -18 },
  { 1953, 11, 25, 16, 2, -25 },
  { 1988, 10, 18, 14, 2, -18 },
  { 2011, 9, 25, 8, 0, -25 },
  { 2040, 11, 26, 16, 2, -18 },
  { 2076, 10, 25, 15, 3, -25 },
  { 2108, 2, 24, 6, 2, -24 },
  { 2114, 5, 32, 6, -1, -24 },
  { 2134, 9, 25, 12, 3, -25 },
  { 2163, 1, 25, 6, 2, -25 },
  { 2167, 17, 18, 22, 3, -18 },
  { 2206, 10, 18, 15, 3, -18 },
  { 2229, 11, 18, 15, 2, -18 },
  { 2254, 11, 26, 16, 3, -18 },
  { 2290, 11, 26, 16, 2, -18 },
  { 2326, 6, 18, 10, 3, -18 },
  { 2340, 10, 18, 12, 1, -18 },
  { 2363, 6, 22, 8, 1, -22 },
  { 2380, 11, 17, 15, 2, -17 },
  { 2404, 11, 17, 11, 0, -17 },
  { 2428, 18, 17, 19, 0, -17 },
  { 2467, 10, 17, 12, 1, -17 },
  { 2489, 11, 25, 12, 0, -17 },
  { 2524, 9, 17, 10, 1, -17 },
  { 2544, 9, 29, 11, 1, -24 },
  { 2577, 1, 33, 14, 6, -25 },
  { 2582, 8, 29, 11, 2, -24 },
  { 2611, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Thin33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_THIN33PT7B_H_
