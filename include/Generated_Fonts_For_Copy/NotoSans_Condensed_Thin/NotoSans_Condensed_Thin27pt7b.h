#ifndef _NOTOSANS_CONDENSED_THIN27PT7B_H_
#define _NOTOSANS_CONDENSED_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x60, 0x99, 0x99, 0x99, 0x90, 0x08, 0x40, 0x88, 0x08,
  0x81, 0x08, 0x10, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10, 0x11,
  0x02, 0x10, 0xFF, 0xE2, 0x10, 0x21, 0x02, 0x10, 0x22, 0x02, 0x20, 0x42,
  0x00, 0x08, 0x02, 0x03, 0xF1, 0x22, 0x88, 0x22, 0x08, 0x82, 0x20, 0x88,
  0x12, 0x03, 0x80, 0x30, 0x0B, 0x02, 0x20, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x8B, 0xAC, 0x1C, 0x02, 0x00, 0x80, 0x30, 0x00, 0x90, 0x21, 0x10, 0x84,
  0x21, 0x08, 0x44, 0x10, 0x88, 0x21, 0x10, 0x42, 0x40, 0x84, 0x99, 0x0A,
  0x49, 0x15, 0x0A, 0x4A, 0x13, 0x24, 0x20, 0x48, 0x41, 0x10, 0x82, 0x21,
  0x04, 0x42, 0x10, 0x84, 0x20, 0x90, 0xC1, 0xE0, 0x0C, 0x01, 0x20, 0x21,
  0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x20, 0x14, 0x00, 0x80, 0x38,
  0x04, 0x40, 0x42, 0x28, 0x22, 0x81, 0x28, 0x0C, 0x80, 0x48, 0x0C, 0x41,
  0x23, 0xE3, 0xFE, 0x18, 0x88, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42,
  0x08, 0x42, 0x10, 0x42, 0x08, 0x20, 0xC2, 0x08, 0x41, 0x08, 0x42, 0x08,
  0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x23, 0x00, 0x08, 0x08, 0x08,
  0xC9, 0x3E, 0x18, 0x14, 0x22, 0x42, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x0F, 0xFC, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x55,
  0xA0, 0xFC, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x00, 0x0C, 0x04, 0xC2, 0x11,
  0x02, 0x40, 0x90, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x14, 0x05, 0x02, 0x40, 0x90, 0x22, 0x10, 0x78, 0x09, 0xD3, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1C, 0x18, 0xC0,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0xFF, 0x1C, 0x31,
  0xA0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x1F, 0x01, 0x80, 0x20,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x5F, 0xC0, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08,
  0x20, 0x84, 0x08, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x70, 0xC6,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x3F, 0x00,
  0x07, 0x02, 0x21, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x9E, 0x28,
  0x4C, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x50, 0x22, 0x08,
  0x7C, 0xFF, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x0C, 0x0C, 0xC4, 0x09, 0x02, 0x40, 0x90, 0x24, 0x08, 0x82, 0x33,
  0x03, 0x01, 0x20, 0x84, 0x40, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x24,
  0x08, 0xFC, 0x1C, 0x08, 0x84, 0x11, 0x02, 0x80, 0xA0, 0x28, 0x06, 0x01,
  0x80, 0x60, 0x24, 0x08, 0x8D, 0x18, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x21, 0xF0, 0x80, 0x0C, 0x40, 0x00, 0x01, 0x56, 0x80, 0x00, 0xC0,
  0xC0, 0xC0, 0xC0, 0x40, 0x30, 0x02, 0x00, 0x60, 0x02, 0x00, 0x60, 0x04,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0xC0, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x30, 0x10, 0x18, 0x18, 0x18, 0x08, 0x00, 0x71,
  0x10, 0x10, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x41, 0x02, 0x04, 0x08,
  0x00, 0x00, 0x00, 0x83, 0x00, 0x07, 0xF0, 0x08, 0x08, 0x10, 0x04, 0x20,
  0x02, 0x20, 0x02, 0x41, 0xE1, 0x42, 0x21, 0x44, 0x21, 0x84, 0x21, 0x84,
  0x21, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x44, 0x52, 0x43,
  0x9C, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x30, 0x03,
  0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x09, 0x00, 0x90, 0x11, 0x01,
  0x08, 0x10, 0x81, 0x08, 0x20, 0x43, 0xFC, 0x20, 0x44, 0x04, 0x40, 0x24,
  0x02, 0x40, 0x28, 0x01, 0x80, 0x10, 0xFF, 0x20, 0x28, 0x0A, 0x01, 0x80,
  0x60, 0x28, 0x0A, 0x02, 0xFF, 0x20, 0xC8, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xA0, 0x6F, 0xE0, 0x07, 0x06, 0x32, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x7F, 0xFF, 0x10, 0x12, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x14, 0x02, 0x80, 0x90, 0x23, 0xF8, 0x00, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x05, 0x81, 0x87, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x81, 0xE8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x01, 0x20, 0x11, 0xFE, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0xF2, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E, 0x80, 0xA0,
  0x48, 0x12, 0x08, 0x84, 0x22, 0x08, 0x82, 0x40, 0xB0, 0x34, 0x0C, 0x82,
  0x10, 0x84, 0x20, 0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x04, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1D, 0x00,
  0x5A, 0x00, 0xB4, 0x01, 0x64, 0x04, 0xC8, 0x09, 0x90, 0x13, 0x10, 0x46,
  0x20, 0x8C, 0x41, 0x18, 0x44, 0x30, 0x88, 0x61, 0x10, 0xC1, 0x41, 0x82,
  0x83, 0x05, 0x06, 0x04, 0x08, 0x80, 0x38, 0x06, 0x80, 0xD0, 0x19, 0x03,
  0x20, 0x62, 0x0C, 0x41, 0x84, 0x30, 0x86, 0x08, 0xC1, 0x18, 0x13, 0x02,
  0x60, 0x2C, 0x05, 0x80, 0x70, 0x0E, 0x00, 0x80, 0x0C, 0x01, 0x18, 0x60,
  0x44, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x20,
  0x41, 0xF8, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x41, 0x3F, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00,
  0x0A, 0x01, 0x18, 0x20, 0x44, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x24, 0x02, 0x20, 0x41, 0xF8, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0x3F, 0x88, 0x42, 0x10, 0x82, 0x20, 0x88, 0x12, 0x04, 0x80, 0xA0,
  0x28, 0x04, 0x0E, 0x0C, 0x64, 0x01, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x13, 0xF8, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x40, 0x48, 0x08, 0xFE, 0x00, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x14,
  0x04, 0x80, 0x88, 0x11, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x81, 0x10,
  0x12, 0x02, 0x40, 0x50, 0x0A, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x40, 0x28,
  0x08, 0x05, 0x02, 0x81, 0x20, 0x50, 0x24, 0x0A, 0x04, 0x41, 0x40, 0x88,
  0x24, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x44, 0x42, 0x08,
  0x84, 0x81, 0x20, 0x90, 0x24, 0x12, 0x02, 0x82, 0x40, 0x50, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x10, 0x10, 0x00, 0x40, 0x50, 0x22, 0x08, 0x84,
  0x11, 0x04, 0x40, 0xA0, 0x28, 0x04, 0x01, 0x00, 0xA0, 0x28, 0x12, 0x04,
  0x42, 0x10, 0x82, 0x40, 0x90, 0x18, 0x04, 0x80, 0x50, 0x24, 0x09, 0x02,
  0x21, 0x08, 0x41, 0x20, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x3F, 0xE0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x81, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0x02, 0x04,
  0x08, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x87, 0xE0, 0x0C, 0x02, 0x81, 0x20, 0x48, 0x21, 0x08, 0x44,
  0x09, 0x02, 0x80, 0x60, 0x10, 0xFF, 0xE0, 0x84, 0x22, 0x10, 0x1C, 0x62,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x61, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x31, 0x66, 0xC1, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x2B,
  0xE0, 0x06, 0x19, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0xC4, 0xCD, 0x40, 0xD0, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x14, 0x0D, 0x05, 0x3E, 0x40, 0x0C, 0x19, 0x90, 0x48, 0x14,
  0x0C, 0x06, 0x03, 0xFF, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x7E,
  0x06, 0x20, 0x41, 0x02, 0x04, 0x08, 0x7E, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x0C, 0x0C, 0xD4, 0x0D, 0x03,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0xD0,
  0x53, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x63, 0x07, 0x00, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x8C, 0xB2, 0xC1, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xFF, 0xF0, 0x24,
  0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x2A, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x88, 0x88, 0x90, 0xA0, 0xB0,
  0xC8, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0xFF, 0xFF, 0xF8, 0x18, 0x32,
  0x99, 0x2C, 0x28, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41,
  0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10,
  0x40, 0x0C, 0xB2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x0C, 0x0C, 0xC4, 0x09, 0x02, 0x40, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x88, 0x21, 0xF0, 0x0C,
  0x59, 0xB0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x0A, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x0C,
  0x0C, 0xD4, 0x0D, 0x03, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x05, 0x01, 0x40, 0xC8, 0x53, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0xBF, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x00, 0x1C, 0x62, 0x80, 0x80, 0x80, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01,
  0x01, 0x01, 0x02, 0xFC, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x70, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0xC0, 0x50, 0x48,
  0x24, 0x11, 0x10, 0x88, 0x44, 0x22, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x40,
  0x81, 0x02, 0x83, 0x05, 0x06, 0x12, 0x14, 0x24, 0x28, 0x44, 0x48, 0x88,
  0x92, 0x12, 0x24, 0x24, 0x48, 0x28, 0x50, 0x50, 0xA0, 0xC1, 0x81, 0x81,
  0x01, 0x02, 0x00, 0x81, 0x42, 0x42, 0x24, 0x24, 0x18, 0x10, 0x18, 0x28,
  0x24, 0x42, 0x42, 0x81, 0x81, 0xC0, 0xA0, 0x50, 0x28, 0x22, 0x11, 0x08,
  0x88, 0x24, 0x12, 0x09, 0x05, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x0C, 0x00, 0xFE, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x1F, 0xC0, 0x0E, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x86, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x30, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x38, 0x00, 0x70, 0x23, 0x10, 0x38,
};

const GFXglyph NotoSans_Condensed_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 7, 8, 2, -19 },
  { 8, 12, 19, 13, 1, -19 },
  { 37, 10, 23, 12, 1, -21 },
  { 66, 15, 20, 17, 1, -20 },
  { 104, 12, 20, 13, 1, -20 },
  { 134, 1, 7, 4, 2, -19 },
  { 135, 5, 23, 7, 1, -19 },
  { 150, 5, 23, 7, 1, -19 },
  { 165, 8, 9, 11, 1, -21 },
  { 174, 10, 13, 12, 1, -16 },
  { 191, 2, 6, 5, 1, -3 },
  { 193, 6, 1, 8, 1, -8 },
  { 194, 1, 2, 5, 2, -2 },
  { 195, 7, 19, 9, 1, -19 },
  { 212, 10, 20, 12, 1, -20 },
  { 237, 5, 19, 12, 2, -19 },
  { 249, 10, 20, 12, 1, -20 },
  { 274, 9, 20, 12, 1, -20 },
  { 297, 12, 19, 12, 0, -19 },
  { 326, 9, 19, 12, 2, -19 },
  { 348, 10, 20, 12, 1, -20 },
  { 373, 10, 19, 12, 1, -19 },
  { 397, 10, 20, 12, 1, -20 },
  { 422, 10, 20, 12, 1, -20 },
  { 447, 1, 14, 5, 2, -14 },
  { 449, 2, 17, 5, 1, -14 },
  { 454, 10, 11, 12, 1, -15 },
  { 468, 10, 7, 12, 1, -13 },
  { 477, 10, 11, 12, 1, -15 },
  { 491, 7, 20, 8, 1, -20 },
  { 509, 16, 22, 19, 1, -19 },
  { 553, 12, 19, 12, 0, -19 },
  { 582, 10, 19, 13, 2, -19 },
  { 606, 10, 20, 13, 2, -20 },
  { 631, 11, 19, 15, 2, -19 },
  { 658, 8, 19, 12, 2, -19 },
  { 677, 8, 19, 11, 2, -19 },
  { 696, 12, 20, 16, 2, -20 },
  { 726, 11, 19, 15, 2, -19 },
  { 753, 4, 19, 6, 1, -19 },
  { 763, 5, 24, 5, -2, -19 },
  { 778, 10, 19, 12, 2, -19 },
  { 802, 8, 19, 11, 2, -19 },
  { 821, 15, 19, 19, 2, -19 },
  { 857, 11, 19, 15, 2, -19 },
  { 884, 12, 20, 16, 2, -20 },
  { 914, 9, 19, 12, 2, -19 },
  { 936, 12, 25, 16, 2, -20 },
  { 974, 10, 19, 12, 2, -19 },
  { 998, 10, 20, 12, 1, -20 },
  { 1023, 10, 19, 10, 0, -19 },
  { 1047, 11, 19, 15, 2, -19 },
  { 1074, 11, 19, 11, 0, -19 },
  { 1101, 19, 19, 19, 0, -19 },
  { 1147, 10, 19, 10, 0, -19 },
  { 1171, 10, 19, 10, 0, -19 },
  { 1195, 9, 19, 11, 1, -19 },
  { 1217, 5, 23, 8, 2, -19 },
  { 1232, 7, 19, 9, 1, -19 },
  { 1249, 5, 23, 8, 1, -19 },
  { 1264, 10, 10, 12, 1, -19 },
  { 1277, 11, 1, 11, 0, 2 },
  { 1279, 4, 5, 6, 1, -21 },
  { 1282, 8, 15, 11, 1, -15 },
  { 1297, 9, 21, 13, 2, -21 },
  { 1321, 8, 15, 10, 1, -15 },
  { 1336, 10, 21, 13, 1, -21 },
  { 1363, 9, 15, 12, 1, -15 },
  { 1380, 7, 21, 6, 0, -21 },
  { 1399, 10, 22, 13, 1, -15 },
  { 1427, 8, 21, 12, 2, -21 },
  { 1448, 1, 20, 5, 2, -20 },
  { 1451, 3, 27, 5, 0, -20 },
  { 1462, 8, 21, 10, 2, -21 },
  { 1483, 1, 21, 5, 2, -21 },
  { 1486, 14, 15, 18, 2, -15 },
  { 1513, 8, 15, 12, 2, -15 },
  { 1528, 10, 15, 12, 1, -15 },
  { 1547, 9, 21, 13, 2, -15 },
  { 1571, 10, 21, 13, 1, -15 },
  { 1598, 6, 14, 8, 2, -14 },
  { 1609, 8, 15, 10, 1, -15 },
  { 1624, 6, 18, 7, 0, -18 },
  { 1638, 8, 14, 12, 2, -14 },
  { 1652, 9, 14, 9, 0, -14 },
  { 1668, 15, 14, 15, 0, -14 },
  { 1695, 8, 14, 10, 1, -14 },
  { 1709, 9, 21, 9, 0, -14 },
  { 1733, 7, 14, 9, 1, -14 },
  { 1746, 7, 23, 9, 1, -19 },
  { 1767, 1, 28, 11, 5, -21 },
  { 1771, 7, 23, 9, 1, -19 },
  { 1792, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Thin27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_THIN27PT7B_H_
