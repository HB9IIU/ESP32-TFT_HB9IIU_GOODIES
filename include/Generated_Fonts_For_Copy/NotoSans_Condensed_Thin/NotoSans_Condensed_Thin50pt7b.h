#ifndef _NOTOSANS_CONDENSED_THIN50PT7B_H_
#define _NOTOSANS_CONDENSED_THIN50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x41, 0xA0, 0xD0, 0x68, 0x34,
  0x10, 0x00, 0x40, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x10,
  0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x30, 0x01,
  0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x1F, 0xFF, 0xFF, 0x01, 0x00,
  0x80, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08,
  0x04, 0x00, 0x20, 0x30, 0x3F, 0xFF, 0xFE, 0x06, 0x02, 0x00, 0x10, 0x08,
  0x00, 0x40, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x40, 0x02, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1F,
  0xF0, 0x1C, 0x87, 0x0C, 0x20, 0x46, 0x08, 0x01, 0x02, 0x00, 0xC0, 0x80,
  0x30, 0x20, 0x08, 0x08, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x20, 0x04,
  0x08, 0x01, 0x82, 0x00, 0x30, 0x80, 0x06, 0x20, 0x00, 0x68, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x26, 0x00, 0x08, 0xE0, 0x02, 0x0C, 0x00, 0x81,
  0x80, 0x20, 0x20, 0x08, 0x08, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x30,
  0x08, 0x0C, 0x02, 0x02, 0x00, 0x81, 0x80, 0x20, 0x48, 0x08, 0x73, 0xE2,
  0x70, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0x00, 0x0C, 0x02, 0x10, 0x01, 0x00, 0x81, 0x00, 0x60, 0x30,
  0x20, 0x08, 0x04, 0x06, 0x01, 0x00, 0x80, 0x40, 0x60, 0x10, 0x08, 0x08,
  0x02, 0x01, 0x03, 0x00, 0x40, 0x20, 0x40, 0x08, 0x04, 0x08, 0x03, 0x00,
  0x83, 0x00, 0x60, 0x10, 0x40, 0x04, 0x02, 0x08, 0x00, 0x80, 0x42, 0x00,
  0x10, 0x08, 0x43, 0xC2, 0x01, 0x18, 0xCC, 0x40, 0x22, 0x30, 0xC8, 0x0C,
  0x44, 0x09, 0x81, 0x11, 0x81, 0x90, 0x62, 0x20, 0x11, 0x18, 0xC4, 0x02,
  0x1E, 0x10, 0x80, 0x40, 0x02, 0x10, 0x08, 0x00, 0xC2, 0x01, 0x00, 0x10,
  0x40, 0x20, 0x06, 0x08, 0x04, 0x00, 0x81, 0x00, 0x80, 0x10, 0x20, 0x10,
  0x06, 0x04, 0x02, 0x00, 0x80, 0x80, 0x40, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x00, 0x80, 0x60, 0x60, 0x30, 0x04, 0x08, 0x04, 0x00, 0xC3, 0x01,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x80, 0x02,
  0x03, 0x00, 0x18, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x01,
  0x00, 0x10, 0x04, 0x00, 0x60, 0x10, 0x00, 0x80, 0xC0, 0x02, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0x40, 0x00, 0x22, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x10, 0x00, 0x30, 0x60,
  0x19, 0x80, 0xC0, 0x44, 0x01, 0x01, 0x10, 0x02, 0x04, 0xC0, 0x0C, 0x12,
  0x00, 0x10, 0xC8, 0x00, 0x22, 0x20, 0x00, 0xD8, 0x80, 0x01, 0x43, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x70, 0x60, 0x03, 0x20, 0xC0, 0x18,
  0xC1, 0x81, 0xC1, 0x03, 0xFC, 0x02, 0x01, 0x80, 0x04, 0xFF, 0xFD, 0x55,
  0x40, 0x01, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x30, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x18, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x40, 0x82, 0xB8, 0x9D, 0x07, 0x60, 0x01, 0x80, 0x03,
  0x40, 0x02, 0x40, 0x04, 0x20, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x7F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x33, 0x32, 0x22, 0x64, 0x4C, 0x80,
  0xFF, 0xF0, 0xFC, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xE0, 0x06, 0x1C, 0x06, 0x03, 0x06, 0x00, 0x82, 0x00, 0x63, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x24, 0x00,
  0x32, 0x00, 0x11, 0x80, 0x08, 0x40, 0x0C, 0x30, 0x04, 0x0C, 0x06, 0x03,
  0x06, 0x00, 0xFE, 0x00, 0x00, 0x80, 0xC1, 0xA1, 0x91, 0x89, 0x87, 0x82,
  0x81, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x07, 0xF0, 0x0F,
  0x07, 0x06, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0x1C, 0x0E, 0x18, 0x01,
  0x90, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x40, 0x03, 0x38, 0x03, 0x07, 0xFF, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x23,
  0x00, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x40, 0x60, 0x06, 0x03, 0x00, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x04, 0x00, 0x18, 0x3F, 0xFF, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xE0, 0x60, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x40, 0x06,
  0x30, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xC1, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x0F,
  0x81, 0x1E, 0x70, 0x98, 0x04, 0x50, 0x01, 0x28, 0x00, 0xD8, 0x00, 0x2C,
  0x00, 0x14, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x04, 0xC0,
  0x06, 0x20, 0x02, 0x18, 0x03, 0x06, 0x03, 0x01, 0xFF, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x03,
  0x83, 0x01, 0x80, 0x20, 0xC0, 0x04, 0x20, 0x01, 0x98, 0x00, 0x26, 0x00,
  0x09, 0x80, 0x02, 0x60, 0x00, 0x98, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04,
  0x10, 0x03, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x1C, 0x60, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x71, 0x80, 0x30, 0x30, 0x18, 0x06, 0x0C, 0x00, 0xC6, 0x00,
  0x19, 0x00, 0x02, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x02, 0x20, 0x01, 0x8C,
  0x00, 0xC1, 0xC0, 0x60, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x06,
  0x0C, 0x04, 0x01, 0x06, 0x00, 0x46, 0x00, 0x32, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xB0, 0x00, 0xC8,
  0x00, 0xA6, 0x00, 0xD1, 0xC1, 0xC8, 0x3F, 0x84, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x07,
  0xF8, 0x00, 0xE0, 0x00, 0xBF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x23,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x32,
  0x26, 0x64, 0x4C, 0x80, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0x87, 0x07, 0x20, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x60, 0x0C, 0xC0, 0x1F, 0xE0, 0x24, 0x01, 0x83, 0x01, 0x60,
  0x10, 0x18, 0x0B, 0x01, 0x80, 0xC0, 0x50, 0x08, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x20, 0x08, 0x07, 0x01, 0x00, 0x40,
  0x38, 0x08, 0x02, 0x01, 0xC0, 0x40, 0x10, 0x0E, 0x02, 0x00, 0x80, 0x70,
  0x10, 0x04, 0x02, 0x80, 0x80, 0x60, 0x14, 0x04, 0x03, 0x00, 0xA0, 0x30,
  0x1C, 0x0D, 0x00, 0x81, 0x20, 0x4C, 0x06, 0x19, 0x84, 0x20, 0x1F, 0x87,
  0xC1, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x60, 0x00,
  0x40, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x40, 0x02, 0x01, 0x00, 0x18, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x00, 0xC0, 0x3F, 0xFF, 0x00, 0x80, 0x04, 0x02, 0x00, 0x10, 0x18,
  0x00, 0x60, 0x40, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00,
  0x30, 0x80, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x06, 0x40, 0x00, 0x09,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0,
  0x01, 0xB0, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x78, 0x3F, 0xFE,
  0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0x30, 0x01,
  0x8C, 0x01, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x38, 0x1C, 0x1C, 0x00,
  0x86, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x01, 0x80, 0x7F, 0xE0, 0x00, 0x80, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x08,
  0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C,
  0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0xE0, 0xC0, 0x78,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF,
  0xFB, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xF7, 0xFF,
  0xEC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xC0,
  0x78, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x0E, 0x00, 0x38,
  0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xDF, 0xC7, 0x80, 0xC0,
  0x01, 0xB0, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03,
  0x0C, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x18, 0x0C, 0x0C, 0x03,
  0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xCE,
  0x00, 0x36, 0x80, 0x0F, 0x30, 0x03, 0x84, 0x00, 0xE1, 0x80, 0x30, 0x20,
  0x0C, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x30, 0x0C, 0x0C, 0x01, 0x03,
  0x00, 0x60, 0xC0, 0x08, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x08, 0xC0,
  0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x5F, 0x00, 0x00, 0x0B, 0xA0, 0x00, 0x03,
  0x74, 0x00, 0x00, 0x4E, 0xC0, 0x00, 0x09, 0xC8, 0x00, 0x03, 0x39, 0x00,
  0x00, 0x47, 0x30, 0x00, 0x08, 0xE2, 0x00, 0x03, 0x1C, 0x40, 0x00, 0x43,
  0x8C, 0x00, 0x08, 0x70, 0x80, 0x03, 0x0E, 0x10, 0x00, 0x41, 0xC3, 0x00,
  0x08, 0x38, 0x20, 0x03, 0x07, 0x04, 0x00, 0x40, 0xE0, 0xC0, 0x08, 0x1C,
  0x08, 0x03, 0x03, 0x81, 0x00, 0x40, 0x70, 0x30, 0x08, 0x0E, 0x02, 0x03,
  0x01, 0xC0, 0x40, 0x40, 0x38, 0x0C, 0x08, 0x07, 0x00, 0x83, 0x00, 0xE0,
  0x10, 0x40, 0x1C, 0x03, 0x08, 0x03, 0x80, 0x23, 0x00, 0x70, 0x04, 0x40,
  0x0E, 0x00, 0xC8, 0x01, 0xC0, 0x0B, 0x00, 0x38, 0x01, 0x40, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x10, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0x00, 0x01, 0xD8, 0x00, 0x1C,
  0x80, 0x01, 0xCC, 0x00, 0x1C, 0x40, 0x01, 0xC6, 0x00, 0x1C, 0x20, 0x01,
  0xC3, 0x00, 0x1C, 0x10, 0x01, 0xC1, 0x80, 0x1C, 0x08, 0x01, 0xC0, 0x40,
  0x1C, 0x04, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01, 0xC0, 0x10, 0x1C, 0x01,
  0x81, 0xC0, 0x08, 0x1C, 0x00, 0xC1, 0xC0, 0x04, 0x1C, 0x00, 0x61, 0xC0,
  0x02, 0x1C, 0x00, 0x31, 0xC0, 0x01, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0x9C,
  0x00, 0x0D, 0xC0, 0x00, 0x5C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0xFF, 0x00, 0x07, 0x03, 0x80, 0x18, 0x01, 0x80, 0x40, 0x01, 0x81,
  0x00, 0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00, 0x44,
  0x00, 0x01, 0x8C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x1C, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0xC0, 0x1C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x04, 0xC0,
  0x18, 0xFF, 0xF0, 0xFF, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0x03, 0x80, 0x18, 0x01, 0x80, 0x40, 0x01, 0x81, 0x80,
  0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x8C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x1C, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x02, 0x30, 0x00, 0xCC, 0x00,
  0x13, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04,
  0xC0, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30,
  0x03, 0x0C, 0x07, 0x03, 0xFF, 0x00, 0xC0, 0xC0, 0x30, 0x10, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0xC0, 0x30, 0x30, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x20,
  0xC0, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x08, 0xC0, 0x03, 0x30,
  0x00, 0x4C, 0x00, 0x1B, 0x00, 0x03, 0x03, 0xFE, 0x07, 0x01, 0xC6, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x38, 0x03, 0x0F, 0xFF, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20,
  0x00, 0xC3, 0x00, 0x18, 0x1C, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80, 0x00, 0x24, 0x00,
  0x01, 0x30, 0x00, 0x18, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x30, 0x00, 0x20,
  0x80, 0x03, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81, 0x80, 0x04, 0x04, 0x00,
  0x60, 0x20, 0x02, 0x01, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x0C, 0x02, 0x00, 0x20, 0x30, 0x01, 0x01, 0x00, 0x08, 0x08,
  0x00, 0x60, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x03,
  0x18, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x03, 0x20, 0x00, 0x0B, 0x00,
  0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x02, 0x40, 0x01, 0x40, 0x00, 0x90, 0x00, 0x58, 0x00,
  0x64, 0x00, 0x16, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x04, 0x20, 0x03, 0x20,
  0x01, 0x08, 0x00, 0x88, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x30, 0xC0, 0x08,
  0x40, 0x08, 0x30, 0x06, 0x10, 0x02, 0x04, 0x01, 0x84, 0x00, 0x81, 0x00,
  0x41, 0x80, 0x60, 0x60, 0x10, 0x60, 0x10, 0x18, 0x04, 0x08, 0x04, 0x02,
  0x03, 0x02, 0x01, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x20, 0x20, 0x30, 0x30,
  0x0C, 0x08, 0x04, 0x08, 0x01, 0x06, 0x01, 0x02, 0x00, 0x41, 0x80, 0x41,
  0x80, 0x10, 0x40, 0x18, 0x60, 0x06, 0x10, 0x06, 0x10, 0x01, 0x84, 0x00,
  0x84, 0x00, 0x23, 0x00, 0x23, 0x00, 0x08, 0x80, 0x08, 0xC0, 0x03, 0x20,
  0x03, 0x20, 0x00, 0xC8, 0x00, 0x48, 0x00, 0x16, 0x00, 0x12, 0x00, 0x05,
  0x80, 0x05, 0x80, 0x01, 0x40, 0x01, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x64, 0x00,
  0x08, 0xC0, 0x03, 0x08, 0x00, 0x41, 0x80, 0x18, 0x10, 0x02, 0x03, 0x00,
  0xC0, 0x20, 0x10, 0x06, 0x06, 0x00, 0x40, 0x80, 0x0C, 0x10, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x03, 0x30, 0x00, 0x24, 0x00, 0x07, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x09, 0x00, 0x03, 0x30,
  0x00, 0x42, 0x00, 0x18, 0x40, 0x02, 0x0C, 0x00, 0xC0, 0x80, 0x10, 0x18,
  0x06, 0x01, 0x00, 0x80, 0x30, 0x30, 0x02, 0x04, 0x00, 0x61, 0x80, 0x0C,
  0x20, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0x30, 0x80, 0x00,
  0x78, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03,
  0x0C, 0x00, 0x40, 0x80, 0x18, 0x18, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18,
  0x06, 0x02, 0x00, 0x40, 0xC0, 0x0C, 0x10, 0x00, 0x82, 0x00, 0x10, 0xC0,
  0x03, 0x10, 0x00, 0x26, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xF0, 0x00, 0x20, 0x00,
  0x07, 0x00, 0x00, 0x50, 0x00, 0x0D, 0x80, 0x00, 0x88, 0x00, 0x18, 0xC0,
  0x01, 0x04, 0x00, 0x30, 0x60, 0x02, 0x02, 0x00, 0x60, 0x30, 0x04, 0x01,
  0x00, 0xC0, 0x18, 0x08, 0x00, 0x81, 0x80, 0x0C, 0x10, 0x00, 0x43, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xF0,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x01, 0x07, 0xE0, 0x3C, 0xE0,
  0x80, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x0F, 0xE0, 0xF0, 0x46, 0x00,
  0x98, 0x01, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x02, 0xA0, 0x05, 0x60, 0x12, 0x60, 0x64, 0x7F, 0x08, 0x10,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x7C, 0x08, 0xF3, 0x84, 0xC0, 0x62, 0xC0, 0x19, 0x40, 0x06, 0xC0,
  0x01, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x02, 0xC0, 0x01, 0x60,
  0x01, 0xA8, 0x00, 0x96, 0x00, 0x89, 0x81, 0xC4, 0x7F, 0x80, 0x02, 0x00,
  0x01, 0xF0, 0x1E, 0xF1, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x70, 0x10, 0x7F, 0xC0,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x07, 0xC3, 0x07, 0x3C, 0xC3, 0x01, 0xB1, 0x80, 0x34, 0xC0,
  0x05, 0x20, 0x01, 0x58, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00,
  0xD0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xC8, 0x00, 0x53, 0x00, 0x14, 0x60, 0x09, 0x0C, 0x0C,
  0x41, 0xFE, 0x10, 0x0C, 0x00, 0x03, 0xC0, 0x0E, 0x70, 0x18, 0x18, 0x30,
  0x0C, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x02, 0x1C, 0x06, 0x07, 0xFC, 0x00,
  0x80, 0x01, 0xF8, 0x18, 0x41, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x0F, 0xFC, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x01, 0xF0, 0x01, 0xEF, 0x10, 0xC0, 0x64, 0x40, 0x0D,
  0x30, 0x01, 0x48, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xD0,
  0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x52, 0x00, 0x1C, 0xC0, 0x0F, 0x18, 0x06, 0xC3,
  0x03, 0x30, 0x7F, 0x8C, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x40, 0x06, 0x0F, 0x07, 0x00, 0xFF, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x1F, 0x08, 0xF7, 0x93, 0x01, 0xAC, 0x01, 0x50,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x7D, 0x80, 0x00, 0x01, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x06, 0x1C, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x41, 0xA6, 0x78, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x1A, 0x00, 0xC8, 0x02, 0x20, 0x18, 0x80, 0xC2, 0x02, 0x08, 0x10,
  0x20, 0xC0, 0x82, 0x02, 0x10, 0x08, 0xC0, 0x27, 0x80, 0x92, 0x02, 0x8C,
  0x0E, 0x10, 0x30, 0x60, 0x80, 0x82, 0x03, 0x08, 0x04, 0x20, 0x18, 0x80,
  0x22, 0x00, 0xC8, 0x01, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x3C, 0x23, 0x98, 0x39, 0xC9, 0x01, 0x18,
  0x1A, 0x80, 0x6C, 0x03, 0xE0, 0x0A, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x03, 0xE1, 0x1C, 0xF2, 0x60,
  0x35, 0x80, 0x2A, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x01, 0xF0,
  0x01, 0xEF, 0x00, 0xC0, 0x60, 0x40, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x26,
  0x00, 0x09, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x14, 0x00, 0x05, 0x00,
  0x01, 0x40, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00,
  0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x18, 0xC0, 0x04, 0x18, 0x03, 0x03, 0x01, 0x80, 0x7F, 0x80, 0x01,
  0x00, 0x03, 0xE0, 0x47, 0xBC, 0x26, 0x03, 0x16, 0x00, 0xCA, 0x00, 0x37,
  0x00, 0x0B, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x16, 0x00, 0x0A,
  0x80, 0x0D, 0x40, 0x04, 0x90, 0x04, 0x4C, 0x0E, 0x21, 0xFC, 0x10, 0x10,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xF0, 0x01, 0xEF, 0x10, 0xC0, 0x64, 0x60, 0x09, 0x30, 0x01, 0x48,
  0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00,
  0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD8,
  0x00, 0x72, 0x00, 0x1C, 0xC0, 0x0F, 0x18, 0x06, 0xC3, 0x03, 0x30, 0x7F,
  0x8C, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x03, 0xA3, 0xF9, 0x82, 0xC0, 0xA0, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x07, 0xE0, 0x7B, 0xF2, 0x00, 0x90, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x80, 0x1B, 0x00, 0xC7,
  0xFE, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x03,
  0xFF, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x0F, 0xC0, 0x40, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0x70, 0x02, 0xA0, 0x09, 0x70, 0x32, 0x3F, 0x84, 0x08,
  0x00, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x18, 0x60, 0x08, 0x10, 0x04, 0x08, 0x06, 0x06, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0xC0, 0x30, 0x40, 0x08, 0x20, 0x04,
  0x30, 0x02, 0x10, 0x01, 0x88, 0x00, 0x44, 0x00, 0x26, 0x00, 0x1A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0B, 0x00, 0x38, 0x01, 0x20, 0x05, 0x00, 0x64, 0x01,
  0xA0, 0x08, 0x80, 0x34, 0x01, 0x18, 0x04, 0xC0, 0x23, 0x00, 0x88, 0x04,
  0x20, 0x31, 0x01, 0x84, 0x06, 0x20, 0x20, 0xC0, 0x86, 0x04, 0x18, 0x10,
  0x40, 0x81, 0x06, 0x08, 0x30, 0x20, 0xC1, 0x04, 0x06, 0x10, 0x30, 0x80,
  0xC2, 0x02, 0x10, 0x08, 0xC0, 0x46, 0x01, 0x18, 0x08, 0x80, 0x22, 0x01,
  0x90, 0x06, 0x40, 0x12, 0x00, 0x58, 0x02, 0xC0, 0x0B, 0x00, 0x58, 0x01,
  0x40, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0xC0, 0x03, 0x60, 0x06, 0x20, 0x04, 0x10, 0x0C, 0x18, 0x08, 0x08,
  0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x20, 0x02, 0x60, 0x03, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04,
  0x30, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x60,
  0x06, 0x40, 0x02, 0xC0, 0x03, 0x40, 0x00, 0xB0, 0x00, 0xC8, 0x00, 0x44,
  0x00, 0x23, 0x00, 0x31, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x18, 0x06,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x81, 0x80, 0x40, 0x80, 0x20, 0x40, 0x10,
  0x60, 0x0C, 0x30, 0x02, 0x10, 0x01, 0x08, 0x00, 0xCC, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x08, 0xC0, 0x07,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x38, 0x07, 0xC0, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x7C, 0x03, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x07, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x7C,
  0x01, 0xE0, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x0F, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0xF0, 0x07, 0x03, 0x83, 0x40, 0x1F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 36, 10, 4, -36 },
  { 10, 9, 13, 15, 3, -36 },
  { 25, 22, 36, 25, 1, -36 },
  { 124, 18, 41, 22, 2, -38 },
  { 217, 27, 36, 32, 2, -36 },
  { 339, 22, 37, 24, 2, -36 },
  { 441, 2, 13, 8, 3, -36 },
  { 445, 9, 44, 13, 2, -36 },
  { 495, 9, 44, 13, 2, -36 },
  { 545, 16, 15, 20, 2, -38 },
  { 575, 19, 23, 23, 2, -29 },
  { 630, 4, 11, 9, 2, -5 },
  { 636, 12, 1, 14, 1, -14 },
  { 638, 2, 3, 10, 4, -3 },
  { 639, 15, 36, 16, 1, -36 },
  { 707, 17, 36, 22, 3, -36 },
  { 784, 9, 36, 22, 4, -36 },
  { 825, 18, 36, 22, 2, -36 },
  { 906, 17, 37, 22, 2, -36 },
  { 985, 21, 36, 22, 1, -36 },
  { 1080, 17, 36, 22, 3, -36 },
  { 1157, 17, 37, 22, 3, -36 },
  { 1236, 18, 36, 22, 2, -36 },
  { 1317, 18, 37, 22, 2, -36 },
  { 1401, 17, 37, 22, 2, -36 },
  { 1480, 2, 27, 10, 4, -27 },
  { 1487, 4, 33, 10, 2, -27 },
  { 1504, 19, 21, 23, 2, -28 },
  { 1554, 19, 12, 23, 2, -24 },
  { 1583, 19, 21, 23, 2, -28 },
  { 1633, 13, 36, 15, 1, -36 },
  { 1692, 29, 41, 34, 3, -36 },
  { 1841, 22, 36, 22, 0, -36 },
  { 1940, 18, 36, 24, 4, -36 },
  { 2021, 19, 37, 24, 3, -36 },
  { 2109, 20, 36, 27, 4, -36 },
  { 2199, 15, 36, 22, 4, -36 },
  { 2267, 15, 36, 20, 4, -36 },
  { 2335, 23, 37, 29, 3, -36 },
  { 2442, 19, 36, 28, 4, -36 },
  { 2528, 8, 36, 12, 2, -36 },
  { 2564, 9, 45, 10, -3, -36 },
  { 2615, 18, 36, 22, 4, -36 },
  { 2696, 15, 36, 20, 4, -36 },
  { 2764, 27, 36, 35, 4, -36 },
  { 2886, 20, 36, 28, 4, -36 },
  { 2976, 23, 37, 29, 3, -36 },
  { 3083, 16, 36, 22, 4, -36 },
  { 3155, 23, 45, 29, 3, -36 },
  { 3285, 18, 36, 23, 4, -36 },
  { 3366, 17, 37, 22, 2, -36 },
  { 3445, 19, 36, 19, 0, -36 },
  { 3531, 20, 37, 28, 4, -36 },
  { 3624, 21, 36, 21, 0, -36 },
  { 3719, 34, 36, 36, 1, -36 },
  { 3872, 19, 36, 19, 0, -36 },
  { 3958, 19, 36, 19, 0, -36 },
  { 4044, 18, 36, 20, 1, -36 },
  { 4125, 10, 44, 15, 4, -36 },
  { 4180, 14, 36, 16, 1, -36 },
  { 4243, 9, 44, 15, 2, -36 },
  { 4293, 20, 19, 22, 1, -36 },
  { 4341, 20, 1, 20, 0, 5 },
  { 4344, 8, 8, 12, 2, -38 },
  { 4352, 15, 28, 20, 2, -27 },
  { 4405, 17, 39, 24, 4, -38 },
  { 4488, 14, 28, 18, 3, -27 },
  { 4537, 18, 39, 24, 2, -38 },
  { 4625, 16, 28, 21, 3, -27 },
  { 4681, 13, 38, 12, 0, -38 },
  { 4743, 18, 39, 24, 2, -27 },
  { 4831, 15, 38, 23, 4, -38 },
  { 4903, 3, 36, 9, 3, -36 },
  { 4917, 7, 48, 9, -1, -36 },
  { 4959, 14, 38, 18, 4, -38 },
  { 5026, 1, 38, 9, 4, -38 },
  { 5031, 26, 27, 34, 4, -27 },
  { 5119, 15, 27, 23, 4, -27 },
  { 5170, 18, 28, 23, 2, -27 },
  { 5233, 17, 39, 24, 4, -27 },
  { 5316, 18, 39, 24, 2, -27 },
  { 5404, 10, 27, 15, 4, -27 },
  { 5438, 14, 28, 18, 2, -27 },
  { 5487, 10, 34, 12, 1, -33 },
  { 5530, 15, 27, 23, 4, -26 },
  { 5581, 17, 26, 17, 0, -26 },
  { 5637, 27, 26, 28, 1, -26 },
  { 5725, 16, 26, 18, 1, -26 },
  { 5777, 17, 38, 18, 0, -26 },
  { 5858, 12, 26, 16, 2, -26 },
  { 5897, 13, 44, 17, 2, -36 },
  { 5969, 1, 50, 21, 10, -38 },
  { 5976, 13, 44, 17, 2, -36 },
  { 6048, 19, 4, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Thin50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_THIN50PT7B_H_
