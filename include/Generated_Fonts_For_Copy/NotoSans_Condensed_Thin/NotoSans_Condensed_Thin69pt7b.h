#ifndef _NOTOSANS_CONDENSED_THIN69PT7B_H_
#define _NOTOSANS_CONDENSED_THIN69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin69pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x10, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x02, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0x10, 0xFC, 0x1C, 0x10, 0x1C, 0x38, 0x10,
  0x00, 0x70, 0x10, 0x00, 0x60, 0x10, 0x00, 0xE0, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x10,
  0x00, 0x60, 0x10, 0x00, 0x30, 0x10, 0x00, 0x18, 0x10, 0x00, 0x0E, 0x10,
  0x00, 0x07, 0x90, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x17, 0x80, 0x00, 0x11, 0xC0, 0x00, 0x10, 0x70, 0x00, 0x10,
  0x38, 0x00, 0x10, 0x1C, 0x00, 0x10, 0x0E, 0x00, 0x10, 0x06, 0x00, 0x10,
  0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x10, 0x06, 0x00, 0x10, 0x0E, 0x00, 0x10, 0x1C, 0xE0, 0x10,
  0x38, 0xFC, 0x11, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x01, 0x83,
  0x80, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x02, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x04, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x02,
  0x01, 0x80, 0x03, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x30, 0x00,
  0x30, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x02, 0x02, 0x00, 0x03, 0x00, 0x08,
  0x18, 0x00, 0x04, 0x00, 0x20, 0x60, 0x00, 0x10, 0x00, 0x83, 0x00, 0x00,
  0x40, 0x06, 0x0C, 0x1F, 0x81, 0x80, 0x18, 0x20, 0xE3, 0x06, 0x00, 0x61,
  0x86, 0x06, 0x18, 0x01, 0x86, 0x18, 0x0C, 0x60, 0x04, 0x30, 0xC0, 0x30,
  0xC0, 0x30, 0xC3, 0x00, 0x43, 0x00, 0xC2, 0x08, 0x01, 0x86, 0x06, 0x18,
  0x60, 0x06, 0x1C, 0x38, 0x61, 0x80, 0x18, 0x3F, 0xC3, 0x06, 0x00, 0x20,
  0x3C, 0x0C, 0x18, 0x00, 0x80, 0x00, 0x30, 0x60, 0x03, 0x00, 0x01, 0x81,
  0x00, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x30, 0x00, 0x10, 0x10, 0x00, 0xC0,
  0x00, 0xC0, 0x40, 0x03, 0x00, 0x03, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x04,
  0x00, 0x30, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x02, 0x00,
  0x0C, 0x01, 0x80, 0x08, 0x00, 0x30, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x00, 0x30, 0xE0, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x08, 0x00, 0x18, 0x00, 0x40, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x60,
  0x03, 0x18, 0x03, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0xCC, 0x00, 0x30, 0x06,
  0x60, 0x01, 0xC0, 0x36, 0x00, 0x06, 0x01, 0x30, 0x00, 0x18, 0x19, 0x80,
  0x00, 0x60, 0xCC, 0x00, 0x03, 0x04, 0x60, 0x00, 0x0C, 0x63, 0x00, 0x00,
  0x33, 0x18, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x07, 0x86, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0F, 0x06, 0x00, 0x00, 0xCC, 0x18,
  0x00, 0x0C, 0x60, 0xE0, 0x00, 0xC1, 0x83, 0x80, 0x1C, 0x06, 0x0F, 0x03,
  0xC0, 0x30, 0x1F, 0xF8, 0x00, 0xC0, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0xC0, 0x3E, 0x04, 0x07, 0x3C,
  0x21, 0xE0, 0x3D, 0x38, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x04, 0x80,
  0x00, 0x66, 0x00, 0x06, 0x18, 0x00, 0x60, 0x40, 0x02, 0x03, 0x00, 0x30,
  0x0C, 0x03, 0x00, 0x30, 0x30, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x18, 0xC6, 0x31, 0x98, 0xC6, 0x33, 0x18, 0xC4, 0x63,
  0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x48, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x80, 0x06, 0x03, 0x00,
  0x18, 0x03, 0x80, 0x60, 0x03, 0xC3, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x30,
  0x0F, 0x01, 0xF0, 0x3B, 0x07, 0x30, 0xC3, 0x38, 0x37, 0x03, 0xE0, 0x3C,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x78, 0x00, 0x70,
  0x20, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x1E, 0x01, 0xE0, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x40, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x80, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xFC, 0x03, 0xE0, 0x1F, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xF8, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0xFF, 0xF0, 0x0F, 0xF1, 0xF8, 0x18, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x7C, 0x07, 0xC0, 0x3F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xF0, 0x08, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x00, 0xC3, 0xFF, 0xC0, 0xC7,
  0x00, 0x60, 0xCC, 0x00, 0x30, 0xD8, 0x00, 0x18, 0xF0, 0x00, 0x0C, 0xE0,
  0x00, 0x0C, 0xE0, 0x00, 0x04, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x07,
  0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x70, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x40, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x0F,
  0x30, 0x00, 0x1B, 0x18, 0x00, 0x13, 0x1C, 0x00, 0x73, 0x0E, 0x00, 0xE3,
  0x07, 0xFF, 0x83, 0x01, 0xFE, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x1F, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x18, 0xF3, 0xCF, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x18, 0x63, 0x8C, 0x30,
  0xC3, 0x18, 0x61, 0x84, 0x30, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x38, 0x07, 0x10,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x3F, 0xC0, 0x04, 0x60, 0x00, 0xF9, 0xE0, 0x06,
  0x60, 0x01, 0xC0, 0x20, 0x06, 0x60, 0x03, 0x00, 0x20, 0x06, 0x60, 0x07,
  0x00, 0x60, 0x06, 0xC0, 0x06, 0x00, 0x60, 0x02, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xC0,
  0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00,
  0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03,
  0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18,
  0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x06, 0xC0, 0x18, 0x00, 0xE0,
  0x06, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0xC0,
  0x0C, 0x01, 0xA0, 0x0C, 0xC0, 0x0C, 0x01, 0xA0, 0x0C, 0xC0, 0x0C, 0x03,
  0x30, 0x18, 0x40, 0x06, 0x07, 0x30, 0x38, 0x60, 0x03, 0x9E, 0x1C, 0xF0,
  0x60, 0x01, 0xF8, 0x0F, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x00, 0xC0, 0x1F,
  0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x70, 0xC0, 0x01,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xC0, 0x01, 0xE0, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x00, 0x20,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x01, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x18, 0x0F, 0xF8, 0x03, 0x00, 0x07,
  0x80, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xE0, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0xFF,
  0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0xFF,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x81, 0xCF, 0xF8, 0xFF, 0x00, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0xC7, 0x80, 0x00, 0xCD, 0xC0, 0x00, 0xD8, 0xC0, 0x00,
  0xD8, 0xE0, 0x00, 0xF0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x05, 0xEC, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x03, 0x7B,
  0x00, 0x00, 0x00, 0x13, 0xCC, 0x00, 0x00, 0x01, 0x9E, 0x60, 0x00, 0x00,
  0x0C, 0xF3, 0x00, 0x00, 0x00, 0x47, 0x8C, 0x00, 0x00, 0x06, 0x3C, 0x60,
  0x00, 0x00, 0x31, 0xE3, 0x00, 0x00, 0x01, 0x0F, 0x0C, 0x00, 0x00, 0x18,
  0x78, 0x60, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x04, 0x1E, 0x0C, 0x00,
  0x00, 0x60, 0xF0, 0x60, 0x00, 0x03, 0x07, 0x83, 0x00, 0x00, 0x10, 0x3C,
  0x0C, 0x00, 0x01, 0x81, 0xE0, 0x60, 0x00, 0x0C, 0x0F, 0x03, 0x00, 0x00,
  0x40, 0x78, 0x0C, 0x00, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x30, 0x1E, 0x03,
  0x00, 0x03, 0x00, 0xF0, 0x0C, 0x00, 0x18, 0x07, 0x80, 0x60, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0x0C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x0F, 0x00, 0x60,
  0x03, 0x00, 0x78, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x01, 0x80, 0x1E,
  0x00, 0x60, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0xC0, 0x07, 0x80, 0x0C, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x30, 0x01, 0xE0, 0x03, 0x03, 0x00, 0x0F, 0x00,
  0x0C, 0x18, 0x00, 0x78, 0x00, 0x60, 0xC0, 0x03, 0xC0, 0x03, 0x0C, 0x00,
  0x1E, 0x00, 0x0C, 0x60, 0x00, 0xF0, 0x00, 0x63, 0x00, 0x07, 0x80, 0x03,
  0x30, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x6C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0xF6, 0x00,
  0x00, 0x1E, 0x60, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x0F,
  0x18, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x07, 0x83, 0x00,
  0x00, 0xF0, 0x60, 0x00, 0x1E, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78,
  0x0C, 0x00, 0x0F, 0x01, 0x80, 0x01, 0xE0, 0x18, 0x00, 0x3C, 0x03, 0x00,
  0x07, 0x80, 0x30, 0x00, 0xF0, 0x02, 0x00, 0x1E, 0x00, 0x60, 0x03, 0xC0,
  0x04, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x0C, 0x01, 0xE0, 0x01, 0x80,
  0x3C, 0x00, 0x18, 0x07, 0x80, 0x03, 0x00, 0xF0, 0x00, 0x30, 0x1E, 0x00,
  0x06, 0x03, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0xC1,
  0xE0, 0x00, 0x18, 0x3C, 0x00, 0x01, 0x87, 0x80, 0x00, 0x30, 0xF0, 0x00,
  0x03, 0x1E, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x06, 0x78, 0x00, 0x00, 0xCF,
  0x00, 0x00, 0x0D, 0xE0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFC, 0x03, 0x01, 0xFE, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0xEC, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x01, 0xE3, 0x00, 0x1E, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xFF,
  0xFC, 0x00, 0xC0, 0xFF, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0xC0, 0xC0,
  0x07, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0x80, 0x1E, 0x0E,
  0x00, 0x02, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xFC, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x14, 0x00, 0x00, 0x26, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x60, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x04, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x04, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x04, 0x00,
  0xC0, 0x06, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x60, 0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x60, 0x00, 0x08, 0x60,
  0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x4C, 0x00,
  0x01, 0x90, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x00, 0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3C, 0x01, 0xC1, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x03, 0xE0, 0x30,
  0xE0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x5C, 0x00, 0x05, 0x60, 0x00, 0xD6, 0x00,
  0x19, 0x30, 0x03, 0x11, 0xC0, 0xE1, 0x0F, 0xFC, 0x10, 0x1E, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0x00, 0xC1,
  0xFF, 0xC0, 0xC7, 0x00, 0xF0, 0xCE, 0x00, 0x30, 0xCC, 0x00, 0x18, 0xD8,
  0x00, 0x0C, 0xD0, 0x00, 0x0C, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x02, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x02, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xF0, 0x00, 0x0C, 0xD0, 0x00, 0x0C, 0xD8, 0x00, 0x18, 0xCC,
  0x00, 0x38, 0xC6, 0x00, 0x70, 0xC3, 0x81, 0xE0, 0xC1, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0E, 0x00, 0x87, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x70, 0x1F, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x7F, 0x01, 0x01, 0xFF, 0xC1,
  0x03, 0x80, 0x61, 0x06, 0x00, 0x31, 0x0C, 0x00, 0x19, 0x18, 0x00, 0x0D,
  0x18, 0x00, 0x0D, 0x30, 0x00, 0x05, 0x30, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x07,
  0x30, 0x00, 0x05, 0x18, 0x00, 0x0D, 0x18, 0x00, 0x09, 0x0C, 0x00, 0x19,
  0x0E, 0x00, 0x31, 0x03, 0x80, 0xE1, 0x01, 0xFF, 0x81, 0x00, 0x3C, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x38, 0x18,
  0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x20, 0xE0, 0x01,
  0x81, 0xE0, 0x3E, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x7F, 0xC0, 0x70, 0x20, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE1, 0x07, 0x80, 0x71, 0x0E,
  0x00, 0x39, 0x0C, 0x00, 0x19, 0x18, 0x00, 0x0D, 0x18, 0x00, 0x05, 0x30,
  0x00, 0x07, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x07, 0x30, 0x00, 0x05, 0x30, 0x00, 0x07, 0x18,
  0x00, 0x0F, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x33, 0x06, 0x00, 0x73, 0x03,
  0x81, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x30, 0x00, 0x30, 0x3E,
  0x01, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x1F, 0xC0, 0xC1, 0xFF, 0x83, 0x1C, 0x03, 0x8C, 0xE0, 0x06,
  0x33, 0x00, 0x0C, 0xD8, 0x00, 0x33, 0x40, 0x00, 0x6F, 0x00, 0x01, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x0B, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF4, 0x00, 0x00, 0x00,
  0x12, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x48, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x8E, 0x7E, 0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x02, 0xC0, 0x00,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C,
  0x3C, 0x00, 0xC6, 0xC0, 0x0C, 0xC6, 0x00, 0xD8, 0x60, 0x0D, 0x83, 0x00,
  0xF0, 0x30, 0x0E, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x06, 0x1F, 0xF8,
  0x0F, 0xFC, 0x31, 0x80, 0xE0, 0xE0, 0x31, 0x98, 0x03, 0x8C, 0x00, 0xCD,
  0x80, 0x0C, 0xC0, 0x03, 0x68, 0x00, 0x26, 0x00, 0x1B, 0xC0, 0x01, 0xE0,
  0x00, 0x5C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x80,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x03,
  0x07, 0xFF, 0x0C, 0x70, 0x0E, 0x33, 0x80, 0x1C, 0xCC, 0x00, 0x33, 0x60,
  0x00, 0x6D, 0x00, 0x01, 0xBC, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0x2E, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x10, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0xC1, 0xFF, 0xC0, 0xC3, 0x80, 0xE0, 0xC6,
  0x00, 0x30, 0xCC, 0x00, 0x18, 0xD8, 0x00, 0x0C, 0xD8, 0x00, 0x0C, 0xF0,
  0x00, 0x06, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x02, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x02, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x06, 0xF0, 0x00, 0x0C, 0xD8,
  0x00, 0x0C, 0xD8, 0x00, 0x18, 0xCC, 0x00, 0x38, 0xC6, 0x00, 0x70, 0xC3,
  0x81, 0xE0, 0xC1, 0xFF, 0x80, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC1, 0x03,
  0x80, 0x61, 0x06, 0x00, 0x31, 0x0C, 0x00, 0x19, 0x18, 0x00, 0x0D, 0x18,
  0x00, 0x0D, 0x30, 0x00, 0x05, 0x30, 0x00, 0x07, 0x20, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x30, 0x00, 0x05, 0x30,
  0x00, 0x0F, 0x18, 0x00, 0x0F, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x33, 0x06,
  0x00, 0x73, 0x03, 0x81, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0xFD, 0x87, 0xFF,
  0x1C, 0x0E, 0x70, 0x0C, 0xC0, 0x1B, 0x00, 0x34, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x70,
  0x07, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xD0, 0x00, 0x3B, 0x00, 0x0E, 0x7C, 0x07, 0x83, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC1, 0x03, 0xFC, 0x01, 0xC0, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x15, 0x80, 0x01, 0xAC, 0x00, 0x09, 0x30, 0x00,
  0xC9, 0xC0, 0x1C, 0x47, 0x83, 0xC2, 0x1F, 0xF8, 0x10, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x01, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x08, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x30, 0x00, 0x40, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x01, 0x04, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x08, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x50, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x04, 0xC0, 0x00,
  0xF0, 0x00, 0x66, 0x00, 0x05, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x19,
  0x80, 0x03, 0x20, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x04, 0x30, 0x00, 0x8C,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x00, 0x18, 0x30,
  0x03, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x0C, 0x08, 0x03, 0x01, 0x00, 0x60, 0x60, 0x10, 0x0C, 0x02,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x60,
  0x08, 0x0C, 0x03, 0x02, 0x00, 0x60, 0x40, 0x18, 0x10, 0x03, 0x06, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x02, 0x0C, 0x00, 0x41, 0x80, 0x18, 0x60, 0x03,
  0x08, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x11,
  0x80, 0x02, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x00, 0x06, 0x40, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x05, 0x80,
  0x00, 0xA0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x0C, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x37,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x20, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x08, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x43, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x87, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xBE,
  0x7C, 0x00, 0x78, 0x07, 0x00, 0x70, 0x00, 0xF0, 0xE8, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 49, 14, 5, -49 },
  { 26, 11, 18, 21, 5, -49 },
  { 51, 31, 49, 34, 1, -49 },
  { 241, 24, 56, 31, 3, -52 },
  { 409, 38, 51, 44, 3, -50 },
  { 652, 29, 51, 33, 3, -50 },
  { 837, 2, 18, 11, 5, -49 },
  { 842, 12, 60, 18, 3, -49 },
  { 932, 12, 60, 18, 3, -49 },
  { 1022, 21, 20, 28, 3, -52 },
  { 1075, 26, 32, 31, 3, -40 },
  { 1179, 5, 16, 12, 3, -7 },
  { 1189, 15, 2, 19, 2, -20 },
  { 1193, 3, 4, 13, 5, -4 },
  { 1195, 20, 49, 23, 1, -49 },
  { 1318, 23, 50, 31, 4, -50 },
  { 1462, 12, 49, 31, 6, -49 },
  { 1536, 24, 50, 31, 3, -50 },
  { 1686, 24, 51, 31, 3, -50 },
  { 1839, 29, 50, 31, 1, -50 },
  { 2021, 23, 50, 31, 4, -49 },
  { 2165, 24, 51, 31, 4, -50 },
  { 2318, 24, 49, 31, 3, -49 },
  { 2465, 25, 51, 31, 3, -50 },
  { 2625, 24, 51, 31, 3, -50 },
  { 2778, 3, 37, 13, 5, -37 },
  { 2792, 6, 46, 13, 3, -37 },
  { 2827, 25, 29, 31, 3, -39 },
  { 2918, 26, 17, 31, 3, -33 },
  { 2974, 25, 29, 31, 3, -39 },
  { 3065, 17, 50, 21, 2, -50 },
  { 3172, 40, 55, 47, 4, -49 },
  { 3447, 30, 49, 30, 0, -49 },
  { 3631, 24, 49, 33, 6, -49 },
  { 3778, 27, 51, 33, 4, -50 },
  { 3951, 27, 49, 37, 6, -49 },
  { 4117, 20, 49, 30, 6, -49 },
  { 4240, 20, 49, 27, 6, -49 },
  { 4363, 32, 51, 40, 4, -50 },
  { 4567, 26, 49, 38, 6, -49 },
  { 4727, 10, 49, 16, 3, -49 },
  { 4789, 12, 61, 14, -4, -49 },
  { 4881, 24, 49, 30, 6, -49 },
  { 5028, 20, 49, 27, 6, -49 },
  { 5151, 37, 49, 49, 6, -49 },
  { 5378, 27, 49, 39, 6, -49 },
  { 5544, 32, 51, 40, 4, -50 },
  { 5748, 22, 49, 31, 6, -49 },
  { 5883, 32, 62, 40, 4, -50 },
  { 6131, 24, 49, 31, 6, -49 },
  { 6278, 24, 51, 30, 3, -50 },
  { 6431, 26, 49, 27, 0, -49 },
  { 6591, 28, 50, 38, 5, -49 },
  { 6766, 29, 49, 29, 0, -49 },
  { 6944, 47, 49, 49, 1, -49 },
  { 7232, 26, 49, 27, 0, -49 },
  { 7392, 26, 49, 26, 0, -49 },
  { 7552, 24, 49, 28, 2, -49 },
  { 7699, 13, 60, 21, 6, -49 },
  { 7797, 20, 49, 23, 1, -49 },
  { 7920, 13, 60, 21, 2, -49 },
  { 8018, 27, 25, 31, 2, -49 },
  { 8103, 27, 2, 27, 0, 6 },
  { 8110, 10, 11, 16, 3, -53 },
  { 8124, 20, 38, 28, 3, -37 },
  { 8219, 24, 53, 33, 5, -52 },
  { 8378, 19, 38, 25, 4, -37 },
  { 8469, 24, 53, 33, 3, -52 },
  { 8628, 22, 38, 30, 4, -37 },
  { 8733, 17, 53, 16, 1, -53 },
  { 8846, 24, 54, 32, 3, -37 },
  { 9008, 22, 52, 32, 5, -52 },
  { 9151, 3, 50, 13, 5, -50 },
  { 9170, 9, 67, 13, -1, -50 },
  { 9246, 20, 52, 25, 5, -52 },
  { 9376, 2, 52, 12, 5, -52 },
  { 9389, 37, 37, 47, 5, -37 },
  { 9561, 22, 37, 32, 5, -37 },
  { 9663, 25, 38, 31, 3, -37 },
  { 9782, 24, 53, 33, 5, -37 },
  { 9941, 24, 53, 32, 3, -37 },
  { 10100, 15, 37, 20, 5, -37 },
  { 10170, 19, 38, 25, 3, -37 },
  { 10261, 14, 46, 17, 1, -45 },
  { 10342, 21, 37, 32, 5, -36 },
  { 10440, 23, 36, 23, 0, -36 },
  { 10544, 37, 36, 39, 1, -36 },
  { 10711, 23, 36, 25, 1, -36 },
  { 10815, 24, 53, 24, 0, -36 },
  { 10974, 18, 36, 22, 2, -36 },
  { 11055, 17, 60, 24, 3, -49 },
  { 11183, 2, 70, 29, 14, -53 },
  { 11201, 18, 60, 24, 3, -49 },
  { 11336, 25, 5, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_Thin69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_THIN69PT7B_H_
