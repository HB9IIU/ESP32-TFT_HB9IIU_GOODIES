#ifndef _NOTOSANS_CONDENSED_THIN60PT7B_H_
#define _NOTOSANS_CONDENSED_THIN60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xC0, 0x00, 0x06, 0xFF, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x10,
  0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x08,
  0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00,
  0x18, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30,
  0x0F, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x18,
  0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x08, 0x03, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x8F, 0x81, 0xC2, 0x03, 0x0C,
  0x08, 0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08,
  0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x10, 0x08, 0x00,
  0x40, 0x20, 0x01, 0x80, 0x80, 0x02, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x38, 0x80, 0x00, 0x3A, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xB8, 0x00, 0x02, 0x38, 0x00, 0x08, 0x70, 0x00, 0x20, 0x60,
  0x00, 0x80, 0xC0, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x20, 0x08, 0x00,
  0x80, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80,
  0x20, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x20, 0x32, 0x00, 0x81, 0x87,
  0x02, 0x1C, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x18,
  0xC0, 0x01, 0x80, 0x30, 0x60, 0x01, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x04, 0x00, 0xC0, 0x18, 0x04, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0x18, 0x08, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0,
  0x18, 0x10, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x20, 0x00, 0xC0,
  0x18, 0x60, 0x00, 0xC0, 0x18, 0x61, 0xF8, 0xC0, 0x18, 0x43, 0x0C, 0x40,
  0x10, 0xC6, 0x04, 0x40, 0x10, 0x84, 0x06, 0x60, 0x31, 0x8C, 0x02, 0x60,
  0x31, 0x8C, 0x03, 0x30, 0x61, 0x08, 0x03, 0x18, 0xC3, 0x08, 0x03, 0x0F,
  0x82, 0x08, 0x01, 0x00, 0x06, 0x18, 0x01, 0x00, 0x06, 0x18, 0x01, 0x00,
  0x04, 0x18, 0x01, 0x00, 0x0C, 0x18, 0x01, 0x00, 0x08, 0x18, 0x01, 0x00,
  0x18, 0x18, 0x01, 0x00, 0x18, 0x18, 0x01, 0x00, 0x10, 0x18, 0x01, 0x00,
  0x30, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x40, 0x0C, 0x02, 0x00, 0xC0, 0x04, 0x06, 0x00,
  0x80, 0x06, 0x04, 0x01, 0x80, 0x03, 0x0C, 0x01, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xFC, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0xC0,
  0x08, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x00,
  0xC0, 0x08, 0x00, 0x10, 0x02, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x20, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x8C, 0x01, 0x00, 0x62, 0x00, 0x60, 0x19, 0x80, 0x0C, 0x06, 0x60, 0x01,
  0x01, 0x10, 0x00, 0x60, 0x44, 0x00, 0x0C, 0x33, 0x00, 0x01, 0x08, 0xC0,
  0x00, 0x62, 0x30, 0x00, 0x0D, 0x84, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x1C, 0x18, 0x00, 0x0D, 0x02, 0x00, 0x03, 0x60, 0xC0, 0x01,
  0x8C, 0x18, 0x01, 0xC1, 0x83, 0x81, 0xE0, 0x60, 0x7F, 0xE0, 0x0C, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x08, 0x04, 0x07, 0x81, 0x07, 0x1C, 0x4E, 0x00, 0xFC, 0x00, 0x0C, 0x00,
  0x06, 0x80, 0x01, 0x30, 0x00, 0x84, 0x00, 0x60, 0x80, 0x30, 0x30, 0x18,
  0x06, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x23, 0x18, 0x84, 0x60, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x60, 0x18,
  0x01, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00, 0x0C,
  0x60, 0x00, 0x23, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00,
  0x01, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00,
  0x48, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0x40,
  0x00, 0xC3, 0x00, 0x06, 0x08, 0x00, 0x20, 0x60, 0x03, 0x01, 0x80, 0x10,
  0x0E, 0x01, 0x80, 0x38, 0x38, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x1C, 0x07,
  0x83, 0xB0, 0xE6, 0x30, 0xCC, 0x1B, 0x03, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x07, 0xFC, 0x03, 0xC0,
  0xF0, 0x70, 0x03, 0x84, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xC0,
  0xF0, 0x60, 0x03, 0x8C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x80, 0x01, 0x8F, 0x00, 0x70, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x04, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x02, 0x00,
  0x1F, 0xFF, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0xC0, 0x03,
  0x87, 0x80, 0x78, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0x83, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x0F, 0xF0, 0x31, 0xE1, 0xE1, 0x98,
  0x01, 0x8D, 0x80, 0x06, 0x68, 0x00, 0x33, 0xC0, 0x00, 0xDC, 0x00, 0x06,
  0xE0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x22, 0x00, 0x03, 0x18, 0x00,
  0x18, 0x40, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x30, 0x1C, 0x00,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x78, 0x3C, 0x07, 0x00, 0x70, 0x60, 0x01, 0x83, 0x00, 0x06, 0x30,
  0x00, 0x11, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x32, 0x00, 0x01,
  0x90, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x10, 0x00, 0x30, 0xC0,
  0x01, 0x83, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x38, 0x00, 0xE3, 0x80,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xCE, 0x00, 0x1C, 0x18, 0x01, 0x80,
  0x70, 0x18, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x6C,
  0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x20,
  0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x70, 0x1C,
  0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0xE0, 0x18,
  0x03, 0x03, 0x00, 0x18, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x76, 0x00,
  0x05, 0x30, 0x00, 0x93, 0x80, 0x19, 0x1C, 0x07, 0x10, 0x7F, 0xC3, 0x00,
  0x40, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x04, 0x03, 0x80, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xB0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x18, 0xF3, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x18, 0x61,
  0x04, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0xF0, 0x38, 0x40,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x00, 0x43, 0x00, 0x03, 0x80, 0x0C, 0x60, 0x03, 0xFE, 0x01, 0x88, 0x00,
  0xC0, 0x40, 0x13, 0x00, 0x30, 0x08, 0x02, 0x60, 0x0C, 0x01, 0x00, 0x6C,
  0x01, 0x00, 0x20, 0x0D, 0x00, 0x60, 0x04, 0x01, 0xA0, 0x08, 0x01, 0x80,
  0x3C, 0x03, 0x00, 0x30, 0x07, 0x80, 0x60, 0x06, 0x00, 0xF0, 0x0C, 0x00,
  0xC0, 0x1E, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x78, 0x06,
  0x00, 0x60, 0x0F, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x18, 0x01, 0x80, 0x3C,
  0x03, 0x00, 0x30, 0x07, 0x80, 0x60, 0x0E, 0x00, 0xB0, 0x0C, 0x01, 0x40,
  0x32, 0x00, 0x80, 0x28, 0x06, 0x40, 0x18, 0x0D, 0x01, 0x8C, 0x01, 0x03,
  0x30, 0x31, 0x80, 0x38, 0xC3, 0x1C, 0x30, 0x03, 0xF0, 0x3F, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x01, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x60, 0x08, 0x00, 0x18, 0x02, 0x00, 0x04, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0C, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x30, 0x00, 0xF1,
  0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x2C,
  0x00, 0x01, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x04, 0xC0, 0x00,
  0x66, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x1E, 0x0F, 0xFF, 0xC0, 0x60,
  0x07, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x98, 0x00,
  0x1C, 0xC0, 0x01, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x78, 0x0F, 0x01, 0xC0, 0x02, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0x00, 0xF0, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0xC0, 0x07, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0xC0, 0xC0, 0x07, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xB0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFB, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x00,
  0x78, 0x01, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x18, 0xFF, 0x8E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x3F, 0xE0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x40, 0xCF, 0xF0, 0x30, 0x00, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x30,
  0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C,
  0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x01, 0x9E, 0x00, 0x0C, 0xF0,
  0x00, 0x6C, 0xC0, 0x03, 0xC2, 0x00, 0x1E, 0x18, 0x00, 0xE0, 0x60, 0x06,
  0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x04,
  0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x18, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x05, 0xF0,
  0x00, 0x00, 0x0D, 0xD0, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x09, 0xD8,
  0x00, 0x00, 0x19, 0xC8, 0x00, 0x00, 0x19, 0xCC, 0x00, 0x00, 0x11, 0xCC,
  0x00, 0x00, 0x31, 0xC4, 0x00, 0x00, 0x31, 0xC6, 0x00, 0x00, 0x21, 0xC6,
  0x00, 0x00, 0x61, 0xC2, 0x00, 0x00, 0x61, 0xC3, 0x00, 0x00, 0x41, 0xC3,
  0x00, 0x00, 0xC1, 0xC1, 0x00, 0x00, 0xC1, 0xC1, 0x80, 0x00, 0x81, 0xC1,
  0x80, 0x01, 0x81, 0xC0, 0x80, 0x01, 0x81, 0xC0, 0xC0, 0x01, 0x01, 0xC0,
  0xC0, 0x03, 0x01, 0xC0, 0x40, 0x03, 0x01, 0xC0, 0x60, 0x02, 0x01, 0xC0,
  0x60, 0x06, 0x01, 0xC0, 0x20, 0x06, 0x01, 0xC0, 0x30, 0x04, 0x01, 0xC0,
  0x30, 0x0C, 0x01, 0xC0, 0x10, 0x0C, 0x01, 0xC0, 0x18, 0x08, 0x01, 0xC0,
  0x18, 0x18, 0x01, 0xC0, 0x08, 0x18, 0x01, 0xC0, 0x0C, 0x10, 0x01, 0xC0,
  0x0C, 0x30, 0x01, 0xC0, 0x04, 0x30, 0x01, 0xC0, 0x06, 0x20, 0x01, 0xC0,
  0x06, 0x60, 0x01, 0xC0, 0x02, 0x60, 0x01, 0xC0, 0x03, 0x40, 0x01, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xD8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCC,
  0x00, 0x03, 0xC6, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3,
  0x00, 0x03, 0xC1, 0x80, 0x03, 0xC1, 0x80, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0,
  0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x08, 0x03, 0xC0, 0x0C, 0x03, 0xC0,
  0x04, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x02, 0x03, 0xC0, 0x03, 0x03, 0xC0,
  0x01, 0x03, 0xC0, 0x01, 0x83, 0xC0, 0x00, 0x83, 0xC0, 0x00, 0xC3, 0xC0,
  0x00, 0x43, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x23, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0x13, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0B, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x6C,
  0x00, 0x19, 0x80, 0x07, 0x30, 0x03, 0x87, 0xFF, 0xE0, 0xFF, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x30, 0x01, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x23,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00, 0x00, 0x98,
  0x00, 0x04, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x03,
  0x0C, 0x00, 0x30, 0x60, 0x07, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0x03, 0xFF, 0x80, 0xF0, 0x1F, 0x1C, 0x00, 0x23, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x80, 0x01, 0x8F, 0x00, 0xF0, 0x7F, 0xFC,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0F, 0x00,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x18,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x10, 0x18, 0x00,
  0x0C, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x0C,
  0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x00, 0x60, 0x00, 0x60, 0x10, 0x00, 0x18, 0x04, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x68, 0x00, 0x03, 0x80, 0x00, 0x24,
  0x00, 0x01, 0x40, 0x00, 0x33, 0x00, 0x01, 0xA0, 0x00, 0x19, 0x80, 0x00,
  0xD0, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0x20, 0x00, 0x26, 0x00,
  0x06, 0x18, 0x00, 0x33, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x80, 0x01, 0x86,
  0x00, 0x0C, 0x60, 0x00, 0x81, 0x00, 0x04, 0x30, 0x00, 0xC0, 0x80, 0x02,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x04, 0x00, 0x30, 0x30, 0x01, 0x82, 0x00,
  0x10, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x04, 0x00, 0x40, 0xC0, 0x0C, 0x03,
  0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x30, 0x10, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x01, 0x00, 0x20, 0x08, 0x06, 0x01, 0x80, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0x40, 0x20, 0x01,
  0x01, 0x80, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x18, 0x18, 0x00, 0x60, 0x40,
  0x0C, 0x0C, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x08, 0x30, 0x01, 0x86,
  0x00, 0x04, 0x18, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x61, 0x80, 0x01,
  0x8C, 0x00, 0x10, 0x80, 0x00, 0xC6, 0x00, 0x08, 0x40, 0x00, 0x23, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x80, 0x01, 0x90,
  0x00, 0x06, 0xC0, 0x00, 0x48, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x00,
  0xB0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x80,
  0x06, 0x01, 0x00, 0x08, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10, 0x20,
  0x00, 0x30, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x66, 0x00, 0x00, 0x48, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x16, 0x00, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x03,
  0x08, 0x00, 0x04, 0x18, 0x00, 0x18, 0x10, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x20, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x60, 0x01, 0x01, 0x80, 0x03, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00,
  0x60, 0x20, 0x01, 0x80, 0xC0, 0x04, 0x03, 0x00, 0x30, 0x06, 0x00, 0x80,
  0x18, 0x06, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30,
  0x00, 0x04, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x06, 0x01, 0x80, 0x0C, 0x02, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x10, 0x60, 0x00, 0x30, 0x80, 0x00,
  0x23, 0x00, 0x00, 0x64, 0x00, 0x00, 0x58, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0xFC, 0x07, 0xE3, 0xC1, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x03, 0xFC, 0x07, 0xF1, 0x0F, 0x00, 0x47, 0x00, 0x13, 0x00, 0x04,
  0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xD0, 0x00, 0x34, 0x00, 0x1D, 0x80, 0x05, 0x60, 0x03, 0x4C, 0x01,
  0x91, 0x80, 0xC4, 0x3F, 0xE1, 0x01, 0x80, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x83, 0xFC, 0x08, 0x70, 0xF0,
  0x9C, 0x01, 0x89, 0x80, 0x0C, 0xB0, 0x00, 0xCA, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06,
  0xE0, 0x00, 0x6A, 0x00, 0x0C, 0xB0, 0x00, 0xC9, 0x80, 0x38, 0x8E, 0x07,
  0x08, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x01, 0xF1, 0xC1, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x02,
  0x07, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x07, 0xF0, 0x60, 0xF0, 0xE3, 0x0C,
  0x01, 0x98, 0xC0, 0x06, 0xCC, 0x00, 0x16, 0x60, 0x00, 0xF2, 0x00, 0x03,
  0xB0, 0x00, 0x1D, 0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0xEC,
  0x00, 0x07, 0x20, 0x00, 0x39, 0x80, 0x02, 0xC4, 0x00, 0x36, 0x30, 0x03,
  0x30, 0xE0, 0x31, 0x81, 0xFF, 0x0C, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x78, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x04,
  0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x02,
  0x07, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x03, 0xFC,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0xF8,
  0x7F, 0xF0, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01,
  0xFE, 0x18, 0x3C, 0x78, 0xC3, 0x00, 0x66, 0x30, 0x01, 0xB3, 0x00, 0x07,
  0x98, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x40, 0x00, 0x1A, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x68,
  0x00, 0x07, 0x40, 0x00, 0x3B, 0x00, 0x01, 0xC8, 0x00, 0x1E, 0x60, 0x00,
  0xB1, 0x00, 0x0D, 0x8C, 0x00, 0xCC, 0x38, 0x1C, 0x60, 0x7F, 0xC3, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x80, 0x03, 0x87, 0x80, 0x78, 0x0F, 0xFF, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x3F, 0xC2, 0x1C, 0x38,
  0x9C, 0x03, 0x26, 0x00, 0x6B, 0x00, 0x1A, 0x80, 0x02, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xFF, 0xA0, 0x00, 0x00,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x00, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x8C, 0xF8, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x0D, 0x00, 0x0C, 0x80, 0x0C, 0x40, 0x04,
  0x20, 0x06, 0x10, 0x06, 0x08, 0x02, 0x04, 0x03, 0x02, 0x03, 0x01, 0x03,
  0x00, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x10, 0xC0, 0x08, 0xF0, 0x04,
  0xC8, 0x02, 0x46, 0x01, 0x41, 0x00, 0xE0, 0xC0, 0x60, 0x20, 0x20, 0x18,
  0x10, 0x04, 0x08, 0x03, 0x04, 0x00, 0x82, 0x00, 0x61, 0x00, 0x10, 0x80,
  0x0C, 0x40, 0x02, 0x20, 0x01, 0x90, 0x00, 0x48, 0x00, 0x34, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0xF0, 0x0F, 0xE1, 0x1C, 0x38,
  0x38, 0x72, 0x60, 0x30, 0xC0, 0x75, 0x80, 0x33, 0x00, 0x6A, 0x00, 0x24,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x83, 0xFC,
  0x21, 0xC3, 0x89, 0xC0, 0x32, 0x40, 0x06, 0xB0, 0x01, 0xA8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x01, 0xFE,
  0x00, 0x3C, 0x78, 0x03, 0x00, 0x70, 0x30, 0x01, 0x83, 0x00, 0x06, 0x18,
  0x00, 0x11, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00,
  0x03, 0x60, 0x00, 0x13, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x60, 0x00, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x60, 0x18, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x30,
  0x00, 0x83, 0xFC, 0x08, 0x78, 0xF0, 0x8C, 0x03, 0x89, 0x80, 0x0C, 0xB0,
  0x00, 0xCA, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xA0, 0x00, 0x6B, 0x00, 0x0C, 0xB0,
  0x00, 0xC9, 0x80, 0x18, 0x8E, 0x07, 0x08, 0x7F, 0xC0, 0x80, 0x40, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x18, 0x3C,
  0x38, 0xC3, 0x00, 0x66, 0x30, 0x01, 0xB3, 0x00, 0x05, 0x98, 0x00, 0x3D,
  0x80, 0x00, 0xEC, 0x00, 0x07, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x68, 0x00, 0x07, 0x40,
  0x00, 0x3B, 0x00, 0x01, 0xC8, 0x00, 0x1E, 0x60, 0x00, 0xB1, 0x80, 0x0D,
  0x8E, 0x00, 0xCC, 0x38, 0x1C, 0x60, 0x7F, 0xC3, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x83, 0xF8, 0xF3,
  0x8C, 0x09, 0x80, 0xB0, 0x0A, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xFC, 0x0F,
  0x8F, 0xCE, 0x00, 0x46, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x34, 0x00,
  0x3B, 0xC0, 0x38, 0x7F, 0xF0, 0x03, 0x80, 0x00, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x03, 0xFF, 0xFF, 0xF0, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x61, 0x07, 0xF0, 0x0C, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xE8, 0x00, 0x1D, 0x80, 0x03,
  0xB0, 0x00, 0xD2, 0x00, 0x32, 0x60, 0x0C, 0x47, 0x03, 0x08, 0x7F, 0xC1,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00,
  0x06, 0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x10,
  0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x81, 0x80, 0x18, 0x08, 0x01, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00, 0x09,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x02, 0x40, 0x03, 0x40, 0x02, 0x60, 0x03, 0x40, 0x06, 0x60,
  0x02, 0x60, 0x06, 0x60, 0x02, 0x60, 0x04, 0x20, 0x06, 0x60, 0x04, 0x30,
  0x06, 0x20, 0x0C, 0x30, 0x04, 0x20, 0x0C, 0x30, 0x04, 0x30, 0x0C, 0x10,
  0x0C, 0x30, 0x08, 0x10, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x10, 0x18, 0x18,
  0x08, 0x18, 0x18, 0x08, 0x18, 0x18, 0x10, 0x08, 0x18, 0x08, 0x10, 0x0C,
  0x10, 0x08, 0x30, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x30, 0x0C, 0x20, 0x04,
  0x30, 0x04, 0x20, 0x06, 0x20, 0x04, 0x60, 0x06, 0x20, 0x06, 0x60, 0x02,
  0x60, 0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x02, 0x40, 0x03,
  0x40, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x10, 0x0C, 0x03,
  0x00, 0x40, 0x20, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x11,
  0x80, 0x01, 0x98, 0x00, 0x0B, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0x90, 0x00, 0x19, 0x80, 0x03, 0x08, 0x00,
  0x30, 0xC0, 0x06, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x03, 0x00, 0x80, 0x30,
  0x18, 0x01, 0x81, 0x00, 0x18, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40,
  0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x10, 0x40, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x30, 0x18, 0x01, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x04, 0x00, 0xC0, 0x20, 0x02, 0x03, 0x00,
  0x10, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x60, 0x00, 0xC2,
  0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00,
  0x36, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x08, 0x60,
  0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0xFC, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x78, 0x03, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x05, 0x80, 0xE0, 0x1E,
  0x00, 0xF0, 0xE8, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 43, 12, 5, -43 },
  { 18, 10, 16, 18, 4, -43 },
  { 38, 27, 43, 29, 1, -43 },
  { 184, 22, 49, 27, 2, -46 },
  { 319, 32, 44, 38, 3, -43 },
  { 495, 26, 44, 29, 2, -43 },
  { 638, 2, 16, 10, 4, -43 },
  { 642, 10, 52, 16, 3, -43 },
  { 707, 11, 52, 16, 2, -43 },
  { 779, 18, 18, 24, 3, -46 },
  { 820, 23, 28, 27, 2, -35 },
  { 901, 5, 14, 11, 2, -6 },
  { 910, 13, 1, 17, 2, -17 },
  { 912, 3, 4, 12, 4, -4 },
  { 914, 18, 43, 20, 1, -43 },
  { 1011, 21, 43, 27, 3, -43 },
  { 1124, 11, 43, 27, 5, -43 },
  { 1184, 20, 43, 27, 3, -43 },
  { 1292, 20, 44, 27, 3, -43 },
  { 1402, 25, 43, 27, 1, -43 },
  { 1537, 21, 44, 27, 3, -43 },
  { 1653, 21, 44, 27, 3, -43 },
  { 1769, 21, 43, 27, 3, -43 },
  { 1882, 21, 44, 27, 3, -43 },
  { 1998, 20, 44, 27, 3, -43 },
  { 2108, 3, 32, 12, 4, -32 },
  { 2120, 6, 40, 11, 2, -32 },
  { 2150, 23, 25, 27, 2, -34 },
  { 2222, 23, 14, 27, 2, -28 },
  { 2263, 23, 25, 27, 2, -34 },
  { 2335, 16, 43, 18, 1, -43 },
  { 2421, 35, 49, 41, 3, -43 },
  { 2636, 26, 43, 26, 0, -43 },
  { 2776, 21, 43, 29, 5, -43 },
  { 2889, 24, 44, 29, 3, -43 },
  { 3021, 24, 43, 32, 5, -43 },
  { 3150, 18, 43, 26, 5, -43 },
  { 3247, 18, 43, 24, 5, -43 },
  { 3344, 28, 45, 35, 3, -44 },
  { 3502, 23, 43, 33, 5, -43 },
  { 3626, 9, 43, 14, 3, -43 },
  { 3675, 11, 54, 12, -4, -43 },
  { 3750, 21, 43, 26, 5, -43 },
  { 3863, 17, 43, 23, 5, -43 },
  { 3955, 32, 43, 42, 5, -43 },
  { 4127, 24, 43, 34, 5, -43 },
  { 4256, 29, 44, 35, 3, -43 },
  { 4416, 19, 43, 27, 5, -43 },
  { 4519, 29, 53, 35, 3, -43 },
  { 4712, 21, 43, 27, 5, -43 },
  { 4825, 20, 44, 26, 3, -43 },
  { 4935, 23, 43, 23, 0, -43 },
  { 5059, 24, 44, 33, 5, -43 },
  { 5191, 26, 43, 26, 0, -43 },
  { 5331, 41, 43, 43, 1, -43 },
  { 5552, 23, 43, 23, 0, -43 },
  { 5676, 22, 43, 22, 0, -43 },
  { 5795, 20, 43, 24, 2, -43 },
  { 5903, 12, 52, 18, 5, -43 },
  { 5981, 18, 43, 20, 1, -43 },
  { 6078, 11, 52, 18, 2, -43 },
  { 6150, 23, 22, 27, 2, -43 },
  { 6214, 24, 2, 24, 0, 5 },
  { 6220, 10, 10, 14, 2, -46 },
  { 6233, 18, 33, 25, 2, -32 },
  { 6308, 20, 47, 28, 5, -46 },
  { 6426, 17, 33, 22, 3, -32 },
  { 6497, 21, 47, 28, 3, -46 },
  { 6621, 20, 33, 26, 3, -32 },
  { 6704, 15, 46, 14, 1, -46 },
  { 6791, 21, 46, 28, 3, -32 },
  { 6912, 18, 46, 27, 5, -46 },
  { 7016, 3, 43, 11, 4, -43 },
  { 7033, 8, 57, 11, -1, -43 },
  { 7090, 17, 46, 22, 5, -46 },
  { 7188, 1, 46, 11, 5, -46 },
  { 7194, 31, 32, 41, 5, -32 },
  { 7318, 18, 32, 27, 5, -32 },
  { 7390, 21, 33, 27, 3, -32 },
  { 7477, 20, 46, 28, 5, -32 },
  { 7592, 21, 46, 28, 3, -32 },
  { 7713, 12, 32, 18, 5, -32 },
  { 7761, 17, 33, 21, 2, -32 },
  { 7832, 12, 40, 15, 1, -39 },
  { 7892, 19, 33, 27, 4, -32 },
  { 7971, 20, 32, 20, 0, -32 },
  { 8051, 32, 32, 34, 1, -32 },
  { 8179, 20, 32, 22, 1, -32 },
  { 8259, 21, 47, 21, 0, -32 },
  { 8383, 15, 32, 19, 2, -32 },
  { 8443, 15, 52, 21, 3, -43 },
  { 8541, 2, 61, 26, 12, -46 },
  { 8557, 15, 52, 21, 3, -43 },
  { 8655, 23, 5, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Thin60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_THIN60PT7B_H_
