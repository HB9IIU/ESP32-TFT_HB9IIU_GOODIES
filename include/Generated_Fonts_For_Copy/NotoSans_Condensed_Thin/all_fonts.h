#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_Thin
// Headers: 67

#include "NotoSans_Condensed_Thin6pt7b.h"
#include "NotoSans_Condensed_Thin7pt7b.h"
#include "NotoSans_Condensed_Thin8pt7b.h"
#include "NotoSans_Condensed_Thin9pt7b.h"
#include "NotoSans_Condensed_Thin10pt7b.h"
#include "NotoSans_Condensed_Thin11pt7b.h"
#include "NotoSans_Condensed_Thin12pt7b.h"
#include "NotoSans_Condensed_Thin13pt7b.h"
#include "NotoSans_Condensed_Thin14pt7b.h"
#include "NotoSans_Condensed_Thin15pt7b.h"
#include "NotoSans_Condensed_Thin16pt7b.h"
#include "NotoSans_Condensed_Thin17pt7b.h"
#include "NotoSans_Condensed_Thin18pt7b.h"
#include "NotoSans_Condensed_Thin19pt7b.h"
#include "NotoSans_Condensed_Thin20pt7b.h"
#include "NotoSans_Condensed_Thin21pt7b.h"
#include "NotoSans_Condensed_Thin22pt7b.h"
#include "NotoSans_Condensed_Thin23pt7b.h"
#include "NotoSans_Condensed_Thin24pt7b.h"
#include "NotoSans_Condensed_Thin25pt7b.h"
#include "NotoSans_Condensed_Thin26pt7b.h"
#include "NotoSans_Condensed_Thin27pt7b.h"
#include "NotoSans_Condensed_Thin28pt7b.h"
#include "NotoSans_Condensed_Thin29pt7b.h"
#include "NotoSans_Condensed_Thin30pt7b.h"
#include "NotoSans_Condensed_Thin31pt7b.h"
#include "NotoSans_Condensed_Thin32pt7b.h"
#include "NotoSans_Condensed_Thin33pt7b.h"
#include "NotoSans_Condensed_Thin34pt7b.h"
#include "NotoSans_Condensed_Thin35pt7b.h"
#include "NotoSans_Condensed_Thin36pt7b.h"
#include "NotoSans_Condensed_Thin37pt7b.h"
#include "NotoSans_Condensed_Thin38pt7b.h"
#include "NotoSans_Condensed_Thin39pt7b.h"
#include "NotoSans_Condensed_Thin40pt7b.h"
#include "NotoSans_Condensed_Thin41pt7b.h"
#include "NotoSans_Condensed_Thin42pt7b.h"
#include "NotoSans_Condensed_Thin43pt7b.h"
#include "NotoSans_Condensed_Thin44pt7b.h"
#include "NotoSans_Condensed_Thin45pt7b.h"
#include "NotoSans_Condensed_Thin46pt7b.h"
#include "NotoSans_Condensed_Thin47pt7b.h"
#include "NotoSans_Condensed_Thin48pt7b.h"
#include "NotoSans_Condensed_Thin49pt7b.h"
#include "NotoSans_Condensed_Thin50pt7b.h"
#include "NotoSans_Condensed_Thin51pt7b.h"
#include "NotoSans_Condensed_Thin52pt7b.h"
#include "NotoSans_Condensed_Thin53pt7b.h"
#include "NotoSans_Condensed_Thin54pt7b.h"
#include "NotoSans_Condensed_Thin55pt7b.h"
#include "NotoSans_Condensed_Thin56pt7b.h"
#include "NotoSans_Condensed_Thin57pt7b.h"
#include "NotoSans_Condensed_Thin58pt7b.h"
#include "NotoSans_Condensed_Thin59pt7b.h"
#include "NotoSans_Condensed_Thin60pt7b.h"
#include "NotoSans_Condensed_Thin61pt7b.h"
#include "NotoSans_Condensed_Thin62pt7b.h"
#include "NotoSans_Condensed_Thin63pt7b.h"
#include "NotoSans_Condensed_Thin64pt7b.h"
#include "NotoSans_Condensed_Thin65pt7b.h"
#include "NotoSans_Condensed_Thin66pt7b.h"
#include "NotoSans_Condensed_Thin67pt7b.h"
#include "NotoSans_Condensed_Thin68pt7b.h"
#include "NotoSans_Condensed_Thin69pt7b.h"
#include "NotoSans_Condensed_Thin70pt7b.h"
#include "NotoSans_Condensed_Thin71pt7b.h"
#include "NotoSans_Condensed_Thin72pt7b.h"
