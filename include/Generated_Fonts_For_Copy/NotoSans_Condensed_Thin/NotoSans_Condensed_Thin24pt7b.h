#ifndef _NOTOSANS_CONDENSED_THIN24PT7B_H_
#define _NOTOSANS_CONDENSED_THIN24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x80, 0x99, 0x99, 0x99, 0x08, 0x41, 0x10, 0x22, 0x04,
  0x40, 0x88, 0xFF, 0xC4, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x7F, 0xF1,
  0x10, 0x22, 0x08, 0x41, 0x10, 0x22, 0x00, 0x08, 0x3E, 0x49, 0x88, 0x88,
  0x88, 0x88, 0x48, 0x28, 0x1C, 0x0A, 0x09, 0x09, 0x09, 0x09, 0x09, 0xCA,
  0x3C, 0x08, 0x78, 0x44, 0x42, 0x22, 0x11, 0x09, 0x08, 0x48, 0x42, 0x82,
  0x14, 0x91, 0x2A, 0x8A, 0x8A, 0xD4, 0x49, 0x22, 0x09, 0x10, 0x48, 0x84,
  0x44, 0x22, 0x22, 0x11, 0x10, 0x70, 0x3C, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x09, 0x02, 0x40, 0x60, 0x28, 0x12, 0x08, 0x46, 0x09, 0x82, 0xA0, 0x68,
  0x1A, 0x0A, 0x7C, 0x40, 0xFC, 0x12, 0x24, 0x44, 0x88, 0x88, 0x88, 0x88,
  0x84, 0x44, 0x21, 0x10, 0x84, 0x42, 0x21, 0x11, 0x11, 0x11, 0x11, 0x12,
  0x22, 0x44, 0x80, 0x10, 0x23, 0x49, 0xE1, 0x84, 0x91, 0x00, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x56,
  0xA0, 0xF8, 0x80, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x10, 0x20, 0xC0, 0x3E, 0x42, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x42, 0x3C, 0x13,
  0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0xFE, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0xFF, 0x7E, 0x81, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x3C, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0xFE, 0x01, 0x00, 0xC0, 0x30, 0x14, 0x05,
  0x02, 0x41, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x04, 0xFF, 0xC0, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFC, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0xFC, 0x00,
  0x1F, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x71, 0x44, 0xC1, 0x40, 0xA0,
  0x30, 0x18, 0x0C, 0x05, 0x04, 0x82, 0x3E, 0x00, 0xFF, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x3E, 0x20, 0xA0, 0x50, 0x28, 0x12, 0x08, 0x88, 0x38, 0x34, 0x21,
  0x10, 0x50, 0x18, 0x0C, 0x06, 0x04, 0x82, 0x3E, 0x00, 0x3C, 0x42, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x67, 0x19, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x7C, 0xC0, 0x08, 0x50, 0x00, 0x05, 0x6A, 0x00, 0x81, 0x83, 0x06,
  0x04, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x20, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x08, 0x18,
  0x30, 0x20, 0x20, 0x00, 0xF8, 0x20, 0x41, 0x04, 0x10, 0x84, 0x20, 0x84,
  0x10, 0x40, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x40, 0x42, 0x00, 0x88, 0x02,
  0x40, 0x05, 0x0F, 0x18, 0x44, 0x62, 0x11, 0x88, 0x46, 0x21, 0x18, 0x84,
  0x62, 0x11, 0x88, 0xC6, 0x16, 0xA4, 0x21, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xFC, 0x00, 0x04, 0x03, 0x00, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x10,
  0x44, 0x21, 0x08, 0x23, 0xF9, 0x02, 0x40, 0x90, 0x14, 0x06, 0x01, 0x80,
  0x40, 0xFE, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0xEC, 0x8E, 0x40,
  0xA0, 0x50, 0x18, 0x0C, 0x06, 0x05, 0x02, 0xFE, 0x00, 0x1F, 0xC8, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0xC0, 0x0F, 0xC0, 0xFC, 0x20, 0xC8, 0x12, 0x02,
  0x80, 0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0,
  0x28, 0x12, 0x08, 0xFC, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x0F,
  0xE2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x81, 0xD0,
  0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x48, 0x08, 0x81, 0x0F, 0xE0, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xF4, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0xE0, 0x81, 0x82, 0x84, 0x84, 0x88, 0x90, 0x90, 0xA0, 0xD0,
  0x90, 0x88, 0x88, 0x84, 0x82, 0x82, 0x81, 0x81, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x80,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3A, 0x02, 0xD0, 0x16, 0x80, 0xB2, 0x09,
  0x90, 0x4C, 0x82, 0x62, 0x23, 0x11, 0x18, 0x88, 0xC2, 0x86, 0x14, 0x30,
  0xA1, 0x82, 0x08, 0x80, 0xE0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11,
  0x88, 0xC2, 0x61, 0x30, 0x58, 0x2C, 0x0E, 0x07, 0x01, 0x80, 0x80, 0x1F,
  0x82, 0x04, 0x40, 0x24, 0x02, 0x40, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x1F,
  0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02,
  0x40, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x88,
  0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x81, 0x3F, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFC,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x81, 0x3F, 0x00, 0x80, 0x60, 0x14, 0x05, 0x02, 0x40, 0x90, 0x22,
  0x08, 0x84, 0x21, 0x08, 0x41, 0x20, 0x48, 0x12, 0x02, 0x80, 0xC0, 0x30,
  0x04, 0x00, 0x80, 0x80, 0xA0, 0x40, 0x50, 0x50, 0x48, 0x28, 0x24, 0x14,
  0x12, 0x0A, 0x08, 0x85, 0x08, 0x44, 0x44, 0x22, 0x22, 0x11, 0x11, 0x04,
  0x89, 0x02, 0x82, 0x81, 0x41, 0x40, 0xA0, 0xA0, 0x30, 0x50, 0x10, 0x30,
  0x08, 0x08, 0x00, 0x40, 0xA0, 0x88, 0x44, 0x41, 0x20, 0x90, 0x30, 0x10,
  0x08, 0x06, 0x05, 0x02, 0x42, 0x21, 0x09, 0x04, 0x81, 0x80, 0x80, 0x80,
  0xC0, 0x90, 0x48, 0x22, 0x21, 0x10, 0x90, 0x28, 0x14, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0xFF, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0xFF,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x0F, 0x80, 0xC0, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x80, 0x81, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x08, 0x0A, 0x05, 0x04, 0x42, 0x22, 0x09, 0x05,
  0x01, 0x80, 0x80, 0xFF, 0x80, 0x84, 0x30, 0x7C, 0x04, 0x08, 0x10, 0x20,
  0x4F, 0xA1, 0x83, 0x06, 0x0C, 0x37, 0xA0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2,
  0xBC, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x03,
  0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xE5, 0x8A, 0x83, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83, 0x41, 0x9F, 0x40, 0x1C, 0x62,
  0x41, 0x81, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x1C,
  0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x41, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x82, 0x7C, 0x81, 0x02, 0x04, 0x08,
  0x17, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04,
  0x8F, 0xFF, 0x80, 0x20, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0xB0,
  0x81, 0x02, 0x04, 0x08, 0x10, 0xA1, 0x44, 0x91, 0x42, 0x86, 0x89, 0x11,
  0x22, 0x42, 0x85, 0x04, 0xFF, 0xFF, 0xC0, 0xB8, 0xE6, 0x28, 0xA0, 0x83,
  0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60,
  0x83, 0x04, 0x18, 0x20, 0x80, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0x3C, 0x21, 0x90, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x50, 0x48, 0x23, 0xE0, 0x9C, 0xC2, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1D, 0x63, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBE, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x00, 0x7D, 0x02, 0x04, 0x08, 0x08,
  0x0C, 0x06, 0x04, 0x04, 0x08, 0x2F, 0xC0, 0x21, 0x09, 0xF2, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x87, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x37, 0xA0, 0x81, 0x81, 0x42, 0x42, 0x42, 0x42, 0x24,
  0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x82, 0x0C, 0x10, 0x50, 0xC2, 0x86,
  0x14, 0x51, 0x22, 0x48, 0x92, 0x44, 0x92, 0x28, 0x91, 0x43, 0x06, 0x18,
  0x20, 0xC1, 0x04, 0x00, 0x41, 0x41, 0x22, 0x22, 0x14, 0x18, 0x08, 0x18,
  0x14, 0x22, 0x22, 0x41, 0xC1, 0x81, 0x41, 0x41, 0x41, 0x42, 0x22, 0x22,
  0x24, 0x14, 0x14, 0x18, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0,
  0xFC, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0xFC, 0x0C, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x04, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x40, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0xC0, 0x60, 0x4C, 0x41,
  0xC0,
};

const GFXglyph NotoSans_Condensed_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 4, 6, 7, 2, -17 },
  { 7, 11, 17, 12, 0, -17 },
  { 31, 8, 19, 11, 1, -18 },
  { 50, 13, 17, 15, 1, -17 },
  { 78, 10, 17, 12, 1, -17 },
  { 100, 1, 6, 4, 1, -17 },
  { 101, 4, 21, 6, 1, -17 },
  { 112, 4, 21, 6, 1, -17 },
  { 123, 7, 7, 10, 1, -18 },
  { 130, 9, 11, 11, 1, -14 },
  { 143, 2, 6, 4, 1, -3 },
  { 145, 5, 1, 7, 1, -7 },
  { 146, 1, 1, 5, 2, -1 },
  { 147, 7, 17, 8, 0, -17 },
  { 162, 8, 17, 11, 1, -17 },
  { 179, 4, 17, 11, 2, -17 },
  { 188, 8, 17, 11, 1, -17 },
  { 205, 8, 17, 11, 1, -17 },
  { 222, 10, 17, 11, 0, -17 },
  { 244, 9, 17, 11, 1, -17 },
  { 264, 9, 17, 11, 1, -17 },
  { 284, 8, 17, 11, 1, -17 },
  { 301, 9, 17, 11, 1, -17 },
  { 321, 8, 17, 11, 1, -17 },
  { 338, 1, 13, 5, 2, -13 },
  { 340, 2, 16, 5, 1, -13 },
  { 344, 9, 11, 11, 1, -14 },
  { 357, 9, 5, 11, 1, -11 },
  { 363, 9, 11, 11, 1, -14 },
  { 376, 6, 17, 7, 1, -17 },
  { 389, 14, 19, 16, 1, -17 },
  { 423, 10, 17, 10, 0, -17 },
  { 445, 9, 17, 12, 2, -17 },
  { 465, 10, 17, 11, 1, -17 },
  { 487, 10, 17, 13, 2, -17 },
  { 509, 7, 17, 10, 2, -17 },
  { 524, 7, 17, 9, 2, -17 },
  { 539, 11, 17, 14, 1, -17 },
  { 563, 9, 17, 13, 2, -17 },
  { 583, 4, 17, 6, 1, -17 },
  { 592, 4, 21, 5, -1, -17 },
  { 603, 8, 17, 10, 2, -17 },
  { 620, 7, 17, 9, 2, -17 },
  { 635, 13, 17, 17, 2, -17 },
  { 663, 9, 17, 13, 2, -17 },
  { 683, 12, 17, 14, 1, -17 },
  { 709, 8, 17, 11, 2, -17 },
  { 726, 12, 21, 14, 1, -17 },
  { 758, 8, 17, 11, 2, -17 },
  { 775, 8, 17, 10, 1, -17 },
  { 792, 9, 17, 9, 0, -17 },
  { 812, 9, 17, 13, 2, -17 },
  { 832, 10, 17, 10, 0, -17 },
  { 854, 17, 17, 17, 0, -17 },
  { 891, 9, 17, 9, 0, -17 },
  { 911, 9, 17, 9, 0, -17 },
  { 931, 8, 17, 10, 1, -17 },
  { 948, 5, 21, 7, 2, -17 },
  { 962, 7, 17, 8, 0, -17 },
  { 977, 4, 21, 7, 1, -17 },
  { 988, 9, 9, 11, 1, -17 },
  { 999, 9, 1, 9, 0, 2 },
  { 1001, 4, 3, 6, 1, -18 },
  { 1003, 7, 13, 10, 1, -13 },
  { 1015, 8, 18, 11, 2, -18 },
  { 1033, 7, 13, 9, 1, -13 },
  { 1045, 9, 18, 11, 1, -18 },
  { 1066, 8, 13, 10, 1, -13 },
  { 1079, 6, 18, 6, 0, -18 },
  { 1093, 8, 19, 11, 1, -13 },
  { 1112, 7, 18, 11, 2, -18 },
  { 1128, 1, 17, 4, 2, -17 },
  { 1131, 3, 23, 4, 0, -17 },
  { 1140, 7, 18, 9, 2, -18 },
  { 1156, 1, 18, 4, 2, -18 },
  { 1159, 13, 13, 16, 2, -13 },
  { 1181, 7, 13, 11, 2, -13 },
  { 1193, 9, 13, 11, 1, -13 },
  { 1208, 8, 19, 11, 2, -13 },
  { 1227, 8, 19, 11, 1, -13 },
  { 1246, 5, 13, 7, 2, -13 },
  { 1255, 7, 13, 9, 1, -13 },
  { 1267, 5, 16, 6, 0, -16 },
  { 1277, 7, 13, 11, 2, -13 },
  { 1289, 8, 13, 8, 0, -13 },
  { 1302, 13, 13, 14, 0, -13 },
  { 1324, 8, 13, 9, 0, -13 },
  { 1337, 8, 19, 8, 0, -13 },
  { 1356, 6, 13, 8, 1, -13 },
  { 1366, 6, 21, 8, 1, -17 },
  { 1382, 1, 24, 10, 5, -18 },
  { 1385, 6, 21, 8, 1, -17 },
  { 1401, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Thin24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_THIN24PT7B_H_
