#ifndef _NOTOSANS_CONDENSED_THIN47PT7B_H_
#define _NOTOSANS_CONDENSED_THIN47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEA, 0xAA, 0xAA, 0xAA, 0xA0, 0x03, 0xF0, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00,
  0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x18, 0x08,
  0x00, 0xC0, 0x40, 0x04, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x40, 0xFF, 0xFF, 0xF0, 0x30, 0x10, 0x01, 0x00, 0x80,
  0x08, 0x0C, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80,
  0x80, 0x0C, 0x04, 0x00, 0x40, 0x20, 0x02, 0x03, 0x03, 0xFF, 0xFF, 0xC0,
  0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08,
  0x00, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0xFF, 0x01, 0x98, 0xE1, 0x0C, 0x11, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80,
  0x40, 0xC0, 0x20, 0x60, 0x10, 0x30, 0x08, 0x18, 0x06, 0x0C, 0x01, 0x06,
  0x00, 0x43, 0x00, 0x39, 0x80, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x1B, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x03, 0x06, 0x01, 0x81, 0x00, 0xC0,
  0x80, 0x60, 0x60, 0x30, 0x30, 0x18, 0x10, 0x0C, 0x08, 0x06, 0x04, 0x03,
  0x04, 0x81, 0x86, 0x78, 0xCC, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x10, 0x0C, 0x60, 0x04, 0x02, 0x08,
  0x02, 0x01, 0x83, 0x00, 0x80, 0x40, 0x40, 0x60, 0x10, 0x10, 0x10, 0x04,
  0x04, 0x04, 0x03, 0x01, 0x02, 0x00, 0xC0, 0x40, 0x80, 0x30, 0x18, 0x60,
  0x0C, 0x06, 0x10, 0x03, 0x01, 0x84, 0x00, 0xC0, 0x42, 0x00, 0x30, 0x10,
  0x83, 0x04, 0x04, 0x63, 0x61, 0x01, 0x11, 0x04, 0x40, 0x44, 0x41, 0x98,
  0x33, 0x20, 0x22, 0x08, 0x88, 0x08, 0xC6, 0x62, 0x02, 0x1E, 0x10, 0x80,
  0x80, 0x04, 0x20, 0x30, 0x03, 0x18, 0x0C, 0x00, 0x86, 0x03, 0x00, 0x61,
  0x80, 0xC0, 0x10, 0x60, 0x30, 0x04, 0x08, 0x0C, 0x03, 0x02, 0x03, 0x00,
  0x80, 0x80, 0x80, 0x20, 0x20, 0x20, 0x10, 0x0C, 0x08, 0x04, 0x01, 0x06,
  0x03, 0x00, 0x61, 0x00, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xC3, 0x00,
  0x08, 0x10, 0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x08,
  0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x18, 0x18, 0x00, 0x81,
  0x00, 0x0C, 0x30, 0x00, 0x46, 0x00, 0x02, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xD8, 0x00, 0x10, 0xC0, 0x02, 0x04, 0x02, 0x60, 0x20, 0x24,
  0x03, 0x02, 0xC0, 0x10, 0x28, 0x00, 0x84, 0x80, 0x0C, 0x48, 0x00, 0x44,
  0x80, 0x02, 0x88, 0x00, 0x38, 0x80, 0x01, 0x0C, 0x00, 0x38, 0x40, 0x06,
  0xC6, 0x00, 0xC4, 0x30, 0x18, 0x20, 0xFE, 0x03, 0xFF, 0xFF, 0xEA, 0x80,
  0x01, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x04, 0x02, 0x03, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08,
  0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0x04, 0x13, 0x93, 0x81, 0xF0,
  0x01, 0x00, 0x0A, 0x00, 0x44, 0x02, 0x08, 0x18, 0x30, 0xC0, 0x60, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xE0, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x33, 0x22, 0x26, 0x44,
  0x48, 0x80, 0xFF, 0xE0, 0x5F, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x1C, 0x02, 0x03,
  0x02, 0x00, 0x83, 0x00, 0x61, 0x00, 0x10, 0x80, 0x08, 0xC0, 0x06, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0B,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20,
  0x00, 0x98, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x21, 0x80, 0x10, 0x40, 0x10,
  0x30, 0x18, 0x0C, 0x18, 0x03, 0xF8, 0x00, 0x01, 0x03, 0x07, 0x0D, 0x31,
  0x61, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0xE0, 0x38, 0x38, 0x60, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0x0F, 0xE0, 0x38, 0x38, 0x60, 0x0C, 0x80, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0xC0, 0x18, 0x7F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x16, 0x00, 0x03, 0x60,
  0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0x86,
  0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x40,
  0x60, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x10, 0x06, 0x01, 0x00, 0x60, 0x20,
  0x06, 0x06, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x7F, 0xFC,
  0x7F, 0xFC, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xDF, 0xC0, 0xF0, 0x70, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0xC0, 0x30, 0x7F, 0xC0, 0x01, 0xF8, 0x07, 0x04, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x81, 0x80, 0x8F, 0xF0,
  0x98, 0x18, 0xA0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x04, 0x20, 0x0C, 0x18, 0x18,
  0x0F, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x03, 0xF0, 0x07, 0x1C, 0x04, 0x01, 0x04, 0x00, 0x46, 0x00, 0x22, 0x00,
  0x19, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x30, 0x01, 0x98, 0x00, 0xC4,
  0x00, 0x41, 0x00, 0x40, 0x40, 0x40, 0x18, 0xC0, 0x06, 0xC0, 0x01, 0xC0,
  0x03, 0x18, 0x03, 0x06, 0x02, 0x00, 0x82, 0x00, 0x23, 0x00, 0x19, 0x00,
  0x05, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x12, 0x00, 0x09, 0x80, 0x0C, 0x60, 0x0C, 0x18, 0x0C, 0x07, 0xFC,
  0x00, 0x07, 0xE0, 0x1C, 0x30, 0x30, 0x08, 0x20, 0x04, 0x60, 0x06, 0x40,
  0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60,
  0x05, 0x30, 0x0D, 0x18, 0x39, 0x07, 0xE1, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x3F, 0xC0, 0x0C, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0xE0, 0x37, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x22, 0x66, 0x44, 0xC8,
  0x80, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x00, 0x3F, 0x0E, 0x1C, 0x80, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x18, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x06, 0x20, 0x07, 0xE0, 0x22, 0x01, 0xC2, 0x02,
  0x60, 0x30, 0x20, 0x24, 0x02, 0x02, 0x03, 0x40, 0x60, 0x20, 0x34, 0x04,
  0x02, 0x03, 0x40, 0xC0, 0x20, 0x14, 0x0C, 0x02, 0x01, 0x40, 0x80, 0x20,
  0x1C, 0x08, 0x02, 0x01, 0xC0, 0x80, 0x20, 0x3C, 0x08, 0x02, 0x03, 0x40,
  0x80, 0x60, 0x24, 0x0C, 0x06, 0x02, 0x40, 0x40, 0x60, 0x24, 0x04, 0x0A,
  0x06, 0x40, 0x60, 0x90, 0xC6, 0x03, 0xB1, 0xD8, 0x20, 0x0E, 0x07, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x4C, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00,
  0x06, 0x08, 0x00, 0x20, 0x60, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0xC0,
  0x40, 0x04, 0x03, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x03, 0x00,
  0xFF, 0xF8, 0x04, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00, 0x18, 0x10, 0x00,
  0x41, 0x80, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0xC2, 0x00, 0x02, 0x30,
  0x00, 0x11, 0x00, 0x00, 0xC8, 0x00, 0x02, 0xC0, 0x00, 0x14, 0x00, 0x00,
  0xC0, 0xFF, 0x00, 0x7F, 0xFC, 0x20, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x24,
  0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0xD0, 0x00, 0x68, 0x00, 0x24, 0x00, 0x32, 0x00, 0x31, 0x00, 0xF0, 0xFF,
  0xE0, 0x40, 0x0E, 0x20, 0x01, 0x90, 0x00, 0x48, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x18, 0x80, 0x38, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0xE0, 0x70, 0x60, 0x04, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x40, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xFE, 0x02,
  0x00, 0x70, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x02, 0x20, 0x00, 0x64,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x1A, 0x00, 0x01, 0x40, 0x00, 0x28,
  0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02, 0x40,
  0x00, 0xC8, 0x00, 0x11, 0x00, 0x06, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80,
  0x70, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFA, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xEF,
  0xFF, 0xA0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x07, 0x81, 0xC0, 0x06,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x58, 0x00, 0x02, 0x40, 0x00, 0x13, 0x00, 0x00, 0x88, 0x00, 0x04, 0x20,
  0x00, 0x21, 0xC0, 0x01, 0x03, 0x00, 0x18, 0x07, 0xFF, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0xFE, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x86, 0x7E, 0x00, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0x80,
  0x60, 0x80, 0x40, 0x80, 0x80, 0x81, 0x80, 0x83, 0x00, 0x82, 0x00, 0x86,
  0x00, 0x8C, 0x00, 0x9C, 0x00, 0x94, 0x00, 0xB2, 0x00, 0xE3, 0x00, 0xC1,
  0x00, 0x81, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x20, 0x80,
  0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xFF,
  0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x74, 0x00,
  0x00, 0x7A, 0x00, 0x00, 0x2D, 0x80, 0x00, 0x16, 0x40, 0x00, 0x1B, 0x20,
  0x00, 0x09, 0x98, 0x00, 0x04, 0xC4, 0x00, 0x06, 0x62, 0x00, 0x02, 0x31,
  0x80, 0x01, 0x18, 0x40, 0x01, 0x8C, 0x20, 0x00, 0x86, 0x18, 0x00, 0x43,
  0x04, 0x00, 0x61, 0x82, 0x00, 0x20, 0xC1, 0x80, 0x10, 0x60, 0x40, 0x18,
  0x30, 0x20, 0x08, 0x18, 0x18, 0x04, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x02,
  0x03, 0x01, 0x81, 0x01, 0x80, 0x41, 0x80, 0xC0, 0x20, 0x80, 0x60, 0x18,
  0x40, 0x30, 0x04, 0x60, 0x18, 0x02, 0x20, 0x0C, 0x01, 0x90, 0x06, 0x00,
  0x58, 0x03, 0x00, 0x28, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x40,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x64,
  0x00, 0x19, 0x00, 0x06, 0x20, 0x01, 0x88, 0x00, 0x61, 0x00, 0x18, 0x40,
  0x06, 0x08, 0x01, 0x83, 0x00, 0x60, 0x40, 0x18, 0x18, 0x06, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x10, 0x18, 0x06, 0x06, 0x00, 0x81, 0x80, 0x30, 0x60,
  0x04, 0x18, 0x01, 0x86, 0x00, 0x21, 0x80, 0x0C, 0x60, 0x01, 0x18, 0x00,
  0x66, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0x58, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x1E, 0x1C, 0x00, 0xC0,
  0x08, 0x06, 0x00, 0x10, 0x30, 0x00, 0x20, 0x80, 0x00, 0xC6, 0x00, 0x01,
  0x10, 0x00, 0x04, 0x40, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x02, 0xC0,
  0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98, 0x00, 0x04, 0x20, 0x00,
  0x30, 0xC0, 0x00, 0x81, 0x00, 0x06, 0x03, 0x00, 0x30, 0x06, 0x01, 0x80,
  0x0F, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xC2, 0x00, 0xE4, 0x00, 0x68, 0x00,
  0x50, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00,
  0x73, 0xFF, 0x87, 0xF8, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1E, 0x1C,
  0x00, 0xC0, 0x08, 0x06, 0x00, 0x10, 0x30, 0x00, 0x20, 0x80, 0x00, 0xC6,
  0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00,
  0x02, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98, 0x00, 0x04,
  0x20, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x00, 0x06, 0x02, 0x00, 0x30, 0x06,
  0x01, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x80, 0x38, 0x80, 0x0C, 0x80,
  0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x18, 0x80, 0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x80,
  0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80,
  0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x03,
  0xF8, 0x0E, 0x0F, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0xC0, 0x18, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0xD0, 0x00, 0x26, 0x00, 0x18, 0xC0, 0x0C,
  0x18, 0x06, 0x03, 0xFF, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00,
  0x24, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x00, 0xC3, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x18,
  0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x0C, 0x03, 0x00,
  0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18,
  0x00, 0x19, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x02, 0x40, 0x02,
  0x80, 0x02, 0x40, 0x02, 0x80, 0x06, 0x40, 0x02, 0xC0, 0x06, 0x60, 0x02,
  0x40, 0x04, 0x60, 0x06, 0x40, 0x04, 0x20, 0x04, 0x40, 0x0C, 0x20, 0x04,
  0x60, 0x0C, 0x20, 0x04, 0x60, 0x08, 0x30, 0x0C, 0x20, 0x08, 0x10, 0x0C,
  0x20, 0x08, 0x10, 0x08, 0x20, 0x18, 0x10, 0x08, 0x30, 0x10, 0x18, 0x08,
  0x10, 0x10, 0x08, 0x18, 0x10, 0x10, 0x08, 0x10, 0x10, 0x30, 0x08, 0x10,
  0x18, 0x20, 0x0C, 0x10, 0x18, 0x20, 0x0C, 0x30, 0x08, 0x20, 0x04, 0x30,
  0x08, 0x60, 0x04, 0x20, 0x08, 0x60, 0x04, 0x20, 0x0C, 0x40, 0x06, 0x20,
  0x04, 0x40, 0x02, 0x60, 0x04, 0x40, 0x02, 0x40, 0x04, 0xC0, 0x02, 0x40,
  0x04, 0x80, 0x03, 0x40, 0x06, 0x80, 0x01, 0x40, 0x02, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0xC8, 0x00, 0x23, 0x00, 0x18, 0x40, 0x04, 0x18, 0x03, 0x02, 0x00, 0x80,
  0x80, 0x60, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x82, 0x00, 0x20, 0x80, 0x0C,
  0x40, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x10, 0x00, 0xC4, 0x00,
  0x21, 0x80, 0x18, 0x20, 0x04, 0x0C, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x08, 0x10, 0x02, 0x0C, 0x00, 0xC2, 0x00, 0x11, 0x80, 0x06, 0x40, 0x00,
  0xB0, 0x00, 0x30, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x22,
  0x00, 0x11, 0x00, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x04, 0x02,
  0x02, 0x03, 0x01, 0x81, 0x00, 0x41, 0x80, 0x20, 0x80, 0x08, 0x40, 0x04,
  0x60, 0x03, 0x20, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0x80, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x48, 0x00, 0x19, 0x00, 0x02, 0x30, 0x00,
  0x82, 0x00, 0x10, 0x60, 0x04, 0x04, 0x00, 0x80, 0xC0, 0x20, 0x08, 0x04,
  0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x08, 0x00, 0x23, 0x00, 0x06, 0x40,
  0x00, 0x58, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x0F, 0xE0, 0xC0, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x7F, 0x0E, 0x04, 0xC0, 0x16, 0x00, 0x50, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x54, 0x01, 0x58, 0x19, 0x1F, 0xC4,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x8F, 0xE0,
  0x98, 0x18, 0xB0, 0x0C, 0xA0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02,
  0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0xA0, 0x08, 0x98, 0x18, 0x8F, 0xE0,
  0x03, 0xFC, 0x18, 0x11, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0xFE, 0x30, 0xC1, 0x98,
  0xC0, 0x2C, 0xC0, 0x0E, 0x40, 0x07, 0x60, 0x01, 0xA0, 0x00, 0xD0, 0x00,
  0x68, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D,
  0x00, 0x06, 0xC0, 0x07, 0x20, 0x02, 0x98, 0x02, 0x46, 0x02, 0x20, 0xFE,
  0x10, 0x07, 0xF0, 0x0C, 0x18, 0x18, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x06, 0x07, 0xFC, 0x01, 0xF8, 0x18, 0x81, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x01, 0xFF, 0x80, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x07, 0xF0, 0x86, 0x04, 0x84, 0x01, 0x66, 0x00, 0x72, 0x00,
  0x3B, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x76, 0x00, 0x39, 0x00,
  0x1C, 0x40, 0x16, 0x30, 0x33, 0x07, 0xF1, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x20, 0x03, 0x1C, 0x07, 0x03, 0xFE, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x23, 0xF8, 0x98, 0x32, 0xC0, 0x6A, 0x00, 0xB0, 0x03, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x5F, 0x00,
  0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x0C,
  0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x30, 0x4F, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x28, 0x02,
  0x40, 0x32, 0x01, 0x10, 0x10, 0x81, 0x04, 0x18, 0x20, 0x81, 0x08, 0x08,
  0xC0, 0x46, 0x02, 0x50, 0x14, 0xC0, 0xE2, 0x06, 0x18, 0x20, 0x41, 0x03,
  0x08, 0x08, 0x40, 0x62, 0x01, 0x10, 0x0C, 0x80, 0x24, 0x01, 0xA0, 0x05,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x8F, 0xC0, 0xFC, 0x48, 0x31,
  0x83, 0x28, 0x0C, 0x80, 0xD8, 0x02, 0x80, 0x2C, 0x01, 0x40, 0x14, 0x00,
  0xC0, 0x0A, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x08, 0x01, 0xC0,
  0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0x00, 0x38, 0x00, 0x80, 0x1C,
  0x00, 0x40, 0x0E, 0x00, 0x20, 0x07, 0x00, 0x10, 0x03, 0x80, 0x08, 0x01,
  0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0x00, 0x38, 0x00, 0x80,
  0x1C, 0x00, 0x40, 0x0E, 0x00, 0x20, 0x07, 0x00, 0x10, 0x03, 0x80, 0x08,
  0x01, 0x80, 0x8F, 0xE2, 0x60, 0xCB, 0x01, 0xB8, 0x02, 0xC0, 0x0F, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x07, 0xF0,
  0x06, 0x0E, 0x06, 0x01, 0x86, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x03, 0x40, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00,
  0xD0, 0x00, 0x4C, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10, 0x40, 0x18, 0x18,
  0x18, 0x07, 0xF8, 0x00, 0x87, 0xE0, 0x98, 0x18, 0xB0, 0x0C, 0xA0, 0x04,
  0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xE0, 0x04,
  0xB0, 0x08, 0x98, 0x18, 0x8F, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x86, 0x0C, 0x86, 0x01, 0x66, 0x00,
  0x72, 0x00, 0x3B, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x76, 0x00,
  0x39, 0x00, 0x3C, 0x40, 0x16, 0x30, 0x33, 0x07, 0xF1, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x8F, 0xCC, 0x6C,
  0x14, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x00, 0x1F, 0xE1, 0x80, 0xD0, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x58, 0x0C, 0x7F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x0F, 0xFC, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0xF8, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1A, 0x00, 0x34,
  0x00, 0x68, 0x01, 0x58, 0x06, 0x98, 0x19, 0x1F, 0xE2, 0xC0, 0x03, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x20,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x10, 0x08,
  0x30, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0xE0, 0x05, 0x00, 0x58, 0x02, 0x80, 0x24,
  0x01, 0x40, 0x12, 0x00, 0xA0, 0x09, 0x00, 0xD8, 0x08, 0xC0, 0x44, 0x04,
  0x20, 0x22, 0x02, 0x10, 0x31, 0x01, 0x08, 0x18, 0xC1, 0x86, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x40, 0x86, 0x08, 0x20, 0x43, 0x06, 0x30, 0x31, 0x01,
  0x10, 0x08, 0x80, 0x88, 0x04, 0xC0, 0x44, 0x02, 0x40, 0x32, 0x01, 0x20,
  0x0A, 0x00, 0xD0, 0x05, 0x00, 0x28, 0x02, 0x80, 0x18, 0x01, 0x40, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x80, 0x08, 0x80, 0x31,
  0x00, 0x41, 0x01, 0x83, 0x02, 0x02, 0x08, 0x06, 0x10, 0x04, 0x40, 0x0D,
  0x80, 0x0A, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x50, 0x00, 0xB0, 0x02, 0x20,
  0x0C, 0x60, 0x10, 0x40, 0x60, 0xC0, 0x80, 0x83, 0x01, 0x84, 0x01, 0x18,
  0x03, 0x20, 0x02, 0xC0, 0x06, 0x40, 0x01, 0x40, 0x01, 0x60, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x06, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x18, 0x04, 0x10, 0x04, 0x10, 0x04,
  0x30, 0x06, 0x20, 0x02, 0x20, 0x02, 0x20, 0x03, 0x60, 0x01, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0xFF, 0xF0, 0x00, 0x10, 0x1F, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0xF0, 0x0F, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xF0, 0x0F, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0xF8, 0x00, 0x08,
  0x00, 0x3F, 0x80, 0x70, 0x30, 0x70, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 34, 10, 4, -34 },
  { 10, 8, 13, 14, 3, -34 },
  { 23, 21, 34, 23, 1, -34 },
  { 113, 17, 39, 21, 2, -36 },
  { 196, 26, 34, 30, 2, -34 },
  { 307, 20, 34, 23, 2, -34 },
  { 392, 2, 13, 8, 3, -34 },
  { 396, 8, 41, 12, 2, -34 },
  { 437, 8, 41, 12, 2, -34 },
  { 478, 14, 14, 19, 2, -36 },
  { 503, 17, 21, 21, 2, -27 },
  { 548, 4, 11, 8, 2, -5 },
  { 554, 11, 1, 13, 1, -13 },
  { 556, 3, 3, 9, 3, -3 },
  { 558, 14, 34, 15, 1, -34 },
  { 618, 17, 34, 21, 2, -34 },
  { 691, 8, 34, 21, 4, -34 },
  { 725, 16, 34, 21, 2, -34 },
  { 793, 16, 34, 21, 2, -34 },
  { 861, 20, 34, 21, 1, -34 },
  { 946, 16, 34, 21, 3, -34 },
  { 1014, 16, 35, 21, 3, -34 },
  { 1084, 16, 34, 21, 2, -34 },
  { 1152, 17, 34, 21, 2, -34 },
  { 1225, 16, 35, 21, 2, -34 },
  { 1295, 3, 25, 9, 3, -25 },
  { 1305, 4, 31, 9, 2, -25 },
  { 1321, 17, 20, 21, 2, -27 },
  { 1364, 17, 11, 21, 2, -22 },
  { 1388, 17, 20, 21, 2, -27 },
  { 1431, 12, 34, 14, 1, -34 },
  { 1482, 28, 38, 32, 2, -34 },
  { 1615, 21, 34, 21, 0, -34 },
  { 1705, 17, 34, 23, 4, -34 },
  { 1778, 18, 34, 22, 3, -34 },
  { 1855, 19, 34, 25, 4, -34 },
  { 1936, 14, 34, 20, 4, -34 },
  { 1996, 14, 34, 19, 4, -34 },
  { 2056, 21, 34, 27, 3, -34 },
  { 2146, 18, 34, 26, 4, -34 },
  { 2223, 7, 34, 11, 2, -34 },
  { 2253, 9, 42, 9, -3, -34 },
  { 2301, 16, 34, 20, 4, -34 },
  { 2369, 13, 34, 18, 4, -34 },
  { 2425, 25, 34, 33, 4, -34 },
  { 2532, 18, 34, 26, 4, -34 },
  { 2609, 22, 34, 27, 3, -34 },
  { 2703, 15, 34, 21, 4, -34 },
  { 2767, 22, 42, 27, 3, -34 },
  { 2883, 16, 34, 21, 4, -34 },
  { 2951, 16, 34, 20, 2, -34 },
  { 3019, 18, 34, 18, 0, -34 },
  { 3096, 18, 34, 26, 4, -34 },
  { 3173, 20, 34, 20, 0, -34 },
  { 3258, 32, 34, 34, 1, -34 },
  { 3394, 18, 34, 18, 0, -34 },
  { 3471, 17, 34, 17, 0, -34 },
  { 3544, 17, 34, 19, 1, -34 },
  { 3617, 9, 41, 14, 4, -34 },
  { 3664, 14, 34, 15, 1, -34 },
  { 3724, 8, 41, 14, 2, -34 },
  { 3765, 19, 18, 21, 1, -34 },
  { 3808, 19, 2, 18, 0, 4 },
  { 3813, 7, 8, 11, 2, -36 },
  { 3820, 14, 25, 19, 2, -25 },
  { 3864, 16, 36, 22, 4, -36 },
  { 3936, 14, 25, 17, 2, -25 },
  { 3980, 17, 36, 22, 2, -36 },
  { 4057, 16, 25, 20, 2, -25 },
  { 4107, 13, 36, 11, 0, -36 },
  { 4166, 17, 36, 22, 2, -25 },
  { 4243, 14, 36, 21, 4, -36 },
  { 4306, 3, 34, 9, 3, -34 },
  { 4319, 7, 45, 9, -1, -34 },
  { 4359, 13, 36, 17, 4, -36 },
  { 4418, 1, 36, 8, 4, -36 },
  { 4423, 25, 25, 32, 4, -25 },
  { 4502, 14, 25, 21, 4, -25 },
  { 4546, 17, 25, 21, 2, -25 },
  { 4600, 16, 36, 22, 4, -25 },
  { 4672, 17, 36, 22, 2, -25 },
  { 4749, 9, 25, 14, 4, -25 },
  { 4778, 13, 25, 17, 2, -25 },
  { 4819, 10, 31, 11, 1, -31 },
  { 4858, 15, 25, 21, 3, -25 },
  { 4905, 16, 25, 16, 0, -25 },
  { 4955, 25, 25, 27, 1, -25 },
  { 5034, 15, 25, 17, 1, -25 },
  { 5081, 16, 36, 16, 0, -25 },
  { 5153, 12, 25, 15, 2, -25 },
  { 5191, 12, 41, 16, 2, -34 },
  { 5253, 2, 48, 20, 9, -36 },
  { 5265, 12, 41, 16, 2, -34 },
  { 5327, 17, 4, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_Thin47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_THIN47PT7B_H_
