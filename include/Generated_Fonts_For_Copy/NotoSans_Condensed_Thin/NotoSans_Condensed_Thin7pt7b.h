#ifndef _NOTOSANS_CONDENSED_THIN7PT7B_H_
#define _NOTOSANS_CONDENSED_THIN7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x7D, 0x5A, 0x79, 0x3C, 0xDE, 0xF7, 0x70, 0xF5, 0x5E,
  0xC0, 0x6A, 0x90, 0xFC, 0xF0, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x56, 0x80,
  0xF6, 0xDE, 0xF8, 0xE4, 0xAE, 0xE5, 0x1E, 0x4A, 0xF2, 0xF1, 0x9E, 0x73,
  0xDE, 0xE5, 0x24, 0xF5, 0x5E, 0xF7, 0x96, 0x90, 0x98, 0x71, 0x80, 0xE0,
  0xC7, 0x00, 0xD6, 0x00, 0x7B, 0xDF, 0x86, 0x4B, 0xDA, 0xFF, 0xC0, 0x72,
  0x46, 0xFF, 0xC0, 0xEE, 0xC0, 0xEE, 0x80, 0x78, 0xA9, 0x70, 0xFF, 0xC0,
  0xF8, 0xFC, 0xEA, 0xC0, 0xAA, 0xC0, 0xB6, 0xFE, 0xFF, 0xC0, 0x79, 0x99,
  0x70, 0xFE, 0x80, 0x79, 0x99, 0x52, 0xFA, 0xC0, 0xF1, 0x1E, 0xE9, 0x24,
  0xFF, 0xC0, 0xB6, 0xA4, 0xAD, 0x75, 0xA5, 0x00, 0xB9, 0x6A, 0xB9, 0x24,
  0xE9, 0x4E, 0xFC, 0xA5, 0x40, 0xD5, 0x70, 0x56, 0x80, 0xE0, 0x80, 0xDF,
  0xAF, 0xC0, 0x6B, 0x2E, 0xDE, 0x57, 0x70, 0xEA, 0x80, 0x76, 0xF3, 0x80,
  0xAF, 0xC0, 0xF8, 0xFE, 0xAA, 0xC0, 0xF8, 0xF6, 0xD0, 0xBF, 0x56, 0xF0,
  0xBF, 0xA0, 0x76, 0xF2, 0x40, 0xF0, 0xE7, 0xBA, 0xC0, 0xFF, 0xFD, 0xDD,
  0x6A, 0xF7, 0xFD, 0x60, 0xDB, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 3, 5, 3, 0, -5 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 1, 6, 2, 0, -5 },
  { 16, 2, 2, 3, 0, -5 },
  { 17, 3, 3, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 2, 5, 2, 0, -5 },
  { 24, 3, 5, 3, 0, -5 },
  { 26, 1, 5, 3, 1, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 1, 4, 1, 0, -4 },
  { 44, 1, 5, 1, 0, -4 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 5, 2, 0, -5 },
  { 52, 4, 6, 5, 0, -5 },
  { 55, 3, 5, 3, 0, -5 },
  { 57, 2, 5, 3, 1, -5 },
  { 59, 3, 5, 3, 0, -5 },
  { 61, 2, 5, 4, 1, -5 },
  { 63, 2, 5, 3, 1, -5 },
  { 65, 2, 5, 3, 1, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 2, 5, 4, 1, -5 },
  { 72, 1, 5, 2, 0, -5 },
  { 73, 1, 6, 1, 0, -5 },
  { 74, 2, 5, 3, 1, -5 },
  { 76, 2, 5, 3, 1, -5 },
  { 78, 3, 5, 5, 1, -5 },
  { 80, 2, 5, 4, 1, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 2, 5, 3, 1, -5 },
  { 87, 4, 6, 4, 0, -5 },
  { 90, 2, 5, 3, 1, -5 },
  { 92, 3, 5, 3, 0, -5 },
  { 94, 3, 5, 3, 0, -5 },
  { 96, 2, 5, 4, 1, -5 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 5, 5, 5, 0, -5 },
  { 104, 3, 5, 3, 0, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 1, 6, 2, 1, -5 },
  { 111, 2, 5, 2, 0, -5 },
  { 113, 2, 6, 2, 0, -5 },
  { 115, 3, 3, 3, 0, -5 },
  { 117, 3, 1, 3, 0, 0 },
  { 118, 1, 1, 2, 0, -5 },
  { 119, 2, 4, 3, 0, -4 },
  { 120, 2, 5, 3, 1, -5 },
  { 122, 2, 4, 3, 0, -4 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 4, 3, 0, -4 },
  { 127, 2, 5, 2, 0, -5 },
  { 129, 3, 6, 3, 0, -4 },
  { 132, 2, 5, 3, 1, -5 },
  { 134, 1, 5, 1, 0, -5 },
  { 135, 1, 7, 1, 0, -5 },
  { 136, 2, 5, 3, 1, -5 },
  { 138, 1, 5, 1, 0, -5 },
  { 139, 3, 4, 5, 1, -4 },
  { 141, 2, 4, 3, 1, -4 },
  { 142, 3, 4, 3, 0, -4 },
  { 144, 2, 6, 3, 1, -4 },
  { 146, 3, 6, 3, 0, -4 },
  { 149, 1, 4, 2, 1, -4 },
  { 150, 2, 4, 2, 0, -4 },
  { 151, 2, 5, 2, 0, -5 },
  { 153, 2, 4, 3, 1, -4 },
  { 154, 2, 4, 2, 0, -4 },
  { 155, 4, 4, 4, 0, -4 },
  { 157, 2, 4, 3, 0, -4 },
  { 158, 2, 6, 2, 0, -4 },
  { 160, 2, 4, 2, 0, -4 },
  { 161, 2, 6, 2, 0, -5 },
  { 163, 1, 7, 3, 1, -5 },
  { 164, 2, 6, 2, 0, -5 },
  { 166, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Thin7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_THIN7PT7B_H_
