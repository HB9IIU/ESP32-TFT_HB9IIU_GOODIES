#ifndef _NOTOSANS_CONDENSED_THIN34PT7B_H_
#define _NOTOSANS_CONDENSED_THIN34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x08,
  0x3F, 0xFF, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01,
  0x04, 0x04, 0x10, 0x7F, 0xFE, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x04, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x02, 0x00, 0x20, 0x0F,
  0xC3, 0x22, 0x42, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x20, 0x42,
  0x02, 0x20, 0x1A, 0x00, 0x60, 0x03, 0x80, 0x24, 0x02, 0x20, 0x21, 0x02,
  0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x18, 0x22, 0x7F, 0xC0, 0x20, 0x02,
  0x00, 0x20, 0x30, 0x00, 0x13, 0x01, 0x08, 0x40, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x84, 0x08, 0x21, 0x02, 0x08, 0x80, 0x82, 0x20, 0x20, 0x88,
  0x08, 0x24, 0x72, 0x09, 0x22, 0x82, 0x90, 0xB1, 0x24, 0x16, 0xC9, 0x04,
  0xC4, 0x41, 0x01, 0x10, 0x40, 0x44, 0x10, 0x21, 0x04, 0x08, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x22, 0x08, 0x0F, 0x00, 0x06,
  0x00, 0x13, 0x00, 0x41, 0x00, 0x82, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x08, 0x20, 0x10, 0x80, 0x11, 0x00, 0x24, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x40, 0x08, 0x41, 0x20, 0x42, 0x40, 0x85, 0x00, 0x8A, 0x00, 0xA4, 0x01,
  0x48, 0x01, 0x88, 0x03, 0x10, 0x0A, 0x10, 0x22, 0x1F, 0x82, 0xFF, 0x80,
  0x0C, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x0C, 0xC0, 0x82,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0xC0, 0x08, 0x02, 0x00, 0x80,
  0x21, 0xE9, 0x87, 0x80, 0xC0, 0x48, 0x22, 0x10, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x24,
  0x94, 0x94, 0xFF, 0xF0, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x0C, 0x02,
  0x30, 0x82, 0x20, 0x24, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x14, 0x02, 0x80, 0x98, 0x11, 0x04, 0x1F, 0x00, 0x0C, 0x52, 0x51,
  0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x0E, 0x0E, 0x32, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x00,
  0xFF, 0xE0, 0x0E, 0x03, 0x1C, 0xC0, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x1F, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x28, 0x06, 0x7F, 0x80, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x01,
  0x40, 0x09, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x04, 0x20, 0x10, 0x80, 0x43, 0xFF, 0xF0,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x7F, 0xC8,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x03,
  0xFE, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xA0, 0x27, 0xF8, 0x03, 0x00, 0xC4, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x0B,
  0x0C, 0xC0, 0x4C, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x24, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0xFF, 0xE0, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x06, 0x00, 0xC6, 0x08, 0x08, 0x40,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x20, 0x21, 0x81, 0x06, 0x30,
  0x0A, 0x00, 0x70, 0x0C, 0x60, 0xC0, 0x8C, 0x06, 0x40, 0x12, 0x00, 0xA0,
  0x03, 0x00, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x04, 0x1F, 0xC0, 0x07,
  0x01, 0x88, 0x20, 0x44, 0x02, 0x40, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x32, 0x05, 0x18, 0xD0, 0xF1, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x24, 0x00, 0x00, 0x00, 0x00, 0x09,
  0x25, 0x25, 0x00, 0x00, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x00, 0x30, 0x63, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x30,
  0x08, 0x01, 0x81, 0x00, 0x08, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00,
  0x24, 0x0F, 0xC2, 0x81, 0x08, 0x28, 0x20, 0x82, 0x82, 0x08, 0x18, 0x20,
  0x81, 0x84, 0x08, 0x18, 0x40, 0x81, 0x84, 0x08, 0x18, 0x40, 0x82, 0x84,
  0x08, 0x28, 0x21, 0x82, 0x82, 0x14, 0x48, 0x1E, 0x78, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x40,
  0x07, 0xF8, 0x00, 0x01, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80,
  0x41, 0x01, 0x01, 0x02, 0x02, 0x07, 0xFC, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x10, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x01,
  0xFF, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x04, 0x81, 0x8F, 0xF0, 0x80, 0x48, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0xCF, 0xF0,
  0x01, 0xE0, 0x30, 0xC6, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x07, 0xF8, 0xFF, 0x04, 0x06, 0x20, 0x09, 0x00, 0x28,
  0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05,
  0x00, 0x28, 0x02, 0x40, 0x32, 0x02, 0x1F, 0xC0, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x00, 0x60, 0x07, 0x0E,
  0x08, 0x02, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x07, 0xFE, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x9F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x0B, 0xC0, 0x80, 0x28, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x20,
  0x86, 0x08, 0x40, 0x88, 0x09, 0x00, 0xB0, 0x0A, 0x80, 0xC8, 0x08, 0x40,
  0x84, 0x08, 0x20, 0x82, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x48, 0x04,
  0x80, 0x28, 0x03, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x80, 0x05, 0xA0, 0x01, 0x68, 0x00, 0x59, 0x00,
  0x26, 0x40, 0x09, 0x90, 0x02, 0x62, 0x01, 0x18, 0x80, 0x46, 0x20, 0x11,
  0x84, 0x08, 0x61, 0x02, 0x18, 0x40, 0x86, 0x08, 0x41, 0x82, 0x10, 0x60,
  0x84, 0x18, 0x12, 0x06, 0x04, 0x81, 0x81, 0x20, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x40, 0x1A, 0x00, 0xC8,
  0x06, 0x40, 0x31, 0x01, 0x88, 0x0C, 0x20, 0x61, 0x03, 0x04, 0x18, 0x20,
  0xC0, 0x86, 0x04, 0x30, 0x11, 0x80, 0x8C, 0x02, 0x60, 0x13, 0x00, 0x58,
  0x02, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x03, 0xC0, 0x0C, 0x30, 0x10, 0x08,
  0x20, 0x04, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x20, 0x04, 0x18, 0x18, 0x0F, 0xE0, 0xFF, 0x10, 0x12, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40,
  0x48, 0x31, 0xE8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x03, 0xC0, 0x0C, 0x30, 0x10, 0x08, 0x20,
  0x04, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20,
  0x04, 0x20, 0x04, 0x18, 0x18, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0xFF, 0x08, 0x08, 0x80, 0x48,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x18, 0xFE, 0x08, 0x60, 0x82, 0x08, 0x30, 0x81, 0x08, 0x18, 0x80, 0x88,
  0x0C, 0x80, 0x48, 0x06, 0x80, 0x28, 0x03, 0x0E, 0x06, 0x1D, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x14, 0x06, 0xFF, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x08, 0x80, 0x83, 0xF8,
  0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x08, 0x80, 0x22, 0x00,
  0x88, 0x04, 0x20, 0x10, 0x40, 0x41, 0x01, 0x04, 0x08, 0x10, 0x20, 0x20,
  0x80, 0x84, 0x02, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x02,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0x40, 0xC0, 0x18, 0x01, 0x40, 0x18, 0x02,
  0x40, 0x18, 0x02, 0x40, 0x18, 0x02, 0x20, 0x14, 0x02, 0x20, 0x24, 0x04,
  0x20, 0x24, 0x04, 0x20, 0x24, 0x04, 0x20, 0x24, 0x04, 0x10, 0x42, 0x04,
  0x10, 0x42, 0x08, 0x10, 0x42, 0x08, 0x10, 0x42, 0x08, 0x08, 0x41, 0x08,
  0x08, 0x81, 0x10, 0x08, 0x81, 0x10, 0x08, 0x81, 0x10, 0x04, 0x81, 0x10,
  0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0,
  0x03, 0x00, 0x40, 0x02, 0x00, 0x40, 0x40, 0x19, 0x00, 0x88, 0x08, 0x20,
  0x41, 0x04, 0x04, 0x20, 0x21, 0x01, 0x10, 0x04, 0x80, 0x28, 0x00, 0xC0,
  0x04, 0x00, 0x30, 0x02, 0x80, 0x12, 0x01, 0x10, 0x08, 0x40, 0x82, 0x04,
  0x10, 0x40, 0x42, 0x02, 0x20, 0x09, 0x00, 0x50, 0x01, 0x80, 0x1A, 0x00,
  0x90, 0x04, 0x80, 0x42, 0x02, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x80,
  0x44, 0x02, 0x40, 0x0A, 0x00, 0x50, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x7F, 0xE0, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0F, 0xFF,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x03, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x1F, 0xE0, 0x03, 0x00, 0x28, 0x01, 0x20, 0x11,
  0x00, 0x84, 0x08, 0x20, 0x40, 0x84, 0x04, 0x20, 0x32, 0x00, 0x90, 0x05,
  0x00, 0x10, 0xFF, 0xF8, 0xC1, 0x02, 0x04, 0x0C, 0x3F, 0x88, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xCC, 0x14, 0x05, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x03, 0x40, 0xCF, 0xD0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F, 0x14, 0x1B, 0x01, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0E, 0x02, 0xE0, 0x93, 0xE0, 0x1F, 0x98, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x0F, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x1F, 0x24, 0x1D, 0x01, 0xA0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A,
  0x03, 0x60, 0xE3, 0xE4, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x23, 0xF8, 0x07, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0xFE, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x1F,
  0xA4, 0x0D, 0x01, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x03, 0x20, 0xA3, 0xE4,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x80, 0xCF, 0xE0, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x9F, 0x28, 0x2C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x74, 0x01, 0x55, 0x55,
  0x55, 0x55, 0x40, 0x08, 0xC2, 0x00, 0x00, 0x01, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22, 0xF0,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x81, 0xC0, 0xA0,
  0x90, 0x88, 0x44, 0x42, 0x41, 0x60, 0xB0, 0x64, 0x22, 0x10, 0x88, 0x44,
  0x12, 0x09, 0x02, 0x81, 0x40, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0xBE, 0x1F,
  0x30, 0x48, 0x2C, 0x0C, 0x0A, 0x03, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18,
  0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02,
  0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80,
  0x60, 0x20, 0x10, 0x9F, 0x28, 0x2C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x1F, 0x82, 0x04, 0x40, 0x68, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x24, 0x06, 0x20, 0x41, 0xF8, 0x9F, 0x14, 0x1B, 0x01, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x02, 0xA0, 0x93, 0xE2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x24, 0x1D, 0x01, 0xA0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0A, 0x03, 0x60, 0xA3, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x9F, 0x43, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x3F, 0xD8, 0x04,
  0x03, 0x00, 0x80, 0x10, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x9F, 0xC0, 0x20, 0x40, 0x81, 0x0F,
  0xE4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x07, 0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50,
  0x1A, 0x03, 0x60, 0xA7, 0xE4, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x24, 0x04,
  0x40, 0x88, 0x21, 0x04, 0x20, 0x82, 0x10, 0x44, 0x08, 0x80, 0x90, 0x14,
  0x02, 0x80, 0x50, 0x06, 0x00, 0x80, 0x80, 0x40, 0x28, 0x0C, 0x05, 0x01,
  0x81, 0x20, 0x50, 0x24, 0x0A, 0x04, 0x41, 0x20, 0x88, 0x24, 0x21, 0x08,
  0x84, 0x21, 0x10, 0x82, 0x21, 0x10, 0x44, 0x24, 0x09, 0x04, 0x81, 0x20,
  0x90, 0x14, 0x0A, 0x02, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x80,
  0x40, 0x80, 0x48, 0x09, 0x02, 0x10, 0x42, 0x10, 0x22, 0x04, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x28, 0x09, 0x01, 0x10, 0x42, 0x08, 0x22, 0x04, 0x80,
  0x50, 0x0C, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x20, 0x42, 0x04, 0x20,
  0x41, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x05,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x0F, 0x00, 0x7F, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x7F, 0xC0, 0x03, 0x82, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x80, 0x20, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0xE0, 0x7E, 0x0C, 0x0F,
  0x80,
};

const GFXglyph NotoSans_Condensed_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 24, 7, 3, -24 },
  { 4, 6, 9, 10, 2, -24 },
  { 11, 15, 24, 17, 1, -24 },
  { 56, 12, 28, 15, 1, -26 },
  { 98, 18, 25, 22, 2, -25 },
  { 155, 15, 25, 16, 1, -25 },
  { 202, 1, 9, 6, 2, -24 },
  { 204, 6, 29, 9, 2, -24 },
  { 226, 6, 29, 9, 1, -24 },
  { 248, 10, 10, 14, 2, -26 },
  { 261, 13, 16, 15, 1, -20 },
  { 287, 3, 8, 6, 1, -4 },
  { 290, 8, 1, 10, 1, -10 },
  { 291, 2, 2, 7, 2, -2 },
  { 292, 10, 24, 11, 1, -24 },
  { 322, 11, 25, 15, 2, -25 },
  { 357, 6, 24, 15, 3, -24 },
  { 375, 11, 25, 15, 2, -25 },
  { 410, 12, 25, 15, 1, -25 },
  { 448, 14, 24, 15, 1, -24 },
  { 490, 11, 24, 15, 2, -24 },
  { 523, 12, 25, 15, 2, -25 },
  { 561, 11, 24, 15, 2, -24 },
  { 594, 13, 25, 15, 1, -25 },
  { 635, 12, 25, 15, 1, -25 },
  { 673, 2, 18, 7, 2, -18 },
  { 678, 3, 22, 6, 1, -18 },
  { 687, 13, 14, 15, 1, -19 },
  { 710, 13, 8, 15, 1, -16 },
  { 723, 13, 14, 15, 1, -19 },
  { 746, 9, 25, 10, 1, -25 },
  { 775, 20, 27, 23, 2, -24 },
  { 843, 15, 24, 15, 0, -24 },
  { 888, 12, 24, 16, 3, -24 },
  { 924, 13, 25, 16, 2, -25 },
  { 965, 13, 24, 18, 3, -24 },
  { 1004, 10, 24, 15, 3, -24 },
  { 1034, 10, 24, 13, 3, -24 },
  { 1064, 16, 25, 20, 2, -25 },
  { 1114, 13, 24, 19, 3, -24 },
  { 1153, 5, 24, 8, 2, -24 },
  { 1168, 6, 30, 7, -2, -24 },
  { 1191, 12, 24, 15, 3, -24 },
  { 1227, 10, 24, 13, 3, -24 },
  { 1257, 18, 24, 24, 3, -24 },
  { 1311, 13, 24, 19, 3, -24 },
  { 1350, 16, 25, 20, 2, -25 },
  { 1400, 11, 24, 15, 3, -24 },
  { 1433, 16, 31, 20, 2, -25 },
  { 1495, 12, 24, 16, 3, -24 },
  { 1531, 11, 25, 15, 2, -25 },
  { 1566, 13, 24, 13, 0, -24 },
  { 1605, 13, 24, 19, 3, -24 },
  { 1644, 14, 24, 14, 0, -24 },
  { 1686, 24, 24, 24, 0, -24 },
  { 1758, 13, 24, 13, 0, -24 },
  { 1797, 13, 24, 13, 0, -24 },
  { 1836, 12, 24, 14, 1, -24 },
  { 1872, 6, 29, 10, 3, -24 },
  { 1894, 10, 24, 11, 1, -24 },
  { 1924, 7, 29, 10, 1, -24 },
  { 1950, 13, 12, 15, 1, -24 },
  { 1970, 13, 1, 13, 0, 3 },
  { 1972, 6, 5, 8, 1, -26 },
  { 1976, 10, 18, 14, 1, -18 },
  { 1999, 11, 26, 16, 3, -26 },
  { 2035, 9, 18, 12, 2, -18 },
  { 2056, 11, 26, 16, 2, -26 },
  { 2092, 11, 18, 15, 2, -18 },
  { 2117, 9, 26, 8, 0, -26 },
  { 2147, 11, 26, 16, 2, -18 },
  { 2183, 10, 26, 16, 3, -26 },
  { 2216, 2, 25, 6, 2, -25 },
  { 2223, 5, 33, 6, -1, -25 },
  { 2244, 9, 26, 12, 3, -26 },
  { 2274, 1, 26, 6, 3, -26 },
  { 2278, 18, 18, 23, 3, -18 },
  { 2319, 10, 18, 16, 3, -18 },
  { 2342, 12, 18, 15, 2, -18 },
  { 2369, 11, 26, 16, 3, -18 },
  { 2405, 11, 26, 16, 2, -18 },
  { 2441, 7, 18, 10, 3, -18 },
  { 2457, 10, 18, 12, 1, -18 },
  { 2480, 7, 22, 8, 1, -22 },
  { 2500, 11, 18, 16, 2, -18 },
  { 2525, 11, 18, 11, 0, -18 },
  { 2550, 19, 18, 19, 0, -18 },
  { 2593, 11, 18, 12, 1, -18 },
  { 2618, 12, 26, 12, 0, -18 },
  { 2657, 9, 18, 11, 1, -18 },
  { 2678, 9, 29, 12, 1, -24 },
  { 2711, 1, 34, 14, 7, -26 },
  { 2716, 8, 29, 12, 2, -24 },
  { 2745, 13, 2, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Thin34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_THIN34PT7B_H_
