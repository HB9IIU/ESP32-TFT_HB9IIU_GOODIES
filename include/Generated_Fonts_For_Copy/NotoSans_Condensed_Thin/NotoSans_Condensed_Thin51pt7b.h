#ifndef _NOTOSANS_CONDENSED_THIN51PT7B_H_
#define _NOTOSANS_CONDENSED_THIN51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xD5, 0x55, 0x54, 0x00, 0x3F, 0xC1, 0xE0,
  0xF0, 0x68, 0x34, 0x1A, 0x0D, 0x06, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x14,
  0x08, 0x00, 0x40, 0x20, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x02,
  0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20,
  0x00, 0x80, 0x40, 0x03, 0x01, 0x80, 0x06, 0x02, 0x03, 0xFF, 0xFF, 0xF0,
  0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20,
  0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x7F, 0xFF, 0xFC, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20,
  0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x0E, 0x9F, 0x8E, 0x20, 0x42, 0x08,
  0x01, 0x82, 0x00, 0x40, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x02, 0x02, 0x00,
  0xC0, 0x80, 0x30, 0x20, 0x04, 0x08, 0x01, 0x82, 0x00, 0x20, 0x80, 0x0E,
  0x20, 0x00, 0xC8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x09,
  0xC0, 0x02, 0x18, 0x00, 0x83, 0x00, 0x20, 0x60, 0x08, 0x0C, 0x02, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x20, 0x20, 0x08, 0x1B, 0x02, 0x0C, 0xF8, 0x9E, 0x07, 0xFC, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x06,
  0x60, 0x03, 0x01, 0x82, 0x00, 0x40, 0x20, 0x40, 0x08, 0x0C, 0x0C, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x04, 0x02, 0x02, 0x00, 0x80,
  0x40, 0x40, 0x10, 0x0C, 0x18, 0x02, 0x01, 0x82, 0x00, 0x40, 0x30, 0xC0,
  0x08, 0x06, 0x10, 0x01, 0x00, 0xC2, 0x00, 0x20, 0x10, 0xC0, 0x04, 0x02,
  0x10, 0xF8, 0x80, 0x42, 0x31, 0x90, 0x08, 0x8C, 0x1B, 0x03, 0x11, 0x01,
  0x20, 0x46, 0x20, 0x26, 0x18, 0x8C, 0x06, 0x66, 0x11, 0x80, 0xC7, 0x84,
  0x20, 0x08, 0x00, 0x84, 0x01, 0x00, 0x30, 0x80, 0x20, 0x04, 0x10, 0x04,
  0x00, 0x82, 0x00, 0x80, 0x30, 0x40, 0x10, 0x04, 0x08, 0x02, 0x01, 0x81,
  0x00, 0x40, 0x20, 0x30, 0x18, 0x04, 0x06, 0x03, 0x01, 0x80, 0x40, 0x40,
  0x20, 0x08, 0x08, 0x0C, 0x01, 0x83, 0x01, 0x00, 0x18, 0xC0, 0x60, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0xC0, 0x80, 0x02, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x60, 0x10, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x60, 0x10, 0x00, 0x80, 0x40, 0x02, 0x03, 0x00, 0x0C, 0x08,
  0x00, 0x10, 0x60, 0x00, 0x61, 0x00, 0x00, 0x98, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x68, 0x00, 0x03, 0x10, 0x00, 0x18, 0x60, 0x00, 0xC0,
  0x80, 0x26, 0x01, 0x00, 0x90, 0x06, 0x06, 0x40, 0x08, 0x13, 0x00, 0x10,
  0x4C, 0x00, 0x61, 0x20, 0x00, 0xCC, 0x80, 0x01, 0x22, 0x00, 0x07, 0x8C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x40, 0x01, 0xE1, 0x80, 0x0C, 0xC3, 0x00,
  0x61, 0x06, 0x03, 0x02, 0x0F, 0xF8, 0x0C, 0x06, 0x00, 0x00, 0xFD, 0x55,
  0x55, 0x40, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x30, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20,
  0x30, 0x30, 0x10, 0x18, 0x18, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x10, 0x20, 0x78, 0x47, 0x0E, 0xB8, 0x03, 0x80, 0x05,
  0x00, 0x12, 0x00, 0x62, 0x00, 0x82, 0x02, 0x06, 0x08, 0x06, 0x10, 0x08,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x33, 0x33, 0x22,
  0x64, 0x44, 0x88, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x1C, 0x06, 0x03, 0x02, 0x00, 0x82,
  0x00, 0x61, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00,
  0xB0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x2C, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C, 0xC0, 0x04, 0x20,
  0x02, 0x18, 0x03, 0x06, 0x03, 0x01, 0x83, 0x00, 0x7F, 0x00, 0x01, 0x81,
  0xC1, 0xA1, 0x93, 0x0B, 0x07, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x03, 0xE0, 0x07, 0x8E, 0x07, 0x00, 0x61, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0x9F, 0x07, 0x00, 0x63, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x48, 0x00, 0x33, 0x80, 0x30,
  0x3F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0A, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00,
  0x02, 0x20, 0x00, 0x31, 0x00, 0x03, 0x08, 0x00, 0x10, 0x40, 0x01, 0x82,
  0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x60, 0x20, 0x02,
  0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x01, 0x80, 0x10,
  0x08, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x20, 0x60, 0x01, 0x06, 0x00,
  0x08, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFE, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x0E, 0x01, 0xFF, 0xF0, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x40, 0x06, 0x30, 0x0E, 0x0F, 0xFC, 0x00,
  0x00, 0x7C, 0x01, 0xF7, 0x81, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x0F, 0xF0, 0x8C, 0x0C,
  0x48, 0x03, 0x28, 0x00, 0xDC, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x03, 0x60, 0x01, 0x10, 0x01,
  0x84, 0x01, 0x83, 0x01, 0x80, 0x7F, 0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x01, 0xEF, 0x01, 0x80,
  0x60, 0x40, 0x04, 0x20, 0x01, 0x88, 0x00, 0x26, 0x00, 0x09, 0x80, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x08, 0x80, 0x02, 0x30, 0x01, 0x86,
  0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0xB8, 0x00, 0x38, 0x00, 0x3B,
  0x00, 0x18, 0x70, 0x0C, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x19, 0x80, 0x02,
  0x40, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00,
  0x30, 0x70, 0x18, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x03, 0x8E,
  0x01, 0x80, 0x40, 0xC0, 0x08, 0x20, 0x03, 0x18, 0x00, 0x44, 0x00, 0x19,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00,
  0x76, 0x00, 0x1C, 0xC0, 0x0B, 0x10, 0x06, 0xC3, 0x87, 0x30, 0x3F, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x3F, 0xE0, 0x03, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x22, 0x64, 0x44, 0x88, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x1F, 0x83, 0xCF, 0x20, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x01,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x00, 0x98, 0x01, 0xF8, 0x04, 0x80, 0x18, 0x60, 0x34, 0x01, 0x01,
  0x01, 0xE0, 0x10, 0x08, 0x07, 0x01, 0x80, 0x40, 0x38, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x30, 0x04, 0x03, 0x01,
  0x00, 0x60, 0x18, 0x08, 0x03, 0x00, 0xC0, 0x40, 0x18, 0x06, 0x02, 0x00,
  0xC0, 0x30, 0x10, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0xA0, 0x10, 0x14, 0x05, 0x80, 0xC1, 0xA0, 0x6C, 0x03, 0x18, 0x86, 0x20,
  0x0F, 0x87, 0xE1, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x10, 0x00,
  0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x86, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x40, 0x80, 0x01, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x10,
  0x00, 0x80, 0x60, 0x02, 0x01, 0x80, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x30, 0x0C, 0x00, 0x40, 0x3F, 0xFF, 0x00, 0x80, 0x06, 0x02, 0x00,
  0x18, 0x18, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x03, 0x0C, 0x00, 0x04,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x98, 0x00, 0x02, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x30, 0x03, 0x8C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x38, 0xFF, 0xF8,
  0x30, 0x3F, 0x0C, 0x00, 0x73, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x01,
  0xB0, 0x00, 0xCC, 0x01, 0xC3, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x1F,
  0x03, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x03, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0xFF, 0xF8, 0x06, 0x00, 0xF0, 0x30,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x23, 0x00, 0x01,
  0x98, 0x00, 0x04, 0xC0, 0x00, 0x26, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x02,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00,
  0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00,
  0x23, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x30,
  0x1F, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xE1, 0xF8, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x16, 0x00, 0x00, 0x24, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x88, 0x00, 0x01, 0x08, 0x00, 0x02, 0x18, 0x00, 0x04, 0x1C,
  0x00, 0x08, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x80, 0x80, 0xD9, 0xC7, 0xC0, 0xC0, 0x01, 0xF0, 0x00,
  0x4C, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x83,
  0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC1,
  0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCA, 0x00, 0x36, 0xC0,
  0x0F, 0x10, 0x03, 0x86, 0x00, 0xC0, 0x80, 0x30, 0x30, 0x0C, 0x04, 0x03,
  0x01, 0x80, 0xC0, 0x30, 0x30, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x20, 0xC0,
  0x0C, 0x30, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00,
  0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF,
  0xF0, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xD0, 0x00, 0x00, 0xBD, 0x00, 0x00, 0x0B, 0xD8, 0x00,
  0x01, 0xBC, 0x80, 0x00, 0x13, 0xC8, 0x00, 0x01, 0x3C, 0xC0, 0x00, 0x33,
  0xC4, 0x00, 0x02, 0x3C, 0x40, 0x00, 0x23, 0xC6, 0x00, 0x06, 0x3C, 0x20,
  0x00, 0x43, 0xC2, 0x00, 0x04, 0x3C, 0x30, 0x00, 0xC3, 0xC1, 0x00, 0x08,
  0x3C, 0x10, 0x00, 0x83, 0xC1, 0x80, 0x18, 0x3C, 0x08, 0x01, 0x03, 0xC0,
  0x80, 0x10, 0x3C, 0x0C, 0x03, 0x03, 0xC0, 0x40, 0x20, 0x3C, 0x04, 0x02,
  0x03, 0xC0, 0x60, 0x60, 0x3C, 0x02, 0x04, 0x03, 0xC0, 0x20, 0x40, 0x3C,
  0x03, 0x0C, 0x03, 0xC0, 0x10, 0x80, 0x3C, 0x01, 0x08, 0x03, 0xC0, 0x19,
  0x80, 0x3C, 0x00, 0x90, 0x03, 0xC0, 0x09, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xD0, 0x00, 0x1D, 0x80, 0x01, 0xC8, 0x00,
  0x1C, 0xC0, 0x01, 0xC4, 0x00, 0x1C, 0x60, 0x01, 0xC2, 0x00, 0x1C, 0x30,
  0x01, 0xC1, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0x80, 0x1C, 0x0C, 0x01, 0xC0,
  0x40, 0x1C, 0x02, 0x01, 0xC0, 0x20, 0x1C, 0x01, 0x01, 0xC0, 0x10, 0x1C,
  0x00, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x41, 0xC0, 0x06, 0x1C, 0x00, 0x21,
  0xC0, 0x03, 0x1C, 0x00, 0x11, 0xC0, 0x01, 0x9C, 0x00, 0x09, 0xC0, 0x00,
  0xDC, 0x00, 0x05, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0x00, 0x7E, 0x00, 0x03, 0xC7, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0x60, 0x0E, 0x30,
  0x01, 0x98, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0B, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x07, 0x30, 0x06, 0x1F,
  0xFE, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xC7, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x12, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x30, 0x07, 0x0C, 0x00,
  0x63, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x4C, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x07, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xC0, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x03, 0x00, 0xC0,
  0xC0, 0x10, 0x30, 0x06, 0x0C, 0x00, 0x83, 0x00, 0x30, 0xC0, 0x04, 0x30,
  0x01, 0x8C, 0x00, 0x23, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x6C, 0x00,
  0x0B, 0x00, 0x03, 0x01, 0xFC, 0x01, 0xE3, 0xE1, 0x80, 0x08, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x33, 0x80, 0x38,
  0x7F, 0xF8, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x26, 0x00, 0x06, 0x30, 0x00, 0x41, 0x80, 0x0C, 0x0C, 0x03, 0x80, 0x7F,
  0xE0, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x01,
  0x90, 0x00, 0x06, 0x60, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08,
  0x00, 0x08, 0x30, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x06, 0x06, 0x00,
  0x10, 0x08, 0x00, 0x40, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0x40, 0x02,
  0x01, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x40, 0x80, 0x01, 0x06,
  0x00, 0x04, 0x18, 0x00, 0x18, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00,
  0x03, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x16, 0x00, 0x00, 0x58, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x01, 0x20, 0x00, 0x70, 0x00,
  0x64, 0x00, 0x1E, 0x00, 0x0C, 0x80, 0x03, 0x40, 0x01, 0x18, 0x00, 0x48,
  0x00, 0x23, 0x00, 0x09, 0x80, 0x0C, 0x20, 0x03, 0x30, 0x01, 0x84, 0x00,
  0x62, 0x00, 0x20, 0xC0, 0x08, 0x40, 0x04, 0x18, 0x01, 0x08, 0x00, 0x81,
  0x00, 0x21, 0x80, 0x30, 0x20, 0x0C, 0x30, 0x04, 0x06, 0x01, 0x82, 0x00,
  0x80, 0xC0, 0x20, 0x40, 0x10, 0x08, 0x04, 0x0C, 0x06, 0x01, 0x00, 0x81,
  0x80, 0xC0, 0x20, 0x30, 0x10, 0x10, 0x06, 0x04, 0x02, 0x02, 0x00, 0x40,
  0x80, 0x40, 0xC0, 0x08, 0x10, 0x0C, 0x18, 0x01, 0x06, 0x01, 0x82, 0x00,
  0x30, 0xC0, 0x10, 0x40, 0x06, 0x10, 0x02, 0x18, 0x00, 0x42, 0x00, 0x63,
  0x00, 0x08, 0x40, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x88, 0x00, 0x32, 0x00,
  0x11, 0x00, 0x02, 0x40, 0x02, 0x60, 0x00, 0x48, 0x00, 0x68, 0x00, 0x0B,
  0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x66,
  0x00, 0x08, 0x40, 0x03, 0x0C, 0x00, 0x40, 0x80, 0x18, 0x18, 0x02, 0x01,
  0x00, 0xC0, 0x30, 0x10, 0x02, 0x06, 0x00, 0x40, 0x80, 0x0C, 0x10, 0x00,
  0x86, 0x00, 0x18, 0x80, 0x01, 0x30, 0x00, 0x34, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x00, 0x03,
  0x10, 0x00, 0x42, 0x00, 0x18, 0x60, 0x02, 0x04, 0x00, 0xC0, 0xC0, 0x10,
  0x08, 0x06, 0x01, 0x80, 0x80, 0x10, 0x30, 0x02, 0x04, 0x00, 0x61, 0x80,
  0x04, 0x20, 0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0xE0, 0x00, 0x10, 0xC0,
  0x00, 0x68, 0x00, 0x09, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0x60,
  0x03, 0x04, 0x00, 0x40, 0xC0, 0x18, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30,
  0x18, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x04, 0x18, 0x00, 0x82, 0x00, 0x18,
  0xC0, 0x01, 0x10, 0x00, 0x22, 0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0xFF, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xF0, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x16, 0x00, 0x01, 0x90, 0x00, 0x08, 0xC0,
  0x00, 0xC2, 0x00, 0x04, 0x18, 0x00, 0x60, 0x40, 0x02, 0x03, 0x00, 0x30,
  0x08, 0x03, 0x00, 0x60, 0x10, 0x01, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x20,
  0xC0, 0x01, 0x84, 0x00, 0x04, 0x60, 0x00, 0x36, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xF0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF0,
  0x70, 0x30, 0x80, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1F, 0xE1, 0xE0,
  0x46, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x05, 0x60, 0x1A, 0x60, 0x64, 0x7F,
  0x88, 0x18, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x87, 0xF8, 0x23, 0x03, 0x09, 0x00,
  0x62, 0x80, 0x0C, 0xA0, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x02,
  0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0B, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x4E, 0x00, 0x32, 0x80, 0x08,
  0x90, 0x06, 0x27, 0x03, 0x08, 0x7F, 0x80, 0x02, 0x00, 0x03, 0xFC, 0x38,
  0x11, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x70, 0x10, 0x7F, 0xC0, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x7F, 0x08, 0xE0, 0xE4, 0xC0, 0x12, 0x40, 0x05, 0x60, 0x03, 0xA0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00,
  0xEC, 0x00, 0x53, 0x00, 0x48, 0xC0, 0x64, 0x3F, 0xC2, 0x01, 0x00, 0x07,
  0xF0, 0x1C, 0x18, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x01, 0x1C, 0x06, 0x07, 0xFC, 0x00, 0x40, 0x01, 0xF8, 0x38, 0x81, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x0F, 0xF8, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07,
  0xF8, 0x8E, 0x06, 0x4C, 0x01, 0xA4, 0x00, 0x56, 0x00, 0x1A, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x0A,
  0xC0, 0x05, 0x30, 0x04, 0x8C, 0x0C, 0x43, 0xFC, 0x20, 0x10, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x68, 0x00, 0x63, 0x80, 0xE0, 0xFF, 0xC0, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xF0,
  0x8C, 0x18, 0x90, 0x04, 0xA0, 0x06, 0xA0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x0A, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA,
  0xAA, 0x80, 0x06, 0x1C, 0x18, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0xF8, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x0E, 0x00, 0x68, 0x03, 0x20,
  0x08, 0x80, 0x42, 0x03, 0x08, 0x08, 0x20, 0x40, 0x83, 0x02, 0x18, 0x08,
  0x40, 0x23, 0x80, 0x9A, 0x02, 0x4C, 0x0A, 0x10, 0x38, 0x60, 0xC0, 0x82,
  0x03, 0x08, 0x04, 0x20, 0x18, 0x80, 0x22, 0x00, 0xC8, 0x01, 0x20, 0x06,
  0x80, 0x0A, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x8F,
  0xE0, 0x7F, 0x13, 0x06, 0x18, 0x32, 0xC0, 0x66, 0x03, 0x50, 0x05, 0x80,
  0x2C, 0x00, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x87, 0xF0, 0x8C, 0x1C, 0x90,
  0x04, 0xA0, 0x06, 0xA0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x07, 0xF8, 0x07, 0x03, 0x03, 0x00, 0x60, 0x80, 0x0C, 0x60, 0x01,
  0x10, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01,
  0x90, 0x00, 0x66, 0x00, 0x10, 0x80, 0x0C, 0x30, 0x06, 0x06, 0x03, 0x00,
  0xFF, 0x80, 0x03, 0x00, 0x87, 0xF8, 0x23, 0x03, 0x09, 0x80, 0x62, 0xC0,
  0x0C, 0xA0, 0x01, 0x38, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x2C, 0x00, 0x0B, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x4A, 0x00, 0x32, 0xC0, 0x08, 0x90, 0x06,
  0x27, 0x03, 0x08, 0x7F, 0x82, 0x02, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x43, 0x83,
  0x91, 0x80, 0x24, 0x40, 0x05, 0x30, 0x01, 0xC8, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x03, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x14,
  0xC0, 0x05, 0x18, 0x02, 0x43, 0x03, 0x10, 0x7F, 0x84, 0x01, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x87, 0xF1, 0x86, 0x40, 0x58, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x00, 0x0F, 0xF8, 0xE0, 0x36, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x80, 0x1B, 0x00, 0xC7,
  0xFE, 0x01, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x03,
  0xFF, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0xF0, 0x10, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x05, 0x60, 0x1A, 0x60, 0x64,
  0x7F, 0x88, 0x10, 0x00, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x4C, 0x00,
  0x26, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08, 0x60, 0x0C, 0x10, 0x04, 0x08,
  0x02, 0x04, 0x01, 0x03, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x30, 0x60,
  0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x1B, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x05, 0x00, 0x24, 0x00, 0xA0, 0x04, 0x80, 0x16, 0x00, 0x90, 0x06,
  0x40, 0x33, 0x00, 0x88, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x30, 0x10,
  0x80, 0xC2, 0x06, 0x18, 0x10, 0x40, 0xC1, 0x02, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x18, 0x10, 0x40, 0xC2, 0x02, 0x18, 0x08, 0x40, 0x42, 0x01,
  0x08, 0x0C, 0x40, 0x23, 0x00, 0x88, 0x06, 0x40, 0x13, 0x00, 0x48, 0x02,
  0x40, 0x09, 0x00, 0x68, 0x01, 0x60, 0x05, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x30, 0x01, 0x08, 0x01, 0x86, 0x00, 0x81, 0x00, 0xC0, 0xC0, 0x40, 0x20,
  0x60, 0x18, 0x20, 0x04, 0x30, 0x01, 0x10, 0x00, 0x98, 0x00, 0x28, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x06, 0x80, 0x02, 0x60, 0x03, 0x10,
  0x01, 0x0C, 0x01, 0x83, 0x01, 0x80, 0x80, 0x80, 0x60, 0xC0, 0x10, 0x40,
  0x0C, 0x60, 0x02, 0x20, 0x01, 0xB0, 0x00, 0x60, 0x40, 0x00, 0xD8, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0x41, 0x00, 0x30,
  0x40, 0x08, 0x18, 0x02, 0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x0C,
  0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x18, 0x00, 0x84,
  0x00, 0x21, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x1A, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x23, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x78, 0x01, 0xE0, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x3C, 0x01, 0xC0, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x07,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x2C, 0x38, 0x06, 0x01, 0xC3, 0x40, 0x0F,
  0xC0,
};

const GFXglyph NotoSans_Condensed_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 36, 10, 4, -36 },
  { 10, 9, 13, 15, 3, -36 },
  { 25, 23, 36, 25, 1, -36 },
  { 129, 18, 42, 23, 2, -39 },
  { 224, 27, 37, 33, 3, -37 },
  { 349, 22, 38, 24, 2, -37 },
  { 454, 2, 13, 8, 3, -36 },
  { 458, 9, 44, 13, 2, -36 },
  { 508, 9, 44, 13, 2, -36 },
  { 558, 15, 16, 21, 3, -39 },
  { 588, 19, 24, 23, 2, -30 },
  { 645, 4, 12, 9, 2, -5 },
  { 651, 11, 2, 14, 2, -15 },
  { 654, 2, 3, 10, 4, -3 },
  { 655, 15, 36, 17, 1, -36 },
  { 723, 17, 37, 23, 3, -37 },
  { 802, 9, 36, 23, 4, -36 },
  { 843, 18, 37, 23, 2, -37 },
  { 927, 18, 38, 23, 2, -37 },
  { 1013, 21, 37, 23, 1, -37 },
  { 1111, 17, 36, 23, 3, -36 },
  { 1188, 17, 38, 23, 3, -37 },
  { 1269, 18, 36, 23, 2, -36 },
  { 1350, 18, 38, 23, 2, -37 },
  { 1436, 18, 38, 23, 2, -37 },
  { 1522, 2, 27, 10, 4, -27 },
  { 1529, 4, 34, 10, 2, -27 },
  { 1546, 19, 22, 23, 2, -29 },
  { 1599, 19, 12, 23, 2, -24 },
  { 1628, 19, 22, 23, 2, -29 },
  { 1681, 13, 37, 16, 1, -37 },
  { 1742, 29, 41, 35, 3, -36 },
  { 1891, 22, 36, 22, 0, -36 },
  { 1990, 18, 36, 25, 4, -36 },
  { 2071, 20, 38, 24, 3, -37 },
  { 2166, 21, 36, 27, 4, -36 },
  { 2261, 15, 36, 22, 4, -36 },
  { 2329, 15, 36, 20, 4, -36 },
  { 2397, 23, 38, 30, 3, -37 },
  { 2507, 20, 36, 28, 4, -36 },
  { 2597, 8, 36, 12, 2, -36 },
  { 2633, 9, 45, 10, -3, -36 },
  { 2684, 18, 36, 22, 4, -36 },
  { 2765, 15, 36, 20, 4, -36 },
  { 2833, 28, 36, 36, 4, -36 },
  { 2959, 20, 36, 29, 4, -36 },
  { 3049, 24, 38, 30, 3, -37 },
  { 3163, 17, 36, 23, 4, -36 },
  { 3240, 24, 46, 30, 3, -37 },
  { 3378, 18, 36, 23, 4, -36 },
  { 3459, 18, 38, 22, 2, -37 },
  { 3545, 19, 36, 20, 0, -36 },
  { 3631, 20, 37, 28, 4, -36 },
  { 3724, 22, 36, 22, 0, -36 },
  { 3823, 35, 36, 36, 1, -36 },
  { 3981, 19, 36, 20, 0, -36 },
  { 4067, 19, 36, 19, 0, -36 },
  { 4153, 17, 36, 20, 2, -36 },
  { 4230, 10, 44, 16, 4, -36 },
  { 4285, 15, 36, 17, 1, -36 },
  { 4353, 9, 44, 16, 2, -36 },
  { 4403, 21, 18, 23, 1, -36 },
  { 4451, 20, 1, 20, 0, 5 },
  { 4454, 8, 8, 12, 2, -39 },
  { 4462, 15, 28, 21, 2, -27 },
  { 4515, 18, 40, 24, 4, -39 },
  { 4605, 14, 28, 18, 3, -27 },
  { 4654, 17, 40, 24, 3, -39 },
  { 4739, 16, 28, 22, 3, -27 },
  { 4795, 13, 39, 12, 1, -39 },
  { 4859, 17, 39, 24, 3, -27 },
  { 4942, 16, 39, 23, 4, -39 },
  { 5020, 2, 37, 9, 4, -37 },
  { 5030, 7, 49, 9, -1, -37 },
  { 5073, 14, 39, 19, 4, -39 },
  { 5142, 1, 39, 9, 4, -39 },
  { 5147, 27, 27, 35, 4, -27 },
  { 5239, 16, 27, 23, 4, -27 },
  { 5293, 18, 28, 23, 3, -27 },
  { 5356, 18, 39, 24, 4, -27 },
  { 5444, 18, 39, 24, 2, -27 },
  { 5532, 11, 27, 15, 4, -27 },
  { 5570, 14, 28, 18, 2, -27 },
  { 5619, 10, 35, 12, 1, -34 },
  { 5663, 15, 28, 23, 4, -27 },
  { 5716, 17, 27, 17, 0, -27 },
  { 5774, 27, 27, 29, 1, -27 },
  { 5866, 17, 27, 19, 1, -27 },
  { 5924, 18, 39, 18, 0, -27 },
  { 6012, 13, 27, 16, 2, -27 },
  { 6056, 13, 44, 18, 2, -36 },
  { 6128, 1, 52, 22, 10, -39 },
  { 6135, 13, 44, 18, 2, -36 },
  { 6207, 19, 4, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Thin51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_THIN51PT7B_H_
