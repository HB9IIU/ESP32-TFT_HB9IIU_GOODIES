#ifndef _NOTOSANS_CONDENSED_THIN15PT7B_H_
#define _NOTOSANS_CONDENSED_THIN15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x14, 0x48, 0x93, 0xF2, 0x45, 0x0A, 0x7F,
  0x48, 0x91, 0x20, 0x75, 0x29, 0x4A, 0x30, 0xC5, 0x29, 0x7C, 0x40, 0xC4,
  0xA4, 0xA4, 0xA8, 0xAA, 0xB5, 0xD9, 0x19, 0x29, 0x29, 0x47, 0x62, 0x49,
  0x24, 0x61, 0x0A, 0x65, 0x8A, 0x2F, 0x40, 0xF0, 0x5A, 0xAA, 0xAA, 0x40,
  0xA5, 0x55, 0x56, 0x80, 0x2B, 0x69, 0x21, 0x09, 0xF2, 0x10, 0x80, 0xF0,
  0xF0, 0x80, 0x08, 0x44, 0x22, 0x10, 0x88, 0x42, 0x20, 0x74, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x5C, 0x2E, 0x92, 0x49, 0x24, 0x80, 0xF0, 0x42, 0x10,
  0x88, 0x44, 0x44, 0x3E, 0xF0, 0x42, 0x11, 0x38, 0x21, 0x08, 0x7C, 0x08,
  0x10, 0x61, 0x42, 0x89, 0x12, 0x44, 0x7E, 0x10, 0x20, 0xF4, 0x21, 0x0E,
  0x0C, 0x21, 0x08, 0x7C, 0x32, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x5C, 0xF8,
  0x42, 0x21, 0x10, 0x84, 0x42, 0x10, 0x74, 0x63, 0x15, 0x32, 0x71, 0x8C,
  0x7C, 0x74, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0xB8, 0x81, 0x83, 0xC0, 0x1B,
  0x20, 0x83, 0x04, 0xF8, 0x3E, 0xC1, 0x82, 0x64, 0x40, 0xE1, 0x11, 0x12,
  0x44, 0x00, 0x40, 0x3C, 0x21, 0x20, 0x53, 0x9A, 0x4D, 0x26, 0x93, 0x49,
  0xAD, 0x49, 0x20, 0x0F, 0x80, 0x10, 0x60, 0xC1, 0x42, 0x89, 0x1E, 0x22,
  0x85, 0x0A, 0x08, 0xF2, 0x28, 0x61, 0x8B, 0xE8, 0x61, 0x86, 0x1F, 0x80,
  0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x03, 0xC0, 0xF2, 0x28, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0xFC, 0x21, 0x08, 0x7A, 0x10, 0x84,
  0x3E, 0xFC, 0x21, 0x08, 0x7A, 0x10, 0x84, 0x20, 0x3E, 0x82, 0x04, 0x08,
  0x11, 0xA0, 0xC1, 0x82, 0x84, 0xF8, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61,
  0x86, 0x18, 0x40, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80,
  0x8A, 0x29, 0x28, 0xA3, 0x0A, 0x24, 0x92, 0x28, 0xC0, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x3E, 0x81, 0x81, 0xC1, 0xC3, 0xA3, 0xA3, 0xA5, 0x95,
  0x95, 0x99, 0x89, 0x86, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x8E, 0x18, 0x40,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0xF4, 0x63,
  0x18, 0xCF, 0x90, 0x84, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x09, 0xE0, 0x40, 0x80, 0x80, 0xF2, 0x28, 0xA2, 0x8B, 0xC9, 0x24,
  0x8A, 0x28, 0x40, 0x7C, 0x21, 0x08, 0x30, 0x41, 0x08, 0x7C, 0xFC, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x17, 0x80, 0x86, 0x18, 0x51, 0x49, 0x24, 0x8A, 0x30, 0x41,
  0x00, 0x84, 0x30, 0x86, 0x31, 0x25, 0x24, 0xA4, 0x94, 0x94, 0xA1, 0x94,
  0x31, 0x86, 0x20, 0x84, 0x00, 0x85, 0x24, 0x8C, 0x30, 0x83, 0x14, 0x49,
  0x28, 0x40, 0x86, 0x24, 0x92, 0x50, 0xC2, 0x08, 0x20, 0x82, 0x00, 0x78,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x0F, 0xC0, 0xF2, 0x49, 0x24, 0x92,
  0x4E, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0xE4, 0x92, 0x49, 0x24,
  0x9E, 0x10, 0xA2, 0x92, 0x46, 0x10, 0xFC, 0x90, 0xF1, 0x17, 0x99, 0x9F,
  0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x7E, 0x78, 0x88, 0x88, 0x87, 0x08,
  0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x7E, 0x74, 0x63, 0xF8, 0x42, 0x0F, 0x74,
  0x4E, 0x44, 0x44, 0x44, 0x40, 0x7C, 0x63, 0x18, 0xC6, 0x3F, 0x08, 0x43,
  0xE0, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x62, 0x9F, 0xE0, 0x41, 0x55,
  0x55, 0x58, 0x88, 0x89, 0xAA, 0xCA, 0xA9, 0x90, 0xFF, 0xE0, 0xF7, 0x89,
  0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x74,
  0x63, 0x18, 0xC6, 0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3F, 0x84, 0x20, 0x7C,
  0x63, 0x18, 0xC6, 0x3F, 0x08, 0x42, 0xF2, 0x49, 0x24, 0xF8, 0x8C, 0x21,
  0x1E, 0x4B, 0xA4, 0x92, 0x4C, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x8C, 0x62,
  0xA5, 0x28, 0x84, 0x89, 0x89, 0x99, 0x55, 0x55, 0x66, 0x22, 0x22, 0x8A,
  0x54, 0x42, 0x29, 0x31, 0x8C, 0x52, 0xA5, 0x28, 0x84, 0x21, 0x11, 0x00,
  0x71, 0x12, 0x24, 0x4F, 0x29, 0x24, 0xA2, 0x49, 0x26, 0xFF, 0xFE, 0x89,
  0x24, 0x8A, 0x49, 0x2C, 0xF8,
};

const GFXglyph NotoSans_Condensed_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 7, 11, 7, 0, -11 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 8, 11, 10, 1, -11 },
  { 34, 6, 11, 7, 1, -11 },
  { 43, 1, 4, 2, 1, -11 },
  { 44, 2, 13, 4, 1, -11 },
  { 48, 2, 13, 4, 1, -11 },
  { 52, 4, 4, 6, 1, -11 },
  { 54, 5, 7, 7, 1, -9 },
  { 59, 1, 4, 3, 1, -2 },
  { 60, 4, 1, 4, 0, -5 },
  { 61, 1, 1, 3, 1, -1 },
  { 62, 5, 11, 5, 0, -11 },
  { 69, 5, 11, 7, 1, -11 },
  { 76, 3, 11, 7, 1, -11 },
  { 81, 5, 11, 7, 1, -11 },
  { 88, 5, 11, 7, 1, -11 },
  { 95, 7, 11, 7, 0, -11 },
  { 105, 5, 11, 7, 1, -11 },
  { 112, 5, 11, 7, 1, -11 },
  { 119, 5, 11, 7, 1, -11 },
  { 126, 5, 11, 7, 1, -11 },
  { 133, 5, 11, 7, 1, -11 },
  { 140, 1, 8, 3, 1, -8 },
  { 141, 1, 10, 3, 1, -8 },
  { 143, 5, 6, 7, 1, -8 },
  { 147, 5, 3, 7, 1, -7 },
  { 149, 5, 6, 7, 1, -8 },
  { 153, 4, 11, 5, 0, -11 },
  { 159, 9, 12, 10, 1, -11 },
  { 173, 7, 11, 7, 0, -11 },
  { 183, 6, 11, 7, 1, -11 },
  { 192, 6, 11, 7, 1, -11 },
  { 201, 6, 11, 8, 1, -11 },
  { 210, 5, 11, 6, 1, -11 },
  { 217, 5, 11, 6, 1, -11 },
  { 224, 7, 11, 9, 1, -11 },
  { 234, 6, 11, 8, 1, -11 },
  { 243, 2, 11, 4, 1, -11 },
  { 246, 3, 14, 3, -1, -11 },
  { 252, 6, 11, 7, 1, -11 },
  { 261, 5, 11, 6, 1, -11 },
  { 268, 8, 11, 11, 1, -11 },
  { 279, 6, 11, 8, 1, -11 },
  { 288, 7, 11, 9, 1, -11 },
  { 298, 5, 11, 7, 1, -11 },
  { 305, 7, 14, 9, 1, -11 },
  { 318, 6, 11, 7, 1, -11 },
  { 327, 5, 11, 7, 1, -11 },
  { 334, 6, 11, 6, 0, -11 },
  { 343, 6, 11, 8, 1, -11 },
  { 352, 6, 11, 6, 0, -11 },
  { 361, 11, 11, 11, 0, -11 },
  { 377, 6, 11, 6, 0, -11 },
  { 386, 6, 11, 6, 0, -11 },
  { 395, 6, 11, 6, 0, -11 },
  { 404, 3, 13, 5, 1, -11 },
  { 409, 5, 11, 5, 0, -11 },
  { 416, 3, 13, 5, 0, -11 },
  { 421, 6, 6, 7, 0, -11 },
  { 426, 6, 1, 6, 0, 1 },
  { 427, 2, 2, 3, 1, -11 },
  { 428, 4, 8, 6, 1, -8 },
  { 432, 5, 11, 7, 1, -11 },
  { 439, 4, 8, 5, 1, -8 },
  { 443, 5, 11, 7, 1, -11 },
  { 450, 5, 8, 6, 1, -8 },
  { 455, 4, 11, 3, 0, -11 },
  { 461, 5, 12, 7, 1, -8 },
  { 469, 5, 11, 7, 1, -11 },
  { 476, 1, 11, 3, 1, -11 },
  { 478, 2, 15, 3, 0, -11 },
  { 482, 4, 11, 5, 1, -11 },
  { 488, 1, 11, 3, 1, -11 },
  { 490, 8, 8, 10, 1, -8 },
  { 498, 5, 8, 7, 1, -8 },
  { 503, 5, 8, 7, 1, -8 },
  { 508, 5, 11, 7, 1, -8 },
  { 515, 5, 11, 7, 1, -8 },
  { 522, 3, 8, 4, 1, -8 },
  { 525, 4, 8, 5, 1, -8 },
  { 529, 3, 10, 4, 0, -10 },
  { 533, 5, 8, 7, 1, -8 },
  { 538, 5, 8, 5, 0, -8 },
  { 543, 8, 8, 8, 0, -8 },
  { 551, 5, 8, 5, 0, -8 },
  { 556, 5, 12, 5, 0, -8 },
  { 564, 4, 8, 5, 0, -8 },
  { 568, 3, 13, 5, 1, -11 },
  { 573, 1, 15, 6, 3, -11 },
  { 575, 3, 13, 5, 1, -11 },
  { 580, 5, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_Thin15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_THIN15PT7B_H_
